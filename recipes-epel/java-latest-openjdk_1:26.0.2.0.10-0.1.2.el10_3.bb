# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-latest-openjdk"
PE = "1"
PV = "26.0.2.0.10"
PR = "0.1.2.el10_3"
PACKAGES = " \
 java-latest-openjdk \
 java-latest-openjdk-crypto-adapter \
 java-latest-openjdk-crypto-adapter-fastdebug \
 java-latest-openjdk-crypto-adapter-slowdebug \
 java-latest-openjdk-demo \
 java-latest-openjdk-demo-fastdebug \
 java-latest-openjdk-demo-slowdebug \
 java-latest-openjdk-devel \
 java-latest-openjdk-devel-fastdebug \
 java-latest-openjdk-devel-slowdebug \
 java-latest-openjdk-fastdebug \
 java-latest-openjdk-headless \
 java-latest-openjdk-headless-fastdebug \
 java-latest-openjdk-headless-slowdebug \
 java-latest-openjdk-javadoc \
 java-latest-openjdk-javadoc-zip \
 java-latest-openjdk-jmods \
 java-latest-openjdk-jmods-fastdebug \
 java-latest-openjdk-jmods-slowdebug \
 java-latest-openjdk-slowdebug \
 java-latest-openjdk-src \
 java-latest-openjdk-src-fastdebug \
 java-latest-openjdk-src-slowdebug \
 java-latest-openjdk-static-libs \
 java-latest-openjdk-static-libs-fastdebug \
 java-latest-openjdk-static-libs-slowdebug \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/java-latest-openjdk-26.0.2.0.10-0.1.2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa8183d94bace4fba95998acf0a1f4d192b9aa47fafaf2f83eb0a6fd19cfd2c3"

URI_x86_64_v2_java-latest-openjdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk}"
SRC_URI[x86_64_v2_java-latest-openjdk.sha256sum] = "0624a5c5af8586de66a8f7207616b79f4b8407041211b1349fe1433bcaff3182"

URI_x86_64_v2_java-latest-openjdk-crypto-adapter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-crypto-adapter}"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter.sha256sum] = "97c52b006e060758a6e4f72f196afaf3e7220d32fbb7b636f85c23005898d484"

URI_x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-fastdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "01f4e8cb55621c6b23c7df899763e90a2769db8e81e3907a8ee34e27ece8bfef"

URI_x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-crypto-adapter-slowdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "7877cd054afeb3cab049cb80474e5d5fb94d5f1543194f43119a2317198072a3"

URI_x86_64_v2_java-latest-openjdk-demo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo.sha256sum] = "3dd9c395adadb6b769eeb19d40132d3e59048beebd8111c665918437ff6462df"

URI_x86_64_v2_java-latest-openjdk-demo-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-fastdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-fastdebug.sha256sum] = "84b8b3194e0937768cc8e3eb9560054c47271f1c7beb273f5038043872d81cb9"

URI_x86_64_v2_java-latest-openjdk-demo-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-demo-slowdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-demo-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-demo-slowdebug.sha256sum] = "cc79d87981dfd5661ef4870b8c011077c3027ddfe579e986dfff594b0793a4c7"

URI_x86_64_v2_java-latest-openjdk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel.sha256sum] = "04c3e287fd066b0bb7c9edfb1908fff683033526e5b9983ca9edf6da94d28cee"

URI_x86_64_v2_java-latest-openjdk-devel-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-fastdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-fastdebug.sha256sum] = "bcb8672cc72a6c1d0d7f152484fff01cee39f299a10946e0e5aebc8800b97f64"

URI_x86_64_v2_java-latest-openjdk-devel-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-devel-slowdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-devel-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-devel-slowdebug.sha256sum] = "8d925f681f3f3a9d66f32b87f70fb0c68e9029123184bee1e3630c3f1b82b26c"

URI_x86_64_v2_java-latest-openjdk-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-fastdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-fastdebug.sha256sum] = "ff566b92fb89a74a260257ea87b6c210dfff9dc98f0898028dac44d9b2697ecb"

URI_x86_64_v2_java-latest-openjdk-headless = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless.sha256sum] = "3ed4d8a2d5eb32aad77e2cb89114fc04780dc8a0bf2f9174c3cfdb7052c5aa98"

URI_x86_64_v2_java-latest-openjdk-headless-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-fastdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-fastdebug.sha256sum] = "cb1bd822d4dccdfccef042912d5333ff4a071a76a65dacdb11a754eca4c3ff99"

URI_x86_64_v2_java-latest-openjdk-headless-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-headless-slowdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-headless-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-headless-slowdebug.sha256sum] = "7e425d875437ca9a583392a8860081a14dc102aa2b1b3256c384a308d5ac2118"

URI_x86_64_v2_java-latest-openjdk-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-javadoc}"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc.sha256sum] = "43e244c46124eb7c8f2b753d4d158503b71bb391a6c566c1f488e2291b8a635f"

URI_x86_64_v2_java-latest-openjdk-javadoc-zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-javadoc-zip-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-javadoc-zip}"
SRC_URI[x86_64_v2_java-latest-openjdk-javadoc-zip.sha256sum] = "96d6c44cf69c258bb9b5802507fb5cb3796b3a20a3f2daacc232d2ec5614ffbb"

URI_x86_64_v2_java-latest-openjdk-jmods = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods.sha256sum] = "134fc816be775023442f63b3dbf2587f8cd8907b003e0b1fc98867522d22ce83"

URI_x86_64_v2_java-latest-openjdk-jmods-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-fastdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-fastdebug.sha256sum] = "8e4322f0303edace6c0c5465199ec30189ce2c146ba47bad9c2fa74e37d40ff7"

URI_x86_64_v2_java-latest-openjdk-jmods-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-jmods-slowdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-jmods-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-jmods-slowdebug.sha256sum] = "eb39583e414ac5bcd0eaec2b5589e990d05de3a5a78bee776bcd3dffd4c28ded"

URI_x86_64_v2_java-latest-openjdk-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-slowdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-slowdebug.sha256sum] = "c258379fbcf8fe1835861eb98b0a862938937e5aa7dc8c6a704b12ad525e2658"

URI_x86_64_v2_java-latest-openjdk-src = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src}"
SRC_URI[x86_64_v2_java-latest-openjdk-src.sha256sum] = "9b964047b426e20cf2bdd525373ca9ce70b12794e3b99506c8deeef7f65a025c"

URI_x86_64_v2_java-latest-openjdk-src-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-fastdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-src-fastdebug.sha256sum] = "bb91ba5f8abc880a96dab7d9476777d7eeae6b71000048459a9c2cedb6e7677a"

URI_x86_64_v2_java-latest-openjdk-src-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-src-slowdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-src-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-src-slowdebug.sha256sum] = "c78882953bee2bcd1a0720c1a979d3980d011fa32049b6ad66d3c741c3d77235"

URI_x86_64_v2_java-latest-openjdk-static-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs.sha256sum] = "ceac1d0811daa0f460b2689e359b2cc43458dfbd0e2e012cba4c132c417ee798"

URI_x86_64_v2_java-latest-openjdk-static-libs-fastdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-fastdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs-fastdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "0231228f9cf133bffb4b80a0f07e76fcbac99511e63bf2ae9e3f74d70306af06"

URI_x86_64_v2_java-latest-openjdk-static-libs-slowdebug = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-latest-openjdk-static-libs-slowdebug-26.0.2.0.10-0.1.2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-latest-openjdk-static-libs-slowdebug}"
SRC_URI[x86_64_v2_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "2f7354669377c6c501d000fd38d8ba5cf176cb57459827cbaf3c2dfbd982c4bf"

URI_aarch64_java-latest-openjdk = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk}"
SRC_URI[aarch64_java-latest-openjdk.sha256sum] = "d6a87f808003505e990c18618723c4b81333b427d3d3ac2f274d584d320a2ed4"

URI_aarch64_java-latest-openjdk-crypto-adapter = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-crypto-adapter}"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter.sha256sum] = "f87447ebec7bbdf93fe2b0928259e80f7a35fdecf0f782027e27c8dd07e3ae23"

URI_aarch64_java-latest-openjdk-crypto-adapter-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-fastdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-crypto-adapter-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-fastdebug.sha256sum] = "8f665e6b4705bde20bfdc3145f391387ae4ef032e28375dfa4a64c3c30a81554"

URI_aarch64_java-latest-openjdk-crypto-adapter-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-crypto-adapter-slowdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-crypto-adapter-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-crypto-adapter-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-crypto-adapter-slowdebug.sha256sum] = "a7cc7d2b1bd492e4514243184a037a5fe1954f74285ff967a2b15e23a1070700"

URI_aarch64_java-latest-openjdk-demo = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-demo;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo}"
SRC_URI[aarch64_java-latest-openjdk-demo.sha256sum] = "da54040d3850d5a64b118b2d5d6a1a046fab28beb59f23e535f8614ad1515321"

URI_aarch64_java-latest-openjdk-demo-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-fastdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-demo-fastdebug.sha256sum] = "a77936f5c90cb1421134336863d47c3ca3de26a1aeb74feb261312f710902884"

URI_aarch64_java-latest-openjdk-demo-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-demo-slowdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-demo-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-demo-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-demo-slowdebug.sha256sum] = "08082e9132650dc06f4a62ed3dc39b956e9f83db3e9ae41644df0cb957371eaf"

URI_aarch64_java-latest-openjdk-devel = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel}"
SRC_URI[aarch64_java-latest-openjdk-devel.sha256sum] = "90b80e15bc88f1129e324b656f5e37c7594962ebeb2e38817ac87cc51de66ae1"

URI_aarch64_java-latest-openjdk-devel-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-fastdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-devel-fastdebug.sha256sum] = "2ca16c6afe9d1f9c5e3a52ccfef2dfcf4c4db1fe1896b05b2732951972e8466f"

URI_aarch64_java-latest-openjdk-devel-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-devel-slowdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-devel-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-devel-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-devel-slowdebug.sha256sum] = "2a0d692f9a68d1689d0a258dbd204313c62da3a76268cde2c83643999ae8f791"

URI_aarch64_java-latest-openjdk-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-fastdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-fastdebug.sha256sum] = "f49ef1ad6a8c5fe9fa858127515e1ca9aef6c15d257ae40ef69f46a231ff5370"

URI_aarch64_java-latest-openjdk-headless = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-headless;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless}"
SRC_URI[aarch64_java-latest-openjdk-headless.sha256sum] = "700f41b39754eac0d4378a9278bc8d72768595ab748b1d0dbf9050611a19fe6a"

URI_aarch64_java-latest-openjdk-headless-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-fastdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-headless-fastdebug.sha256sum] = "b504e52cc6cc9bd4e56c3c8a32180ff4e46ae118bb7c4118bda84d2d3e386a13"

URI_aarch64_java-latest-openjdk-headless-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-headless-slowdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-headless-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-headless-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-headless-slowdebug.sha256sum] = "ffbd5dabd89d36d524728cdb6597fed79178d52a34853231f592dbbbb3844747"

URI_aarch64_java-latest-openjdk-javadoc = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-javadoc}"
SRC_URI[aarch64_java-latest-openjdk-javadoc.sha256sum] = "47132460ed81ce64fa763cba81c5af8b38b252571e82559eb1918b5a9fefca1b"

URI_aarch64_java-latest-openjdk-javadoc-zip = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-javadoc-zip-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-javadoc-zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-javadoc-zip}"
SRC_URI[aarch64_java-latest-openjdk-javadoc-zip.sha256sum] = "5d8bce1baaf5f2fd2fecf09645b7bfd2281c7ed3b7d35df859db8be62bdfabd9"

URI_aarch64_java-latest-openjdk-jmods = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods}"
SRC_URI[aarch64_java-latest-openjdk-jmods.sha256sum] = "b74419f4d57d8ade999a2e7fc807b68e59dfcf6ac1e199af9259bccea30129ce"

URI_aarch64_java-latest-openjdk-jmods-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-fastdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-jmods-fastdebug.sha256sum] = "538d1b4c021f5a8ab7b674119999e9187ff338f8c8971ee80ad5f51407ae2279"

URI_aarch64_java-latest-openjdk-jmods-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-jmods-slowdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-jmods-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-jmods-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-jmods-slowdebug.sha256sum] = "339682f9586f6c42e4305eb40c00c7be416894d5ab918e5124af18f5ea067319"

URI_aarch64_java-latest-openjdk-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-slowdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-slowdebug.sha256sum] = "51df2378332f1fd65b0ffb05bbffa78d39aa67a952a392c04b0d60aa2958386b"

URI_aarch64_java-latest-openjdk-src = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src}"
SRC_URI[aarch64_java-latest-openjdk-src.sha256sum] = "efd09736b7bbc92bef129f21f3de7cda89522a14256a2bd169c0e7af00be44a6"

URI_aarch64_java-latest-openjdk-src-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-fastdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-src-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-src-fastdebug.sha256sum] = "a833895048c18d5a8288019e7125bedd3f186bb34f2f412700974026d0edfadb"

URI_aarch64_java-latest-openjdk-src-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-src-slowdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-src-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-src-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-src-slowdebug.sha256sum] = "1f513ddf25ad312444ed46f06f3004b3d2bb03b2c99c7c63293fcb5c270ad2f3"

URI_aarch64_java-latest-openjdk-static-libs = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs}"
SRC_URI[aarch64_java-latest-openjdk-static-libs.sha256sum] = "b7d7597c250a7f3429e601146f5335257c25f627eff3725e3623be258d35c65f"

URI_aarch64_java-latest-openjdk-static-libs-fastdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-fastdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs-fastdebug}"
SRC_URI[aarch64_java-latest-openjdk-static-libs-fastdebug.sha256sum] = "e74841fb01ab68e51c482d38d013c8f36093b6411424cfe4a768141b41176627"

URI_aarch64_java-latest-openjdk-static-libs-slowdebug = "${EPEL_MIRROR}/aarch64/Packages/j/java-latest-openjdk-static-libs-slowdebug-26.0.2.0.10-0.1.2.el10_3.aarch64.rpm;name=aarch64_java-latest-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-latest-openjdk-static-libs-slowdebug}"
SRC_URI[aarch64_java-latest-openjdk-static-libs-slowdebug.sha256sum] = "b0e27e7abc3078c64ca860fcb4a4af011d8f46ae6c51510e3f38a2f4b392b3c5"

RDEPENDS:java-latest-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-fastdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-crypto-adapter-slowdebug = " \
 glibc \
 nss \
 nss-softokn \
 "
RDEPENDS:java-latest-openjdk-demo = " \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-demo-fastdebug = " \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-demo-slowdebug = " \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk \
 "
RDEPENDS:java-latest-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-fastdebug \
 "
RDEPENDS:java-latest-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 glibc \
 java-latest-openjdk-slowdebug \
 "
RDEPENDS:java-latest-openjdk-fastdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-fastdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-fastdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-fastdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-headless-slowdebug = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 java-latest-openjdk-crypto-adapter-slowdebug \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-latest-openjdk-javadoc = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:java-latest-openjdk-jmods = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-jmods-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-jmods-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
RDEPENDS:java-latest-openjdk-slowdebug = " \
 bash \
 fontconfig \
 glibc \
 java-latest-openjdk-headless-slowdebug \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-latest-openjdk-src = " \
 java-latest-openjdk-headless \
 "
RDEPENDS:java-latest-openjdk-src-fastdebug = " \
 java-latest-openjdk-headless-fastdebug \
 "
RDEPENDS:java-latest-openjdk-src-slowdebug = " \
 java-latest-openjdk-headless-slowdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs = " \
 java-latest-openjdk-devel \
 "
RDEPENDS:java-latest-openjdk-static-libs-fastdebug = " \
 java-latest-openjdk-devel-fastdebug \
 "
RDEPENDS:java-latest-openjdk-static-libs-slowdebug = " \
 java-latest-openjdk-devel-slowdebug \
 "
