# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-winnow0.7"
PV = "0.7.15"
PR = "1.el10_3"
PACKAGES = " \
 rust-winnow0.7+alloc-devel \
 rust-winnow0.7+debug-devel \
 rust-winnow0.7+default-devel \
 rust-winnow0.7+simd-devel \
 rust-winnow0.7+std-devel \
 rust-winnow0.7+unstable-doc-devel \
 rust-winnow0.7+unstable-recover-devel \
 rust-winnow0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-winnow0.7-0.7.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3830b5be89ac920c8a2b3047182c3bf6606ba81b3f31aa031b629b38e8a4bdd7"

URI_x86_64_v2_rust-winnow0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.7+alloc-devel-0.7.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-winnow0.7+alloc-devel.sha256sum] = "18699868a80d2e4026c5d230dfe7dbb64cdef2c3997d0373d8e30efdd6b4efab"

URI_x86_64_v2_rust-winnow0.7+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.7+debug-devel-0.7.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.7+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.7+debug-devel}"
SRC_URI[x86_64_v2_rust-winnow0.7+debug-devel.sha256sum] = "1eb282169a9aaa7e097df316012b201343bc555915b40d34488930af566feb58"

URI_x86_64_v2_rust-winnow0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.7+default-devel-0.7.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.7+default-devel}"
SRC_URI[x86_64_v2_rust-winnow0.7+default-devel.sha256sum] = "f1a5a4bebcd5c9c4fe6b1dd031317f5677dcdcc49f402baf64f4319d07fdd6b8"

URI_x86_64_v2_rust-winnow0.7+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.7+simd-devel-0.7.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.7+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.7+simd-devel}"
SRC_URI[x86_64_v2_rust-winnow0.7+simd-devel.sha256sum] = "6ce8394cc09b9209f8207185e1075264c71b5ada2960c83575d0dde47259ce8f"

URI_x86_64_v2_rust-winnow0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.7+std-devel-0.7.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.7+std-devel}"
SRC_URI[x86_64_v2_rust-winnow0.7+std-devel.sha256sum] = "cf527b6f19f56bc9752249403afa3a3366b4f88300b85abd5762266d40155501"

URI_x86_64_v2_rust-winnow0.7+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.7+unstable-doc-devel-0.7.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.7+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.7+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-winnow0.7+unstable-doc-devel.sha256sum] = "e87ff6b0edb78ad59ebdb6d9aef2093f95ea11cd014d573fbd33fb042af47d17"

URI_x86_64_v2_rust-winnow0.7+unstable-recover-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.7+unstable-recover-devel-0.7.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.7+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.7+unstable-recover-devel}"
SRC_URI[x86_64_v2_rust-winnow0.7+unstable-recover-devel.sha256sum] = "e26fcb05352061f513c40a1b9cb2ea07a8726ea36e27601dec8d4e62a371e620"

URI_x86_64_v2_rust-winnow0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-winnow0.7-devel-0.7.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-winnow0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-winnow0.7-devel}"
SRC_URI[x86_64_v2_rust-winnow0.7-devel.sha256sum] = "874e8c08b5b4d5488b14478275d421c3b8aa6b641ad774f667512f725aa8ef03"

URI_aarch64_rust-winnow0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.7+alloc-devel-0.7.15-1.el10_3.noarch.rpm;name=aarch64_rust-winnow0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.7+alloc-devel}"
SRC_URI[aarch64_rust-winnow0.7+alloc-devel.sha256sum] = "ebcfcb6d64ffab69228acc0cd7d7aa7a87a602f1d0d1486713de8b96f62eec70"

URI_aarch64_rust-winnow0.7+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.7+debug-devel-0.7.15-1.el10_3.noarch.rpm;name=aarch64_rust-winnow0.7+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.7+debug-devel}"
SRC_URI[aarch64_rust-winnow0.7+debug-devel.sha256sum] = "681a49983a5b22e4ee47f22a24c4b9129303e2d0ef1fe686f9360861ec9e8226"

URI_aarch64_rust-winnow0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.7+default-devel-0.7.15-1.el10_3.noarch.rpm;name=aarch64_rust-winnow0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.7+default-devel}"
SRC_URI[aarch64_rust-winnow0.7+default-devel.sha256sum] = "26ea6919817708b50d84bb17daa315e332e062a601f5ee2441b1383b631e5192"

URI_aarch64_rust-winnow0.7+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.7+simd-devel-0.7.15-1.el10_3.noarch.rpm;name=aarch64_rust-winnow0.7+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.7+simd-devel}"
SRC_URI[aarch64_rust-winnow0.7+simd-devel.sha256sum] = "a3b8ec280f390145c308a986590348e3c4d5aece81967faf6728ca4e23e2ea60"

URI_aarch64_rust-winnow0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.7+std-devel-0.7.15-1.el10_3.noarch.rpm;name=aarch64_rust-winnow0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.7+std-devel}"
SRC_URI[aarch64_rust-winnow0.7+std-devel.sha256sum] = "ae823fb66b0f16d746b49273863861b77189207b97fd3f6c2d899274e468156d"

URI_aarch64_rust-winnow0.7+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.7+unstable-doc-devel-0.7.15-1.el10_3.noarch.rpm;name=aarch64_rust-winnow0.7+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.7+unstable-doc-devel}"
SRC_URI[aarch64_rust-winnow0.7+unstable-doc-devel.sha256sum] = "c3ed586f27916e1ddcec09ab316f528c0f37aa39acdd250b403de373e2d5c028"

URI_aarch64_rust-winnow0.7+unstable-recover-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.7+unstable-recover-devel-0.7.15-1.el10_3.noarch.rpm;name=aarch64_rust-winnow0.7+unstable-recover-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.7+unstable-recover-devel}"
SRC_URI[aarch64_rust-winnow0.7+unstable-recover-devel.sha256sum] = "1a572f08a07181d9b5f40d8bed065af8021703ea4fbb5b1303fe51496f458227"

URI_aarch64_rust-winnow0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-winnow0.7-devel-0.7.15-1.el10_3.noarch.rpm;name=aarch64_rust-winnow0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-winnow0.7-devel}"
SRC_URI[aarch64_rust-winnow0.7-devel.sha256sum] = "d3b9293973f17a7f35fb179a8865318204956fc0bf554163e84e930de861e06d"

RDEPENDS:rust-winnow0.7+alloc-devel = " \
 cargo \
 rust-winnow0.7-devel \
 "
RDEPENDS:rust-winnow0.7+debug-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-terminal_size+default-devel \
 rust-winnow0.7+std-devel \
 rust-winnow0.7-devel \
 "
RDEPENDS:rust-winnow0.7+default-devel = " \
 cargo \
 rust-winnow0.7+std-devel \
 rust-winnow0.7-devel \
 "
RDEPENDS:rust-winnow0.7+simd-devel = " \
 cargo \
 rust-memchr-devel \
 rust-winnow0.7-devel \
 "
RDEPENDS:rust-winnow0.7+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-winnow0.7+alloc-devel \
 rust-winnow0.7-devel \
 "
RDEPENDS:rust-winnow0.7+unstable-doc-devel = " \
 cargo \
 rust-winnow0.7+alloc-devel \
 rust-winnow0.7+simd-devel \
 rust-winnow0.7+std-devel \
 rust-winnow0.7+unstable-recover-devel \
 rust-winnow0.7-devel \
 "
RDEPENDS:rust-winnow0.7+unstable-recover-devel = " \
 cargo \
 rust-winnow0.7-devel \
 "
RDEPENDS:rust-winnow0.7-devel = " \
 cargo \
 rust \
 "
