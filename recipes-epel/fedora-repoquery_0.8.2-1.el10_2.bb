# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedora-repoquery"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 fedora-repoquery \
 fedora-repoquery-short \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedora-repoquery-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d536bcf4fc52c1a88912e804076c36742840aa216631c9e24fff0371c599f1d8"

URI_x86_64_v2_fedora-repoquery = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-repoquery-0.8.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fedora-repoquery;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-repoquery}"
SRC_URI[x86_64_v2_fedora-repoquery.sha256sum] = "5c2a78e5fdbe8fb68123a33a5bef9c741e021149b29020631f1d546bb6c094a5"

URI_x86_64_v2_fedora-repoquery-short = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedora-repoquery-short-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedora-repoquery-short;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedora-repoquery-short}"
SRC_URI[x86_64_v2_fedora-repoquery-short.sha256sum] = "1e15822a0dabb8da82458a9625da0eb783748e3c8d9ceb035e05c8eaa55f6388"

URI_aarch64_fedora-repoquery = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-repoquery-0.8.2-1.el10_2.aarch64.rpm;name=aarch64_fedora-repoquery;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-repoquery}"
SRC_URI[aarch64_fedora-repoquery.sha256sum] = "129b1ae7a9169320a24feeb5040ae1bd8a49513f5398ba444b21fc44a2844a03"

URI_aarch64_fedora-repoquery-short = "${EPEL_MIRROR}/aarch64/Packages/f/fedora-repoquery-short-0.8.2-1.el10_2.noarch.rpm;name=aarch64_fedora-repoquery-short;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedora-repoquery-short}"
SRC_URI[aarch64_fedora-repoquery-short.sha256sum] = "1de2f54fc94d503eb97a5173a00e128bca03c2f21c6d0e1f51d2fb862b263935"

RDEPENDS:fedora-repoquery = " \
 glibc \
 gmp \
 libffi \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:fedora-repoquery-short = " \
 fedora-repoquery \
 "
