# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-desktop"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-desktop \
 plasma-desktop-doc \
 sddm-breeze \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-desktop-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "79dac541c3fa531027078e892b0854dcdfa536a5310d790f93d382785248a163"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-desktop;unpack=0"
SRC_URI[x86_64_v2_plasma-desktop.sha256sum] = "3a441868f5f7ee7a542037f75823372e9e27a9ed970f1245b79938e577d15dc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-desktop-doc;unpack=0"
SRC_URI[x86_64_v2_plasma-desktop-doc.sha256sum] = "5cfae91aa7f76b92bfddedc37d4b794a313c2855a3bb81a0f117c91b51df1919"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-breeze-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-breeze;unpack=0"
SRC_URI[x86_64_v2_sddm-breeze.sha256sum] = "fe8a57c6475452bb35e234837557e925b76ec78374615777637c9b8e2894e65f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-desktop;unpack=0"
SRC_URI[aarch64_plasma-desktop.sha256sum] = "095602ea78f9607adbd79c561c619aaa3d561c62332e96340370ae7057130599"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma-desktop-doc;unpack=0"
SRC_URI[aarch64_plasma-desktop-doc.sha256sum] = "daca83ebd378ea211458798102902c270a77c32613c5d7f131dcb701031eb94c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sddm-breeze-6.7.5-1.el10_3.noarch.rpm;name=aarch64_sddm-breeze;unpack=0"
SRC_URI[aarch64_sddm-breeze.sha256sum] = "b8a6a3a7ef883f92005b455d6136c986fc2303e8e200451ca7797473a33f26c9"

RDEPENDS:plasma-desktop = " \
 PackageKit-Qt6 \
 accountsservice \
 bash \
 glib2 \
 glibc \
 google-noto-color-emoji-fonts \
 ibus-libs \
 kaccounts-integration-qt6 \
 kde-cli-tools \
 kf6-attica \
 kf6-baloo-libs \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 kf6-solid \
 kf6-sonnet \
 kio-extras \
 kmenuedit \
 kpipewire \
 kwin \
 kwrited \
 libX11 \
 libXi \
 libaccounts-qt6 \
 libcanberra \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwacom \
 libwayland-client \
 libxcb \
 libxkbcommon \
 libxkbfile \
 plasma-activities \
 plasma-activities-stats \
 plasma-integration \
 plasma-systemsettings \
 plasma-workspace \
 plasma-workspace-libs \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 signon-plugin-oauth2 \
 systemd-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 xcb-util-keysyms \
 xdg-utils \
 "
RDEPENDS:plasma-desktop-doc = " \
 "
RDEPENDS:sddm-breeze = " \
 kde-settings-sddm \
 kf6-kimageformats \
 libplasma \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 virtual/desktop-backgrounds-compat \
 "
