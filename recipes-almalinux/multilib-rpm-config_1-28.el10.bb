# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "multilib-rpm-config"
PV = "1"
PR = "28.el10"
PACKAGES = " \
 multilib-rpm-config \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/multilib-rpm-config-1-28.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d0eecad94fb08078a1b334fd04fccb00cec6f113d90cd338d0c925271cc17579"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/multilib-rpm-config-1-28.el10.noarch.rpm;name=x86_64_v2_multilib-rpm-config;unpack=0"
SRC_URI[x86_64_v2_multilib-rpm-config.sha256sum] = "6758e8b973ff4cd006eefc485a6cec761498e5057cd596af0bfcd59e5c1bea38"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/multilib-rpm-config-1-28.el10.noarch.rpm;name=aarch64_multilib-rpm-config;unpack=0"
SRC_URI[aarch64_multilib-rpm-config.sha256sum] = "6758e8b973ff4cd006eefc485a6cec761498e5057cd596af0bfcd59e5c1bea38"

RDEPENDS:multilib-rpm-config = " \
 bash \
 redhat-rpm-config \
 "
