# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sqlmodel"
PV = "0.0.24"
PR = "1.el10_1"
PACKAGES = " \
 python3-sqlmodel \
 python3-sqlmodel-slim \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-sqlmodel-0.0.24-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "560a7ccd55ffeecaaf60740b803b79b9411cc591911403cb7ceea7fe600e1a17"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sqlmodel-0.0.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sqlmodel;unpack=0"
SRC_URI[x86_64_v2_python3-sqlmodel.sha256sum] = "0cd4b6d376a764717f43561f749dd426bcae67189429df284871018262dc6c1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sqlmodel-slim-0.0.24-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sqlmodel-slim;unpack=0"
SRC_URI[x86_64_v2_python3-sqlmodel-slim.sha256sum] = "4ebaf4110eaef0140fc06e41ff2294df7b3ff318026def46c7108f2c1e7fd490"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-sqlmodel-0.0.24-1.el10_1.noarch.rpm;name=aarch64_python3-sqlmodel;unpack=0"
SRC_URI[aarch64_python3-sqlmodel.sha256sum] = "8229e4d9a962376ddad11a5b81f8992435fd3f0d979ff06a5fa93d4743097bda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-sqlmodel-slim-0.0.24-1.el10_1.noarch.rpm;name=aarch64_python3-sqlmodel-slim;unpack=0"
SRC_URI[aarch64_python3-sqlmodel-slim.sha256sum] = "e7fd19716641cfdf1ee2e4e3263c2516b958b8c39a91fbcc31f0351c7a05c943"

RDEPENDS:python3-sqlmodel = " \
 python3 \
 python3-pydantic \
 python3-sqlalchemy \
 python3-sqlmodel-slim \
 "
RDEPENDS:python3-sqlmodel-slim = " \
 python3 \
 python3-pydantic \
 python3-sqlalchemy \
 "
