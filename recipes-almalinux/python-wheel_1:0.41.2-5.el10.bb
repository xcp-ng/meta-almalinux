# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wheel"
PE = "1"
PV = "0.41.2"
PR = "5.el10"
PACKAGES = " \
 python3-wheel \
 python3-wheel-wheel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-wheel-0.41.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6200b7aef03c1e23ba2d9ef9952db75ace64d137f12a7360fd46862b6dc519a"

URI_x86_64_v2_python3-wheel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-wheel-0.41.2-5.el10.noarch.rpm;name=x86_64_v2_python3-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wheel}"
SRC_URI[x86_64_v2_python3-wheel.sha256sum] = "2bf29316e3e2331bac510dd1559e0ab121360a2e861699a3f00a70301ece9bb5"

URI_x86_64_v2_python3-wheel-wheel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-wheel-wheel-0.41.2-5.el10.noarch.rpm;name=x86_64_v2_python3-wheel-wheel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wheel-wheel}"
SRC_URI[x86_64_v2_python3-wheel-wheel.sha256sum] = "ec64660996c065ca938df05f01ad9b367b20dd3e0f1d2c05be399c1a303da8aa"

URI_aarch64_python3-wheel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-wheel-0.41.2-5.el10.noarch.rpm;name=aarch64_python3-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wheel}"
SRC_URI[aarch64_python3-wheel.sha256sum] = "2bf29316e3e2331bac510dd1559e0ab121360a2e861699a3f00a70301ece9bb5"

URI_aarch64_python3-wheel-wheel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-wheel-wheel-0.41.2-5.el10.noarch.rpm;name=aarch64_python3-wheel-wheel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wheel-wheel}"
SRC_URI[aarch64_python3-wheel-wheel.sha256sum] = "ec64660996c065ca938df05f01ad9b367b20dd3e0f1d2c05be399c1a303da8aa"

RDEPENDS:python3-wheel = " \
 python3 \
 "
RDEPENDS:python3-wheel-wheel = " \
 "
