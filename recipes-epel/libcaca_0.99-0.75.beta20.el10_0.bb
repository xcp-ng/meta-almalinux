# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcaca"
PV = "0.99"
PR = "0.75.beta20.el10_0"
PACKAGES = " \
 caca-utils \
 libcaca \
 libcaca-devel \
 python3-caca \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcaca-0.99-0.75.beta20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25a16cea0350b53aeba650219297399d4c2776366866333fec30213f127d1e76"

URI_x86_64_v2_caca-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/caca-utils-0.99-0.75.beta20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_caca-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_caca-utils}"
SRC_URI[x86_64_v2_caca-utils.sha256sum] = "9f60f6e81ba73c6928ad8ea23ae5fe0089998a00defe623133a9261761884691"

URI_x86_64_v2_libcaca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcaca-0.99-0.75.beta20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcaca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcaca}"
SRC_URI[x86_64_v2_libcaca.sha256sum] = "f018320cd8e66899c88745de80fe2f1287d7514f01f179abd7ef08b495e924af"

URI_x86_64_v2_libcaca-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcaca-devel-0.99-0.75.beta20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcaca-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcaca-devel}"
SRC_URI[x86_64_v2_libcaca-devel.sha256sum] = "f707e19f828a95ca25cbf40a10a3bd7713c47f7cc2ea95b9216b0626e6d5680d"

URI_x86_64_v2_python3-caca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-caca-0.99-0.75.beta20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-caca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-caca}"
SRC_URI[x86_64_v2_python3-caca.sha256sum] = "9007679ab6796b52bae83f512cf9cf9d196e8b17e0a0240d689f655a8aed24dc"

URI_aarch64_caca-utils = "${EPEL_MIRROR}/aarch64/Packages/c/caca-utils-0.99-0.75.beta20.el10_0.aarch64.rpm;name=aarch64_caca-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_caca-utils}"
SRC_URI[aarch64_caca-utils.sha256sum] = "d7a99765d6d47ffc6900af2ff44540f4583cc070ed9e75730f1e5bb06fe4802a"

URI_aarch64_libcaca = "${EPEL_MIRROR}/aarch64/Packages/l/libcaca-0.99-0.75.beta20.el10_0.aarch64.rpm;name=aarch64_libcaca;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcaca}"
SRC_URI[aarch64_libcaca.sha256sum] = "17f68b7ca097abf67d349ef39c55511500932dbf850997229604f4841fb0677f"

URI_aarch64_libcaca-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcaca-devel-0.99-0.75.beta20.el10_0.aarch64.rpm;name=aarch64_libcaca-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcaca-devel}"
SRC_URI[aarch64_libcaca-devel.sha256sum] = "df8c88b6f35ef2a46331be19e62602a0039b0dd4da25ef6c03f80ad48d9a2d96"

URI_aarch64_python3-caca = "${EPEL_MIRROR}/aarch64/Packages/p/python3-caca-0.99-0.75.beta20.el10_0.aarch64.rpm;name=aarch64_python3-caca;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-caca}"
SRC_URI[aarch64_python3-caca.sha256sum] = "9de092ee9e8a66f3f53a524235438f1580d5fff70f1fcc3f71f42e4a5100df76"

RDEPENDS:caca-utils = " \
 glibc \
 imlib2 \
 libcaca \
 toilet \
 "
RDEPENDS:libcaca = " \
 freeglut \
 glib2 \
 glibc \
 libX11 \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 mesa-libGLU \
 ncurses-libs \
 slang \
 zlib-ng-compat \
 "
RDEPENDS:libcaca-devel = " \
 bash \
 freeglut-devel \
 imlib2-devel \
 libX11-devel \
 libcaca \
 mesa-libGLU-devel \
 ncurses-devel \
 pango-devel \
 pkgconf-pkg-config \
 slang-devel \
 "
RDEPENDS:python3-caca = " \
 python3 \
 "
