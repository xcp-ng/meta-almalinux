# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libchewing"
PV = "0.9.1"
PR = "3.el10_2"
PACKAGES = " \
 libchewing \
 libchewing-devel \
 python3-libchewing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libchewing-0.9.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "315a3ed7d48a25850934ce46c1a7bea8181537b4cdcae0f38d1722f83702fa51"

URI_x86_64_v2_libchewing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libchewing-0.9.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libchewing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libchewing}"
SRC_URI[x86_64_v2_libchewing.sha256sum] = "494c4dcaa5c4d34db94bb3e634181de8c5a85f0afb54b99f2ed1c55669cc2009"

URI_x86_64_v2_libchewing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libchewing-devel-0.9.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libchewing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libchewing-devel}"
SRC_URI[x86_64_v2_libchewing-devel.sha256sum] = "f687c11be2d7b607b224be7524b3e1bd90daf202eea7c0af30f4ee8ba6723097"

URI_x86_64_v2_python3-libchewing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libchewing-0.9.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-libchewing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libchewing}"
SRC_URI[x86_64_v2_python3-libchewing.sha256sum] = "0a73b1753a45fb736fa626bd50424139e99bb463d187b15d9aae7d59419e2011"

URI_aarch64_libchewing = "${EPEL_MIRROR}/aarch64/Packages/l/libchewing-0.9.1-3.el10_2.aarch64.rpm;name=aarch64_libchewing;unpack=0"
SRC_URI:append = " ${URI_aarch64_libchewing}"
SRC_URI[aarch64_libchewing.sha256sum] = "8c7087597ebea13bb5e39a87f41901597ef63a165fbe7a6bb2e57ce072aff5b4"

URI_aarch64_libchewing-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libchewing-devel-0.9.1-3.el10_2.aarch64.rpm;name=aarch64_libchewing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libchewing-devel}"
SRC_URI[aarch64_libchewing-devel.sha256sum] = "d3f1cb2b1ab7fb264ae1046cb326f1179885bd57b557b29c4e00da32923e788c"

URI_aarch64_python3-libchewing = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libchewing-0.9.1-3.el10_2.noarch.rpm;name=aarch64_python3-libchewing;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libchewing}"
SRC_URI[aarch64_python3-libchewing.sha256sum] = "3753f4d3eb98e56e1ffa26be5cc90471fbe0631ff33e4fcde92f8503c615109b"

RDEPENDS:libchewing = " \
 glibc \
 libgcc \
 sqlite-libs \
 "
RDEPENDS:libchewing-devel = " \
 cmake-filesystem \
 libchewing \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libchewing = " \
 libchewing \
 python3 \
 "
