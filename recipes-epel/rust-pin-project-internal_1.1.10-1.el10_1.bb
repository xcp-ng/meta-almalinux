# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project-internal"
PV = "1.1.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-pin-project-internal+default-devel \
 rust-pin-project-internal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-internal-1.1.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f71fd503a2c09aaa96a95be01703af59165c40628ddfd2db5dc1376ad8de735b"

URI_x86_64_v2_rust-pin-project-internal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-internal+default-devel-1.1.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-internal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-internal+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project-internal+default-devel.sha256sum] = "46f2ed096ea987efdc65289764d75c66aba5768e8b50cfbd6f188400333a1b7e"

URI_x86_64_v2_rust-pin-project-internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-internal-devel-1.1.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-internal-devel}"
SRC_URI[x86_64_v2_rust-pin-project-internal-devel.sha256sum] = "f264e757f1b96a5c224e4f5c2849c63c726875042769cf01f78c019e3f00c083"

URI_aarch64_rust-pin-project-internal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-internal+default-devel-1.1.10-1.el10_1.noarch.rpm;name=aarch64_rust-pin-project-internal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-internal+default-devel}"
SRC_URI[aarch64_rust-pin-project-internal+default-devel.sha256sum] = "ec1d5ffb051869854fd7f5124084d78ea3d4df36abde80067304f975991d12ac"

URI_aarch64_rust-pin-project-internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-internal-devel-1.1.10-1.el10_1.noarch.rpm;name=aarch64_rust-pin-project-internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-internal-devel}"
SRC_URI[aarch64_rust-pin-project-internal-devel.sha256sum] = "5260e4878fb19e23cea807f0f371ed0f65e4e83cce0425082c0b107c34b78743"

RDEPENDS:rust-pin-project-internal+default-devel = " \
 cargo \
 rust-pin-project-internal-devel \
 "
RDEPENDS:rust-pin-project-internal-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
