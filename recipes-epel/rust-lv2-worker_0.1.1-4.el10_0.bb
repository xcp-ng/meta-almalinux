# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lv2-worker"
PV = "0.1.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-lv2-worker+default-devel \
 rust-lv2-worker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lv2-worker-0.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72704ed39585d980600f83720dfe36d5c5763a8328fe07cd750d269d07023c8d"

URI_x86_64_v2_rust-lv2-worker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-worker+default-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-worker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-worker+default-devel}"
SRC_URI[x86_64_v2_rust-lv2-worker+default-devel.sha256sum] = "b36325786f7d0706e699dcd05bb7c24ded2b6f96462deca08ad7da57e22c0040"

URI_x86_64_v2_rust-lv2-worker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lv2-worker-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lv2-worker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lv2-worker-devel}"
SRC_URI[x86_64_v2_rust-lv2-worker-devel.sha256sum] = "d326064399fc71635eee1e7eb9d96605ef0df5f15a2d12087fe3dde95bddb9e1"

URI_aarch64_rust-lv2-worker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-worker+default-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-lv2-worker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-worker+default-devel}"
SRC_URI[aarch64_rust-lv2-worker+default-devel.sha256sum] = "fb659aa0433f1ab7a06c50028189dc7051a4c4be6015eb10f852da650877c46e"

URI_aarch64_rust-lv2-worker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lv2-worker-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-lv2-worker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lv2-worker-devel}"
SRC_URI[aarch64_rust-lv2-worker-devel.sha256sum] = "cfe7d05736f0b990680fdcd4b91e865f08d99e21da76a6c82d796a580f6df2e7"

RDEPENDS:rust-lv2-worker+default-devel = " \
 cargo \
 rust-lv2-worker-devel \
 "
RDEPENDS:rust-lv2-worker-devel = " \
 cargo \
 rust-lv2-core+default-devel \
 rust-lv2-sys+default-devel \
 rust-urid+default-devel \
 "
