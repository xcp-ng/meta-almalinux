# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16"
PV = "16.14"
PR = "1.el10_2"
PACKAGES = " \
 postgresql \
 postgresql-contrib \
 postgresql-docs \
 postgresql-plperl \
 postgresql-plpython3 \
 postgresql-pltcl \
 postgresql-private-devel \
 postgresql-private-libs \
 postgresql-server \
 postgresql-server-devel \
 postgresql-static \
 postgresql-test \
 postgresql-test-rpm-macros \
 postgresql-upgrade \
 postgresql-upgrade-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-16.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b7e6f935b69ec2e642b376a40064a85d06da91b730777d00f2bd3174d215ffb"

URI_x86_64_v2_postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql}"
SRC_URI[x86_64_v2_postgresql.sha256sum] = "b63e31b29e4b0b656025c9581b0e7adfce121702dcf26875f04e33c01f8cb0e2"

URI_x86_64_v2_postgresql-contrib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-contrib-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-contrib}"
SRC_URI[x86_64_v2_postgresql-contrib.sha256sum] = "2e748207c224fc88407bdc0395ae52b653fbeb8b1408891c0e47a0247d5495c2"

URI_x86_64_v2_postgresql-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-docs-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-docs}"
SRC_URI[x86_64_v2_postgresql-docs.sha256sum] = "27867af6868f01f1e723a36e5e502a1d96784f2212cd9ffdae073230c54bfb6a"

URI_x86_64_v2_postgresql-plperl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plperl-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-plperl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-plperl}"
SRC_URI[x86_64_v2_postgresql-plperl.sha256sum] = "cc14ab4fde544e6111f0b1a1e6e867bad1524d6148ba340de66a2e920bf3cbc4"

URI_x86_64_v2_postgresql-plpython3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-plpython3-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-plpython3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-plpython3}"
SRC_URI[x86_64_v2_postgresql-plpython3.sha256sum] = "296e4bb62688e678ed7aab282cdfa4e24b464c180b56a4918f63e6da9df5e563"

URI_x86_64_v2_postgresql-pltcl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-pltcl-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-pltcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-pltcl}"
SRC_URI[x86_64_v2_postgresql-pltcl.sha256sum] = "45e4fb3525a97f216f0563bcc24e9ae15c3f491f32a04624a884b51daadda1c4"

URI_x86_64_v2_postgresql-private-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-devel-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-private-devel}"
SRC_URI[x86_64_v2_postgresql-private-devel.sha256sum] = "89ff78f4b0e58bcdaeca01f15db501c3b7de2ae3fd997a3cac8a08a1c422d552"

URI_x86_64_v2_postgresql-private-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-private-libs-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-private-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-private-libs}"
SRC_URI[x86_64_v2_postgresql-private-libs.sha256sum] = "584cb4bed4c44d79cc2e9f31889825855cb94eb07f6a7cbbe7dbcd7f8911b8a2"

URI_x86_64_v2_postgresql-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-server}"
SRC_URI[x86_64_v2_postgresql-server.sha256sum] = "00fa22a135d72911ce7986756892ceccd6967d189412698b7b379e0e748f46cc"

URI_x86_64_v2_postgresql-server-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-server-devel-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-server-devel}"
SRC_URI[x86_64_v2_postgresql-server-devel.sha256sum] = "b7e27beb3890078cc73848481b3fee68356bbf2e49e28880730265283c730237"

URI_x86_64_v2_postgresql-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-static-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-static}"
SRC_URI[x86_64_v2_postgresql-static.sha256sum] = "8a6f1d2f45aa825096b9755061dd3440279eb4a9c28fb2881e385db73367dda2"

URI_x86_64_v2_postgresql-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-test-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-test}"
SRC_URI[x86_64_v2_postgresql-test.sha256sum] = "77ddd9c2f4bcefcf80242f569f7ee6c19462b42d27413508d1b3de054e464496"

URI_x86_64_v2_postgresql-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql-test-rpm-macros-16.14-1.el10_2.noarch.rpm;name=x86_64_v2_postgresql-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-test-rpm-macros}"
SRC_URI[x86_64_v2_postgresql-test-rpm-macros.sha256sum] = "f0c9d441dd4f2c10e7ccd46c88122dd2272396a602ea50eee9f8f60032a39627"

URI_x86_64_v2_postgresql-upgrade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-upgrade}"
SRC_URI[x86_64_v2_postgresql-upgrade.sha256sum] = "2c3d9284330417884d6280988c67ebcda3fc357e556a0820136d4f7114a24e2f"

URI_x86_64_v2_postgresql-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql-upgrade-devel-16.14-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql-upgrade-devel}"
SRC_URI[x86_64_v2_postgresql-upgrade-devel.sha256sum] = "5d94556b4da6d50f9f87d4fa32d7e51702284e4a1351fbf72053497313673307"

URI_aarch64_postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql}"
SRC_URI[aarch64_postgresql.sha256sum] = "55731064834a3f6229e80e0c2d4dd1fbc243968a9f1ffa6622e943e1c6007ed2"

URI_aarch64_postgresql-contrib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-contrib-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-contrib}"
SRC_URI[aarch64_postgresql-contrib.sha256sum] = "205c2a38e6f59ca8a424802a66e8a3aaf7c78b7a656d417ad8aa581d12065cf9"

URI_aarch64_postgresql-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-docs-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-docs}"
SRC_URI[aarch64_postgresql-docs.sha256sum] = "30d5a7a836afd6c1d5a571786ad641b63611fd342bbe87e8c1eb41968a1444ca"

URI_aarch64_postgresql-plperl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plperl-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-plperl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-plperl}"
SRC_URI[aarch64_postgresql-plperl.sha256sum] = "e253ccbe4b05df256fab479dde57f30fa51548dae40011118512e969e0e0d6a6"

URI_aarch64_postgresql-plpython3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-plpython3-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-plpython3;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-plpython3}"
SRC_URI[aarch64_postgresql-plpython3.sha256sum] = "765c9bcc24b023d6ce25171f60c254686d25843fd4ec6a34316b7c544b99706d"

URI_aarch64_postgresql-pltcl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-pltcl-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-pltcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-pltcl}"
SRC_URI[aarch64_postgresql-pltcl.sha256sum] = "9aa96fd3cfe1e93d02b9cecb98028dd0d01f6ed6184fe8a2eaabe55cf627cdab"

URI_aarch64_postgresql-private-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-devel-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-private-devel}"
SRC_URI[aarch64_postgresql-private-devel.sha256sum] = "3020baf649c422919bc23152a81f092c93177dc13e786c53bbd2a1b334c269b2"

URI_aarch64_postgresql-private-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-private-libs-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-private-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-private-libs}"
SRC_URI[aarch64_postgresql-private-libs.sha256sum] = "e7b3032a391e9efb14743496a411883ef8aff277aa882f93e131ae6b22a074f8"

URI_aarch64_postgresql-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-server}"
SRC_URI[aarch64_postgresql-server.sha256sum] = "608cc46bf84032055805605505508d1952d84192e50ffdc6633a4154ebcb0819"

URI_aarch64_postgresql-server-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-server-devel-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-server-devel}"
SRC_URI[aarch64_postgresql-server-devel.sha256sum] = "8df06ad5a163a5b0c065abd28f0590859b321bb76357938b79f5c85ed3e35cd7"

URI_aarch64_postgresql-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-static-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-static}"
SRC_URI[aarch64_postgresql-static.sha256sum] = "9609274a1592b7eb25145f80335e50db14acb792c3386d4205d6563b0f5f473e"

URI_aarch64_postgresql-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-test-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-test}"
SRC_URI[aarch64_postgresql-test.sha256sum] = "02550f2a17e107d47773c462ed8615f8280e6be029821312318bae41e07b611d"

URI_aarch64_postgresql-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql-test-rpm-macros-16.14-1.el10_2.noarch.rpm;name=aarch64_postgresql-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-test-rpm-macros}"
SRC_URI[aarch64_postgresql-test-rpm-macros.sha256sum] = "f0c9d441dd4f2c10e7ccd46c88122dd2272396a602ea50eee9f8f60032a39627"

URI_aarch64_postgresql-upgrade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-upgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-upgrade}"
SRC_URI[aarch64_postgresql-upgrade.sha256sum] = "3bb5f47a78b72d8246cf388fab492263e415960b9a4cc81292d92f038179d0ca"

URI_aarch64_postgresql-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql-upgrade-devel-16.14-1.el10_2.aarch64.rpm;name=aarch64_postgresql-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql-upgrade-devel}"
SRC_URI[aarch64_postgresql-upgrade-devel.sha256sum] = "a812368d04acb5e8eb9926477893de1956072b83fd40011caeb0dae13b38b901"

RDEPENDS:postgresql = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql \
 postgresql-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-docs = " \
 glibc \
 postgresql \
 "
RDEPENDS:postgresql-plperl = " \
 glibc \
 perl-libs \
 postgresql-server \
 "
RDEPENDS:postgresql-plpython3 = " \
 glibc \
 postgresql-server \
 python3-libs \
 "
RDEPENDS:postgresql-pltcl = " \
 glibc \
 postgresql-server \
 tcl \
 "
RDEPENDS:postgresql-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql \
 postgresql-private-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql-private-devel \
 postgresql-private-libs \
 "
RDEPENDS:postgresql-static = " \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test = " \
 bash \
 glibc \
 postgresql-contrib \
 postgresql-server \
 postgresql-server-devel \
 "
RDEPENDS:postgresql-test-rpm-macros = " \
 postgresql-server \
 "
RDEPENDS:postgresql-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 openldap \
 openssl-libs \
 pam-libs \
 perl-libs \
 postgresql-private-libs \
 postgresql-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql-upgrade-devel = " \
 bash \
 glibc \
 postgresql-upgrade \
 "
