# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "asdcplib"
PV = "2.13.2"
PR = "1.el10_3"
PACKAGES = " \
 asdcplib \
 asdcplib-devel \
 asdcplib-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/asdcplib-2.13.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ad3e6a58e9fc8bd41932632391e56477f269cd64387fedfe623bba7142d06498"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-2.13.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib;unpack=0"
SRC_URI[x86_64_v2_asdcplib.sha256sum] = "7cc0ffab9495e78bb14df59acfc7834f95d030246b660bc1d90c761e69415e6e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-devel-2.13.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib-devel;unpack=0"
SRC_URI[x86_64_v2_asdcplib-devel.sha256sum] = "4a4bcd645cc396575284201707e1c0257a3e1454db1eca2454d074e44fd53850"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/asdcplib-tools-2.13.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_asdcplib-tools;unpack=0"
SRC_URI[x86_64_v2_asdcplib-tools.sha256sum] = "4af6e43d5eb3d3ead9184129cc34add7ad9a2d6189de81c2e6d73276ac270e9e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-2.13.2-1.el10_3.aarch64.rpm;name=aarch64_asdcplib;unpack=0"
SRC_URI[aarch64_asdcplib.sha256sum] = "9c80878da4e7403bb74cdfa41168fd7c365e153c27f4a47dc6232877422cfd13"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-devel-2.13.2-1.el10_3.aarch64.rpm;name=aarch64_asdcplib-devel;unpack=0"
SRC_URI[aarch64_asdcplib-devel.sha256sum] = "74a5ea78d7ff06c64522ed35b79e4d07cca0a8d5b7775d47aedba36c5709b02b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/asdcplib-tools-2.13.2-1.el10_3.aarch64.rpm;name=aarch64_asdcplib-tools;unpack=0"
SRC_URI[aarch64_asdcplib-tools.sha256sum] = "ba540519ab7d3df9c1a3d80972953ed9e0196da7ab64f13c71c84a018e07f35d"

RDEPENDS:asdcplib = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 xerces-c \
 "
RDEPENDS:asdcplib-devel = " \
 asdcplib \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:asdcplib-tools = " \
 asdcplib \
 glibc \
 libgcc \
 libstdc++ \
 "
