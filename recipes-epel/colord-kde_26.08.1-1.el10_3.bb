# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colord-kde"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 colord-kde \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/colord-kde-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "300aed617778a246d1f8e496651299a7523cf7068ce227161c24e51b5649841a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/colord-kde-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_colord-kde;unpack=0"
SRC_URI[x86_64_v2_colord-kde.sha256sum] = "e38ec55957998c3e2123c66b59507d6838fbc07c567a07911472cb793e05c238"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/colord-kde-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_colord-kde;unpack=0"
SRC_URI[aarch64_colord-kde.sha256sum] = "b202bb3de00f2aedcf0672f196b1b310bf43de2075e43119a275681a952f1073"

RDEPENDS:colord-kde = " \
 colord \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami-addons \
 kf6-kwidgetsaddons \
 lcms2 \
 libX11 \
 libXrandr \
 libstdc++ \
 plasma-systemsettings \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
