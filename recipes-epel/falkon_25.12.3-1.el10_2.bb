# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "falkon"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 falkon \
 falkon-kde \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/falkon-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fde8c8c456649634573d2705b3c1b264bbcad23cca3e02ce48f2c237ea9f322"

URI_x86_64_v2_falkon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_falkon}"
SRC_URI[x86_64_v2_falkon.sha256sum] = "683bb2707738b791aae30984efc6587ffaba62fd7a059ec176e737ee1fdfed7a"

URI_x86_64_v2_falkon-kde = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/falkon-kde-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_falkon-kde;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_falkon-kde}"
SRC_URI[x86_64_v2_falkon-kde.sha256sum] = "0fb4927ab89e402da2e31e7d00beb8484044ab3352989644b1a6caf94de24998"

URI_aarch64_falkon = "${EPEL_MIRROR}/aarch64/Packages/f/falkon-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_falkon;unpack=0"
SRC_URI:append = " ${URI_aarch64_falkon}"
SRC_URI[aarch64_falkon.sha256sum] = "b45fe9487216da22c7527d246fe28222c8ddf759094e3d600209af67f446c56c"

URI_aarch64_falkon-kde = "${EPEL_MIRROR}/aarch64/Packages/f/falkon-kde-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_falkon-kde;unpack=0"
SRC_URI:append = " ${URI_aarch64_falkon-kde}"
SRC_URI[aarch64_falkon-kde.sha256sum] = "d7e3a6aeb33f1da99eba31d3157bbbc0095f217bd1fbfe7d7b76b76e2c2130dc"

RDEPENDS:falkon = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 libgcc \
 libstdc++ \
 libxcb \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
RDEPENDS:falkon-kde = " \
 falkon \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kio-core-libs \
 kf6-kjobwidgets \
 kf6-kwallet-libs \
 kf6-purpose \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
