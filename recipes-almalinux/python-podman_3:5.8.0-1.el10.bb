# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-podman"
PE = "3"
PV = "5.8.0"
PR = "1.el10"
PACKAGES = " \
 python3-podman \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-podman-5.8.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fb986eb79a28c401343691f30c65ef9480d3e36a739619511a929fb69f89916"

URI_x86_64_v2_python3-podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-podman-5.8.0-1.el10.noarch.rpm;name=x86_64_v2_python3-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-podman}"
SRC_URI[x86_64_v2_python3-podman.sha256sum] = "1a6e8e78b686c1fa52ce007167fd608cdbaf49f39f3b48f1f3bb7764da71879a"

URI_aarch64_python3-podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-podman-5.8.0-1.el10.noarch.rpm;name=aarch64_python3-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-podman}"
SRC_URI[aarch64_python3-podman.sha256sum] = "1a6e8e78b686c1fa52ce007167fd608cdbaf49f39f3b48f1f3bb7764da71879a"

RDEPENDS:python3-podman = " \
 python3 \
 python3-requests \
 python3-urllib3 \
 "
