# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus-python"
PV = "1.3.2"
PR = "8.el10"
PACKAGES = " \
 dbus-python-devel \
 python3-dbus \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dbus-python-1.3.2-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fc39e071e552931ba2383a78e0caf7fd487e075f5b253bfdf9985aaa12ac19d"

URI_x86_64_v2_dbus-python-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dbus-python-devel-1.3.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-python-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-python-devel}"
SRC_URI[x86_64_v2_dbus-python-devel.sha256sum] = "1f0886b8e941cb994174f2cd47ae13261aa55c6376c9c62dbd7e72b699a9ac27"

URI_x86_64_v2_python3-dbus = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dbus-1.3.2-8.el10.x86_64_v2.rpm;name=x86_64_v2_python3-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dbus}"
SRC_URI[x86_64_v2_python3-dbus.sha256sum] = "08b7bedeb61cbd8fadc25ecadaa14a4010daf84e20ad1a8216ca60d1490656bb"

URI_aarch64_dbus-python-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dbus-python-devel-1.3.2-8.el10.aarch64.rpm;name=aarch64_dbus-python-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-python-devel}"
SRC_URI[aarch64_dbus-python-devel.sha256sum] = "068c394e6249dca109f6ad8c2ace3ac68af212ab4e42fedbd317547d32294a65"

URI_aarch64_python3-dbus = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dbus-1.3.2-8.el10.aarch64.rpm;name=aarch64_python3-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dbus}"
SRC_URI[aarch64_python3-dbus.sha256sum] = "0335fdd866a82a04e2e9149b61eb54f1046a764af4c0e7d21a9f08452f7be881"

RDEPENDS:dbus-python-devel = " \
 dbus-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-dbus = " \
 dbus-libs \
 glib2 \
 glibc \
 python3 \
 "
