# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "coreutils"
PV = "9.5"
PR = "12.el10"
PACKAGES = " \
 coreutils \
 coreutils-common \
 coreutils-single \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/coreutils-9.5-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7879e385a70ba6fde0c8a2f5752d2fdca6ebc7faa841b736481bd0b5c7f0fb06"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - coreutils-single: libcap.so.2()(64bit)
# - coreutils: libcap.so.2()(64bit)

URI_x86_64_v2_coreutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-9.5-12.el10.x86_64_v2.rpm;name=x86_64_v2_coreutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreutils}"
SRC_URI[x86_64_v2_coreutils.sha256sum] = "327f01e63169639b8942910cebe4c19f3a81e3d96977bb4056d6ef252055bffb"
RPROVIDES:coreutils:x86_64_v2 = "virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

URI_x86_64_v2_coreutils-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-common-9.5-12.el10.x86_64_v2.rpm;name=x86_64_v2_coreutils-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreutils-common}"
SRC_URI[x86_64_v2_coreutils-common.sha256sum] = "9e314480c739f0760360b0331ceff3c9d3f73430db004cc1e5c0a9abd496860b"

URI_x86_64_v2_coreutils-single = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/coreutils-single-9.5-12.el10.x86_64_v2.rpm;name=x86_64_v2_coreutils-single;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_coreutils-single}"
SRC_URI[x86_64_v2_coreutils-single.sha256sum] = "3e53740c5143a3aba3765daddd324e1798408b83b7467337c61bf7d1a36704c8"
RPROVIDES:coreutils-single:x86_64_v2 = "virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

URI_aarch64_coreutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-9.5-12.el10.aarch64.rpm;name=aarch64_coreutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreutils}"
SRC_URI[aarch64_coreutils.sha256sum] = "2d43b60e80033d54e0b2fdfb9ee4ef5e597a2f95cfa2b77b2e5faa78e6545cee"
RPROVIDES:coreutils:aarch64 = "virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

URI_aarch64_coreutils-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-common-9.5-12.el10.aarch64.rpm;name=aarch64_coreutils-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreutils-common}"
SRC_URI[aarch64_coreutils-common.sha256sum] = "2169e17eb0d25facfc67df3e988afd5a647d3c14e13c0c3c3415b284e6d4ffbf"

URI_aarch64_coreutils-single = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/coreutils-single-9.5-12.el10.aarch64.rpm;name=aarch64_coreutils-single;unpack=0"
SRC_URI:append = " ${URI_aarch64_coreutils-single}"
SRC_URI[aarch64_coreutils-single.sha256sum] = "55ed27ccefdd431c2bc199e6b1893fd7bc90446f93fbe786dd2cf135cbeaa991"
RPROVIDES:coreutils-single:aarch64 = "virtual//usr/bin/basename virtual//usr/bin/chcon virtual//usr/bin/chmod virtual//usr/bin/date virtual//usr/bin/env virtual//usr/bin/head virtual//usr/bin/readlink virtual//usr/bin/realpath virtual//usr/bin/sha512sum virtual//usr/bin/tr virtual/coreutils"

RDEPENDS:coreutils:x86_64_v2 = " \
 coreutils-common \
 glibc \
 gmp \
 libacl \
 libattr \
 libcap \
 libselinux \
 openssl-libs \
"
RDEPENDS:coreutils:aarch64 = " \
 coreutils-common \
 glibc \
 gmp \
 libacl \
 libattr \
 libselinux \
 openssl-libs \
"
RDEPENDS:coreutils-common = " \
 "
RDEPENDS:coreutils-single:x86_64_v2 = " \
 glibc \
 libacl \
 libattr \
 libcap \
 libselinux \
"
RDEPENDS:coreutils-single:aarch64 = " \
 glibc \
 libacl \
 libattr \
 libselinux \
"

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/basename rpm/virtual//usr/bin/chcon rpm/virtual//usr/bin/chmod rpm/virtual//usr/bin/date rpm/virtual//usr/bin/env rpm/virtual//usr/bin/head rpm/virtual//usr/bin/readlink rpm/virtual//usr/bin/realpath rpm/virtual//usr/bin/sha512sum rpm/virtual//usr/bin/tr rpm/virtual/coreutils"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/basename rpm/virtual//usr/bin/chcon rpm/virtual//usr/bin/chmod rpm/virtual//usr/bin/date rpm/virtual//usr/bin/env rpm/virtual//usr/bin/head rpm/virtual//usr/bin/readlink rpm/virtual//usr/bin/realpath rpm/virtual//usr/bin/sha512sum rpm/virtual//usr/bin/tr rpm/virtual/coreutils"
