# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-byteorder"
PV = "1.5.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-byteorder+default-devel \
 rust-byteorder+i128-devel \
 rust-byteorder+std-devel \
 rust-byteorder-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-byteorder-1.5.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ecc093759e7526eba942e6b0e1d70f1a964d5a87ffbd9eb28995bef49dafbbf4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byteorder+default-devel-1.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byteorder+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-byteorder+default-devel.sha256sum] = "e9440f62c3d01012c78d2c5795115ae3ed6d2002412fc1c2b3c1ca413f53887a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byteorder+i128-devel-1.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byteorder+i128-devel;unpack=0"
SRC_URI[x86_64_v2_rust-byteorder+i128-devel.sha256sum] = "2340cf910b955c7173483f529f2da3a538b0f0e62212245310f1f908082388de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byteorder+std-devel-1.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byteorder+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-byteorder+std-devel.sha256sum] = "7a971130f0483ebf21712a8dec6d3cabe3ebb3111383fff9ca9b455cd61d323c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-byteorder-devel-1.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-byteorder-devel;unpack=0"
SRC_URI[x86_64_v2_rust-byteorder-devel.sha256sum] = "527c2b22efbc501beabe3315242b1e4d3a53ad35bd6bbbb263685dbf2eef6686"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-byteorder+default-devel-1.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-byteorder+default-devel;unpack=0"
SRC_URI[aarch64_rust-byteorder+default-devel.sha256sum] = "4dc3e011bd61db53740e810e5fa3df2294b79112ecb1d80ef9f752ed26871bfc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-byteorder+i128-devel-1.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-byteorder+i128-devel;unpack=0"
SRC_URI[aarch64_rust-byteorder+i128-devel.sha256sum] = "eafb9757eea6c7bf8263c2700234d208e138506cf2c9786a2da53eb2445037e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-byteorder+std-devel-1.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-byteorder+std-devel;unpack=0"
SRC_URI[aarch64_rust-byteorder+std-devel.sha256sum] = "5f7f1ef240da8405f888248c0747d3120d7ad4caf92d636df54699168deb0b42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-byteorder-devel-1.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-byteorder-devel;unpack=0"
SRC_URI[aarch64_rust-byteorder-devel.sha256sum] = "16b05d21ba946ba1a39f3d1003bb6f864cf98c2b4aa935ef4f5e530a7c63dc4d"

RDEPENDS:rust-byteorder+default-devel = " \
 cargo \
 rust-byteorder+std-devel \
 rust-byteorder-devel \
 "
RDEPENDS:rust-byteorder+i128-devel = " \
 cargo \
 rust-byteorder-devel \
 "
RDEPENDS:rust-byteorder+std-devel = " \
 cargo \
 rust-byteorder-devel \
 "
RDEPENDS:rust-byteorder-devel = " \
 cargo \
 rust \
 "
