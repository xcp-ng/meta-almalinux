# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der"
PV = "0.8.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-der+alloc-devel \
 rust-der+arbitrary-devel \
 rust-der+ber-devel \
 rust-der+bytes-devel \
 rust-der+default-devel \
 rust-der+derive-devel \
 rust-der+flagset-devel \
 rust-der+heapless-devel \
 rust-der+oid-devel \
 rust-der+pem-devel \
 rust-der+real-devel \
 rust-der+std-devel \
 rust-der+time-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-der-0.8.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "32db927d450e49e0548485d3b7cee5a7ed7e7c0f27645179895d0f04c1707962"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+alloc-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+alloc-devel.sha256sum] = "af30a18ce4ba9a7a7ede26f9c25dd229fca7c2279dd08db906b5fe87aafa73c5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+arbitrary-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+arbitrary-devel.sha256sum] = "47c458e13c2bb37f6175a1cfd3a06f46ba360f6e00b2b0bf91b892ce0d0b2c6c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+ber-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+ber-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+ber-devel.sha256sum] = "4316a8370525437e2e44d8205fc1c54091af090c035e1e81bd3106aa260df232"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+bytes-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+bytes-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+bytes-devel.sha256sum] = "71ce0375cd416ab60e0ae5130de7787e43bbbb2006e81f5197ae9fd270c06ef3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+default-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+default-devel.sha256sum] = "26235b44e8315109a9ac380e12fbdd55220314964d9ccadc223955d6bbd327d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+derive-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+derive-devel.sha256sum] = "b77fa18c1e220ebc04265858582121119bb7baced22b8c335658112bafa38eaa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+flagset-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+flagset-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+flagset-devel.sha256sum] = "5ce8dee7cf2bfbb8bdf9dd23717c5851fceb42306e22a844a0fc6ca593ae7cf4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+heapless-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+heapless-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+heapless-devel.sha256sum] = "d37a8afa4a9cd40c4554cc1d8157aa11f20f02c85a21c8b6a9009308f0da9c83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+oid-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+oid-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+oid-devel.sha256sum] = "68797b635b06824fc58ae54ea6cd71b32d5f1afb20862ffac05c1e8567ea0e8e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+pem-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+pem-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+pem-devel.sha256sum] = "f20062fac37ba21ece680fec3e977460dd79865e9c0c6b1711a2346eab60e11c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+real-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+real-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+real-devel.sha256sum] = "f4ebd241c589532704c04cfb8e778ee12e00e94d13583e1a63038b2af3027330"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+std-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+std-devel.sha256sum] = "3587ceec46e81121fb7d1a4e48c9f06694fe3803226cd821e0c14a8094c1ddfd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+time-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+time-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+time-devel.sha256sum] = "8ee52183e7d3ab1cfc291193032fbec6c0c6023ee49d22f5dab6e01d87d3e148"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der+zeroize-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der+zeroize-devel.sha256sum] = "44795ab8dd1d73ba3479930c16fe53ccf5673274dff8ae9c98add679389f5b6e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-devel;unpack=0"
SRC_URI[x86_64_v2_rust-der-devel.sha256sum] = "359852beb4e2f9c3abf5b0ee0d8c13173029b2dbb70e4e3deb9eaf529219bb85"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+alloc-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-der+alloc-devel.sha256sum] = "099d3d944bac43198434136953fd24433e6b86d07069b4ee944d41955e9982e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+arbitrary-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-der+arbitrary-devel.sha256sum] = "0fc6f71fd9fddc4e3ae6a48e2e55c15959294a7004396974a315928bb93c8ac7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+ber-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+ber-devel;unpack=0"
SRC_URI[aarch64_rust-der+ber-devel.sha256sum] = "664f4d36c24485cad9e3ce0fdeb7748fbd52bdd09b91becb92f184d82d77d161"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+bytes-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+bytes-devel;unpack=0"
SRC_URI[aarch64_rust-der+bytes-devel.sha256sum] = "d2dfe031596a0f45aa71046a3c90a80d22d0710e1c37aa55205602896bfa158c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+default-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+default-devel;unpack=0"
SRC_URI[aarch64_rust-der+default-devel.sha256sum] = "1b7adf4d932b88b72d9c535b437d81305d0adecfc087e924315594236cab5268"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+derive-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+derive-devel;unpack=0"
SRC_URI[aarch64_rust-der+derive-devel.sha256sum] = "b314bb515ea5290688538685d92f0c376cb92196df8f1b95b95c97e711357f7e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+flagset-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+flagset-devel;unpack=0"
SRC_URI[aarch64_rust-der+flagset-devel.sha256sum] = "e20cc326927d10bec8e8e4a018e6b684c94bcc6b6d388be66b54168a8f6ee42a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+heapless-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+heapless-devel;unpack=0"
SRC_URI[aarch64_rust-der+heapless-devel.sha256sum] = "483e29d682fb9e88e5fae799a4de62851697d3d2d000e2c40daa7186e0bf6247"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+oid-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+oid-devel;unpack=0"
SRC_URI[aarch64_rust-der+oid-devel.sha256sum] = "dc1a814d4965fffa069f650d340beecfefb0f5cbe8fe4ca07f065b636a452f58"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+pem-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+pem-devel;unpack=0"
SRC_URI[aarch64_rust-der+pem-devel.sha256sum] = "2fad7663962e2480dd49eaef2113ee5c7a05090a6f6f84296d224fecc87541f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+real-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+real-devel;unpack=0"
SRC_URI[aarch64_rust-der+real-devel.sha256sum] = "08086344caba25e9f6cd0fedd3615e6539a6e20669fb8a6a502c22cad9047532"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+std-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+std-devel;unpack=0"
SRC_URI[aarch64_rust-der+std-devel.sha256sum] = "9f011a2913a983c8bf327d3c750215a848365df709bb05e07698f32690848aa5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+time-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+time-devel;unpack=0"
SRC_URI[aarch64_rust-der+time-devel.sha256sum] = "1403b40c4c77dfe9fec3af6af2ebe702493953cfd7986231767fad712cfc7d95"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der+zeroize-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-der+zeroize-devel.sha256sum] = "d00f1c0725740c600940f840510e6cc40c969bd17d199190dbe9d3b8f779a9c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-der-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-der-devel;unpack=0"
SRC_URI[aarch64_rust-der-devel.sha256sum] = "f15b5925bf8fbf8dc0d6dbac9520bfd6ef416a6d78dedfc2e8029bed8442b945"

RDEPENDS:rust-der+alloc-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-const-oid+arbitrary-devel \
 rust-const-oid+default-devel \
 rust-der+std-devel \
 rust-der-devel \
 rust-derive_arbitrary+default-devel \
 "
RDEPENDS:rust-der+ber-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+bytes-devel = " \
 cargo \
 rust-bytes-devel \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+default-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+derive-devel = " \
 cargo \
 rust-der-devel \
 rust-der_derive+default-devel \
 "
RDEPENDS:rust-der+flagset-devel = " \
 cargo \
 rust-der-devel \
 rust-flagset+default-devel \
 "
RDEPENDS:rust-der+heapless-devel = " \
 cargo \
 rust-der-devel \
 rust-heapless-devel \
 "
RDEPENDS:rust-der+oid-devel = " \
 cargo \
 rust-const-oid+default-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+pem-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der+zeroize-devel \
 rust-der-devel \
 rust-pem-rfc7468+alloc-devel \
 rust-pem-rfc7468+default-devel \
 "
RDEPENDS:rust-der+real-devel = " \
 cargo \
 rust-der-devel \
 "
RDEPENDS:rust-der+std-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-der-devel \
 "
RDEPENDS:rust-der+time-devel = " \
 cargo \
 rust-der-devel \
 rust-time-devel \
 "
RDEPENDS:rust-der+zeroize-devel = " \
 cargo \
 rust-der-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-der-devel = " \
 cargo \
 rust \
 "
