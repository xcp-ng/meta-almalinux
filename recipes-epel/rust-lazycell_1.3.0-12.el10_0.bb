# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lazycell"
PV = "1.3.0"
PR = "12.el10_0"
PACKAGES = " \
 rust-lazycell+default-devel \
 rust-lazycell+serde-devel \
 rust-lazycell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lazycell-1.3.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13ec400d20dd90abd251e2d98d4580c5ff675c66768653283640bce65747f505"

URI_x86_64_v2_rust-lazycell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lazycell+default-devel-1.3.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lazycell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lazycell+default-devel}"
SRC_URI[x86_64_v2_rust-lazycell+default-devel.sha256sum] = "8bb9ad1388112a45857c5b347688df3e10c498e8ffdbeaf95fc4f1fa682fccc4"

URI_x86_64_v2_rust-lazycell+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lazycell+serde-devel-1.3.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lazycell+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lazycell+serde-devel}"
SRC_URI[x86_64_v2_rust-lazycell+serde-devel.sha256sum] = "83d562d33e521c9a5dbfa52d8c8ed1cfcc2a893422ff74bf05581bbab8ae0247"

URI_x86_64_v2_rust-lazycell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lazycell-devel-1.3.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lazycell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lazycell-devel}"
SRC_URI[x86_64_v2_rust-lazycell-devel.sha256sum] = "ea7e988627a6d912ff1b676517e5290cbfb2dde90d89efebc4d0203b96fa2911"

URI_aarch64_rust-lazycell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lazycell+default-devel-1.3.0-12.el10_0.noarch.rpm;name=aarch64_rust-lazycell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lazycell+default-devel}"
SRC_URI[aarch64_rust-lazycell+default-devel.sha256sum] = "859cd0f0e813df20f60f82006708a0bfcf5107b5bcefd2ca22f222eaa524e285"

URI_aarch64_rust-lazycell+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lazycell+serde-devel-1.3.0-12.el10_0.noarch.rpm;name=aarch64_rust-lazycell+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lazycell+serde-devel}"
SRC_URI[aarch64_rust-lazycell+serde-devel.sha256sum] = "0cfbc6d21004ea5a65618ff563bc1a00967f6fe56a654a88e10482d9d255d82c"

URI_aarch64_rust-lazycell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lazycell-devel-1.3.0-12.el10_0.noarch.rpm;name=aarch64_rust-lazycell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lazycell-devel}"
SRC_URI[aarch64_rust-lazycell-devel.sha256sum] = "2b3dab4dc6e9ee0cf23e97cab1add5b1baf031b1799549ba9eaaca6097fc0522"

RDEPENDS:rust-lazycell+default-devel = " \
 cargo \
 rust-lazycell-devel \
 "
RDEPENDS:rust-lazycell+serde-devel = " \
 cargo \
 rust-lazycell-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-lazycell-devel = " \
 cargo \
 "
