# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chic"
PV = "1.2.2"
PR = "5.el10_0"
PACKAGES = " \
 rust-chic+default-devel \
 rust-chic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chic-1.2.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d68a19fbea0b7e181e93c504b19920a479d6adf42bc52aaacd758f73bb964b62"

URI_x86_64_v2_rust-chic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chic+default-devel-1.2.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chic+default-devel}"
SRC_URI[x86_64_v2_rust-chic+default-devel.sha256sum] = "65c5e5ad4303ed4af0eb3ab4d21b53d5f2b9c383f0eed03324a6c95e80b46664"

URI_x86_64_v2_rust-chic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chic-devel-1.2.2-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chic-devel}"
SRC_URI[x86_64_v2_rust-chic-devel.sha256sum] = "a2a6607ce63cddfe4b52beed1a53700533510ee879ce881704d2caad7e354bdb"

URI_aarch64_rust-chic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chic+default-devel-1.2.2-5.el10_0.noarch.rpm;name=aarch64_rust-chic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chic+default-devel}"
SRC_URI[aarch64_rust-chic+default-devel.sha256sum] = "7f80bd1fc55eafe522489eabf662d8b196067560fdce60fc54a774b27aed9760"

URI_aarch64_rust-chic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chic-devel-1.2.2-5.el10_0.noarch.rpm;name=aarch64_rust-chic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chic-devel}"
SRC_URI[aarch64_rust-chic-devel.sha256sum] = "4b105dce378cf76cfddf3c279bce28ceb0535bba86ac304b1cf27d15c18057f2"

RDEPENDS:rust-chic+default-devel = " \
 cargo \
 rust-chic-devel \
 "
RDEPENDS:rust-chic-devel = " \
 cargo \
 rust-annotate-snippets+default-devel \
 "
