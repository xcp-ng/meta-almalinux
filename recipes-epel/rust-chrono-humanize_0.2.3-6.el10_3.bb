# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono-humanize"
PV = "0.2.3"
PR = "6.el10_3"
PACKAGES = " \
 rust-chrono-humanize+default-devel \
 rust-chrono-humanize+pedantic-devel \
 rust-chrono-humanize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-humanize-0.2.3-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adf19891b5743fd6814e62d9d7e7e551ee6032b5f067e87a5499b3885f012079"

URI_x86_64_v2_rust-chrono-humanize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-humanize+default-devel-0.2.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-humanize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-humanize+default-devel}"
SRC_URI[x86_64_v2_rust-chrono-humanize+default-devel.sha256sum] = "9a0dda64f833cd8ef9131cd3304a5be2fe0d71e29dc6984e28f524d88998efec"

URI_x86_64_v2_rust-chrono-humanize+pedantic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-humanize+pedantic-devel-0.2.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-humanize+pedantic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-humanize+pedantic-devel}"
SRC_URI[x86_64_v2_rust-chrono-humanize+pedantic-devel.sha256sum] = "e6b63c5b952e5df95ac307b7376d3c17fa35df0fdd7b4ef6785d4db65c300979"

URI_x86_64_v2_rust-chrono-humanize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-humanize-devel-0.2.3-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-humanize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-humanize-devel}"
SRC_URI[x86_64_v2_rust-chrono-humanize-devel.sha256sum] = "21375cc2c8f982f5cab9ff38e74d6cc2837f20b41d3354c611c66b2553549640"

URI_aarch64_rust-chrono-humanize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-humanize+default-devel-0.2.3-6.el10_3.noarch.rpm;name=aarch64_rust-chrono-humanize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-humanize+default-devel}"
SRC_URI[aarch64_rust-chrono-humanize+default-devel.sha256sum] = "bfc85dab6f53ac5abb69c6edef6760bf24c8f2558760a06acfeb5533d06c82b7"

URI_aarch64_rust-chrono-humanize+pedantic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-humanize+pedantic-devel-0.2.3-6.el10_3.noarch.rpm;name=aarch64_rust-chrono-humanize+pedantic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-humanize+pedantic-devel}"
SRC_URI[aarch64_rust-chrono-humanize+pedantic-devel.sha256sum] = "58b74c46b7173af6a1c40c587fc028e58af1c202b9ad0856fca1e0753bfcf786"

URI_aarch64_rust-chrono-humanize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-humanize-devel-0.2.3-6.el10_3.noarch.rpm;name=aarch64_rust-chrono-humanize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-humanize-devel}"
SRC_URI[aarch64_rust-chrono-humanize-devel.sha256sum] = "f54e61b1a6c692dc5b542242e907ef57b5ec76eff1ce9cdb014d2d16197a7c79"

RDEPENDS:rust-chrono-humanize+default-devel = " \
 cargo \
 rust-chrono-humanize-devel \
 "
RDEPENDS:rust-chrono-humanize+pedantic-devel = " \
 cargo \
 rust-chrono-humanize-devel \
 "
RDEPENDS:rust-chrono-humanize-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
