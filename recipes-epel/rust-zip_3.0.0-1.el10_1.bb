# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zip"
PV = "3.0.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-zip+_all-features-devel \
 rust-zip+_deflate-any-devel \
 rust-zip+aes-crypto-devel \
 rust-zip+aes-devel \
 rust-zip+bzip2-devel \
 rust-zip+chrono-devel \
 rust-zip+constant_time_eq-devel \
 rust-zip+default-devel \
 rust-zip+deflate-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip+deflate-flate2-zlib-devel \
 rust-zip+deflate-flate2-zlib-rs-devel \
 rust-zip+deflate-zopfli-devel \
 rust-zip+deflate64-devel \
 rust-zip+getrandom-devel \
 rust-zip+hmac-devel \
 rust-zip+jiff-02-devel \
 rust-zip+lzma-devel \
 rust-zip+lzma-rs-devel \
 rust-zip+pbkdf2-devel \
 rust-zip+sha1-devel \
 rust-zip+time-devel \
 rust-zip+unreserved-devel \
 rust-zip+xz-devel \
 rust-zip+zeroize-devel \
 rust-zip+zopfli-devel \
 rust-zip+zstd-devel \
 rust-zip-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zip-3.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46af8a6e6058e06b1ab999f12b85275e3bf52200b52136046ea86030688542c9"

URI_x86_64_v2_rust-zip+_all-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_all-features-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+_all-features-devel}"
SRC_URI[x86_64_v2_rust-zip+_all-features-devel.sha256sum] = "48a03383270c5d3fff7346f2c5f61386c8562c22d90cfc3bc3bc756afe6576db"

URI_x86_64_v2_rust-zip+_deflate-any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+_deflate-any-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+_deflate-any-devel}"
SRC_URI[x86_64_v2_rust-zip+_deflate-any-devel.sha256sum] = "6595ae0beaf7687d5f7a6b13139c5d7bab97466caabe9086e5411e617fc3e67e"

URI_x86_64_v2_rust-zip+aes-crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+aes-crypto-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+aes-crypto-devel}"
SRC_URI[x86_64_v2_rust-zip+aes-crypto-devel.sha256sum] = "2160d1f927563df7deca8b0a4ac9c073b1cad4cb1c9cedc90b2beb99081081c3"

URI_x86_64_v2_rust-zip+aes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+aes-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+aes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+aes-devel}"
SRC_URI[x86_64_v2_rust-zip+aes-devel.sha256sum] = "78fd646c7d8df041f02c88c07621d9b997d2b2a9aff8a1a3b3091db1dcc206ba"

URI_x86_64_v2_rust-zip+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+bzip2-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+bzip2-devel}"
SRC_URI[x86_64_v2_rust-zip+bzip2-devel.sha256sum] = "e97c5bdb899a5fe7f2479b08f4bea670cc32cea761dea0171f847ec9d7c67b30"
RPROVIDES:rust-zip+bzip2-devel:append:x86_64_v2 = " virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_7.0.0~"

URI_x86_64_v2_rust-zip+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+chrono-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+chrono-devel}"
SRC_URI[x86_64_v2_rust-zip+chrono-devel.sha256sum] = "96ce3f820d3515b6c7f3c58706e53748d80ad73c18f2875068a1f3df25dd4b7f"

URI_x86_64_v2_rust-zip+constant_time_eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+constant_time_eq-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+constant_time_eq-devel}"
SRC_URI[x86_64_v2_rust-zip+constant_time_eq-devel.sha256sum] = "185b638d9d3acb8478861101436aa4534797e2af6d72790a6be8cddc061539c5"

URI_x86_64_v2_rust-zip+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+default-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+default-devel}"
SRC_URI[x86_64_v2_rust-zip+default-devel.sha256sum] = "55b528599ed1c826193efe1cda3414bcad32ad2a4d669a41bef8eba7b1859f92"

URI_x86_64_v2_rust-zip+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-devel.sha256sum] = "14b629f14cf9b72061b674960cf47989b46daa26faad48826604154d2c58793f"
RPROVIDES:rust-zip+deflate-devel:append:x86_64_v2 = " virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_7.0.0~"

URI_x86_64_v2_rust-zip+deflate-flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-flate2-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-devel.sha256sum] = "c0c004a7463c55944661d6a2f494dbdb69ce923a57acd2af87f68a8bbfaf67de"

URI_x86_64_v2_rust-zip+deflate-flate2-zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-zlib-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-flate2-zlib-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-zlib-devel.sha256sum] = "adaac0e43cb3226a06628a17e6cb57cfe88a71dcc5af2d1c9be3ba617b02fd4a"

URI_x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-flate2-zlib-rs-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-flate2-zlib-rs-devel.sha256sum] = "0f849561299de5102c0512c2beaee521e07528e5068ac55109fca513bc91b38e"

URI_x86_64_v2_rust-zip+deflate-zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate-zopfli-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate-zopfli-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate-zopfli-devel.sha256sum] = "3b91c3269ce46acb0bc908e7fed2ec167ea1e21a6f5be7941ad5e76600b8f896"

URI_x86_64_v2_rust-zip+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+deflate64-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+deflate64-devel}"
SRC_URI[x86_64_v2_rust-zip+deflate64-devel.sha256sum] = "0d2733f7be357e779dcc59a2b27495917676735bcfdd1874754a0b828969d095"

URI_x86_64_v2_rust-zip+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+getrandom-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+getrandom-devel}"
SRC_URI[x86_64_v2_rust-zip+getrandom-devel.sha256sum] = "40a406c82bdaf6e945d1348dc1be284c9e6f6390bb6e5a2576bcfb7a28216f84"

URI_x86_64_v2_rust-zip+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+hmac-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+hmac-devel}"
SRC_URI[x86_64_v2_rust-zip+hmac-devel.sha256sum] = "30a813c188cfdb5c701d0879369be2343b6fdd8eac8f54552012eb42acc5f08e"

URI_x86_64_v2_rust-zip+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+jiff-02-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-zip+jiff-02-devel.sha256sum] = "4173ee4bd061103470a8d5d3eabc5e33d938c8315ca7dd8b171dab6bb8f19fec"

URI_x86_64_v2_rust-zip+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+lzma-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+lzma-devel}"
SRC_URI[x86_64_v2_rust-zip+lzma-devel.sha256sum] = "be7c0452c5300e3f2e15a5ce011bb8bc4e49713fc72f03221c11b37b8f79508c"

URI_x86_64_v2_rust-zip+lzma-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+lzma-rs-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+lzma-rs-devel}"
SRC_URI[x86_64_v2_rust-zip+lzma-rs-devel.sha256sum] = "34f1834e055833ca5f8b998b203c33c888574a3226075ea06a938bd649b0fd93"

URI_x86_64_v2_rust-zip+pbkdf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+pbkdf2-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+pbkdf2-devel}"
SRC_URI[x86_64_v2_rust-zip+pbkdf2-devel.sha256sum] = "7627569fcb6e8320a1cb26e5f44a37a038490fba033ce89e399c9b327e5819f5"

URI_x86_64_v2_rust-zip+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+sha1-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+sha1-devel}"
SRC_URI[x86_64_v2_rust-zip+sha1-devel.sha256sum] = "fb1e0d1fdadc579be2689908bb858b8635de5a05c9831d90e077342a8a4920d6"

URI_x86_64_v2_rust-zip+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+time-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+time-devel}"
SRC_URI[x86_64_v2_rust-zip+time-devel.sha256sum] = "c4b6fcc58d1862776d5b1d99c97b81213519c00128258627e58fc04d28150f7d"

URI_x86_64_v2_rust-zip+unreserved-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+unreserved-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+unreserved-devel}"
SRC_URI[x86_64_v2_rust-zip+unreserved-devel.sha256sum] = "4d5e07a052f7b93de60bf4bff80d9dad7e3406e29a8c2d5dcd4901fce86bf754"

URI_x86_64_v2_rust-zip+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+xz-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+xz-devel}"
SRC_URI[x86_64_v2_rust-zip+xz-devel.sha256sum] = "10f543dc53059df48ec4446801b5fdac467d646b34efa035bbd5c15d89d0d7be"

URI_x86_64_v2_rust-zip+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+zeroize-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+zeroize-devel}"
SRC_URI[x86_64_v2_rust-zip+zeroize-devel.sha256sum] = "01d2a9ee52253c6c92c276b771eb74161917c0d7310e1fd1c00914de2fea5a33"

URI_x86_64_v2_rust-zip+zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+zopfli-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+zopfli-devel}"
SRC_URI[x86_64_v2_rust-zip+zopfli-devel.sha256sum] = "e45f0e7d16a6e6e9099e152f4bdc20aef1c4cd1fa841ef55d581d72387451c11"

URI_x86_64_v2_rust-zip+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip+zstd-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip+zstd-devel}"
SRC_URI[x86_64_v2_rust-zip+zstd-devel.sha256sum] = "a9c96687b9445b933ec72b6ab08a5d9c72534b772b83fbe043590f1c8d85c290"

URI_x86_64_v2_rust-zip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zip-devel-3.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zip-devel}"
SRC_URI[x86_64_v2_rust-zip-devel.sha256sum] = "48ee56d906dbdc0005f625f334939863b39964f5f3d6c0b443f3d307e8cc0280"
RPROVIDES:rust-zip-devel:append:x86_64_v2 = " virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_7.0.0~"

URI_aarch64_rust-zip+_all-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_all-features-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+_all-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+_all-features-devel}"
SRC_URI[aarch64_rust-zip+_all-features-devel.sha256sum] = "2831bc2cc7dfb4a0e642705520d4dd1943afd6f7c3593c49800ac044786041ed"

URI_aarch64_rust-zip+_deflate-any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+_deflate-any-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+_deflate-any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+_deflate-any-devel}"
SRC_URI[aarch64_rust-zip+_deflate-any-devel.sha256sum] = "b6cd931737130de9e352e26b12e591722a95a11dd1e5fa23545169cc5f4f19e6"

URI_aarch64_rust-zip+aes-crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+aes-crypto-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+aes-crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+aes-crypto-devel}"
SRC_URI[aarch64_rust-zip+aes-crypto-devel.sha256sum] = "88e6a2c9371deb79c25b334f2fac83001f0cbafd9aedbbfa6e3fff473b3c5698"

URI_aarch64_rust-zip+aes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+aes-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+aes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+aes-devel}"
SRC_URI[aarch64_rust-zip+aes-devel.sha256sum] = "7047f1daaf38f09ed7cdd3cd7d97a7f8bc2f6a93cd73f492ab3969268fb1b8c9"

URI_aarch64_rust-zip+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+bzip2-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+bzip2-devel}"
SRC_URI[aarch64_rust-zip+bzip2-devel.sha256sum] = "81f14bcdcec758650717e0df53ed546877584b101bb83470aeff3d06fd7eddc5"
RPROVIDES:rust-zip+bzip2-devel:append:aarch64 = " virtual/crate_zip/bzip2__ge_0.6.0_with_crate_zip/bzip2__lt_7.0.0~"

URI_aarch64_rust-zip+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+chrono-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+chrono-devel}"
SRC_URI[aarch64_rust-zip+chrono-devel.sha256sum] = "ad2acf62060892c5523fa2d0e58707212721c148d61651295cc1e21d01985fb2"

URI_aarch64_rust-zip+constant_time_eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+constant_time_eq-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+constant_time_eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+constant_time_eq-devel}"
SRC_URI[aarch64_rust-zip+constant_time_eq-devel.sha256sum] = "b1a5fa5855a26b679d44c9432c3d54c691768422edcad71d47583b16767be720"

URI_aarch64_rust-zip+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+default-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+default-devel}"
SRC_URI[aarch64_rust-zip+default-devel.sha256sum] = "fba7e85f8a6034d517a702b34e7a7670bd80a321d672be2f0b048bdc2050bcbd"

URI_aarch64_rust-zip+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-devel}"
SRC_URI[aarch64_rust-zip+deflate-devel.sha256sum] = "dde029eb7394dfe41e5d17d2b083b629829f6e1065620dfc41260000b04dfb56"
RPROVIDES:rust-zip+deflate-devel:append:aarch64 = " virtual/crate_zip/deflate__ge_0.6.0_with_crate_zip/deflate__lt_7.0.0~"

URI_aarch64_rust-zip+deflate-flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-flate2-devel}"
SRC_URI[aarch64_rust-zip+deflate-flate2-devel.sha256sum] = "0b88edfe4ce6935942eff80504ace26097fea5c317d7898a4f9299bc8e5d0996"

URI_aarch64_rust-zip+deflate-flate2-zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-zlib-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-flate2-zlib-devel}"
SRC_URI[aarch64_rust-zip+deflate-flate2-zlib-devel.sha256sum] = "4566919776e74651e5e77f00233914f65154e48b0e13b6b6637146313c7de6b4"

URI_aarch64_rust-zip+deflate-flate2-zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-flate2-zlib-rs-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+deflate-flate2-zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-flate2-zlib-rs-devel}"
SRC_URI[aarch64_rust-zip+deflate-flate2-zlib-rs-devel.sha256sum] = "a18b761d1731639810cb0636ebefd5cd75eb9c5c65a7d4bd301c5a431947487f"

URI_aarch64_rust-zip+deflate-zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate-zopfli-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+deflate-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate-zopfli-devel}"
SRC_URI[aarch64_rust-zip+deflate-zopfli-devel.sha256sum] = "0e7cf20f4732bdbf1a7d8f4ccccb56c1955c5f9a1d7a9d623959942e23739284"

URI_aarch64_rust-zip+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+deflate64-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+deflate64-devel}"
SRC_URI[aarch64_rust-zip+deflate64-devel.sha256sum] = "e27aa2c862a270a3d458d927d9d5cb2996c2c3ae887e2b14d30630849bb77e4e"

URI_aarch64_rust-zip+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+getrandom-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+getrandom-devel}"
SRC_URI[aarch64_rust-zip+getrandom-devel.sha256sum] = "7814b454d9168f7d7a7175866197575baa70a9c7b079e6e6dd200e9bf6e8ab4e"

URI_aarch64_rust-zip+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+hmac-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+hmac-devel}"
SRC_URI[aarch64_rust-zip+hmac-devel.sha256sum] = "705c96d437440b4df414ca3c39bf1db835c490abd8c814578b571819e816035f"

URI_aarch64_rust-zip+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+jiff-02-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+jiff-02-devel}"
SRC_URI[aarch64_rust-zip+jiff-02-devel.sha256sum] = "c99ee3c419955235a1e9217e7da8ba1d90c3dbf001324a5ff7591e63384e80ba"

URI_aarch64_rust-zip+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+lzma-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+lzma-devel}"
SRC_URI[aarch64_rust-zip+lzma-devel.sha256sum] = "4137d3ecee45d9caeeae64ba5b6e5285d5b8d9186783da1fa0eff60f1b608bc8"

URI_aarch64_rust-zip+lzma-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+lzma-rs-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+lzma-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+lzma-rs-devel}"
SRC_URI[aarch64_rust-zip+lzma-rs-devel.sha256sum] = "5db779308fd9b298c7ff596d51546a9588ead86752b3a180f3de088e7cb17009"

URI_aarch64_rust-zip+pbkdf2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+pbkdf2-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+pbkdf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+pbkdf2-devel}"
SRC_URI[aarch64_rust-zip+pbkdf2-devel.sha256sum] = "1fb61e9d56929ad3dad85d922d3fec448f4e6b2679bff3c394dd24b422f61e27"

URI_aarch64_rust-zip+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+sha1-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+sha1-devel}"
SRC_URI[aarch64_rust-zip+sha1-devel.sha256sum] = "c8de5a72dbed18036bcb260b687b72995f22dad71e3e26a2dc8404b98402a422"

URI_aarch64_rust-zip+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+time-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+time-devel}"
SRC_URI[aarch64_rust-zip+time-devel.sha256sum] = "37bdf64de55a5381a476e4eafd2c7e4491f03466fe31547ca3fe8acfd549b24a"

URI_aarch64_rust-zip+unreserved-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+unreserved-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+unreserved-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+unreserved-devel}"
SRC_URI[aarch64_rust-zip+unreserved-devel.sha256sum] = "1cbe2160aaa1e3cc0792815fe2f6e72dbc315a61721bb0313e7eba343c413f8f"

URI_aarch64_rust-zip+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+xz-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+xz-devel}"
SRC_URI[aarch64_rust-zip+xz-devel.sha256sum] = "3c5ef4753a25faf03c2118651161e1e4593197c04bc75ec3a3e7b685cdf53613"

URI_aarch64_rust-zip+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+zeroize-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+zeroize-devel}"
SRC_URI[aarch64_rust-zip+zeroize-devel.sha256sum] = "157899a054bcdfae49fbc40867e56743df55aa8769950d5818d330a0652a00a1"

URI_aarch64_rust-zip+zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+zopfli-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+zopfli-devel}"
SRC_URI[aarch64_rust-zip+zopfli-devel.sha256sum] = "3ce3832a952b794907074e2e860bc812f25ca34d516989ab2e389c5feeed2a34"

URI_aarch64_rust-zip+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip+zstd-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip+zstd-devel}"
SRC_URI[aarch64_rust-zip+zstd-devel.sha256sum] = "98b71207755ae07cbf392d6edbb2c1250b1aa8a0a84ee9b06be0f4d7512a608c"

URI_aarch64_rust-zip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zip-devel-3.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-zip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zip-devel}"
SRC_URI[aarch64_rust-zip-devel.sha256sum] = "1f0e563636d91bd0419ad5b5382c23e9df29e5d33946d4f3a0acc130a414ea27"
RPROVIDES:rust-zip-devel:append:aarch64 = " virtual/crate_zip__ge_0.6.0_with_crate_zip__lt_7.0.0~"

RDEPENDS:rust-zip+_all-features-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+_deflate-any-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+aes-crypto-devel = " \
 cargo \
 rust-zip+aes-devel \
 rust-zip+constant_time_eq-devel \
 rust-zip+getrandom-devel \
 rust-zip+hmac-devel \
 rust-zip+pbkdf2-devel \
 rust-zip+sha1-devel \
 rust-zip+zeroize-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+aes-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+chrono-devel = " \
 cargo \
 rust-chrono+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+constant_time_eq-devel = " \
 cargo \
 rust-constant_time_eq+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+default-devel = " \
 cargo \
 rust-zip+aes-crypto-devel \
 rust-zip+bzip2-devel \
 rust-zip+deflate-devel \
 rust-zip+deflate64-devel \
 rust-zip+lzma-devel \
 rust-zip+time-devel \
 rust-zip+xz-devel \
 rust-zip+zstd-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-devel = " \
 cargo \
 rust-zip+deflate-flate2-zlib-rs-devel \
 rust-zip+deflate-zopfli-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-devel = " \
 cargo \
 rust-flate2-devel \
 rust-zip+_deflate-any-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-zlib-devel = " \
 cargo \
 rust-flate2+zlib-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-flate2-zlib-rs-devel = " \
 cargo \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-zip+deflate-flate2-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate-zopfli-devel = " \
 cargo \
 rust-zip+_deflate-any-devel \
 rust-zip+zopfli-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+deflate64-devel = " \
 cargo \
 rust-deflate64+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+hmac-devel = " \
 cargo \
 rust-hmac+default-devel \
 rust-hmac+reset-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+lzma-devel = " \
 cargo \
 rust-lzma-rs+stream-devel \
 rust-lzma-rs-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+lzma-rs-devel = " \
 cargo \
 rust-lzma-rs-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+pbkdf2-devel = " \
 cargo \
 rust-pbkdf2+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+sha1-devel = " \
 cargo \
 rust-sha1+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+time-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+unreserved-devel = " \
 cargo \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+xz-devel = " \
 cargo \
 rust-xz2+default-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+zeroize-devel = " \
 cargo \
 rust-zeroize+default-devel \
 rust-zeroize+zeroize_derive-devel \
 rust-zip-devel \
 "
RDEPENDS:rust-zip+zopfli-devel = " \
 cargo \
 rust-zip-devel \
 rust-zopfli+default-devel \
 "
RDEPENDS:rust-zip+zstd-devel = " \
 cargo \
 rust-zip-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-zip-devel = " \
 cargo \
 rust \
 rust-crc32fast+default-devel \
 rust-indexmap+default-devel \
 rust-memchr+default-devel \
 "
