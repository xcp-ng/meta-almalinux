# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sys-info"
PV = "0.9.1"
PR = "8.el10_0"
PACKAGES = " \
 rust-sys-info+default-devel \
 rust-sys-info-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sys-info-0.9.1-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9b048ad6de45231733004dbd8b39e4d87d90cd2289c5cae44353f96d8b85ebd"

URI_x86_64_v2_rust-sys-info+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sys-info+default-devel-0.9.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sys-info+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sys-info+default-devel}"
SRC_URI[x86_64_v2_rust-sys-info+default-devel.sha256sum] = "89588355bfc74997bf52a1aefa42ffdbadc2707ce1ff011cd10bea5b79dc87f9"

URI_x86_64_v2_rust-sys-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sys-info-devel-0.9.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sys-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sys-info-devel}"
SRC_URI[x86_64_v2_rust-sys-info-devel.sha256sum] = "b5e6c614f1b0e3e624a5e0f642f42e2141dc4981618f47258123353ed2c95726"

URI_aarch64_rust-sys-info+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sys-info+default-devel-0.9.1-8.el10_0.noarch.rpm;name=aarch64_rust-sys-info+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sys-info+default-devel}"
SRC_URI[aarch64_rust-sys-info+default-devel.sha256sum] = "72a3788e47f6d96bd970f068c415bd651111e953ba1c5bab1a5f42acc55f110e"

URI_aarch64_rust-sys-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sys-info-devel-0.9.1-8.el10_0.noarch.rpm;name=aarch64_rust-sys-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sys-info-devel}"
SRC_URI[aarch64_rust-sys-info-devel.sha256sum] = "8eef70ccec0cdb94dea05d0109fae645ee9ca70e559faa8d77686acc3cc6d45b"

RDEPENDS:rust-sys-info+default-devel = " \
 cargo \
 rust-sys-info-devel \
 "
RDEPENDS:rust-sys-info-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-libc+default-devel \
 "
