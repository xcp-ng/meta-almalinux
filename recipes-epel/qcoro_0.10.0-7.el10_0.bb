# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qcoro"
PV = "0.10.0"
PR = "7.el10_0"
PACKAGES = " \
 qcoro-qt5 \
 qcoro-qt5-devel \
 qcoro-qt6 \
 qcoro-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qcoro-0.10.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "764c68efc5f81a2403befa0056b7bf5dc03e1f7fa68d749460ca6dea83c1ca44"

URI_x86_64_v2_qcoro-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt5-0.10.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt5}"
SRC_URI[x86_64_v2_qcoro-qt5.sha256sum] = "0d0d265540bedadc3be7c3213262b9c47555ff494591623859c457df35052e8b"

URI_x86_64_v2_qcoro-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt5-devel-0.10.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt5-devel}"
SRC_URI[x86_64_v2_qcoro-qt5-devel.sha256sum] = "7bc1778550a94bd5707731ff78649351f30dca9a194a7943710dc41da7356229"

URI_x86_64_v2_qcoro-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt6-0.10.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt6}"
SRC_URI[x86_64_v2_qcoro-qt6.sha256sum] = "6e1f935ed11eb8f5526f652b7364bb29223d44e4f08c7efc00eab16c867926d5"

URI_x86_64_v2_qcoro-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qcoro-qt6-devel-0.10.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qcoro-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qcoro-qt6-devel}"
SRC_URI[x86_64_v2_qcoro-qt6-devel.sha256sum] = "49fdda6b599c2a73dca1a4e50a2d4c259baecca5fc48d251b0e9b54a633e262d"

URI_aarch64_qcoro-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt5-0.10.0-7.el10_0.aarch64.rpm;name=aarch64_qcoro-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt5}"
SRC_URI[aarch64_qcoro-qt5.sha256sum] = "a4e29ae8d1023ad4a8d82a3335e2c104343488d614474694a335e4557d603778"

URI_aarch64_qcoro-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt5-devel-0.10.0-7.el10_0.aarch64.rpm;name=aarch64_qcoro-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt5-devel}"
SRC_URI[aarch64_qcoro-qt5-devel.sha256sum] = "1635e1518aeb87ad35b3cc282442069e7fbd7285b9ab9ca5500c7812e78e7842"

URI_aarch64_qcoro-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt6-0.10.0-7.el10_0.aarch64.rpm;name=aarch64_qcoro-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt6}"
SRC_URI[aarch64_qcoro-qt6.sha256sum] = "81cf6cd59d60f37645374a1fd29cf419fd6e33904fd920dcf69797ea7224be4f"

URI_aarch64_qcoro-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qcoro-qt6-devel-0.10.0-7.el10_0.aarch64.rpm;name=aarch64_qcoro-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qcoro-qt6-devel}"
SRC_URI[aarch64_qcoro-qt6-devel.sha256sum] = "c4cee3cdbed89079db2b131c00b003564db7288286d7829b6fa3660e87d21e4c"

RDEPENDS:qcoro-qt5 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtwebsockets \
 "
RDEPENDS:qcoro-qt5-devel = " \
 cmake-filesystem \
 qcoro-qt5 \
 qt5-qtbase-devel \
 "
RDEPENDS:qcoro-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:qcoro-qt6-devel = " \
 cmake-filesystem \
 qcoro-qt6 \
 qt6-qtbase-devel \
 "
