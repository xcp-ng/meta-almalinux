# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocblas"
PV = "7.1.1"
PR = "6.el10_2"
PACKAGES:x86_64_v2 = " \
 rocblas \
 rocblas-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocblas-7.1.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7df8dd5e4d3df6a73e4cd2d65373bcf06ae594e0d2ed46043207b3cb54670263"

URI_x86_64_v2_rocblas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocblas-7.1.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocblas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocblas}"
SRC_URI[x86_64_v2_rocblas.sha256sum] = "6efd924a191012ff8f36662616e2d2f7a86530d9ea94253729865bed78c90e5f"

URI_x86_64_v2_rocblas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocblas-devel-7.1.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocblas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocblas-devel}"
SRC_URI[x86_64_v2_rocblas-devel.sha256sum] = "8cc645a7519fd1d475dd566358dc08bdf4b4521120b5511b3278e6311d4dae99"

RDEPENDS:rocblas = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:rocblas-devel = " \
 cmake-filesystem \
 rocblas \
 rocm-hip-devel \
 "
