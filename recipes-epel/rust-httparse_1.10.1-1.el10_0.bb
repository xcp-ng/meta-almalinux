# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-httparse"
PV = "1.10.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-httparse+default-devel \
 rust-httparse+std-devel \
 rust-httparse-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-httparse-1.10.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "abb4e51bb4f18bff4048991c554667ea828c0a33998abc8ae403d99266b9e76a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-httparse+default-devel-1.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-httparse+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-httparse+default-devel.sha256sum] = "17eff6878671193b2494dcbdeac29a6852b8b36a79ea14e591c986c3dd07b561"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-httparse+std-devel-1.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-httparse+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-httparse+std-devel.sha256sum] = "73c4ef45a6a54acddef2c0724c45fd3f09f2b26871e3f367707c7415173ffcd0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-httparse-devel-1.10.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-httparse-devel;unpack=0"
SRC_URI[x86_64_v2_rust-httparse-devel.sha256sum] = "56e3a377741fad920d63bb5aaade67b665ae96593e2e64282d3ec16b6c802959"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-httparse+default-devel-1.10.1-1.el10_0.noarch.rpm;name=aarch64_rust-httparse+default-devel;unpack=0"
SRC_URI[aarch64_rust-httparse+default-devel.sha256sum] = "6ac2d31981cc6d8b2d97b4a81131c5cee8c6190c5f566a1766e4a9590a7f57cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-httparse+std-devel-1.10.1-1.el10_0.noarch.rpm;name=aarch64_rust-httparse+std-devel;unpack=0"
SRC_URI[aarch64_rust-httparse+std-devel.sha256sum] = "5273fba586793fce712a235feae6ffdf369816be785bcd58f040e253c605a37e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-httparse-devel-1.10.1-1.el10_0.noarch.rpm;name=aarch64_rust-httparse-devel;unpack=0"
SRC_URI[aarch64_rust-httparse-devel.sha256sum] = "8d902ff797a6cde0004dc61d062fbf6130ba26a233592fffe76cc0be0ae33caa"

RDEPENDS:rust-httparse+default-devel = " \
 cargo \
 rust-httparse+std-devel \
 rust-httparse-devel \
 "
RDEPENDS:rust-httparse+std-devel = " \
 cargo \
 rust-httparse-devel \
 "
RDEPENDS:rust-httparse-devel = " \
 cargo \
 "
