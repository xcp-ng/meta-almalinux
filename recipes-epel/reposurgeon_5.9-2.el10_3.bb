# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "reposurgeon"
PV = "5.9"
PR = "2.el10_3"
PACKAGES = " \
 reposurgeon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/reposurgeon-5.9-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b48204e35286360592a7c597d7788939294653a3352276758662a68702cc22e"

URI_x86_64_v2_reposurgeon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/reposurgeon-5.9-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_reposurgeon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_reposurgeon}"
SRC_URI[x86_64_v2_reposurgeon.sha256sum] = "db75dc01c2a348dfd44fa959415eaecd9e91b018311859dcdbe5da1e67ad6095"

URI_aarch64_reposurgeon = "${EPEL_MIRROR}/aarch64/Packages/r/reposurgeon-5.9-2.el10_3.aarch64.rpm;name=aarch64_reposurgeon;unpack=0"
SRC_URI:append = " ${URI_aarch64_reposurgeon}"
SRC_URI[aarch64_reposurgeon.sha256sum] = "84ee19d190f0ac4ecbc0cf1af1c15887d81e3138b7cf27f54fc8e03b9489f433"

RDEPENDS:reposurgeon = " \
 emacs-filesystem \
 glibc \
 "
