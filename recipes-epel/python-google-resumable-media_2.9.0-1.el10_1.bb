# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-resumable-media"
PV = "2.9.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-google-resumable-media \
 python3-google-resumable-media+requests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-resumable-media-2.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a32a50d6baadbb64582508b33a0b6b2f82cef885e51c5cb95b4c777b621c4cf8"

URI_x86_64_v2_python3-google-resumable-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-resumable-media-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-resumable-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-resumable-media}"
SRC_URI[x86_64_v2_python3-google-resumable-media.sha256sum] = "46093ed1e46e3ea44adf73529de4ab2c71e55cd4edd582a554a90fea5e1e5fb5"

URI_x86_64_v2_python3-google-resumable-media+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-resumable-media+requests-2.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-resumable-media+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-resumable-media+requests}"
SRC_URI[x86_64_v2_python3-google-resumable-media+requests.sha256sum] = "2bc4f1820ea01cce25905c33b2674f09988f4f55f74b5ec0328a76098ba825cb"

URI_aarch64_python3-google-resumable-media = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-resumable-media-2.9.0-1.el10_1.noarch.rpm;name=aarch64_python3-google-resumable-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-resumable-media}"
SRC_URI[aarch64_python3-google-resumable-media.sha256sum] = "1d8bccb45afdfabccdbc4f727cd6691feafc0fd0b84443ef2c66a49fe0f3f5a8"

URI_aarch64_python3-google-resumable-media+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-resumable-media+requests-2.9.0-1.el10_1.noarch.rpm;name=aarch64_python3-google-resumable-media+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-resumable-media+requests}"
SRC_URI[aarch64_python3-google-resumable-media+requests.sha256sum] = "a4fa84496067c514e8ba0cdcd1074ca31b8d536246939cc46de6bd2fdb064be4"

RDEPENDS:python3-google-resumable-media = " \
 python3 \
 python3-google-crc32c \
 "
RDEPENDS:python3-google-resumable-media+requests = " \
 python3 \
 python3-google-resumable-media \
 python3-requests \
 "
