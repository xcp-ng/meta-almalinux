# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pymilter"
PV = "1.0.6"
PR = "14.el10_2"
PACKAGES = " \
 python-pymilter-common \
 python-pymilter-selinux \
 python3-pymilter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pymilter-1.0.6-14.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4c8e07d4959b1dd4b852ffd8f50456990be51720d201466798f3f2971234a40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pymilter-common-1.0.6-14.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-pymilter-common;unpack=0"
SRC_URI[x86_64_v2_python-pymilter-common.sha256sum] = "3ab85802870d27bd63e2890f5608ed039255696350c00a035182ac9beb6c2663"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pymilter-selinux-1.0.6-14.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-pymilter-selinux;unpack=0"
SRC_URI[x86_64_v2_python-pymilter-selinux.sha256sum] = "5f1083797f579551c7e0ca7b347c0700bf52e3484a6e9009e72377ffef0ffaf7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pymilter-1.0.6-14.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pymilter;unpack=0"
SRC_URI[x86_64_v2_python3-pymilter.sha256sum] = "e1528577337ef11ecd2882b467ef8caa7350e32b28ff8424ac9b5cf6d23fdd60"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-pymilter-common-1.0.6-14.el10_2.noarch.rpm;name=aarch64_python-pymilter-common;unpack=0"
SRC_URI[aarch64_python-pymilter-common.sha256sum] = "f459b9d06041410f66f29110feb9a19449a3b02682efa72624c00722e9a1fd87"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-pymilter-selinux-1.0.6-14.el10_2.noarch.rpm;name=aarch64_python-pymilter-selinux;unpack=0"
SRC_URI[aarch64_python-pymilter-selinux.sha256sum] = "98f6847c2193e44d8ee994ae91e361764ce2bca70346c41fe2a6f84f10296976"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pymilter-1.0.6-14.el10_2.aarch64.rpm;name=aarch64_python3-pymilter;unpack=0"
SRC_URI[aarch64_python3-pymilter.sha256sum] = "2a434e143cd9ebf9b2df45bfbd26bf76701a99c4a94b8177c7a65021b524f2cf"

RDEPENDS:python-pymilter-common = " \
 "
RDEPENDS:python-pymilter-selinux = " \
 bash \
 policycoreutils \
 python-pymilter-common \
 selinux-policy-targeted \
 "
RDEPENDS:python3-pymilter = " \
 glibc \
 python-pymilter-common \
 python3 \
 python3-py3dns \
 sendmail-milter \
 "
