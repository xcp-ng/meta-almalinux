# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-locale"
PV = "0.9.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-unic-locale+default-devel \
 rust-unic-locale+likelysubtags-devel \
 rust-unic-locale+macros-devel \
 rust-unic-locale+unic-locale-macros-devel \
 rust-unic-locale-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-unic-locale-0.9.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91a2debe489a67e394f731fc8700652b9bef4ad27e9a9acd65f29ade080c9395"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale+default-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unic-locale+default-devel.sha256sum] = "5519cfe6e138c77da33085356b495fa826c94c263a600964c680da096509e56c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale+likelysubtags-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale+likelysubtags-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unic-locale+likelysubtags-devel.sha256sum] = "5bd3aaa040aa12eae32967f288b149b52c7670c8df3da468a6bc5ab452408886"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale+macros-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale+macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unic-locale+macros-devel.sha256sum] = "ec2ba532cc3672dc96eb62453a86211d034e91dc11f764db0834d7cfd49d9075"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale+unic-locale-macros-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale+unic-locale-macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unic-locale+unic-locale-macros-devel.sha256sum] = "a4c864d7bed49b81ee31d46cc7553144c29beeabd6366dc98464d5d3934fd12e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-locale-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-locale-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unic-locale-devel.sha256sum] = "e6943d0e4b756f0d1e5ef55bcf8b424a3bea7d8a8ad3a2b4636d6634d1eacac3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale+default-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale+default-devel;unpack=0"
SRC_URI[aarch64_rust-unic-locale+default-devel.sha256sum] = "3235a7a929a2b5df5ba00fa96bd4ec14d42f76f745c8486d64110a06b1dbfb1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale+likelysubtags-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale+likelysubtags-devel;unpack=0"
SRC_URI[aarch64_rust-unic-locale+likelysubtags-devel.sha256sum] = "1278707fd9a5437db2bf5d1ba7a8309a77ed3eedd8601ccbe60b8ce6809c90be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale+macros-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale+macros-devel;unpack=0"
SRC_URI[aarch64_rust-unic-locale+macros-devel.sha256sum] = "3f5aae07a33a0a6200050771373c29e975b11a2eed731b7c885a2ab14cef34fb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale+unic-locale-macros-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale+unic-locale-macros-devel;unpack=0"
SRC_URI[aarch64_rust-unic-locale+unic-locale-macros-devel.sha256sum] = "79328caa13e2f1cd1ca3049dae3f3a9d3fbc1c8bb3f5b07f9387319395d62df0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-locale-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-locale-devel;unpack=0"
SRC_URI[aarch64_rust-unic-locale-devel.sha256sum] = "47cc2d7deb260f0292840604c8ac9e293457142b630c8822f7de7f813da1fd5c"

RDEPENDS:rust-unic-locale+default-devel = " \
 cargo \
 rust-unic-locale-devel \
 "
RDEPENDS:rust-unic-locale+likelysubtags-devel = " \
 cargo \
 rust-unic-locale-devel \
 rust-unic-locale-impl+likelysubtags-devel \
 "
RDEPENDS:rust-unic-locale+macros-devel = " \
 cargo \
 rust-unic-locale+unic-locale-macros-devel \
 rust-unic-locale-devel \
 "
RDEPENDS:rust-unic-locale+unic-locale-macros-devel = " \
 cargo \
 rust-unic-locale-devel \
 rust-unic-locale-macros+default-devel \
 "
RDEPENDS:rust-unic-locale-devel = " \
 cargo \
 rust-unic-langid-impl+default-devel \
 rust-unic-locale-impl+default-devel \
 "
