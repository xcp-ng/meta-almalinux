# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-volcengine-tos"
PV = "3.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-volcengine-tos+default-devel \
 rust-reqsign-volcengine-tos-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-volcengine-tos-3.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e6a623913138a559c204ad0dbb6319469146bdf9096cc7b2f59ddd6f78713db"

URI_x86_64_v2_rust-reqsign-volcengine-tos+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-volcengine-tos+default-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-volcengine-tos+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-volcengine-tos+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-volcengine-tos+default-devel.sha256sum] = "d81e18f454694ca07c548dde14a04aa162598d806826c8c67e4a3b2cce500744"

URI_x86_64_v2_rust-reqsign-volcengine-tos-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-volcengine-tos-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-volcengine-tos-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-volcengine-tos-devel}"
SRC_URI[x86_64_v2_rust-reqsign-volcengine-tos-devel.sha256sum] = "a91d6828b793243ad4db1996b1116ff7ca0df2018f328e28221e25c5ff55a26d"

URI_aarch64_rust-reqsign-volcengine-tos+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-volcengine-tos+default-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-volcengine-tos+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-volcengine-tos+default-devel}"
SRC_URI[aarch64_rust-reqsign-volcengine-tos+default-devel.sha256sum] = "468ab17ae6fe08bb6e0c0f91320d20fb6a8e13da4fbef55c6deec46373467d69"

URI_aarch64_rust-reqsign-volcengine-tos-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-volcengine-tos-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-volcengine-tos-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-volcengine-tos-devel}"
SRC_URI[aarch64_rust-reqsign-volcengine-tos-devel.sha256sum] = "1b9de5ef8136ae8238d7e4fabb17483f0fc33d358bdd20355f5137c7a191feab"

RDEPENDS:rust-reqsign-volcengine-tos+default-devel = " \
 cargo \
 rust-reqsign-volcengine-tos-devel \
 "
RDEPENDS:rust-reqsign-volcengine-tos-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 "
