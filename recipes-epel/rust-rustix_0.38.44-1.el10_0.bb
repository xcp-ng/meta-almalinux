# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustix"
PV = "0.38.44"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustix+all-apis-devel \
 rust-rustix+alloc-devel \
 rust-rustix+cc-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+itoa-devel \
 rust-rustix+libc-devel \
 rust-rustix+libc-extra-traits-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix+linux_4_11-devel \
 rust-rustix+linux_latest-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+once_cell-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+procfs-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+std-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix+try_close-devel \
 rust-rustix+use-explicitly-provided-auxv-devel \
 rust-rustix+use-libc-auxv-devel \
 rust-rustix+use-libc-devel \
 rust-rustix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustix-0.38.44-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd79a963477f7283007beab4f5cd491a6c4c300200593abbcaf6697620d0ba8f"

URI_x86_64_v2_rust-rustix+all-apis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+all-apis-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+all-apis-devel}"
SRC_URI[x86_64_v2_rust-rustix+all-apis-devel.sha256sum] = "ad1e5f2e2cc56643bf81f3b2bfd27754419995217d5fade7b1c7df5492fa3ad5"

URI_x86_64_v2_rust-rustix+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+alloc-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustix+alloc-devel.sha256sum] = "9db63b3295a4c9da9092ba3dfd61da665632d88aab93aa48112b2a8cfd4df61c"

URI_x86_64_v2_rust-rustix+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+cc-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+cc-devel}"
SRC_URI[x86_64_v2_rust-rustix+cc-devel.sha256sum] = "0eb2841b713dea936c71084bd4c7a8c7cf3d2f3f19ba1655df9576b48b9a33c7"

URI_x86_64_v2_rust-rustix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+default-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+default-devel}"
SRC_URI[x86_64_v2_rust-rustix+default-devel.sha256sum] = "a8ba9941f2a2f0dfe629db54f24db933ea8e1f1268fdce324f5630af4d8fe802"

URI_x86_64_v2_rust-rustix+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+event-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+event-devel}"
SRC_URI[x86_64_v2_rust-rustix+event-devel.sha256sum] = "a6443ca811e02a4fe98a915699c395741dd7a8889f27a40da47fc22dec1dec9e"

URI_x86_64_v2_rust-rustix+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+fs-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+fs-devel}"
SRC_URI[x86_64_v2_rust-rustix+fs-devel.sha256sum] = "08e13ede45cda96ee48ed82031a487760bc16fdfa8667b8580785eaa1d1227da"

URI_x86_64_v2_rust-rustix+io_uring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+io_uring-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+io_uring-devel}"
SRC_URI[x86_64_v2_rust-rustix+io_uring-devel.sha256sum] = "d1aa328a36e94c45b140526abb6a6702ffeacd6d2d7a6c4265e0e9c6714a8bc9"

URI_x86_64_v2_rust-rustix+itoa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+itoa-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+itoa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+itoa-devel}"
SRC_URI[x86_64_v2_rust-rustix+itoa-devel.sha256sum] = "e83a25a7d0f4a53cdc94d5ac0264b359c3037bee6efbe1e664debeb089279456"

URI_x86_64_v2_rust-rustix+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+libc-devel}"
SRC_URI[x86_64_v2_rust-rustix+libc-devel.sha256sum] = "9f5dbd4d1533a0a0c9981180cf6b2212fa8dc25fa5084022f78d4d212fb5e013"

URI_x86_64_v2_rust-rustix+libc-extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc-extra-traits-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc-extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+libc-extra-traits-devel}"
SRC_URI[x86_64_v2_rust-rustix+libc-extra-traits-devel.sha256sum] = "fcd94a55fc229c6d67b75145a4b6d3f770ff6bae5e43855a30262e0c9c3680fc"

URI_x86_64_v2_rust-rustix+libc_errno-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+libc_errno-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+libc_errno-devel}"
SRC_URI[x86_64_v2_rust-rustix+libc_errno-devel.sha256sum] = "5c80024aa882dae8d19566a05570ef35e49680a3248feabb657b9736bff48a10"

URI_x86_64_v2_rust-rustix+linux_4_11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_4_11-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_4_11-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_4_11-devel.sha256sum] = "9ac9903cc53ed95ba063f808727cabb43ab5ba0243cc790bf69185c6eaa21fc1"

URI_x86_64_v2_rust-rustix+linux_latest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+linux_latest-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+linux_latest-devel}"
SRC_URI[x86_64_v2_rust-rustix+linux_latest-devel.sha256sum] = "90ee0b7cc71b9106df7bf783f0db2d20a5a5003454de28c06904e070393fed97"

URI_x86_64_v2_rust-rustix+mm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mm-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+mm-devel}"
SRC_URI[x86_64_v2_rust-rustix+mm-devel.sha256sum] = "89c7b525fb62946972beaefcbcce3b5ad1cab75b4086d6c1f7be60e93ac9178b"

URI_x86_64_v2_rust-rustix+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+mount-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+mount-devel}"
SRC_URI[x86_64_v2_rust-rustix+mount-devel.sha256sum] = "b0ef086a7fbb5d66029a3cdd51eff6f43eacf4ed066c6f497beddf5665cdcc2f"

URI_x86_64_v2_rust-rustix+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+net-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+net-devel}"
SRC_URI[x86_64_v2_rust-rustix+net-devel.sha256sum] = "0b45648ecc5738599df58ceee35277e27c3afd7a0e0aac8f7d567ed348f60d86"

URI_x86_64_v2_rust-rustix+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+once_cell-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+once_cell-devel}"
SRC_URI[x86_64_v2_rust-rustix+once_cell-devel.sha256sum] = "ac8dac4b1723e3dd00ce8b93734195f9ccc91c0615f7dc943499e46dcfc75c0e"

URI_x86_64_v2_rust-rustix+param-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+param-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+param-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+param-devel}"
SRC_URI[x86_64_v2_rust-rustix+param-devel.sha256sum] = "86ac97ed825edf0ff2f3351d94f2827d6d56dfd35c5a7d4ce3a1ef90295c6b8d"

URI_x86_64_v2_rust-rustix+pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pipe-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+pipe-devel}"
SRC_URI[x86_64_v2_rust-rustix+pipe-devel.sha256sum] = "040db2a387bfad81004c50b58980324c15bf3a651ce89017f743e534004f9505"

URI_x86_64_v2_rust-rustix+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+process-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+process-devel}"
SRC_URI[x86_64_v2_rust-rustix+process-devel.sha256sum] = "733c69c4a183f50f581027732ab689514cabc71d0eda578b4945e0d915b605e1"

URI_x86_64_v2_rust-rustix+procfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+procfs-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+procfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+procfs-devel}"
SRC_URI[x86_64_v2_rust-rustix+procfs-devel.sha256sum] = "a3e920c3f41937e2c6e3f89fccc9629a51000d4b3d7330b463b03f13de9d6a40"

URI_x86_64_v2_rust-rustix+pty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+pty-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+pty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+pty-devel}"
SRC_URI[x86_64_v2_rust-rustix+pty-devel.sha256sum] = "8b9cc34f9b6fa3dd463a177566b7c66675d867583694c5de4ef43436e412da0e"

URI_x86_64_v2_rust-rustix+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+rand-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+rand-devel}"
SRC_URI[x86_64_v2_rust-rustix+rand-devel.sha256sum] = "a33cd31e159aba11fc5abf5b10f927c4531b63182a04b9ad9c9ff1f55deb0739"

URI_x86_64_v2_rust-rustix+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+runtime-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+runtime-devel}"
SRC_URI[x86_64_v2_rust-rustix+runtime-devel.sha256sum] = "5b4f44bc777219e100d629e14feac4e7a60ccbf5f0b9eaa014a2336e1079a9c7"

URI_x86_64_v2_rust-rustix+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+shm-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+shm-devel}"
SRC_URI[x86_64_v2_rust-rustix+shm-devel.sha256sum] = "26f508d7390cd4bcefb6e35a12864286dc81d7756a95118a989910381b211644"

URI_x86_64_v2_rust-rustix+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+std-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+std-devel}"
SRC_URI[x86_64_v2_rust-rustix+std-devel.sha256sum] = "e3cf41ec7cffef7f78b1dbd014201cd8593072260937aca8fb51bd8b57cdd3bc"

URI_x86_64_v2_rust-rustix+stdio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+stdio-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+stdio-devel}"
SRC_URI[x86_64_v2_rust-rustix+stdio-devel.sha256sum] = "cac2cd59170cb60b958abd0eeb0b56681fc6e4bd96595a056efa6efa2dccc041"

URI_x86_64_v2_rust-rustix+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+system-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+system-devel}"
SRC_URI[x86_64_v2_rust-rustix+system-devel.sha256sum] = "fa65aa50ef182df4b0639e2b0286d078f09212b8574ab14fe464de4690d52e3d"

URI_x86_64_v2_rust-rustix+termios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+termios-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+termios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+termios-devel}"
SRC_URI[x86_64_v2_rust-rustix+termios-devel.sha256sum] = "7b0cabeb2abd68cb8ea012301e5fc7c76c1654354600677f2fa51faa6e55a1d6"

URI_x86_64_v2_rust-rustix+thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+thread-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+thread-devel}"
SRC_URI[x86_64_v2_rust-rustix+thread-devel.sha256sum] = "3e7f1fea235f570fcd84476e7e0f2e91b7cea465e2c158dea44fb92b512cb68b"

URI_x86_64_v2_rust-rustix+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+time-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+time-devel}"
SRC_URI[x86_64_v2_rust-rustix+time-devel.sha256sum] = "472e436b011cb65fa998492562d7cb9198ef200d580004b4ea63620c773314ac"

URI_x86_64_v2_rust-rustix+try_close-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+try_close-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+try_close-devel}"
SRC_URI[x86_64_v2_rust-rustix+try_close-devel.sha256sum] = "5dca7efaec6daafdc8e7025df0f0c76af3f4ed698dc90e0858e26c05cc26aa24"

URI_x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-explicitly-provided-auxv-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "869cc368031f4dd3f1744ef86b0594945a6b0604895d899b19a6cbcc8adef95a"

URI_x86_64_v2_rust-rustix+use-libc-auxv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-auxv-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-libc-auxv-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-libc-auxv-devel.sha256sum] = "e06107b144bbdb2de7feac90c2f47b96aae99ffa150813103ff638f625510949"

URI_x86_64_v2_rust-rustix+use-libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix+use-libc-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix+use-libc-devel}"
SRC_URI[x86_64_v2_rust-rustix+use-libc-devel.sha256sum] = "1f6b68d87a32caf02cf744d99f1de23e90cbd7c195c24eb6e5a8100d42ccb0bf"

URI_x86_64_v2_rust-rustix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustix-devel-0.38.44-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustix-devel}"
SRC_URI[x86_64_v2_rust-rustix-devel.sha256sum] = "1d296f3a7273919952a0d80808e541a34299cfc12a18a530f366c5feb769fcc8"

URI_aarch64_rust-rustix+all-apis-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+all-apis-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+all-apis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+all-apis-devel}"
SRC_URI[aarch64_rust-rustix+all-apis-devel.sha256sum] = "0bf118078f16d1b4cf6f3882df4f3dcc62648ac2a273d1b2f6339f45eae7a048"

URI_aarch64_rust-rustix+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+alloc-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+alloc-devel}"
SRC_URI[aarch64_rust-rustix+alloc-devel.sha256sum] = "57092a40b4890154b8bc4e500c2d949b7fc744a260828ed3cf5a6e2d185177d8"

URI_aarch64_rust-rustix+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+cc-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+cc-devel}"
SRC_URI[aarch64_rust-rustix+cc-devel.sha256sum] = "4e7309e9c661debd014aade837fc6fc5870ddeba4b6f6ca35b6d5a73e860df01"

URI_aarch64_rust-rustix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+default-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+default-devel}"
SRC_URI[aarch64_rust-rustix+default-devel.sha256sum] = "5ddd42bb790867be12e2adef589b0afdd10812e09663d949ac7b2771109cc218"

URI_aarch64_rust-rustix+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+event-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+event-devel}"
SRC_URI[aarch64_rust-rustix+event-devel.sha256sum] = "07c93ffee36baf17e01021491f40c7f03bcd50040771d424a362eeb1cc372304"

URI_aarch64_rust-rustix+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+fs-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+fs-devel}"
SRC_URI[aarch64_rust-rustix+fs-devel.sha256sum] = "5a511b7d17c72bd6a4f5b252ca19ba1fb0ce787a7a997a32008e1da1d24014bb"

URI_aarch64_rust-rustix+io_uring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+io_uring-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+io_uring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+io_uring-devel}"
SRC_URI[aarch64_rust-rustix+io_uring-devel.sha256sum] = "a496ad63fa5f9e9efa3a92ec08b2e41c9086b82f26e738b723b5e147a0d981a0"

URI_aarch64_rust-rustix+itoa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+itoa-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+itoa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+itoa-devel}"
SRC_URI[aarch64_rust-rustix+itoa-devel.sha256sum] = "044232bf018df84299f99d23b8c726e1188141537418895b99c619a3425363ea"

URI_aarch64_rust-rustix+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+libc-devel}"
SRC_URI[aarch64_rust-rustix+libc-devel.sha256sum] = "e36487d4d5fbb0bd4892267bb9ab096ce67738892386748815d8639afb59d5c6"

URI_aarch64_rust-rustix+libc-extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc-extra-traits-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+libc-extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+libc-extra-traits-devel}"
SRC_URI[aarch64_rust-rustix+libc-extra-traits-devel.sha256sum] = "a34a6b1d3691c1b2e148fec38b368ff4933475c7a13082e0dbb4dd897f60d0bb"

URI_aarch64_rust-rustix+libc_errno-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+libc_errno-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+libc_errno-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+libc_errno-devel}"
SRC_URI[aarch64_rust-rustix+libc_errno-devel.sha256sum] = "2040c873326dd7961437b9b24e8e528310149b6c847c7c3532fde25d5320d068"

URI_aarch64_rust-rustix+linux_4_11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_4_11-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+linux_4_11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_4_11-devel}"
SRC_URI[aarch64_rust-rustix+linux_4_11-devel.sha256sum] = "f4cebd310c2181bc4f87f6c681549f06d4057d67731a3ee87e32c4171aca66aa"

URI_aarch64_rust-rustix+linux_latest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+linux_latest-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+linux_latest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+linux_latest-devel}"
SRC_URI[aarch64_rust-rustix+linux_latest-devel.sha256sum] = "6bdb2559ac9db1d4bb80bc4542184485fcd78abc13c217c34a39f728147197b8"

URI_aarch64_rust-rustix+mm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mm-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+mm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+mm-devel}"
SRC_URI[aarch64_rust-rustix+mm-devel.sha256sum] = "efacadc2b60c2b916e2305db740fbefb077aa917a6936099c7e0ea655a86e53a"

URI_aarch64_rust-rustix+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+mount-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+mount-devel}"
SRC_URI[aarch64_rust-rustix+mount-devel.sha256sum] = "3c7f3868e097798e0eb7c575da840073826a12a9d997ab6ae4653d33c3884b81"

URI_aarch64_rust-rustix+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+net-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+net-devel}"
SRC_URI[aarch64_rust-rustix+net-devel.sha256sum] = "cd9724c42a033486ca44dca3778a41b734578b432db04f140600801f72a49da8"

URI_aarch64_rust-rustix+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+once_cell-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+once_cell-devel}"
SRC_URI[aarch64_rust-rustix+once_cell-devel.sha256sum] = "da1d9af3368512800e1030a91d47673af08f53c736e58e8ced56731204088bcd"

URI_aarch64_rust-rustix+param-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+param-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+param-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+param-devel}"
SRC_URI[aarch64_rust-rustix+param-devel.sha256sum] = "634af5df4055d1963837f7127f2ce6be9e71df05786c440c1ac1d67f38cf465b"

URI_aarch64_rust-rustix+pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pipe-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+pipe-devel}"
SRC_URI[aarch64_rust-rustix+pipe-devel.sha256sum] = "10d626f143f016ef31b405e876d8b29b96f0f437143004a856747ef4b7c79a68"

URI_aarch64_rust-rustix+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+process-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+process-devel}"
SRC_URI[aarch64_rust-rustix+process-devel.sha256sum] = "92760dba95332a6188116b348ea97cf1aa7ed5c30587b2bddece3bab79bc4cb6"

URI_aarch64_rust-rustix+procfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+procfs-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+procfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+procfs-devel}"
SRC_URI[aarch64_rust-rustix+procfs-devel.sha256sum] = "6fff85a1dd45e1c712bf7cab28ed2a9de72d2dbc05b979711d63c347304a1b82"

URI_aarch64_rust-rustix+pty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+pty-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+pty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+pty-devel}"
SRC_URI[aarch64_rust-rustix+pty-devel.sha256sum] = "81f68fb09a462723be3d618f8b99a18cd6cce180e5a6504e4532b352474fc8c8"

URI_aarch64_rust-rustix+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+rand-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+rand-devel}"
SRC_URI[aarch64_rust-rustix+rand-devel.sha256sum] = "853992b6460e43684432f6b7d275de8d8e13a5ffe71d170f82978b6f54bcc10a"

URI_aarch64_rust-rustix+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+runtime-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+runtime-devel}"
SRC_URI[aarch64_rust-rustix+runtime-devel.sha256sum] = "d5c95d838e379d728ab4507f590fa12dcd6233d2b8df57c29b9f32d0f4f52901"

URI_aarch64_rust-rustix+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+shm-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+shm-devel}"
SRC_URI[aarch64_rust-rustix+shm-devel.sha256sum] = "2e7a42c9d66e00752a777f056374b11b532cdc145050e349894434ddec100d9f"

URI_aarch64_rust-rustix+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+std-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+std-devel}"
SRC_URI[aarch64_rust-rustix+std-devel.sha256sum] = "7dd5f0ff5f303a250d9dfc5a2028e639eab8441bb399a55193f1c4b95fe386a5"

URI_aarch64_rust-rustix+stdio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+stdio-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+stdio-devel}"
SRC_URI[aarch64_rust-rustix+stdio-devel.sha256sum] = "49c146b391d42ef8fa2b5008ecfba2a3bbc036f71982e33edf0f5ca5cf69bbc4"

URI_aarch64_rust-rustix+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+system-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+system-devel}"
SRC_URI[aarch64_rust-rustix+system-devel.sha256sum] = "64ba056a4881fc13ca297cdd29b6d6320367ac09e93ab04fbc337f6898ec153e"

URI_aarch64_rust-rustix+termios-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+termios-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+termios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+termios-devel}"
SRC_URI[aarch64_rust-rustix+termios-devel.sha256sum] = "b1ec3a1994013db55c838adcb66241de10ecc7931d79823d48d0adac0d7c8ea0"

URI_aarch64_rust-rustix+thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+thread-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+thread-devel}"
SRC_URI[aarch64_rust-rustix+thread-devel.sha256sum] = "cacb5fb8e8ec1b0a092eef1c92d120e9014d2737e3f1bc4f9fdd89fe07081b66"

URI_aarch64_rust-rustix+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+time-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+time-devel}"
SRC_URI[aarch64_rust-rustix+time-devel.sha256sum] = "bc10d6c2f42afe1f6e5ef0ed7e11d3c193272c0eab9f49789b0b7a7611ea6520"

URI_aarch64_rust-rustix+try_close-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+try_close-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+try_close-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+try_close-devel}"
SRC_URI[aarch64_rust-rustix+try_close-devel.sha256sum] = "a7cc62865bc9f201113b2feba68b87fc12d753bc231e6c234494f9ede1c0a974"

URI_aarch64_rust-rustix+use-explicitly-provided-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-explicitly-provided-auxv-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+use-explicitly-provided-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-explicitly-provided-auxv-devel}"
SRC_URI[aarch64_rust-rustix+use-explicitly-provided-auxv-devel.sha256sum] = "8b2ef357248144603482d9db0a42072defa5c1e487f3f211bbfcfeec39b6dc91"

URI_aarch64_rust-rustix+use-libc-auxv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-auxv-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+use-libc-auxv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-libc-auxv-devel}"
SRC_URI[aarch64_rust-rustix+use-libc-auxv-devel.sha256sum] = "d3854d0d40a87bdcab79c93eed1cfa4dad550c92831e30955d62cf20de1b00e7"

URI_aarch64_rust-rustix+use-libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix+use-libc-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix+use-libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix+use-libc-devel}"
SRC_URI[aarch64_rust-rustix+use-libc-devel.sha256sum] = "8c3f02a8fa51d2358f3feee213e481dd675b8019b7eabd805e0bc259d5ad99f8"

URI_aarch64_rust-rustix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustix-devel-0.38.44-1.el10_0.noarch.rpm;name=aarch64_rust-rustix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustix-devel}"
SRC_URI[aarch64_rust-rustix-devel.sha256sum] = "7d0d5b018d68099b3f4776084c3611bc78321d9d14432868f27648efb48f8018"

RDEPENDS:rust-rustix+all-apis-devel = " \
 cargo \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+io_uring-devel \
 rust-rustix+mm-devel \
 rust-rustix+mount-devel \
 rust-rustix+net-devel \
 rust-rustix+param-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+procfs-devel \
 rust-rustix+pty-devel \
 rust-rustix+rand-devel \
 rust-rustix+runtime-devel \
 rust-rustix+shm-devel \
 rust-rustix+stdio-devel \
 rust-rustix+system-devel \
 rust-rustix+termios-devel \
 rust-rustix+thread-devel \
 rust-rustix+time-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+alloc-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+cc-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+default-devel = " \
 cargo \
 rust-rustix+std-devel \
 rust-rustix+use-libc-auxv-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+event-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+fs-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+io_uring-devel = " \
 cargo \
 rust-linux-raw-sys0.4+io_uring-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+itoa-devel = " \
 cargo \
 rust-itoa-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc-devel = " \
 cargo \
 rust-libc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc-extra-traits-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-libc-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+libc_errno-devel = " \
 cargo \
 rust-errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_4_11-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+linux_latest-devel = " \
 cargo \
 rust-rustix+linux_4_11-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mm-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+mount-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+net-devel = " \
 cargo \
 rust-linux-raw-sys0.4+if_ether-devel \
 rust-linux-raw-sys0.4+net-devel \
 rust-linux-raw-sys0.4+netlink-devel \
 rust-linux-raw-sys0.4+xdp-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+param-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pipe-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+process-devel = " \
 cargo \
 rust-linux-raw-sys0.4+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+procfs-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix+itoa-devel \
 rust-rustix+once_cell-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+pty-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix+itoa-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+rand-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+runtime-devel = " \
 cargo \
 rust-linux-raw-sys0.4+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+shm-devel = " \
 cargo \
 rust-rustix+fs-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+std-devel = " \
 cargo \
 rust-bitflags+std-devel \
 rust-errno+std-devel \
 rust-errno-devel \
 rust-libc+std-devel \
 rust-libc-devel \
 rust-rustix+alloc-devel \
 rust-rustix+libc-extra-traits-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+stdio-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+system-devel = " \
 cargo \
 rust-linux-raw-sys0.4+system-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+termios-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+thread-devel = " \
 cargo \
 rust-linux-raw-sys0.4+prctl-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+time-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+try_close-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-explicitly-provided-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-auxv-devel = " \
 cargo \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix+use-libc-devel = " \
 cargo \
 rust-rustix+libc-devel \
 rust-rustix+libc-extra-traits-devel \
 rust-rustix+libc_errno-devel \
 rust-rustix-devel \
 "
RDEPENDS:rust-rustix-devel = " \
 cargo \
 rust \
 rust-bitflags-devel \
 rust-errno-devel \
 rust-libc-devel \
 rust-linux-raw-sys0.4+elf-devel \
 rust-linux-raw-sys0.4+errno-devel \
 rust-linux-raw-sys0.4+general-devel \
 rust-linux-raw-sys0.4+ioctl-devel \
 rust-linux-raw-sys0.4+no_std-devel \
 rust-linux-raw-sys0.4-devel \
 "
