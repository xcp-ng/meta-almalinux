# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-revwalk"
PV = "0.23.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-revwalk+default-devel \
 rust-gix-revwalk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-revwalk-0.23.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "faba4abbe063302527902ec3a84f5c1b4c9bc6b0a136980a0d5510d4f23c4c1e"

URI_x86_64_v2_rust-gix-revwalk+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revwalk+default-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revwalk+default-devel}"
SRC_URI[x86_64_v2_rust-gix-revwalk+default-devel.sha256sum] = "52e91f88c5a563506fda9b02769fc4600efb867222f1cc105f43335372d5eab5"

URI_x86_64_v2_rust-gix-revwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revwalk-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revwalk-devel}"
SRC_URI[x86_64_v2_rust-gix-revwalk-devel.sha256sum] = "742e18bb83029e49d2b4433c965ea807586781edd040589a20b8be0e7c0e74f0"

URI_aarch64_rust-gix-revwalk+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revwalk+default-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-revwalk+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revwalk+default-devel}"
SRC_URI[aarch64_rust-gix-revwalk+default-devel.sha256sum] = "419fedf7eb712a5cc5f77813e5e594290458b5bc8c40fa2ed7d8b887950212b8"

URI_aarch64_rust-gix-revwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revwalk-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-revwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revwalk-devel}"
SRC_URI[aarch64_rust-gix-revwalk-devel.sha256sum] = "2c12422f14f8df81a32921a0ae5efbd9cb258b5b9c853dda7b490a5c3704204b"

RDEPENDS:rust-gix-revwalk+default-devel = " \
 cargo \
 rust-gix-revwalk-devel \
 "
RDEPENDS:rust-gix-revwalk-devel = " \
 cargo \
 rust \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
