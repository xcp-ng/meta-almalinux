# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-average"
PV = "0.15.1"
PR = "4.el10_2"
PACKAGES = " \
 rust-average+default-devel \
 rust-average+easy-cast-devel \
 rust-average+libm-devel \
 rust-average+nightly-devel \
 rust-average+rayon-core-devel \
 rust-average+rayon-devel \
 rust-average+serde-big-array-devel \
 rust-average+serde-devel \
 rust-average+serde1-devel \
 rust-average+serde_derive-devel \
 rust-average+std-devel \
 rust-average-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-average-0.15.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b5691f5aad11c5ef3f778be39eda18a65202a458e67eacd7c680db8e98dd88b"

URI_x86_64_v2_rust-average+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+default-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+default-devel}"
SRC_URI[x86_64_v2_rust-average+default-devel.sha256sum] = "bf45d7f255e3557acfff68177f293e759d43b4aa290302b6721f27e00440789d"

URI_x86_64_v2_rust-average+easy-cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+easy-cast-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+easy-cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+easy-cast-devel}"
SRC_URI[x86_64_v2_rust-average+easy-cast-devel.sha256sum] = "ea7390fa66ac1ea02e25ed92c7ef5ca4571f4c1d47b60a7f297d4564ab09e95e"

URI_x86_64_v2_rust-average+libm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+libm-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+libm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+libm-devel}"
SRC_URI[x86_64_v2_rust-average+libm-devel.sha256sum] = "966da7fffeeb89f551c9a7ac816a1aa14846c699e49e4efbc8aff978e89714a1"

URI_x86_64_v2_rust-average+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+nightly-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+nightly-devel}"
SRC_URI[x86_64_v2_rust-average+nightly-devel.sha256sum] = "ad7b6e5fba965752398a05e4dfef277020296699ff03e5c75bbb217403cfe234"

URI_x86_64_v2_rust-average+rayon-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+rayon-core-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+rayon-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+rayon-core-devel}"
SRC_URI[x86_64_v2_rust-average+rayon-core-devel.sha256sum] = "ececbac910af1f6ba3280281ac70672d3ec1034a7e861dbb2503ef8c85025183"

URI_x86_64_v2_rust-average+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+rayon-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+rayon-devel}"
SRC_URI[x86_64_v2_rust-average+rayon-devel.sha256sum] = "a92555b8f2f539af3d453a1ec2eae643022e77c9089b120fc454b4a49fad70d7"

URI_x86_64_v2_rust-average+serde-big-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+serde-big-array-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+serde-big-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+serde-big-array-devel}"
SRC_URI[x86_64_v2_rust-average+serde-big-array-devel.sha256sum] = "d4911b9089b2478132649e8de5265e09565caebc07cc1fe4e9495416ac0dfb4b"

URI_x86_64_v2_rust-average+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+serde-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+serde-devel}"
SRC_URI[x86_64_v2_rust-average+serde-devel.sha256sum] = "65b33a886b52885a6e6fa94b5cbfc0aa7c6ffccff467714522fa64686859545e"

URI_x86_64_v2_rust-average+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+serde1-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+serde1-devel}"
SRC_URI[x86_64_v2_rust-average+serde1-devel.sha256sum] = "fe5eec66adbf6915cc2a254c6093daa18a195737ee4abfa9ccc5f9bb76977ee1"

URI_x86_64_v2_rust-average+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+serde_derive-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-average+serde_derive-devel.sha256sum] = "49ca8e8e9b0f2ae88e7271fadb056044c85900ddd197d933ec694294f9c5fc1f"

URI_x86_64_v2_rust-average+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average+std-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average+std-devel}"
SRC_URI[x86_64_v2_rust-average+std-devel.sha256sum] = "23e4a77046294ff34778ecab31783c4dbc20a7fe10422be3d07ab335b3955c22"

URI_x86_64_v2_rust-average-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-average-devel-0.15.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-average-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-average-devel}"
SRC_URI[x86_64_v2_rust-average-devel.sha256sum] = "320c86cf1514adf0822087657fccd19bff6a694af5be8410c889da721818a191"

URI_aarch64_rust-average+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+default-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+default-devel}"
SRC_URI[aarch64_rust-average+default-devel.sha256sum] = "f1472be14885f81e8f540710ead002a4f191fe897d8e5641b671e79957482bdc"

URI_aarch64_rust-average+easy-cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+easy-cast-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+easy-cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+easy-cast-devel}"
SRC_URI[aarch64_rust-average+easy-cast-devel.sha256sum] = "8fca21eff0358bb467f2dc710fa3d925dd05f464bfdf0e375a89a64baadbb966"

URI_aarch64_rust-average+libm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+libm-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+libm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+libm-devel}"
SRC_URI[aarch64_rust-average+libm-devel.sha256sum] = "1761de8254dda14cda202543db65239222e031f06e08b2f667cc09d35ad1ecdb"

URI_aarch64_rust-average+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+nightly-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+nightly-devel}"
SRC_URI[aarch64_rust-average+nightly-devel.sha256sum] = "2e56aae0c9b79e08eb62a8c874703a336cbae434e7b9d21675adfef005c6cdb9"

URI_aarch64_rust-average+rayon-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+rayon-core-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+rayon-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+rayon-core-devel}"
SRC_URI[aarch64_rust-average+rayon-core-devel.sha256sum] = "5e6f7204d1ccec33f8a70355fba2ff22de377a4ef4be73f4d3ef61dce6dedd54"

URI_aarch64_rust-average+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+rayon-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+rayon-devel}"
SRC_URI[aarch64_rust-average+rayon-devel.sha256sum] = "277512647bf468f10e7151f37291dc3c2504eae06ef8ebcfcfeb3651cb59a6f1"

URI_aarch64_rust-average+serde-big-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+serde-big-array-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+serde-big-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+serde-big-array-devel}"
SRC_URI[aarch64_rust-average+serde-big-array-devel.sha256sum] = "f2240a04a24647a839656c9488c7ab5965afd26248567b4fcdbefbf8c2d55238"

URI_aarch64_rust-average+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+serde-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+serde-devel}"
SRC_URI[aarch64_rust-average+serde-devel.sha256sum] = "637d50de09c24037fb8ac74cbfffe7bfe1de8121a3bdd1a9103195b91f572fb2"

URI_aarch64_rust-average+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+serde1-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+serde1-devel}"
SRC_URI[aarch64_rust-average+serde1-devel.sha256sum] = "d151a5ee6d088bb4e8c37ce42b1615de8ef1de9a941d2b70223c5d0f5624eaf1"

URI_aarch64_rust-average+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+serde_derive-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+serde_derive-devel}"
SRC_URI[aarch64_rust-average+serde_derive-devel.sha256sum] = "3862860275045c108c7eecb6fb22227255bcd9b01785b2b2a4c1894c2437fafc"

URI_aarch64_rust-average+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average+std-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average+std-devel}"
SRC_URI[aarch64_rust-average+std-devel.sha256sum] = "7d37efdd47632b561aa1a70f2e2d0f8a8b1a01aa3021cccfc4a4a7d60090af53"

URI_aarch64_rust-average-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-average-devel-0.15.1-4.el10_2.noarch.rpm;name=aarch64_rust-average-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-average-devel}"
SRC_URI[aarch64_rust-average-devel.sha256sum] = "1e454384a851ba5abace6cf03b6cba69f1f4d35a755921bce2a001553ea82154"

RDEPENDS:rust-average+default-devel = " \
 cargo \
 rust-average+libm-devel \
 rust-average-devel \
 "
RDEPENDS:rust-average+easy-cast-devel = " \
 cargo \
 rust-average-devel \
 rust-easy-cast-devel \
 "
RDEPENDS:rust-average+libm-devel = " \
 cargo \
 rust-average-devel \
 rust-easy-cast+libm-devel \
 rust-easy-cast-devel \
 rust-num-traits+libm-devel \
 "
RDEPENDS:rust-average+nightly-devel = " \
 cargo \
 rust-average-devel \
 "
RDEPENDS:rust-average+rayon-core-devel = " \
 cargo \
 rust-average-devel \
 rust-rayon-core+default-devel \
 "
RDEPENDS:rust-average+rayon-devel = " \
 cargo \
 rust-average-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-average+serde-big-array-devel = " \
 cargo \
 rust-average-devel \
 rust-serde-big-array+default-devel \
 "
RDEPENDS:rust-average+serde-devel = " \
 cargo \
 rust-average-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-average+serde1-devel = " \
 cargo \
 rust-average+serde-big-array-devel \
 rust-average+serde-devel \
 rust-average+serde_derive-devel \
 rust-average-devel \
 "
RDEPENDS:rust-average+serde_derive-devel = " \
 cargo \
 rust-average-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-average+std-devel = " \
 cargo \
 rust-average-devel \
 rust-easy-cast+std-devel \
 rust-easy-cast-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-average-devel = " \
 cargo \
 rust \
 rust-float-ord+default-devel \
 rust-num-traits-devel \
 "
