# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-notify"
PV = "8.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-notify+crossbeam-channel-devel \
 rust-notify+default-devel \
 rust-notify+flume-devel \
 rust-notify+serde-devel \
 rust-notify+serialization-compat-6-devel \
 rust-notify-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-notify-8.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "723c23a5b4d471cf0bb98df9137e714b0b38a2740d8d54106c394c79fb94b2ae"

URI_x86_64_v2_rust-notify+crossbeam-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+crossbeam-channel-devel-8.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+crossbeam-channel-devel}"
SRC_URI[x86_64_v2_rust-notify+crossbeam-channel-devel.sha256sum] = "397bc172714d0ceba50163ac32ab705f37e4b5b8e62e0f54de08c2ab22aab6ba"

URI_x86_64_v2_rust-notify+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+default-devel-8.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+default-devel}"
SRC_URI[x86_64_v2_rust-notify+default-devel.sha256sum] = "183963fff71c92c468e49cf5f42b4c6375a0482564b8d4149ba23f8c5d3db959"

URI_x86_64_v2_rust-notify+flume-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+flume-devel-8.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+flume-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+flume-devel}"
SRC_URI[x86_64_v2_rust-notify+flume-devel.sha256sum] = "db6d9768cc358c11f37dbe3e503275fe61494f5421123b1670c4a8b0245791b4"

URI_x86_64_v2_rust-notify+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+serde-devel-8.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+serde-devel}"
SRC_URI[x86_64_v2_rust-notify+serde-devel.sha256sum] = "b62b0c292a87d03c9b26e946e2df756f3696bedf741b74fd101872ff2f5c65f6"

URI_x86_64_v2_rust-notify+serialization-compat-6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify+serialization-compat-6-devel-8.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify+serialization-compat-6-devel}"
SRC_URI[x86_64_v2_rust-notify+serialization-compat-6-devel.sha256sum] = "3637f5870ee51e5b662224470e4ee4988212e42f4e4927c240e13d67678e259f"

URI_x86_64_v2_rust-notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-notify-devel-8.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-notify-devel}"
SRC_URI[x86_64_v2_rust-notify-devel.sha256sum] = "4fafe7cc507cb766423faf1c5f9ed566b8d2a9f986ad5f7bf56fa342d74e3fe4"

URI_aarch64_rust-notify+crossbeam-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+crossbeam-channel-devel-8.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify+crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+crossbeam-channel-devel}"
SRC_URI[aarch64_rust-notify+crossbeam-channel-devel.sha256sum] = "4cd84aa66352c879e8b6aadfc0ccb18fe846767cafdfb58b183643b278caa923"

URI_aarch64_rust-notify+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+default-devel-8.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+default-devel}"
SRC_URI[aarch64_rust-notify+default-devel.sha256sum] = "aaf553e6184645c45bb11bd99f1bb34865773a8ab439c909d49f677e7c463bfa"

URI_aarch64_rust-notify+flume-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+flume-devel-8.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify+flume-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+flume-devel}"
SRC_URI[aarch64_rust-notify+flume-devel.sha256sum] = "4674a975aa49f02295c4ceaf565ec4a45ceeb7ddb662a1a0f1c805cdb7352f69"

URI_aarch64_rust-notify+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+serde-devel-8.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+serde-devel}"
SRC_URI[aarch64_rust-notify+serde-devel.sha256sum] = "c72c34a7b7d4fe96e2745ebd7ca0e03b501eb14a3e88b14e6fd7db40987112e3"

URI_aarch64_rust-notify+serialization-compat-6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify+serialization-compat-6-devel-8.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify+serialization-compat-6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify+serialization-compat-6-devel}"
SRC_URI[aarch64_rust-notify+serialization-compat-6-devel.sha256sum] = "5ff433eb99e5e1999019b95c98fdc35abd0b1f4cd59514868959f56c6fed3524"

URI_aarch64_rust-notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-notify-devel-8.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-notify-devel}"
SRC_URI[aarch64_rust-notify-devel.sha256sum] = "136ce0bf44405d42fabbe64370a856b2e161584f311418f70e41d0b79572e944"

RDEPENDS:rust-notify+crossbeam-channel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-notify-devel \
 "
RDEPENDS:rust-notify+default-devel = " \
 cargo \
 rust-notify-devel \
 "
RDEPENDS:rust-notify+flume-devel = " \
 cargo \
 rust-flume+default-devel \
 rust-notify-devel \
 "
RDEPENDS:rust-notify+serde-devel = " \
 cargo \
 rust-notify-devel \
 rust-notify-types+serde-devel \
 "
RDEPENDS:rust-notify+serialization-compat-6-devel = " \
 cargo \
 rust-notify-devel \
 rust-notify-types+serialization-compat-6-devel \
 "
RDEPENDS:rust-notify-devel = " \
 cargo \
 rust \
 rust-inotify-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-mio+default-devel \
 rust-mio+os-ext-devel \
 rust-notify-types+default-devel \
 rust-walkdir+default-devel \
 "
