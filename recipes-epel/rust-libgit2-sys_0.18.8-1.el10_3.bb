# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libgit2-sys"
PV = "0.18.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-libgit2-sys+default-devel \
 rust-libgit2-sys+https-devel \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys+ssh-devel \
 rust-libgit2-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libgit2-sys-0.18.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "30443ba92198ad5b0281f9c099326f687e3b5c0b062601913751e7ccc7e5ae8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+default-devel-0.18.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+default-devel.sha256sum] = "f192e12c3e5eb36da382cf5c4a03cf3979fb0b59d0a560efa96edadd0f1cea76"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+https-devel-0.18.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+https-devel.sha256sum] = "7142ba1b888a6621c2a49b453fa654f11c2a54ef59bb46d586f591e6f9b84dfa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+libssh2-sys-devel-0.18.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "2912333ab8c9adf20f45496eaff7cf050ece48bbe1fb97c8e2ff3ea1125192c8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+openssl-sys-devel-0.18.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "5a79b5930ff4d0e6a7f6b9144178de27c281ebb7a454501cbd1898065d491345"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+ssh-devel-0.18.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+ssh-devel.sha256sum] = "7644c772b058300fbe50f334d03d409686df622c2b6bcea289dff83e96c1b70e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys-devel-0.18.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys-devel.sha256sum] = "e1e146bba4aa626988470e622db0807a70b5ff8590d456be11fd00f8f41b3351"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+default-devel-0.18.8-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+default-devel.sha256sum] = "710b3c0f5808969a6842b086cdf0036796ea851cf4d7703917c0308633720d40"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+https-devel-0.18.8-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+https-devel.sha256sum] = "e7d2fc0f58c001c22c4cecc62355fe99462984bf087e85fd138e6a64f27cbc0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+libssh2-sys-devel-0.18.8-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "92d523a71bd1394bf4cede49e8e21f2109011ccbf855dfb915fb03694d76c338"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+openssl-sys-devel-0.18.8-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "21d277ac44c80b45995c69fc5266a639d5a717bf25b79c4cb0928523530f1647"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+ssh-devel-0.18.8-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+ssh-devel.sha256sum] = "df0637f7ce8f747a461dcdd6a7e64f1b1b21e85c3eba4968c23ea1bf424423da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys-devel-0.18.8-1.el10_3.noarch.rpm;name=aarch64_rust-libgit2-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys-devel.sha256sum] = "709271c12b9ef8764c00688d64189d1dfe71fd6bdb97b59ee83ee06285f1edbd"

RDEPENDS:rust-libgit2-sys+default-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+https-devel = " \
 cargo \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+libssh2-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-libssh2-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+openssl-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+ssh-devel = " \
 cargo \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys-devel = " \
 cargo \
 libgit2_1.9-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-pkg-config+default-devel \
 "
