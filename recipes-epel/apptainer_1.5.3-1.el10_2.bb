# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apptainer"
PV = "1.5.3"
PR = "1.el10_2"
PACKAGES = " \
 apptainer \
 apptainer-suid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apptainer-1.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c355298f7d21023d8f2d9f7b19f036c4c564a08ab2386a22dbd4709b9a19bde3"

URI_x86_64_v2_apptainer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-1.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apptainer}"
SRC_URI[x86_64_v2_apptainer.sha256sum] = "01c9c704ac94295ae7af4de58fabfbec3f035656bf991c49632098a3e8e58356"

URI_x86_64_v2_apptainer-suid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-suid-1.5.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer-suid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apptainer-suid}"
SRC_URI[x86_64_v2_apptainer-suid.sha256sum] = "70a61483b0d8be1c649e130a4195f011fa57405f3d8e3e1cb8decaba187bfe25"

URI_aarch64_apptainer = "${EPEL_MIRROR}/aarch64/Packages/a/apptainer-1.5.3-1.el10_2.aarch64.rpm;name=aarch64_apptainer;unpack=0"
SRC_URI:append = " ${URI_aarch64_apptainer}"
SRC_URI[aarch64_apptainer.sha256sum] = "e4203fd64ce265b2332bb9119267a99350e57d2b5793536270ebd449c97b8912"

URI_aarch64_apptainer-suid = "${EPEL_MIRROR}/aarch64/Packages/a/apptainer-suid-1.5.3-1.el10_2.aarch64.rpm;name=aarch64_apptainer-suid;unpack=0"
SRC_URI:append = " ${URI_aarch64_apptainer-suid}"
SRC_URI[aarch64_apptainer-suid.sha256sum] = "f58636b7234b7cde46beb8f1277d39a4c77fe62d5b29772751f8708a17cae293"

RDEPENDS:apptainer = " \
 bash \
 fakeroot \
 fuse3-libs \
 glibc \
 libgcc \
 libseccomp \
 libtalloc \
 libzstd \
 lz4-libs \
 lzo \
 protobuf-c \
 shadow-utils-subid \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apptainer-suid = " \
 apptainer \
 fuse3-libs \
 glibc \
 libseccomp \
 shadow-utils-subid \
 "
