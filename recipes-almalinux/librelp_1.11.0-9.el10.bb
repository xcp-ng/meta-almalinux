# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librelp"
PV = "1.11.0"
PR = "9.el10"
PACKAGES = " \
 librelp \
 librelp-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/librelp-1.11.0-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "93824734b9fefc4cd009f9fe514ce999fc889737b0746f4488342bbc42e82ecd"

URI_x86_64_v2_librelp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/librelp-1.11.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_librelp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librelp}"
SRC_URI[x86_64_v2_librelp.sha256sum] = "7a0c3f42b287d38253e7bd1657c096ad6b6f94ea492ebca171c45b5f99e1309f"

URI_x86_64_v2_librelp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/librelp-devel-1.11.0-9.el10.x86_64_v2.rpm;name=x86_64_v2_librelp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librelp-devel}"
SRC_URI[x86_64_v2_librelp-devel.sha256sum] = "6db9859d8a8f7136e469189980d39fee25e49aa0981400fc1b1e276bf6224afb"

URI_aarch64_librelp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/librelp-1.11.0-9.el10.aarch64.rpm;name=aarch64_librelp;unpack=0"
SRC_URI:append = " ${URI_aarch64_librelp}"
SRC_URI[aarch64_librelp.sha256sum] = "f2cb5d5420c672ca5c77e80dc71e3fd9b17fbe33ebadc6feffb5caa7066c6ed0"

URI_aarch64_librelp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/librelp-devel-1.11.0-9.el10.aarch64.rpm;name=aarch64_librelp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librelp-devel}"
SRC_URI[aarch64_librelp-devel.sha256sum] = "e801cb914a7a1ea1026c2edde618926a052155ab48e1d89e402bcf4c11cb0ece"

RDEPENDS:librelp = " \
 glibc \
 gnutls \
 openssl-libs \
 "
RDEPENDS:librelp-devel = " \
 librelp \
 pkgconf-pkg-config \
 "
