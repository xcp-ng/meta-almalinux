# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Find-Rule"
PV = "0.35"
PR = "1.el10_0"
PACKAGES = " \
 perl-File-Find-Rule \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Find-Rule-0.35-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a5174113caa9a545ca61a6b6d9a7947353743f13d70567a67b494ba646ec635"

URI_x86_64_v2_perl-File-Find-Rule = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Find-Rule-0.35-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Find-Rule;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Find-Rule}"
SRC_URI[x86_64_v2_perl-File-Find-Rule.sha256sum] = "6781ebe7c12bba870380dd7e0dfc2be8cefae1ee6640392716a740f7d933c7bd"

URI_aarch64_perl-File-Find-Rule = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Find-Rule-0.35-1.el10_0.noarch.rpm;name=aarch64_perl-File-Find-Rule;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Find-Rule}"
SRC_URI[aarch64_perl-File-Find-Rule.sha256sum] = "6d52145a703c3bcd1dda1dd46a5f0444afcd85f0ee29ab5506692a635a133e84"

RDEPENDS:perl-File-Find-Rule = " \
 perl-Carp \
 perl-File-Find \
 perl-File-Find-Rule \
 perl-Number-Compare \
 perl-PathTools \
 perl-Text-Glob \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
