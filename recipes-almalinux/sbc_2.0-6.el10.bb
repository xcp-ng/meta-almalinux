# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sbc"
PV = "2.0"
PR = "6.el10"
PACKAGES = " \
 libsbc \
 sbc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sbc-2.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7b6e41ef0027de93248c1f9b6f3a34013b69f8c523d8c21873a304340f44913"

URI_x86_64_v2_libsbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsbc-2.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_libsbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsbc}"
SRC_URI[x86_64_v2_libsbc.sha256sum] = "47255d3dd61b58b952c021416814025bb36cbde5f0dfbf2ddde78699e7cf4beb"

URI_x86_64_v2_sbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sbc-2.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_sbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sbc}"
SRC_URI[x86_64_v2_sbc.sha256sum] = "bf4e8cad7bddd40e1753d75bf64fd865908b196ea84d9d646c594d0cf37bb8cc"

URI_aarch64_libsbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsbc-2.0-6.el10.aarch64.rpm;name=aarch64_libsbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsbc}"
SRC_URI[aarch64_libsbc.sha256sum] = "89a9d1d77c905e37947571c972049210d48b6700ae7aef55c37d3dae013fef1c"

URI_aarch64_sbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sbc-2.0-6.el10.aarch64.rpm;name=aarch64_sbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sbc}"
SRC_URI[aarch64_sbc.sha256sum] = "d0a6404d9e46e96072ed064236cd9a44a93f2eee35c77b4f7be55e1158d20d6f"

RDEPENDS:libsbc = " \
 glibc \
 "
RDEPENDS:sbc = " \
 glibc \
 libsbc \
 "
