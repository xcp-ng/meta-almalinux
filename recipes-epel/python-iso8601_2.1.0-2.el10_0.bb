# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-iso8601"
PV = "2.1.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-iso8601 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-iso8601-2.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32782b02e08f6217df7af4fb8219978388e3c9fb35af400117e7ac6aa509f821"

URI_x86_64_v2_python3-iso8601 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-iso8601-2.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-iso8601;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-iso8601}"
SRC_URI[x86_64_v2_python3-iso8601.sha256sum] = "7afca6f75df8f15b761c49875bff4b0080f13a3e1085cbf67ad9ecb6cfb8fbd2"

URI_aarch64_python3-iso8601 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-iso8601-2.1.0-2.el10_0.noarch.rpm;name=aarch64_python3-iso8601;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-iso8601}"
SRC_URI[aarch64_python3-iso8601.sha256sum] = "a39c82beb3d5401d0b4caf28e6b2ebdaca90b7fb0da2d9eeeb6d105bda00908e"

RDEPENDS:python3-iso8601 = " \
 python3 \
 "
