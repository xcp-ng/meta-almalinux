# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nuclei"
PV = "3.11.0"
PR = "1.el10_3"
PACKAGES = " \
 nuclei \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nuclei-3.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0963656e83396f0a2a39cfc210550334f1da0377c18323dd2b4f4d6d7a337c46"

URI_x86_64_v2_nuclei = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nuclei-3.11.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nuclei;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nuclei}"
SRC_URI[x86_64_v2_nuclei.sha256sum] = "eec11451714719c5a0145e42994e8d88f5e90cb5fd7a4ee6f632069e006dddf8"

URI_aarch64_nuclei = "${EPEL_MIRROR}/aarch64/Packages/n/nuclei-3.11.0-1.el10_3.aarch64.rpm;name=aarch64_nuclei;unpack=0"
SRC_URI:append = " ${URI_aarch64_nuclei}"
SRC_URI[aarch64_nuclei.sha256sum] = "be6ee875f5eadb9dbf9ec940c4388b7810bf78687a18bd571a9f48cd5a122ef9"

RDEPENDS:nuclei = " \
 glibc \
 "
