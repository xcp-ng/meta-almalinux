# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-unbound"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 lua-unbound \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-unbound-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cad80ac07d2d510e1c2790072d4f7bf69ee6441f7cc7bd07390cec03d34ba8ed"

URI_x86_64_v2_lua-unbound = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-unbound-1.1.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-unbound}"
SRC_URI[x86_64_v2_lua-unbound.sha256sum] = "e4d6a4347da32bdc56a808793f66c7a42bd8986c3ff87824b6c14a0b595935f0"

URI_aarch64_lua-unbound = "${EPEL_MIRROR}/aarch64/Packages/l/lua-unbound-1.1.0-1.el10_3.aarch64.rpm;name=aarch64_lua-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-unbound}"
SRC_URI[aarch64_lua-unbound.sha256sum] = "eaef760be3c206cf3cf1a73b714fa605e2a79d8f1801bd20d7d1416ed0f5cc8f"

RDEPENDS:lua-unbound = " \
 glibc \
 lua-libs \
 unbound-libs \
 "
