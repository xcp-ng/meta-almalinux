# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcontacts"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kcontacts \
 kf6-kcontacts-devel \
 kf6-kcontacts-doc \
 kf6-kcontacts-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcontacts-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ca62085cf2c4f3953fb05cfb70053a857e653bffa918e14625d3ccc1eca1041"

URI_x86_64_v2_kf6-kcontacts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts}"
SRC_URI[x86_64_v2_kf6-kcontacts.sha256sum] = "adab1ff64b890f36eea95c500e597fd69434664378ae9fdbc8feeae56d3c64a0"

URI_x86_64_v2_kf6-kcontacts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcontacts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-devel}"
SRC_URI[x86_64_v2_kf6-kcontacts-devel.sha256sum] = "ad7ff11efd3d7ce6f7ece4d9a9a066e66706305e6d5f8af0627517b750177170"

URI_x86_64_v2_kf6-kcontacts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcontacts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-doc}"
SRC_URI[x86_64_v2_kf6-kcontacts-doc.sha256sum] = "3aa7a16ff71672561d9071eae0793bdb3014f8bb59c1239fb93b238551f80ab8"

URI_x86_64_v2_kf6-kcontacts-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcontacts-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcontacts-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcontacts-html}"
SRC_URI[x86_64_v2_kf6-kcontacts-html.sha256sum] = "c70a882de17b60424fc627534ba17399c325b229830ff6f0c43c0cacc5cccc55"

URI_aarch64_kf6-kcontacts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcontacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts}"
SRC_URI[aarch64_kf6-kcontacts.sha256sum] = "26f1e3319f73373855b040ab4ed5647d23c882f204137850eb2ed0c02e6f23d5"

URI_aarch64_kf6-kcontacts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcontacts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-devel}"
SRC_URI[aarch64_kf6-kcontacts-devel.sha256sum] = "55effb265b382a0a8e17846123e9a63027bac24dd164ea4f6754dcc653e88210"

URI_aarch64_kf6-kcontacts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcontacts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-doc}"
SRC_URI[aarch64_kf6-kcontacts-doc.sha256sum] = "a14cb12b248f2911e195afda9f620b2fa5d89cbdbf22e0411d166b4ed50bbd9b"

URI_aarch64_kf6-kcontacts-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcontacts-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcontacts-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcontacts-html}"
SRC_URI[aarch64_kf6-kcontacts-html.sha256sum] = "f76d9c89fb4c867c45c8be8073b3cae8df4e99185e583bac5154710c016f19f0"

RDEPENDS:kf6-kcontacts = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcodecs-devel \
 kf6-kcontacts \
 kf6-kcoreaddons-devel \
 kf6-ki18n-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcontacts-doc = " \
 "
RDEPENDS:kf6-kcontacts-html = " \
 "
