# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-localftpserver"
PV = "1.3.2"
PR = "3.el10_1"
PACKAGES = " \
 python3-pytest-localftpserver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-localftpserver-1.3.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e4e10eaa887d06e15660e8bf334b37674b3c077581688bfc1a2d55ea3a192bd"

URI_x86_64_v2_python3-pytest-localftpserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-localftpserver-1.3.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-localftpserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-localftpserver}"
SRC_URI[x86_64_v2_python3-pytest-localftpserver.sha256sum] = "83a5bd8ef96376a996415671c6c4061aa3119b68be8dee3f0883cb00244d8c7d"

URI_aarch64_python3-pytest-localftpserver = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-localftpserver-1.3.2-3.el10_1.noarch.rpm;name=aarch64_python3-pytest-localftpserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-localftpserver}"
SRC_URI[aarch64_python3-pytest-localftpserver.sha256sum] = "25d3c4c3ed8209ecac1d7c83330302bace1b259d00e026fadd1184b2f2fb3fe9"

RDEPENDS:python3-pytest-localftpserver = " \
 python3 \
 python3-pyOpenSSL \
 python3-pyftpdlib \
 python3-pytest \
 "
