# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pin-project-internal"
PV = "1.1.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-pin-project-internal+default-devel \
 rust-pin-project-internal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pin-project-internal-1.1.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a72ba70492aeb0c959fb50cbf7fae29de1d155ceae58bce3c40826775ebc25c"

URI_x86_64_v2_rust-pin-project-internal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-internal+default-devel-1.1.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-internal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-internal+default-devel}"
SRC_URI[x86_64_v2_rust-pin-project-internal+default-devel.sha256sum] = "844ca4f7961fb4179d05089a24e652a09c828b4a7549ac007faa7089db184ce0"

URI_x86_64_v2_rust-pin-project-internal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pin-project-internal-devel-1.1.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pin-project-internal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pin-project-internal-devel}"
SRC_URI[x86_64_v2_rust-pin-project-internal-devel.sha256sum] = "7b503a6e05b2652799550f6ff8d5a9feadec6630101306abeeafc91083bb3dcc"

URI_aarch64_rust-pin-project-internal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-internal+default-devel-1.1.11-1.el10_2.noarch.rpm;name=aarch64_rust-pin-project-internal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-internal+default-devel}"
SRC_URI[aarch64_rust-pin-project-internal+default-devel.sha256sum] = "ce61a9dec3e49868a9e40b995a621a4cf47f06a87a0781c89941129b5b53109e"

URI_aarch64_rust-pin-project-internal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pin-project-internal-devel-1.1.11-1.el10_2.noarch.rpm;name=aarch64_rust-pin-project-internal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pin-project-internal-devel}"
SRC_URI[aarch64_rust-pin-project-internal-devel.sha256sum] = "bff563ab88ad53d2acc42857b2f7cc6414944cc184aa2d6232a00d96f717dec5"

RDEPENDS:rust-pin-project-internal+default-devel = " \
 cargo \
 rust-pin-project-internal-devel \
 "
RDEPENDS:rust-pin-project-internal-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn+visit-mut-devel \
 rust-syn-devel \
 "
