# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpackage"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kpackage \
 kf6-kpackage-devel \
 kf6-kpackage-doc \
 kf6-kpackage-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpackage-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b5f95ff73ab9c11a13ae48b01fd85f54d7c11008dbbc1eb121cac8371dd3304"

URI_x86_64_v2_kf6-kpackage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage}"
SRC_URI[x86_64_v2_kf6-kpackage.sha256sum] = "bbaad5e56f8617e953b71ee3ab5b608f333739daffa20ccd9e6c6e318f6a9c9a"

URI_x86_64_v2_kf6-kpackage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-devel}"
SRC_URI[x86_64_v2_kf6-kpackage-devel.sha256sum] = "2e0e7f7130c936ffea1e04a07cee05ac45570ee591444ce1a00ccd0d00a49693"

URI_x86_64_v2_kf6-kpackage-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpackage-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-doc}"
SRC_URI[x86_64_v2_kf6-kpackage-doc.sha256sum] = "58897f82a8668ecaa2f63134e2345e2e1e61349e86fd8b37a4571d773f95f244"

URI_x86_64_v2_kf6-kpackage-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpackage-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-html}"
SRC_URI[x86_64_v2_kf6-kpackage-html.sha256sum] = "58914d481291d554b469983710756f0010749044edd41b0669cbffb04dc0680f"

URI_aarch64_kf6-kpackage = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpackage;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage}"
SRC_URI[aarch64_kf6-kpackage.sha256sum] = "5262d46eb841758435d46a6eaccd0e9a5056e7c11914ac8936f4f9999b1fd3ba"

URI_aarch64_kf6-kpackage-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpackage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-devel}"
SRC_URI[aarch64_kf6-kpackage-devel.sha256sum] = "a3936369bb5de01648f3e9701da55bd2f7053975d813d4917416e1cd65a8d1ac"

URI_aarch64_kf6-kpackage-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpackage-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-doc}"
SRC_URI[aarch64_kf6-kpackage-doc.sha256sum] = "0626c0afb7622c0f76b905e1aea8299c8b2c24e41a91c37dd72b0730ec41683b"

URI_aarch64_kf6-kpackage-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpackage-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-html}"
SRC_URI[aarch64_kf6-kpackage-html.sha256sum] = "973dcd88478a11e2c131a2f7a2e339ff1e65a43245fab3c238edf54cec03fab5"

RDEPENDS:kf6-kpackage = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kpackage-devel = " \
 cmake-filesystem \
 kf6-kpackage \
 "
RDEPENDS:kf6-kpackage-doc = " \
 "
RDEPENDS:kf6-kpackage-html = " \
 "
