# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "strongswan"
PV = "6.0.6"
PR = "1.el10_3"
PACKAGES = " \
 perl-vici \
 strongswan \
 strongswan-charon-nm \
 strongswan-libipsec \
 strongswan-sqlite \
 strongswan-tnc-imcvs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/strongswan-6.0.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bacaee4c2acd8781d89c687d89573fe8fe3eaa71d1d635ec59f6785d5d991381"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - strongswan-libipsec: libcap.so.2()(64bit)
# - strongswan-tnc-imcvs: libcap.so.2()(64bit)
# - strongswan: libcap.so.2()(64bit)

URI_x86_64_v2_perl-vici = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-vici-6.0.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-vici;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-vici}"
SRC_URI[x86_64_v2_perl-vici.sha256sum] = "f4b48196fd165bfed48484433a4f736284418bf677d874b6f1f6a7227a4571a5"

URI_x86_64_v2_strongswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan}"
SRC_URI[x86_64_v2_strongswan.sha256sum] = "95b81cf5d7b907d211fa59f66c794cf176a11f390d192f445a4ac12e6bb0a57a"

URI_x86_64_v2_strongswan-charon-nm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-charon-nm-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan-charon-nm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan-charon-nm}"
SRC_URI[x86_64_v2_strongswan-charon-nm.sha256sum] = "5a2a8bee4ee1455d346691a304d435e8e1b3f061118422d8015a4c3e94d144c4"

URI_x86_64_v2_strongswan-libipsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-libipsec-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan-libipsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan-libipsec}"
SRC_URI[x86_64_v2_strongswan-libipsec.sha256sum] = "bc1f210072b7a6048e06ad5db4c804572546f12d14dd96d203c921a9796a81e3"

URI_x86_64_v2_strongswan-sqlite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-sqlite-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan-sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan-sqlite}"
SRC_URI[x86_64_v2_strongswan-sqlite.sha256sum] = "13c725ef300e7df7f8c23797290d39a25641479dbf2d2990b8e1b359f2ee8851"

URI_x86_64_v2_strongswan-tnc-imcvs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/strongswan-tnc-imcvs-6.0.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_strongswan-tnc-imcvs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_strongswan-tnc-imcvs}"
SRC_URI[x86_64_v2_strongswan-tnc-imcvs.sha256sum] = "aa5e4e8e3b497ce05959a1ddcead6f15aebd4bd823a199c8593f77f68f267f31"

URI_aarch64_perl-vici = "${EPEL_MIRROR}/aarch64/Packages/p/perl-vici-6.0.6-1.el10_3.noarch.rpm;name=aarch64_perl-vici;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-vici}"
SRC_URI[aarch64_perl-vici.sha256sum] = "1cf7e5b2c367a56830a8ea6682ea6967d0164623da4c978a9040fbc73da5f828"

URI_aarch64_strongswan = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_strongswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan}"
SRC_URI[aarch64_strongswan.sha256sum] = "36df86a01811e0d7d724c85f35432306702b9ceed4a3b83e7c1a3b82aa37be79"

URI_aarch64_strongswan-charon-nm = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-charon-nm-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_strongswan-charon-nm;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan-charon-nm}"
SRC_URI[aarch64_strongswan-charon-nm.sha256sum] = "cb7955441fd0247ddef885bfd33b4123d3cb57c5ef9557f2a7c331efa41a83b1"

URI_aarch64_strongswan-libipsec = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-libipsec-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_strongswan-libipsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan-libipsec}"
SRC_URI[aarch64_strongswan-libipsec.sha256sum] = "376cda588c18986de5e1e1cffcca311fee232c7e301206ffd21dced45ff69fc9"

URI_aarch64_strongswan-sqlite = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-sqlite-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_strongswan-sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan-sqlite}"
SRC_URI[aarch64_strongswan-sqlite.sha256sum] = "d367e861ff922695b34d63b3a7a95b57d0309277f5cd5e72922b1629194d8a8b"

URI_aarch64_strongswan-tnc-imcvs = "${EPEL_MIRROR}/aarch64/Packages/s/strongswan-tnc-imcvs-6.0.6-1.el10_3.aarch64.rpm;name=aarch64_strongswan-tnc-imcvs;unpack=0"
SRC_URI:append = " ${URI_aarch64_strongswan-tnc-imcvs}"
SRC_URI[aarch64_strongswan-tnc-imcvs.sha256sum] = "c17609d6d915f9751d0634e87016bf04fd8684b474a797b4bb3611a42317ddf1"

RDEPENDS:perl-vici = " \
 perl-constant \
 perl-libs \
 perl-vici \
 "
RDEPENDS:strongswan:x86_64_v2 = " \
 bash \
 glibc \
 gmp \
 libcap \
 libgcc \
 libgcrypt \
 libgpg-error \
 libselinux \
 openssl-libs \
 pam-libs \
 systemd \
 systemd-libs \
 tpm2-tss \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:strongswan:aarch64 = " \
 bash \
 glibc \
 gmp \
 libgcc \
 libgcrypt \
 libgpg-error \
 libselinux \
 openssl-libs \
 pam-libs \
 systemd \
 systemd-libs \
 tpm2-tss \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:strongswan-charon-nm = " \
 NetworkManager-libnm \
 dbus \
 glib2 \
 glibc \
 strongswan \
 "
RDEPENDS:strongswan-libipsec:x86_64_v2 = " \
 glibc \
 libcap \
 libselinux \
 strongswan \
 systemd-libs \
"
RDEPENDS:strongswan-libipsec:aarch64 = " \
 glibc \
 libselinux \
 strongswan \
 systemd-libs \
"
RDEPENDS:strongswan-sqlite = " \
 glibc \
 sqlite-libs \
 strongswan \
 "
RDEPENDS:strongswan-tnc-imcvs:x86_64_v2 = " \
 glibc \
 json-c \
 libcap \
 libselinux \
 libxml2 \
 strongswan \
 strongswan-sqlite \
 systemd-libs \
 tpm2-tss \
"
RDEPENDS:strongswan-tnc-imcvs:aarch64 = " \
 glibc \
 json-c \
 libselinux \
 libxml2 \
 strongswan \
 strongswan-sqlite \
 systemd-libs \
 tpm2-tss \
"
