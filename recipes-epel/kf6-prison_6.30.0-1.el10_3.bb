# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-prison"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-prison \
 kf6-prison-devel \
 kf6-prison-doc \
 kf6-prison-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-prison-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "00646f43b194ca472c4bace3192e454f5185a856d25776f9189a75b4d94a64c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison;unpack=0"
SRC_URI[x86_64_v2_kf6-prison.sha256sum] = "a7483340dc8a145f4b9bddf36bd29812c081b9768603ee70f3f11a42c627f130"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-prison-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-prison-devel.sha256sum] = "0b420de7f5885b553de1b676e496f97ef6fb60ab865fab73011c19bd20cb6620"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-prison-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-prison-doc.sha256sum] = "63d56684974374a747d6dff35d055c37ad98823139e19b8c7f3d287f3dd2f1b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-prison-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-prison-html;unpack=0"
SRC_URI[x86_64_v2_kf6-prison-html.sha256sum] = "b1faa37bead85e301504c15451a12e5c9a659b04a5799cd0c9fb0b3e44f40b94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-prison;unpack=0"
SRC_URI[aarch64_kf6-prison.sha256sum] = "8df920d13ec30fa613b301dd2eb17e658e097bfb04a2e29dbd72a745e5799085"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-prison-devel;unpack=0"
SRC_URI[aarch64_kf6-prison-devel.sha256sum] = "bc3d0aa48b9ba029d61ca0fe8f125f9e59cbf763c6a7280511b0e15ea0e6e0a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-prison-doc;unpack=0"
SRC_URI[aarch64_kf6-prison-doc.sha256sum] = "48e54d8a2d20243f548e18505420310a85349a0bf3dc809561498e41abcac2aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-prison-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-prison-html;unpack=0"
SRC_URI[aarch64_kf6-prison-html.sha256sum] = "3b15636b4c6bb26a714786b316ff415ab29035d78389eeecbb6230e25a928771"

RDEPENDS:kf6-prison = " \
 glibc \
 kf6-filesystem \
 libdmtx \
 libgcc \
 libstdc++ \
 qrencode-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 zxing-cpp \
 "
RDEPENDS:kf6-prison-devel = " \
 cmake-filesystem \
 kf6-prison \
 "
RDEPENDS:kf6-prison-doc = " \
 "
RDEPENDS:kf6-prison-html = " \
 "
