# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "java-21-openjdk"
PE = "1"
PV = "21.0.12.1.1"
PR = "2.1.el10.alma.3"
PACKAGES = " \
 java-21-openjdk \
 java-21-openjdk-demo \
 java-21-openjdk-demo-fastdebug \
 java-21-openjdk-demo-slowdebug \
 java-21-openjdk-devel \
 java-21-openjdk-devel-fastdebug \
 java-21-openjdk-devel-slowdebug \
 java-21-openjdk-fastdebug \
 java-21-openjdk-headless \
 java-21-openjdk-headless-fastdebug \
 java-21-openjdk-headless-slowdebug \
 java-21-openjdk-javadoc \
 java-21-openjdk-javadoc-zip \
 java-21-openjdk-jmods \
 java-21-openjdk-jmods-fastdebug \
 java-21-openjdk-jmods-slowdebug \
 java-21-openjdk-slowdebug \
 java-21-openjdk-src \
 java-21-openjdk-src-fastdebug \
 java-21-openjdk-src-slowdebug \
 java-21-openjdk-static-libs \
 java-21-openjdk-static-libs-fastdebug \
 java-21-openjdk-static-libs-slowdebug \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/java-21-openjdk-21.0.12.1.1-2.1.el10.alma.3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5671070e3094c546eaf61354da9795265eb211a1a4a6e8283f509558b82431e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk.sha256sum] = "3d89a526d216aa4c95198671a350c585060e44ac0c57a053c91a30ee94fb7e9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-demo-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-demo.sha256sum] = "6ecc84371a9a523c2351d3df51f2bfe2b3c0af23546a198e7be4136ed823bfaa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-fastdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-demo-fastdebug.sha256sum] = "e6558b3de2c64b38d6ae3ea1bebff92392bbd87193bb45452dc7867cefd63502"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-demo-slowdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-demo-slowdebug.sha256sum] = "d5d682ed2c6963cd662d8f795a72bbbf4b5c7e3785a131a578672e5d2a415492"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-devel-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-devel.sha256sum] = "39997631e73b09c7ab25822f3a9047dd8288c73edb1e7518ebee683e9e868a18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-fastdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-devel-fastdebug.sha256sum] = "3edc59355bbdea81587395022b1436d9b0596ec7056b3a9f9c0b0c4945d28d04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-devel-slowdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-devel-slowdebug.sha256sum] = "2757c9d026244d47d4b372237b948b186e56790791e71083eb30bdd30ed30d30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-fastdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-fastdebug.sha256sum] = "538b3ac2cd6cf128f0521daec7c799a9656178efbc8f1aae7eca43e01344e7e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-headless-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-headless.sha256sum] = "79323e598e1be41b113625cf366bb53c605195b72418949b822619cf5f05a6fb"
RPROVIDES:java-21-openjdk-headless:append:x86_64_v2 = " virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-fastdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-headless-fastdebug.sha256sum] = "a1fadb8510cc421dcdc5aa91cb8d76a62c7555f0451ad8eec402b104487b7456"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-headless-slowdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-headless-slowdebug.sha256sum] = "f17e82700f23dc9eaef973d8c63615ae0cd1c2c310fbd0c3729ec92a3133f5a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc.sha256sum] = "5aa96237cfa325e510fef81079a1449e2c3704d65ecbc7a4e7a993f24e42bcb9"
RPROVIDES:java-21-openjdk-javadoc:append:x86_64_v2 = " virtual/java-javadoc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-javadoc-zip-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-javadoc-zip.sha256sum] = "e3f2d770d291ee0d1bcebf674adc5b20aa73b4e302f24e136410da845b9f5df5"
RPROVIDES:java-21-openjdk-javadoc-zip:append:x86_64_v2 = " virtual/java-javadoc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-jmods-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-jmods.sha256sum] = "a7d254234ca5c8716397ed8f5e6e300af4c41e662028091bba1bd4aec9e2f9ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-fastdebug.sha256sum] = "7813c340310eb6bfd3706f86387646082462f6d578502c0b029b67d773d2fc1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-jmods-slowdebug.sha256sum] = "7b03e0c236a7541508be3920a12f46e4dfaad06ef64251aa326ca0d2a44fdcdf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-slowdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-slowdebug.sha256sum] = "2d19d8a6739a8a7e790f5407fb293ffe7a0083b186a49031b31d20272cf3d620"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-src-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-src.sha256sum] = "e1bbd695f7c9e6d98061c0ad7b05b1ed291c4b746f82e1ae5a8de294ac77d250"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-fastdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-src-fastdebug.sha256sum] = "19ccb0b597971b565db5614f2661d90b8c73df515682b93c7af1a3e1c0e1966b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-src-slowdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-src-slowdebug.sha256sum] = "e58113c79f3f2ba28e534a5a4ee6445ea11cbe3a97f3f1a37df7daa34abbbfdb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/java-21-openjdk-static-libs-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs.sha256sum] = "1541ae9193f9a0800b53eaedf99f7f685d996a28988fb59fa63b34001f558a4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-fastdebug.sha256sum] = "655e5acbb87ef146d1d7bb912b0ea8646f6538a15c42e29e9cd1af5e993520f0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.12.1.1-2.1.el10.alma.3.x86_64_v2.rpm;name=x86_64_v2_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[x86_64_v2_java-21-openjdk-static-libs-slowdebug.sha256sum] = "24855fb9f6e64a126444305def01c2e2a1c9109989e90b6988e5678f7b0895cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk;unpack=0"
SRC_URI[aarch64_java-21-openjdk.sha256sum] = "291bec308b6008f64d355005b33cefc840b173c148cd38e5d321411a25eef65a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-demo-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-demo;unpack=0"
SRC_URI[aarch64_java-21-openjdk-demo.sha256sum] = "e5e69ea5826820858785294b6291d8f5a59ba11f3f6cd4384d88f52177b332a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-fastdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-demo-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-demo-fastdebug.sha256sum] = "b1d3a686fc8d5d4aae1ab24746e2495aa0be90c881ab22fc3d246650a02692d1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-demo-slowdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-demo-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-demo-slowdebug.sha256sum] = "62bffb80d34362f631287cf19804a26897e3f6d29dc345e64babaa81ccf337d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-devel-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-devel;unpack=0"
SRC_URI[aarch64_java-21-openjdk-devel.sha256sum] = "cfa51680854649b147f4b872beb48d940a1c1d7bc2a372850718a59cdbe8869c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-fastdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-devel-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-devel-fastdebug.sha256sum] = "1bbf6dce765587164c8873c7b64338f86920cdcb1423618554836ea926e8c645"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-devel-slowdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-devel-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-devel-slowdebug.sha256sum] = "9a6171f2d1d948c80e60238fe3cc6b2d46541c71700dd191af070d4e7e12ea0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-fastdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-fastdebug.sha256sum] = "b2eb3f9004a01a2ad9093a645577f9674ac97368576fa7fd10d12ecb3c53f1a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-headless-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-headless;unpack=0"
SRC_URI[aarch64_java-21-openjdk-headless.sha256sum] = "a8e3bfc1ec4fdf14108edfa7f1dc196434b32cb5fd0c955b8754e0e3de98493e"
RPROVIDES:java-21-openjdk-headless:append:aarch64 = " virtual/java-headless_or_java-21-headless_or_java-25-headless virtual/java-headless_or_java-25-headless"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-fastdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-headless-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-headless-fastdebug.sha256sum] = "bd01d37c1447b62506e9ec744d4f79e28bb1b307aba0fb6ec34bec76cade4757"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-headless-slowdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-headless-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-headless-slowdebug.sha256sum] = "4473d5e89d15eff042d80430e6b20f416e21c7d7c1a5c9c80cc88d932272afcf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc;unpack=0"
SRC_URI[aarch64_java-21-openjdk-javadoc.sha256sum] = "5463f662cd515059a8d60b70a01611c4bed3aa01d707879810fc8891d6cfdcfc"
RPROVIDES:java-21-openjdk-javadoc:append:aarch64 = " virtual/java-javadoc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-javadoc-zip-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-javadoc-zip;unpack=0"
SRC_URI[aarch64_java-21-openjdk-javadoc-zip.sha256sum] = "14be63e552394b499ca3c6e5a7ed319e82ced9529c8daffe0459b80de292a025"
RPROVIDES:java-21-openjdk-javadoc-zip:append:aarch64 = " virtual/java-javadoc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-jmods-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-jmods;unpack=0"
SRC_URI[aarch64_java-21-openjdk-jmods.sha256sum] = "5d7b00a63fcd33ef82b4d5e49400d36f1bb188dac49c87fea3b8ecd2c515dd61"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-fastdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-jmods-fastdebug.sha256sum] = "341e6969f05543a44dc832056f0d4a01a9f8801c20d1aacae81bca5e92a0f4be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-jmods-slowdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-jmods-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-jmods-slowdebug.sha256sum] = "a3c783f6bd6e8974416168f45bf1123b051e1f2398c5d2db993ed32146383e0e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-slowdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-slowdebug.sha256sum] = "4bf0e121044daafbcc015c1dc1b742c6be7152471015a64875f9d424f8f98788"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-src-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-src;unpack=0"
SRC_URI[aarch64_java-21-openjdk-src.sha256sum] = "5c422efd0a35903960b64f3aa95bee84b235f3648358c6c8f7e1e408d73cead3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-fastdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-src-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-src-fastdebug.sha256sum] = "c9fab970851d93e5e1cb2688a49086b6c4e74ed297f4400c24a29f225d2e8043"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-src-slowdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-src-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-src-slowdebug.sha256sum] = "91f52c27e3360d450f88c0e1c24bfe756f81bee3a47d41e03c50250a9c9cb886"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/java-21-openjdk-static-libs-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs;unpack=0"
SRC_URI[aarch64_java-21-openjdk-static-libs.sha256sum] = "755a27a5b9dd0651c5a0cb4181fa2fc6bc74c51f7be499381434d20c8d7f5d19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-fastdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-fastdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-static-libs-fastdebug.sha256sum] = "f56aade82e302341c156a2bcef371922a94a1680462f8f38ba734fb7df54ae8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/java-21-openjdk-static-libs-slowdebug-21.0.12.1.1-2.1.el10.alma.3.aarch64.rpm;name=aarch64_java-21-openjdk-static-libs-slowdebug;unpack=0"
SRC_URI[aarch64_java-21-openjdk-static-libs-slowdebug.sha256sum] = "c3b39174a7215f4131cf29660d15b08e99f2661a2ad36401ee0db5519f275e7b"

RDEPENDS:java-21-openjdk = " \
 bash \
 fontconfig \
 glibc \
 java-21-openjdk-headless \
 libX11 \
 libXcomposite \
 libXext \
 libXi \
 libXrender \
 libXtst \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-demo = " \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-demo-fastdebug = " \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-demo-slowdebug = " \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-devel = " \
 alternatives \
 bash \
 glibc \
 java-21-openjdk \
 "
RDEPENDS:java-21-openjdk-devel-fastdebug = " \
 alternatives \
 bash \
 java-21-openjdk-fastdebug \
 "
RDEPENDS:java-21-openjdk-devel-slowdebug = " \
 alternatives \
 bash \
 java-21-openjdk-slowdebug \
 "
RDEPENDS:java-21-openjdk-fastdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-fastdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-headless = " \
 alsa-lib \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 glibc \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-fastdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-headless-slowdebug = " \
 alternatives \
 bash \
 ca-certificates \
 crypto-policies \
 cups-libs \
 javapackages-filesystem \
 lksctp-tools \
 nss \
 tzdata-java \
 "
RDEPENDS:java-21-openjdk-javadoc = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-javadoc-zip = " \
 alternatives \
 bash \
 java-21-openjdk-headless \
 javapackages-filesystem \
 "
RDEPENDS:java-21-openjdk-jmods = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-jmods-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-jmods-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "
RDEPENDS:java-21-openjdk-slowdebug = " \
 bash \
 fontconfig \
 java-21-openjdk-headless-slowdebug \
 libXcomposite \
 xorg-x11-fonts-Type1 \
 "
RDEPENDS:java-21-openjdk-src = " \
 java-21-openjdk-headless \
 "
RDEPENDS:java-21-openjdk-src-fastdebug = " \
 java-21-openjdk-headless-fastdebug \
 "
RDEPENDS:java-21-openjdk-src-slowdebug = " \
 java-21-openjdk-headless-slowdebug \
 "
RDEPENDS:java-21-openjdk-static-libs = " \
 java-21-openjdk-devel \
 "
RDEPENDS:java-21-openjdk-static-libs-fastdebug = " \
 java-21-openjdk-devel-fastdebug \
 "
RDEPENDS:java-21-openjdk-static-libs-slowdebug = " \
 java-21-openjdk-devel-slowdebug \
 "
