# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebsockets"
PV = "6.9.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtwebsockets \
 qt6-qtwebsockets-devel \
 qt6-qtwebsockets-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtwebsockets-6.9.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2450af93f3bd6a0f7e01c556a4986582896427b81b44adf07cbc99f33b745c47"

URI_x86_64_v2_qt6-qtwebsockets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebsockets-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebsockets}"
SRC_URI[x86_64_v2_qt6-qtwebsockets.sha256sum] = "a3edc3d39df41ed0b6fe9bc7fee50085844cdd21cad929cf21ea221fa24c92be"

URI_x86_64_v2_qt6-qtwebsockets-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwebsockets-devel-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebsockets-devel}"
SRC_URI[x86_64_v2_qt6-qtwebsockets-devel.sha256sum] = "a045960dbdd07d76e7abc9fa7b211b75863316fa93f94f90a81cfbe5701ca959"

URI_x86_64_v2_qt6-qtwebsockets-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtwebsockets-examples-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebsockets-examples}"
SRC_URI[x86_64_v2_qt6-qtwebsockets-examples.sha256sum] = "450e805544685e8354e2fedff60503b1ba4cc04a0bc1ac5d127e612cd0bd2c0c"

URI_aarch64_qt6-qtwebsockets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebsockets-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwebsockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebsockets}"
SRC_URI[aarch64_qt6-qtwebsockets.sha256sum] = "1a5255681b29e78e2798c804cd84501361ee3e8826d137b8e5ebe86142472718"

URI_aarch64_qt6-qtwebsockets-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwebsockets-devel-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwebsockets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebsockets-devel}"
SRC_URI[aarch64_qt6-qtwebsockets-devel.sha256sum] = "7b8cab3fb45b63afdba690d76797d2f0b6f3bf512049a3490493da570f7ab765"

URI_aarch64_qt6-qtwebsockets-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtwebsockets-examples-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtwebsockets-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebsockets-examples}"
SRC_URI[aarch64_qt6-qtwebsockets-examples.sha256sum] = "9cf3eaeddcfb058fe7c7ee1b84248334a0733e58971fabf26a0624baf39fb339"

RDEPENDS:qt6-qtwebsockets = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtwebsockets-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:qt6-qtwebsockets-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
