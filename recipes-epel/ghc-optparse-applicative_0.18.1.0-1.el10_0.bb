# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-optparse-applicative"
PV = "0.18.1.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-optparse-applicative \
 ghc-optparse-applicative-devel \
 ghc-optparse-applicative-doc \
 ghc-optparse-applicative-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-optparse-applicative-0.18.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ffe895783de215361f3dc7858254ea58e3e0586bb80fb2ebb997eb26a0bc80a"

URI_x86_64_v2_ghc-optparse-applicative = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optparse-applicative-0.18.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-optparse-applicative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optparse-applicative}"
SRC_URI[x86_64_v2_ghc-optparse-applicative.sha256sum] = "4bf50ac5c0d5fe603255c5267ff492dc563b7dc40ccec960ee4b2378a6dac32a"

URI_x86_64_v2_ghc-optparse-applicative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optparse-applicative-devel-0.18.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-optparse-applicative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optparse-applicative-devel}"
SRC_URI[x86_64_v2_ghc-optparse-applicative-devel.sha256sum] = "7a401e50de67d0d79cf09a7dd0c53309fcf583e44e988012c72fad53c10c1961"

URI_x86_64_v2_ghc-optparse-applicative-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optparse-applicative-doc-0.18.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-optparse-applicative-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optparse-applicative-doc}"
SRC_URI[x86_64_v2_ghc-optparse-applicative-doc.sha256sum] = "01c93a8b024b5abb1d7c5a7ea9fe8d6f97eff38f4b2f341d0e6301d8fa9050ff"

URI_x86_64_v2_ghc-optparse-applicative-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optparse-applicative-prof-0.18.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-optparse-applicative-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optparse-applicative-prof}"
SRC_URI[x86_64_v2_ghc-optparse-applicative-prof.sha256sum] = "d46fd99eaef0a1548ca59f3ef78912db1d2023e5431a346af8965905372af98d"

URI_aarch64_ghc-optparse-applicative = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optparse-applicative-0.18.1.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-optparse-applicative;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optparse-applicative}"
SRC_URI[aarch64_ghc-optparse-applicative.sha256sum] = "57529b16be0fa17a918171ff2bb878311afc96a39160a6e383416f1c602d798e"

URI_aarch64_ghc-optparse-applicative-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optparse-applicative-devel-0.18.1.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-optparse-applicative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optparse-applicative-devel}"
SRC_URI[aarch64_ghc-optparse-applicative-devel.sha256sum] = "6338f50cee78eadf62a6444e0e0e7658f4810b46330cf49468648cc03e27a88b"

URI_aarch64_ghc-optparse-applicative-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optparse-applicative-doc-0.18.1.0-1.el10_0.noarch.rpm;name=aarch64_ghc-optparse-applicative-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optparse-applicative-doc}"
SRC_URI[aarch64_ghc-optparse-applicative-doc.sha256sum] = "d7ce4173ccd8f7061944d1df05261ff45adf4ca3debdf465303368b554616415"

URI_aarch64_ghc-optparse-applicative-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optparse-applicative-prof-0.18.1.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-optparse-applicative-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optparse-applicative-prof}"
SRC_URI[aarch64_ghc-optparse-applicative-prof.sha256sum] = "985d128ee777aa77de39420158a275952cd742f7e5119d5b5a82723002d419f5"

RDEPENDS:ghc-optparse-applicative = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-optparse-applicative-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-optparse-applicative \
 ghc-prettyprinter-ansi-terminal-devel \
 ghc-prettyprinter-devel \
 ghc-process-devel \
 ghc-text-devel \
 ghc-transformers-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-optparse-applicative-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-optparse-applicative-prof = " \
 ghc-base-prof \
 ghc-optparse-applicative-devel \
 ghc-prettyprinter-ansi-terminal-prof \
 ghc-prettyprinter-prof \
 ghc-process-prof \
 ghc-text-prof \
 ghc-transformers-compat-prof \
 ghc-transformers-prof \
 "
