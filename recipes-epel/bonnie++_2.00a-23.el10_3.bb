# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bonnie++"
PV = "2.00a"
PR = "23.el10_3"
PACKAGES = " \
 bonnie++ \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bonnie++-2.00a-23.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f995a58b10e63a244dff0a3941c66139541ec8964338039226116ef0414cb3d9"

URI_x86_64_v2_bonnie++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bonnie++-2.00a-23.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bonnie++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bonnie++}"
SRC_URI[x86_64_v2_bonnie++.sha256sum] = "bb7a257e9aec59d9e9e76feadedf5521427cc697bb59967cb87191a2d76d69c9"

URI_aarch64_bonnie++ = "${EPEL_MIRROR}/aarch64/Packages/b/bonnie++-2.00a-23.el10_3.aarch64.rpm;name=aarch64_bonnie++;unpack=0"
SRC_URI:append = " ${URI_aarch64_bonnie++}"
SRC_URI[aarch64_bonnie++.sha256sum] = "4576146e87dfdce4057797d4d75e3636d906d301f3e705f9c61172553becfb30"

RDEPENDS:bonnie++ = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 "
