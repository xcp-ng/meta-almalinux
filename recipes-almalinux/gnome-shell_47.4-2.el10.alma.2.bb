# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell"
PV = "47.4"
PR = "2.el10.alma.2"
PACKAGES = " \
 gnome-shell \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-47.4-2.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c368bc366d34c9b9eeb80fd88094930e893691721b7925c38fcc3424123c7a2"

URI_x86_64_v2_gnome-shell = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-47.4-2.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_gnome-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell}"
SRC_URI[x86_64_v2_gnome-shell.sha256sum] = "39baf881c8389472ca0677e5dafaf7b50ab4932e5cfcec056f1241bd515102a3"

URI_aarch64_gnome-shell = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-47.4-2.el10.alma.2.aarch64.rpm;name=aarch64_gnome-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell}"
SRC_URI[aarch64_gnome-shell.sha256sum] = "f957d66a2e64935fbc1c7eeb1f6dcef5bd4a6645b6712df7069d0599139e6dd4"

RDEPENDS:gnome-shell = " \
 NetworkManager-libnm \
 accountsservice-libs \
 at-spi2-atk \
 atk \
 cairo \
 evolution-data-server \
 gcr \
 gcr-libs \
 gdk-pixbuf2 \
 gdm \
 geoclue2-libs \
 gettext \
 gjs \
 glib2 \
 glibc \
 gnome-autoar \
 gnome-control-center \
 gnome-desktop3 \
 gnome-desktop4 \
 gnome-settings-daemon \
 gobject-introspection \
 graphene \
 gsettings-desktop-schemas \
 gstreamer1 \
 gstreamer1-plugins-good \
 gtk4 \
 ibus \
 json-glib \
 libX11 \
 libXfixes \
 libadwaita \
 libgcc \
 libglvnd-gles \
 libgweather \
 libical-glib \
 libnma-gtk4 \
 librsvg2 \
 libsecret \
 mutter \
 pango \
 pipewire-gstreamer \
 pipewire-libs \
 polkit \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 python3 \
 switcheroo-control \
 systemd-libs \
 tecla \
 upower \
 xdg-desktop-portal-gnome \
 xdg-desktop-portal-gtk \
 xdg-user-dirs-gtk \
 "
