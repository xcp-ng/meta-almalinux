# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-cola"
PV = "4.14.0"
PR = "1.el10_1"
PACKAGES = " \
 git-cola \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-cola-4.14.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49b49edf09ec44cac7a78ad774d1bd5ee2a6cf8a8d4fc47e7f230e8beb729ec0"

URI_x86_64_v2_git-cola = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-cola-4.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_git-cola;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-cola}"
SRC_URI[x86_64_v2_git-cola.sha256sum] = "fe30b642f0f59036d11dde3f22aab3b7cd8c700abc3844aced020b155fd902f1"

URI_aarch64_git-cola = "${EPEL_MIRROR}/aarch64/Packages/g/git-cola-4.14.0-1.el10_1.noarch.rpm;name=aarch64_git-cola;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-cola}"
SRC_URI[aarch64_git-cola.sha256sum] = "8336a9fcff62680edef0620ab65286aa44b065d43717a89e48b6956ecd6f0987"

RDEPENDS:git-cola = " \
 bash \
 git \
 hicolor-icon-theme \
 python3 \
 python3-QtPy \
 python3-polib \
 python3-pyqt6 \
 tcl \
 "
