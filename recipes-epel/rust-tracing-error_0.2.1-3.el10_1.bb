# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-error"
PV = "0.2.1"
PR = "3.el10_1"
PACKAGES = " \
 rust-tracing-error+default-devel \
 rust-tracing-error+traced-error-devel \
 rust-tracing-error-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-error-0.2.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c739df4e2147ba53dd7021a4c9501f44f11f4965ec8dcedea9d7d7ada160df99"

URI_x86_64_v2_rust-tracing-error+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-error+default-devel-0.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-error+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-error+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-error+default-devel.sha256sum] = "da813a24418df1ff0b22767a466e170770c4d99c007d78859e90cf3ac1196b1a"

URI_x86_64_v2_rust-tracing-error+traced-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-error+traced-error-devel-0.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-error+traced-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-error+traced-error-devel}"
SRC_URI[x86_64_v2_rust-tracing-error+traced-error-devel.sha256sum] = "526dbcbc247a7f1fed2e603435667d23c9ca47c8f44422ba63c986f0bed99ccd"

URI_x86_64_v2_rust-tracing-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-error-devel-0.2.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-error-devel}"
SRC_URI[x86_64_v2_rust-tracing-error-devel.sha256sum] = "5939a1b6cf1eb0d3cfa496afaa9e95a625718e6bc14b5025299c4dd2f2ef1c4a"

URI_aarch64_rust-tracing-error+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-error+default-devel-0.2.1-3.el10_1.noarch.rpm;name=aarch64_rust-tracing-error+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-error+default-devel}"
SRC_URI[aarch64_rust-tracing-error+default-devel.sha256sum] = "3a744ad7da870837833c6a81eeb5204bb3f9f5a1f646e6cc9003c2046e23d07f"

URI_aarch64_rust-tracing-error+traced-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-error+traced-error-devel-0.2.1-3.el10_1.noarch.rpm;name=aarch64_rust-tracing-error+traced-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-error+traced-error-devel}"
SRC_URI[aarch64_rust-tracing-error+traced-error-devel.sha256sum] = "5a5c1af4f816cde6e9c642836a9647dbf85a7d7086571a116f63ae3e74aa9071"

URI_aarch64_rust-tracing-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-error-devel-0.2.1-3.el10_1.noarch.rpm;name=aarch64_rust-tracing-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-error-devel}"
SRC_URI[aarch64_rust-tracing-error-devel.sha256sum] = "5ffec80551615fd984761c310be4b6db3f3e52d2c65e8e4452765a5e70beb43f"

RDEPENDS:rust-tracing-error+default-devel = " \
 cargo \
 rust-tracing-error+traced-error-devel \
 rust-tracing-error-devel \
 "
RDEPENDS:rust-tracing-error+traced-error-devel = " \
 cargo \
 rust-tracing-error-devel \
 "
RDEPENDS:rust-tracing-error-devel = " \
 cargo \
 rust \
 rust-tracing+std-devel \
 rust-tracing-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber-devel \
 "
