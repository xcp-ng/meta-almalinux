# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uucore_procs"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uucore_procs+default-devel \
 rust-uucore_procs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uucore_procs-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0887cab276f834e6a8726cbd10e4bf4c687ec57ebb1334de530433adec0ed6aa"

URI_x86_64_v2_rust-uucore_procs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore_procs+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore_procs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore_procs+default-devel}"
SRC_URI[x86_64_v2_rust-uucore_procs+default-devel.sha256sum] = "9383019eb0478a966b57e851f184915d8b704cd283850b1769aab0f1431ff992"

URI_x86_64_v2_rust-uucore_procs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uucore_procs-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uucore_procs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uucore_procs-devel}"
SRC_URI[x86_64_v2_rust-uucore_procs-devel.sha256sum] = "02a588a3d73a799a4be2e2410c927225419920a73618e28f23c35c452e4728ef"

URI_aarch64_rust-uucore_procs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore_procs+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore_procs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore_procs+default-devel}"
SRC_URI[aarch64_rust-uucore_procs+default-devel.sha256sum] = "55148fc02c34766c1629fcdc7c2ce6a1fc5ab196d148708992661c3464c0438e"

URI_aarch64_rust-uucore_procs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uucore_procs-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uucore_procs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uucore_procs-devel}"
SRC_URI[aarch64_rust-uucore_procs-devel.sha256sum] = "1d7e6cc8064534a939293ee49f2ec3bef26dfe9b7e71b13f85c68bd68a0c330f"

RDEPENDS:rust-uucore_procs+default-devel = " \
 cargo \
 rust-uucore_procs-devel \
 "
RDEPENDS:rust-uucore_procs-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
