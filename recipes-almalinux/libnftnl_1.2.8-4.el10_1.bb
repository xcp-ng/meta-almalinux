# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnftnl"
PV = "1.2.8"
PR = "4.el10_1"
PACKAGES = " \
 libnftnl \
 libnftnl-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libnftnl-1.2.8-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eec421f5311955a2196336acdf7dfa6b5352d5c64acafc2d29303590870b97ea"

URI_x86_64_v2_libnftnl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnftnl-1.2.8-4.el10_1.x86_64_v2.rpm;name=x86_64_v2_libnftnl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnftnl}"
SRC_URI[x86_64_v2_libnftnl.sha256sum] = "f11cda81b6d2027889653dc2c0a9c0202150dde0663e7a7009c55ab2302cbc44"

URI_x86_64_v2_libnftnl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnftnl-devel-1.2.8-4.el10_1.x86_64_v2.rpm;name=x86_64_v2_libnftnl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnftnl-devel}"
SRC_URI[x86_64_v2_libnftnl-devel.sha256sum] = "a469f91ee47dc4582299a125bbb79307c6b946e4f0d0189a7bfe06387afe8352"

URI_aarch64_libnftnl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnftnl-1.2.8-4.el10_1.aarch64.rpm;name=aarch64_libnftnl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnftnl}"
SRC_URI[aarch64_libnftnl.sha256sum] = "fe189198955f63be6923a9960fe819c03d75d1cc110e3dfcc8c089a5c3c5d9b8"

URI_aarch64_libnftnl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnftnl-devel-1.2.8-4.el10_1.aarch64.rpm;name=aarch64_libnftnl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnftnl-devel}"
SRC_URI[aarch64_libnftnl-devel.sha256sum] = "1ae0ddab26ce03e1496b95a767a06361964924382bd7da4fb8957982b3cd9ca3"

RDEPENDS:libnftnl = " \
 glibc \
 libmnl \
 "
RDEPENDS:libnftnl-devel = " \
 libmnl-devel \
 libnftnl \
 pkgconf-pkg-config \
 "
