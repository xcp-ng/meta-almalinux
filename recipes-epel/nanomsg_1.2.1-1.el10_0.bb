# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nanomsg"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 nanomsg \
 nanomsg-devel \
 nanomsg-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nanomsg-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef7c7a95078d20671d4d51f424bb4ee961a0f2b5608d8118275642eaadb22e96"

URI_x86_64_v2_nanomsg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nanomsg-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nanomsg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nanomsg}"
SRC_URI[x86_64_v2_nanomsg.sha256sum] = "e4ce5c973d4db42dc182fdcef85341d55c58ee99c364e58b0c5b11399647644a"

URI_x86_64_v2_nanomsg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nanomsg-devel-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nanomsg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nanomsg-devel}"
SRC_URI[x86_64_v2_nanomsg-devel.sha256sum] = "101b1da8d51879894429cc3cb70792fdeaa884d47026950cdb1b18a7acc7002e"

URI_x86_64_v2_nanomsg-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nanomsg-doc-1.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nanomsg-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nanomsg-doc}"
SRC_URI[x86_64_v2_nanomsg-doc.sha256sum] = "b29242fef54717d7da37a90df4ff6c6d04917b1e431683d7bd9a44668c10934b"

URI_aarch64_nanomsg = "${EPEL_MIRROR}/aarch64/Packages/n/nanomsg-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_nanomsg;unpack=0"
SRC_URI:append = " ${URI_aarch64_nanomsg}"
SRC_URI[aarch64_nanomsg.sha256sum] = "81693c0acca7237b06ae0155aa19bcd65c349494020aabe040ee38f6903b4fcc"

URI_aarch64_nanomsg-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nanomsg-devel-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_nanomsg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nanomsg-devel}"
SRC_URI[aarch64_nanomsg-devel.sha256sum] = "e0182eb3df7b1939890cac310570f1fd5f3b989bae477daaa19a1e4c0e67a03a"

URI_aarch64_nanomsg-doc = "${EPEL_MIRROR}/aarch64/Packages/n/nanomsg-doc-1.2.1-1.el10_0.aarch64.rpm;name=aarch64_nanomsg-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_nanomsg-doc}"
SRC_URI[aarch64_nanomsg-doc.sha256sum] = "d631ac0c4d287802723c9187083a24140435f0884d0fbacc4f8991d418ca78c7"

RDEPENDS:nanomsg = " \
 glibc \
 "
RDEPENDS:nanomsg-devel = " \
 cmake-filesystem \
 nanomsg \
 pkgconf-pkg-config \
 "
RDEPENDS:nanomsg-doc = " \
 nanomsg \
 "
