# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipmitool"
PV = "1.8.19"
PR = "10.el10_1"
PACKAGES = " \
 bmc-snmp-proxy \
 exchange-bmc-os-info \
 ipmievd \
 ipmitool \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipmitool-1.8.19-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6d60f45fc3dc91ff91897a85f571dd11db498c6f6e30e2d1c820432be24e3f4"

URI_x86_64_v2_bmc-snmp-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bmc-snmp-proxy-1.8.19-10.el10_1.noarch.rpm;name=x86_64_v2_bmc-snmp-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bmc-snmp-proxy}"
SRC_URI[x86_64_v2_bmc-snmp-proxy.sha256sum] = "897f10ea3d7151b5f304679f93125427e414973e0d8a007fc6257685339e4613"

URI_x86_64_v2_exchange-bmc-os-info = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/exchange-bmc-os-info-1.8.19-10.el10_1.noarch.rpm;name=x86_64_v2_exchange-bmc-os-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exchange-bmc-os-info}"
SRC_URI[x86_64_v2_exchange-bmc-os-info.sha256sum] = "f3f82ebd30ee56d6cf69f888370f2cfefefde7be517d9f8ed172e3b8970edc96"

URI_x86_64_v2_ipmievd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipmievd-1.8.19-10.el10_1.x86_64_v2.rpm;name=x86_64_v2_ipmievd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipmievd}"
SRC_URI[x86_64_v2_ipmievd.sha256sum] = "57ccf6be26e44fd8a9525d84d85cb7a868459a580d7d7460fc4f7c07a78a9112"

URI_x86_64_v2_ipmitool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipmitool-1.8.19-10.el10_1.x86_64_v2.rpm;name=x86_64_v2_ipmitool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipmitool}"
SRC_URI[x86_64_v2_ipmitool.sha256sum] = "4550cda8984ed290630221da9df30975ec06885fb30d2f077959ce8008ef5fbd"

URI_aarch64_bmc-snmp-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bmc-snmp-proxy-1.8.19-10.el10_1.noarch.rpm;name=aarch64_bmc-snmp-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_bmc-snmp-proxy}"
SRC_URI[aarch64_bmc-snmp-proxy.sha256sum] = "897f10ea3d7151b5f304679f93125427e414973e0d8a007fc6257685339e4613"

URI_aarch64_exchange-bmc-os-info = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/exchange-bmc-os-info-1.8.19-10.el10_1.noarch.rpm;name=aarch64_exchange-bmc-os-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_exchange-bmc-os-info}"
SRC_URI[aarch64_exchange-bmc-os-info.sha256sum] = "f3f82ebd30ee56d6cf69f888370f2cfefefde7be517d9f8ed172e3b8970edc96"

URI_aarch64_ipmievd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipmievd-1.8.19-10.el10_1.aarch64.rpm;name=aarch64_ipmievd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipmievd}"
SRC_URI[aarch64_ipmievd.sha256sum] = "78ca2e9c20d3124a3aca3a9db9ddb5a9ee96f18abf7a797bbe0ce2f6618770bb"

URI_aarch64_ipmitool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipmitool-1.8.19-10.el10_1.aarch64.rpm;name=aarch64_ipmitool;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipmitool}"
SRC_URI[aarch64_ipmitool.sha256sum] = "4f2458ed7fad19b9d956d1ddfcf44995fa3a69e54edc1c5cde3546c1f106f304"

RDEPENDS:bmc-snmp-proxy = " \
 bash \
 exchange-bmc-os-info \
 net-snmp \
 "
RDEPENDS:exchange-bmc-os-info = " \
 bash \
 hostname \
 ipmitool \
 systemd \
 "
RDEPENDS:ipmievd = " \
 bash \
 glibc \
 ipmitool \
 openssl-libs \
 systemd \
 "
RDEPENDS:ipmitool = " \
 bash \
 glibc \
 openssl-libs \
 readline \
 systemd \
 "
