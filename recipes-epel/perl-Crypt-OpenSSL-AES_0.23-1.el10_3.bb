# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-OpenSSL-AES"
PV = "0.23"
PR = "1.el10_3"
PACKAGES = " \
 perl-Crypt-OpenSSL-AES \
 perl-Crypt-OpenSSL-AES-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-OpenSSL-AES-0.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90a316f05e12cdb9119c1abb0b87d79f18223e0958097d31b5d1d1e20a630cee"

URI_x86_64_v2_perl-Crypt-OpenSSL-AES = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-AES-0.23-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-AES;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-AES}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-AES.sha256sum] = "0b6320212a164429ebe198441e6a45011ad82c7c44e1775b182750b23e066aa0"

URI_x86_64_v2_perl-Crypt-OpenSSL-AES-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-OpenSSL-AES-tests-0.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-OpenSSL-AES-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-OpenSSL-AES-tests}"
SRC_URI[x86_64_v2_perl-Crypt-OpenSSL-AES-tests.sha256sum] = "d90fed09e7348e2d12708ea2564df6422b0d5983c0e3cd9ab58e5ed860fbb707"

URI_aarch64_perl-Crypt-OpenSSL-AES = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-AES-0.23-1.el10_3.aarch64.rpm;name=aarch64_perl-Crypt-OpenSSL-AES;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-AES}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-AES.sha256sum] = "8a0eabb1e0bae356d1871d9c9e059cc0aa51a1fb7db3635888c049690524d0be"

URI_aarch64_perl-Crypt-OpenSSL-AES-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-OpenSSL-AES-tests-0.23-1.el10_3.noarch.rpm;name=aarch64_perl-Crypt-OpenSSL-AES-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-OpenSSL-AES-tests}"
SRC_URI[aarch64_perl-Crypt-OpenSSL-AES-tests.sha256sum] = "e453699700b6845ffb44cdf0fd5ec92f3f7b92d6c434aa63c96c4f406f52c769"

RDEPENDS:perl-Crypt-OpenSSL-AES = " \
 glibc \
 openssl-libs \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Crypt-OpenSSL-AES-tests = " \
 bash \
 openssl \
 perl-Crypt-OpenSSL-AES \
 perl-Crypt-OpenSSL-Guess \
 perl-Crypt-URandom \
 perl-Digest-SHA \
 perl-MIME-Base64 \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
