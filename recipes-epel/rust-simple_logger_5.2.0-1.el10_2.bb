# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simple_logger"
PV = "5.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-simple_logger+colored-devel \
 rust-simple_logger+colors-devel \
 rust-simple_logger+default-devel \
 rust-simple_logger+nightly-devel \
 rust-simple_logger+stderr-devel \
 rust-simple_logger+threads-devel \
 rust-simple_logger+time-devel \
 rust-simple_logger+timestamps-devel \
 rust-simple_logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simple_logger-5.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "730550856a8ed2dbb32e23c85bac7251d0034b1c55315674c7f2ef246e807330"

URI_x86_64_v2_rust-simple_logger+colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+colored-devel-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+colored-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+colored-devel.sha256sum] = "066acd1226f53b83bcfa76326683cae20c90e1f7995db52a0d1133f38625c881"

URI_x86_64_v2_rust-simple_logger+colors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+colors-devel-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+colors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+colors-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+colors-devel.sha256sum] = "d6bfc31a0c057305e00f7bcc8a427c4c36f278753dc71e57d81f5fead8916a1c"

URI_x86_64_v2_rust-simple_logger+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+default-devel-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+default-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+default-devel.sha256sum] = "a7cd101205e4a2abc2fe2c05b04ebbf0ea9e9fd38d23a59ff70c6352b834b2f8"

URI_x86_64_v2_rust-simple_logger+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+nightly-devel-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+nightly-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+nightly-devel.sha256sum] = "6793a47405e34e8597db935ee7a48b143bccdbdf2b21f23daca1862eb6b7caf4"

URI_x86_64_v2_rust-simple_logger+stderr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+stderr-devel-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+stderr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+stderr-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+stderr-devel.sha256sum] = "f5f870f5f43aafacddfd242e76f80116d5cb8598071a95845c54ad99cfc7e295"

URI_x86_64_v2_rust-simple_logger+threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+threads-devel-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+threads-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+threads-devel.sha256sum] = "1a6a3b994fb61d467528fd8d84e4dfaffa7207d32fdcaa24f62fcf6fd7db8712"

URI_x86_64_v2_rust-simple_logger+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+time-devel-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+time-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+time-devel.sha256sum] = "465cf7b8f6b500921a83d3eb6ff179cb6ed0de34337004a2429f68fca6a34f6b"

URI_x86_64_v2_rust-simple_logger+timestamps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger+timestamps-devel-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger+timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger+timestamps-devel}"
SRC_URI[x86_64_v2_rust-simple_logger+timestamps-devel.sha256sum] = "b3d0984dc68e82598d1f1b69532648898c5f945a885ed296d2724f816061e918"

URI_x86_64_v2_rust-simple_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simple_logger-devel-5.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simple_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simple_logger-devel}"
SRC_URI[x86_64_v2_rust-simple_logger-devel.sha256sum] = "b0866a5ed293f4950eefb8da0fd197c397ca79390178ffe7db1e3d0dd7cea80e"

URI_aarch64_rust-simple_logger+colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+colored-devel-5.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-simple_logger+colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+colored-devel}"
SRC_URI[aarch64_rust-simple_logger+colored-devel.sha256sum] = "e0066e1b23804753982d52494b52b25ea13c863145d3615c587ad211441e906f"

URI_aarch64_rust-simple_logger+colors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+colors-devel-5.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-simple_logger+colors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+colors-devel}"
SRC_URI[aarch64_rust-simple_logger+colors-devel.sha256sum] = "13f1abe9bb40b2f3555934b6b7be1d9a43b83e446e2b4fb734059b1afd4de572"

URI_aarch64_rust-simple_logger+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+default-devel-5.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-simple_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+default-devel}"
SRC_URI[aarch64_rust-simple_logger+default-devel.sha256sum] = "afdc935c972581469f96dc163afd21bd0f8e07064ce01b0ce3673fd8947edb91"

URI_aarch64_rust-simple_logger+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+nightly-devel-5.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-simple_logger+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+nightly-devel}"
SRC_URI[aarch64_rust-simple_logger+nightly-devel.sha256sum] = "142eeff832378d4c47c7854a71d2de870f8b4bccfa8c51dd059d98ead0013cf3"

URI_aarch64_rust-simple_logger+stderr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+stderr-devel-5.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-simple_logger+stderr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+stderr-devel}"
SRC_URI[aarch64_rust-simple_logger+stderr-devel.sha256sum] = "5f3ab9d500ccfb2b62dd12718910c86721743379d39afd9922b518d1201f6c50"

URI_aarch64_rust-simple_logger+threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+threads-devel-5.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-simple_logger+threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+threads-devel}"
SRC_URI[aarch64_rust-simple_logger+threads-devel.sha256sum] = "915a72975b74ee2a7e5911c929ea455abe07e0d2593f2f552d75b2f3e9e858a3"

URI_aarch64_rust-simple_logger+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+time-devel-5.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-simple_logger+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+time-devel}"
SRC_URI[aarch64_rust-simple_logger+time-devel.sha256sum] = "4a85c03c9b6ea1606cae5ee828b22a45f3974cd4736d44db4d6f294ce83df910"

URI_aarch64_rust-simple_logger+timestamps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger+timestamps-devel-5.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-simple_logger+timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger+timestamps-devel}"
SRC_URI[aarch64_rust-simple_logger+timestamps-devel.sha256sum] = "053ffab72221b36c5471b3481e603eadc3f76d98a351ea2420002ac9f816b8c0"

URI_aarch64_rust-simple_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simple_logger-devel-5.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-simple_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simple_logger-devel}"
SRC_URI[aarch64_rust-simple_logger-devel.sha256sum] = "0492e66f57a338eb99b987d1a95137767d91f737a74bb98044b7e9afed9880f8"

RDEPENDS:rust-simple_logger+colored-devel = " \
 cargo \
 rust-colored+default-devel \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+colors-devel = " \
 cargo \
 rust-simple_logger+colored-devel \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+default-devel = " \
 cargo \
 rust-simple_logger+colors-devel \
 rust-simple_logger+timestamps-devel \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+nightly-devel = " \
 cargo \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+stderr-devel = " \
 cargo \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+threads-devel = " \
 cargo \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger+time-devel = " \
 cargo \
 rust-simple_logger-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-time+macros-devel \
 "
RDEPENDS:rust-simple_logger+timestamps-devel = " \
 cargo \
 rust-simple_logger+time-devel \
 rust-simple_logger-devel \
 "
RDEPENDS:rust-simple_logger-devel = " \
 cargo \
 rust-log+default-devel \
 rust-log+std-devel \
 "
