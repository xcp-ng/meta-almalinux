# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cloudflare"
PV = "2.19.4"
PR = "2.el10_0"
PACKAGES = " \
 python3-cloudflare \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cloudflare-2.19.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c0dbe6a6947b27219906e09d94051adcbf9864705cd620683513b5553d7308"

URI_x86_64_v2_python3-cloudflare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cloudflare-2.19.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cloudflare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cloudflare}"
SRC_URI[x86_64_v2_python3-cloudflare.sha256sum] = "c0a9694960c0af41be13f54b988f367d4b7dda9b759347fa8d72ce3a29dd5f7f"

URI_aarch64_python3-cloudflare = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cloudflare-2.19.4-2.el10_0.noarch.rpm;name=aarch64_python3-cloudflare;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cloudflare}"
SRC_URI[aarch64_python3-cloudflare.sha256sum] = "80361d9244e27f343a463c249f717d360a62377a60f4ef750ead4354ab642b69"

RDEPENDS:python3-cloudflare = " \
 python3 \
 python3-pyyaml \
 python3-requests \
 "
