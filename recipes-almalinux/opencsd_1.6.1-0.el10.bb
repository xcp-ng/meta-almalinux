# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opencsd"
PV = "1.6.1"
PR = "0.el10"
PACKAGES:x86_64_v2 = " \
  \
"
PACKAGES:aarch64 = " \
 opencsd \
 opencsd-devel \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/opencsd-1.6.1-0.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46e1c03ab8c9adda965f8b5a59cf2e5701c1b3f7bd166d2c34bb18784cc605ff"

URI_aarch64_opencsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/opencsd-1.6.1-0.el10.aarch64.rpm;name=aarch64_opencsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencsd}"
SRC_URI[aarch64_opencsd.sha256sum] = "09bf2695ccbd0cc339fd6d45223887d865bcefefefb15d1575ada7bbbce28779"

URI_aarch64_opencsd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/opencsd-devel-1.6.1-0.el10.aarch64.rpm;name=aarch64_opencsd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_opencsd-devel}"
SRC_URI[aarch64_opencsd-devel.sha256sum] = "cc58bc6c80caf6e30afae0b4ffdd4356fc91d9d2b01b57d165a5f160856f2e1d"

RDEPENDS:opencsd = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:opencsd-devel = " \
 opencsd \
 "
