# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cxxopts"
PV = "3.3.1"
PR = "1.el10_3"
PACKAGES = " \
 cxxopts-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cxxopts-3.3.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c4fb958305e4ce8c6eda867b2b8c5fcddff5b406973433c5f41488b45cb35a01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cxxopts-devel-3.3.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cxxopts-devel;unpack=0"
SRC_URI[x86_64_v2_cxxopts-devel.sha256sum] = "38e093074793416ea42882e007976e78c2f3cea912862152105175485ac9ec07"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cxxopts-devel-3.3.1-1.el10_3.aarch64.rpm;name=aarch64_cxxopts-devel;unpack=0"
SRC_URI[aarch64_cxxopts-devel.sha256sum] = "9cf4a99eb08d9bf36be5f69e5233ba6617a920bceac603adeda57262c01f99db"

RDEPENDS:cxxopts-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 pkgconf-pkg-config \
 "
