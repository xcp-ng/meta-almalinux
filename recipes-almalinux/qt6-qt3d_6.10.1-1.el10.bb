# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qt3d"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qt3d \
 qt6-qt3d-devel \
 qt6-qt3d-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qt3d-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6020913221713c22499d2be7f46f4ba7ce1b90102155560ae976e2c1e467a163"

URI_x86_64_v2_qt6-qt3d = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt3d-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt3d}"
SRC_URI[x86_64_v2_qt6-qt3d.sha256sum] = "f2b69060d9a0996b9e76b18319ac5e1b5fc50b64b085e06d353cd87fe5799a82"

URI_x86_64_v2_qt6-qt3d-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt3d-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt3d-devel}"
SRC_URI[x86_64_v2_qt6-qt3d-devel.sha256sum] = "9aa0aec7f91c680f602abfd7c80e03db2d0552153bdd35a6548f5ca96e1fa71a"

URI_x86_64_v2_qt6-qt3d-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qt3d-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt3d-examples}"
SRC_URI[x86_64_v2_qt6-qt3d-examples.sha256sum] = "30c810dff8c975bda71d83538c89ea314a15bb22f8aa7eeb68acfb8592e57ac7"

URI_aarch64_qt6-qt3d = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt3d-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qt3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt3d}"
SRC_URI[aarch64_qt6-qt3d.sha256sum] = "b14adf854e52e3278ef5c7dddb50d1e449ae71f77344e00d55669390185fc850"

URI_aarch64_qt6-qt3d-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt3d-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt3d-devel}"
SRC_URI[aarch64_qt6-qt3d-devel.sha256sum] = "c716e61706bcb6bc11cd9383a2e5fd199a87dcb521189ff7808b3559e0b38db9"

URI_aarch64_qt6-qt3d-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qt3d-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt3d-examples}"
SRC_URI[aarch64_qt6-qt3d-examples.sha256sum] = "d26504f7b516d921aa2c6fdea74fcb05c29e26fe62483b0f13834eda903e15c3"

RDEPENDS:qt6-qt3d = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtimageformats \
 qt6-qtshadertools \
 zlib-ng-compat \
 "
RDEPENDS:qt6-qt3d-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qt3d \
 qt6-qt3d-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qt3d-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qt3d \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
