# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kddockwidgets"
PV = "2.4.0"
PR = "5.el10_2"
PACKAGES = " \
 kddockwidgets-doc \
 kddockwidgets-qt6 \
 kddockwidgets-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kddockwidgets-2.4.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e103955b8ccc002299c536e0a4920805097ad4c8d4d98e5a527664c58ead6172"

URI_x86_64_v2_kddockwidgets-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kddockwidgets-doc-2.4.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kddockwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kddockwidgets-doc}"
SRC_URI[x86_64_v2_kddockwidgets-doc.sha256sum] = "29dfc77da8395cdcaa94713d699ad952af74e0284bdee144bea4fc8d10fbffc8"

URI_x86_64_v2_kddockwidgets-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kddockwidgets-qt6-2.4.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kddockwidgets-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kddockwidgets-qt6}"
SRC_URI[x86_64_v2_kddockwidgets-qt6.sha256sum] = "7769cff6a7ddd1f4f083c572097d1528013a30f4e42e787bf74d938d06d795d0"

URI_x86_64_v2_kddockwidgets-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kddockwidgets-qt6-devel-2.4.0-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kddockwidgets-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kddockwidgets-qt6-devel}"
SRC_URI[x86_64_v2_kddockwidgets-qt6-devel.sha256sum] = "75d778f43681bc9ca2c8b9e6bc84e6f57806f233229cb348633e1f6bdd232f6c"

URI_aarch64_kddockwidgets-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kddockwidgets-doc-2.4.0-5.el10_2.noarch.rpm;name=aarch64_kddockwidgets-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kddockwidgets-doc}"
SRC_URI[aarch64_kddockwidgets-doc.sha256sum] = "ad685231915900d64608841a6929e445d569fec7c79cb7194f5a1e6ab6df2741"

URI_aarch64_kddockwidgets-qt6 = "${EPEL_MIRROR}/aarch64/Packages/k/kddockwidgets-qt6-2.4.0-5.el10_2.aarch64.rpm;name=aarch64_kddockwidgets-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_kddockwidgets-qt6}"
SRC_URI[aarch64_kddockwidgets-qt6.sha256sum] = "b49351b0b694b8578dcae2624dbaf36e1477f9ecd5f40dc67a29ac400d12b093"

URI_aarch64_kddockwidgets-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kddockwidgets-qt6-devel-2.4.0-5.el10_2.aarch64.rpm;name=aarch64_kddockwidgets-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kddockwidgets-qt6-devel}"
SRC_URI[aarch64_kddockwidgets-qt6-devel.sha256sum] = "d78c5f8ffa2742935301b1fc4a8cfaccab353dfc6786d8e82d7dbf525696cf04"

RDEPENDS:kddockwidgets-doc = " \
 "
RDEPENDS:kddockwidgets-qt6 = " \
 fmt \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 spdlog \
 "
RDEPENDS:kddockwidgets-qt6-devel = " \
 cmake-filesystem \
 kddockwidgets-qt6 \
 "
