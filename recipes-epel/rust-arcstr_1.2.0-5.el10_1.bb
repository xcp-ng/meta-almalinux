# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arcstr"
PV = "1.2.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-arcstr+default-devel \
 rust-arcstr+serde-devel \
 rust-arcstr+std-devel \
 rust-arcstr+substr-devel \
 rust-arcstr+substr-usize-indices-devel \
 rust-arcstr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arcstr-1.2.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9452e72a0be450801e43c4bb9e29f70bf0e340731f6066f5ade7b6fb6f03a55"

URI_x86_64_v2_rust-arcstr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+default-devel-1.2.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+default-devel}"
SRC_URI[x86_64_v2_rust-arcstr+default-devel.sha256sum] = "ba7e427d536b106ad35c05d4fcb8189b38c3958ac459fb271059c5bf0a6b7a22"

URI_x86_64_v2_rust-arcstr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+serde-devel-1.2.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+serde-devel}"
SRC_URI[x86_64_v2_rust-arcstr+serde-devel.sha256sum] = "8cea461a384461c358cb86d39a3aa0231452a8c4cb1d5cf7b0cd75ae1bd112f6"

URI_x86_64_v2_rust-arcstr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+std-devel-1.2.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+std-devel}"
SRC_URI[x86_64_v2_rust-arcstr+std-devel.sha256sum] = "32f9528044c51ed6fd0a5ea6b47dc629671ee4d0984f94ef56ce36daf998e938"

URI_x86_64_v2_rust-arcstr+substr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+substr-devel-1.2.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+substr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+substr-devel}"
SRC_URI[x86_64_v2_rust-arcstr+substr-devel.sha256sum] = "fa94a44ddd2f7df093a282735f03eb7e924680c526c7ab902624bdecd02d7959"

URI_x86_64_v2_rust-arcstr+substr-usize-indices-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+substr-usize-indices-devel-1.2.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+substr-usize-indices-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+substr-usize-indices-devel}"
SRC_URI[x86_64_v2_rust-arcstr+substr-usize-indices-devel.sha256sum] = "6ebb9620cd999529d58c62317fff386d035997cb9219b382c49c862be9fc04ce"

URI_x86_64_v2_rust-arcstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr-devel-1.2.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr-devel}"
SRC_URI[x86_64_v2_rust-arcstr-devel.sha256sum] = "ac4278640a75e1c772d314abd08975bb2b4a1a8cb3faceef63b94681eeb8f29d"

URI_aarch64_rust-arcstr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+default-devel-1.2.0-5.el10_1.noarch.rpm;name=aarch64_rust-arcstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+default-devel}"
SRC_URI[aarch64_rust-arcstr+default-devel.sha256sum] = "b2d7f3a5a844b41761459762ef1565fb3dbe37ac7b0f4bc73112a57d13141ef6"

URI_aarch64_rust-arcstr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+serde-devel-1.2.0-5.el10_1.noarch.rpm;name=aarch64_rust-arcstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+serde-devel}"
SRC_URI[aarch64_rust-arcstr+serde-devel.sha256sum] = "4dd4386841e3516fe0ea0b054ab63e46fdf7c8f185d1473f95ef2b48044f88d5"

URI_aarch64_rust-arcstr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+std-devel-1.2.0-5.el10_1.noarch.rpm;name=aarch64_rust-arcstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+std-devel}"
SRC_URI[aarch64_rust-arcstr+std-devel.sha256sum] = "4df9189a7c6cc641130dd2f03bc212d6131af82ce61113b4a3b958a392e6a0c5"

URI_aarch64_rust-arcstr+substr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+substr-devel-1.2.0-5.el10_1.noarch.rpm;name=aarch64_rust-arcstr+substr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+substr-devel}"
SRC_URI[aarch64_rust-arcstr+substr-devel.sha256sum] = "3bbe7d617f67df69de0317da1dd2a0d1b8074a991f06ff96df3c4ce284e9a618"

URI_aarch64_rust-arcstr+substr-usize-indices-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+substr-usize-indices-devel-1.2.0-5.el10_1.noarch.rpm;name=aarch64_rust-arcstr+substr-usize-indices-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+substr-usize-indices-devel}"
SRC_URI[aarch64_rust-arcstr+substr-usize-indices-devel.sha256sum] = "84ce8e869fcf4242705d96bd46e6621c0682a7e2853e4b09070bf5069e9c11b1"

URI_aarch64_rust-arcstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr-devel-1.2.0-5.el10_1.noarch.rpm;name=aarch64_rust-arcstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr-devel}"
SRC_URI[aarch64_rust-arcstr-devel.sha256sum] = "1e5d47a0c31535b8a934c16c53bbf738dab7539f7a0c98e8bef9b78b858d58d6"

RDEPENDS:rust-arcstr+default-devel = " \
 cargo \
 rust-arcstr+substr-devel \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr+serde-devel = " \
 cargo \
 rust-arcstr-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-arcstr+std-devel = " \
 cargo \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr+substr-devel = " \
 cargo \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr+substr-usize-indices-devel = " \
 cargo \
 rust-arcstr+substr-devel \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr-devel = " \
 cargo \
 rust \
 "
