# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-resumable-media"
PV = "2.9.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-google-resumable-media \
 python3-google-resumable-media+requests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-resumable-media-2.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eec5f5ac742af0fa011ee884bcddea0222a02a21376a284f2d27da8cbc54c77"

URI_x86_64_v2_python3-google-resumable-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-resumable-media-2.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-resumable-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-resumable-media}"
SRC_URI[x86_64_v2_python3-google-resumable-media.sha256sum] = "bc445805287ac84f031457378d1c54c2696c57de591e7bf0bc350c91899a9d70"

URI_x86_64_v2_python3-google-resumable-media+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-resumable-media+requests-2.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-resumable-media+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-resumable-media+requests}"
SRC_URI[x86_64_v2_python3-google-resumable-media+requests.sha256sum] = "a9926a9fc1b444696e6d343df00ade41a0560d8899db080115652d85611ecc57"

URI_aarch64_python3-google-resumable-media = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-resumable-media-2.9.0-1.el10_2.noarch.rpm;name=aarch64_python3-google-resumable-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-resumable-media}"
SRC_URI[aarch64_python3-google-resumable-media.sha256sum] = "dbe6b9d1496402d169013b5172178d25791bcc191de963f37de6952aa2b92f71"

URI_aarch64_python3-google-resumable-media+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-resumable-media+requests-2.9.0-1.el10_2.noarch.rpm;name=aarch64_python3-google-resumable-media+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-resumable-media+requests}"
SRC_URI[aarch64_python3-google-resumable-media+requests.sha256sum] = "e39abac894877d77aace2b4efde681e0e02b9d06094a45d891aea7b271490468"

RDEPENDS:python3-google-resumable-media = " \
 python3 \
 python3-google-crc32c \
 "
RDEPENDS:python3-google-resumable-media+requests = " \
 python3 \
 python3-google-resumable-media \
 python3-requests \
 "
