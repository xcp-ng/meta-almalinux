# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-FTP-AutoReconnect"
PV = "0.3"
PR = "46.el10_3"
PACKAGES = " \
 perl-Net-FTP-AutoReconnect \
 perl-Net-FTP-AutoReconnect-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-FTP-AutoReconnect-0.3-46.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09ba832574c72a2021bdf8b8d7ad336a48a0e2961d64e641e305c80c3cf091a0"

URI_x86_64_v2_perl-Net-FTP-AutoReconnect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-AutoReconnect-0.3-46.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-AutoReconnect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-AutoReconnect}"
SRC_URI[x86_64_v2_perl-Net-FTP-AutoReconnect.sha256sum] = "2aa18f9f794f2ae0dbc45f1fbae29148f3244cc5410e71525a0f12ea04db65e0"

URI_x86_64_v2_perl-Net-FTP-AutoReconnect-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-AutoReconnect-tests-0.3-46.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-AutoReconnect-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-AutoReconnect-tests}"
SRC_URI[x86_64_v2_perl-Net-FTP-AutoReconnect-tests.sha256sum] = "3c1aaae623acfcaf53010581759048ead667e5a36662a81829b1043146686ba2"

URI_aarch64_perl-Net-FTP-AutoReconnect = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-AutoReconnect-0.3-46.el10_3.noarch.rpm;name=aarch64_perl-Net-FTP-AutoReconnect;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-AutoReconnect}"
SRC_URI[aarch64_perl-Net-FTP-AutoReconnect.sha256sum] = "d3e8cdd173fae77d8c2ac43e06ef4a762d14fb1342c6620ff36a166d2851cde8"

URI_aarch64_perl-Net-FTP-AutoReconnect-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-AutoReconnect-tests-0.3-46.el10_3.noarch.rpm;name=aarch64_perl-Net-FTP-AutoReconnect-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-AutoReconnect-tests}"
SRC_URI[aarch64_perl-Net-FTP-AutoReconnect-tests.sha256sum] = "fb1ddeb9b86cea46ba4cea6e6faf987d480425d792853471ac112f3cb98bb296"

RDEPENDS:perl-Net-FTP-AutoReconnect = " \
 perl-libnet \
 perl-libs \
 "
RDEPENDS:perl-Net-FTP-AutoReconnect-tests = " \
 bash \
 perl-Net-FTP-AutoReconnect \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
