# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-autocfg"
PV = "1.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-autocfg+default-devel \
 rust-autocfg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-autocfg-1.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57f773eeec79e41569f25392aedf4fdfdbcf9937f0454f388a543ca683f24393"

URI_x86_64_v2_rust-autocfg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-autocfg+default-devel-1.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-autocfg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-autocfg+default-devel}"
SRC_URI[x86_64_v2_rust-autocfg+default-devel.sha256sum] = "e0827653b02f1e43f0b648b1379425f0ea90418e0bd700f57bccdc04e1d2cc28"

URI_x86_64_v2_rust-autocfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-autocfg-devel-1.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-autocfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-autocfg-devel}"
SRC_URI[x86_64_v2_rust-autocfg-devel.sha256sum] = "14738c1ffc273331fda7a60557339b66a63efd7d7fcc67664a4163badc293763"

URI_aarch64_rust-autocfg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-autocfg+default-devel-1.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-autocfg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-autocfg+default-devel}"
SRC_URI[aarch64_rust-autocfg+default-devel.sha256sum] = "164f7e61e56e5fbbd5f193cd932de7267b96ae69bfad06291bb7ef179f417580"

URI_aarch64_rust-autocfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-autocfg-devel-1.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-autocfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-autocfg-devel}"
SRC_URI[aarch64_rust-autocfg-devel.sha256sum] = "133fb7cc470360a83ff7cb0bfd303462a6110face5b14eab4935ec4a25dbddb7"

RDEPENDS:rust-autocfg+default-devel = " \
 cargo \
 rust-autocfg-devel \
 "
RDEPENDS:rust-autocfg-devel = " \
 cargo \
 rust \
 "
