# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_tsort"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_tsort+default-devel \
 rust-uu_tsort-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_tsort-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9196637f9ba8109a996cb9bf5b9f50a7e8eb42091b6df380215bb160309d60bb"

URI_x86_64_v2_rust-uu_tsort+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tsort+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tsort+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_tsort+default-devel}"
SRC_URI[x86_64_v2_rust-uu_tsort+default-devel.sha256sum] = "e178b338d758e0315d4dcfbd6870df47f8664bf8a9d8d21e1664431626183d28"

URI_x86_64_v2_rust-uu_tsort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tsort-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tsort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_tsort-devel}"
SRC_URI[x86_64_v2_rust-uu_tsort-devel.sha256sum] = "b6c174897626710bb865648838667fb2c206a83ce915d673ce683998ea08581f"

URI_aarch64_rust-uu_tsort+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tsort+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tsort+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_tsort+default-devel}"
SRC_URI[aarch64_rust-uu_tsort+default-devel.sha256sum] = "533517cb08f0da8dba6967679e9aa0455aa69f27d6f601578b99cf97c690f6b5"

URI_aarch64_rust-uu_tsort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tsort-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tsort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_tsort-devel}"
SRC_URI[aarch64_rust-uu_tsort-devel.sha256sum] = "8d235c2c1ebe20d3b552f7c92350fa2a5895bbf74b78be1ed54905c030514ca4"

RDEPENDS:rust-uu_tsort+default-devel = " \
 cargo \
 rust-uu_tsort-devel \
 "
RDEPENDS:rust-uu_tsort-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30-devel \
 rust-rustc-hash+default-devel \
 rust-string-interner+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 "
