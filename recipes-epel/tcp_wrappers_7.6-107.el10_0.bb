# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcp_wrappers"
PV = "7.6"
PR = "107.el10_0"
PACKAGES = " \
 tcp_wrappers \
 tcp_wrappers-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tcp_wrappers-7.6-107.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67f71c11e65e7456415ecff17ab72e4f1dafb0a8b4d669876978cab905d644b9"

URI_x86_64_v2_tcp_wrappers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcp_wrappers-7.6-107.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcp_wrappers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcp_wrappers}"
SRC_URI[x86_64_v2_tcp_wrappers.sha256sum] = "ec82c537ec7712b2816e1a8c5daecd56d02ee0c037740c407a6ed32ae7ce0f92"

URI_x86_64_v2_tcp_wrappers-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcp_wrappers-libs-7.6-107.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcp_wrappers-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcp_wrappers-libs}"
SRC_URI[x86_64_v2_tcp_wrappers-libs.sha256sum] = "565eaec5a42d336fe2ec8a338311ccc076db08ade3f166a190568fc10853fb01"

URI_aarch64_tcp_wrappers = "${EPEL_MIRROR}/aarch64/Packages/t/tcp_wrappers-7.6-107.el10_0.aarch64.rpm;name=aarch64_tcp_wrappers;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcp_wrappers}"
SRC_URI[aarch64_tcp_wrappers.sha256sum] = "85b2de32aee407f4b9d127849524fac7113876f39528b2d917b90a536b2e087f"

URI_aarch64_tcp_wrappers-libs = "${EPEL_MIRROR}/aarch64/Packages/t/tcp_wrappers-libs-7.6-107.el10_0.aarch64.rpm;name=aarch64_tcp_wrappers-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcp_wrappers-libs}"
SRC_URI[aarch64_tcp_wrappers-libs.sha256sum] = "e7f6de81724413238a29c561732470ec1bac8dbd6ff694a338d85208ab255ac4"

RDEPENDS:tcp_wrappers = " \
 glibc \
 libnsl2 \
 tcp_wrappers-libs \
 "
RDEPENDS:tcp_wrappers-libs = " \
 glibc \
 libnsl2 \
 "
