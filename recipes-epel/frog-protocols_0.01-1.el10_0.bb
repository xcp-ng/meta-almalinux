# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "frog-protocols"
PV = "0.01"
PR = "1.el10_0"
PACKAGES = " \
 frog-protocols \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/frog-protocols-0.01-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c0c486d7513c0d557534e435223c74c0d3cdc3b65090eed21b180b3b192e6288"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/frog-protocols-0.01-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_frog-protocols;unpack=0"
SRC_URI[x86_64_v2_frog-protocols.sha256sum] = "f3b72e5b40d240d25e0cffadf1942e75f2df3aac3b3330f7ca43b02deb017113"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/frog-protocols-0.01-1.el10_0.noarch.rpm;name=aarch64_frog-protocols;unpack=0"
SRC_URI[aarch64_frog-protocols.sha256sum] = "be1e38349503f14d1fb685250fa8d11a74118de666e0d226cf4db947cc039236"

RDEPENDS:frog-protocols = " \
 pkgconf-pkg-config \
 "
