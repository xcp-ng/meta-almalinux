# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "composable_kernel"
PV = "7.1.1"
PR = "5.el10_2"
PACKAGES:x86_64_v2 = " \
 composable_kernel \
 composable_kernel-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/c/composable_kernel-7.1.1-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b22b307e8cd66a36499b3418589ad210c47414a347bb27b082e948904772995"

URI_x86_64_v2_composable_kernel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/composable_kernel-7.1.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_composable_kernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composable_kernel}"
SRC_URI[x86_64_v2_composable_kernel.sha256sum] = "0475b80bd0130275b665d2ccb9b45735efad8268a3428318d4bf604b45af0c06"

URI_x86_64_v2_composable_kernel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/composable_kernel-devel-7.1.1-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_composable_kernel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_composable_kernel-devel}"
SRC_URI[x86_64_v2_composable_kernel-devel.sha256sum] = "85db98d59c70727db9f0ebe8e7096015c83dbb9cf486a0209550b566fcee6cef"

RDEPENDS:composable_kernel = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:composable_kernel-devel = " \
 cmake-filesystem \
 composable_kernel \
 "
