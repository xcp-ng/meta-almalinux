# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gofrs-flock"
PV = "0.8.1"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-gofrs-flock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gofrs-flock-0.8.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4ac5e025ac7622323d20b2b6a3757f415059a16d669bfaf5250bf06734544c1"

URI_x86_64_v2_golang-github-gofrs-flock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gofrs-flock-devel-0.8.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gofrs-flock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gofrs-flock-devel}"
SRC_URI[x86_64_v2_golang-github-gofrs-flock-devel.sha256sum] = "fb1662295aa225e47adc59533e7d16a0166f76e286da0c4b2494cf84727697a2"

URI_aarch64_golang-github-gofrs-flock-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gofrs-flock-devel-0.8.1-12.el10_0.noarch.rpm;name=aarch64_golang-github-gofrs-flock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gofrs-flock-devel}"
SRC_URI[aarch64_golang-github-gofrs-flock-devel.sha256sum] = "fefb5cf3cfd52cd85a94075eaa71ac900bb52704ecc9ed537af86acf25326e23"

RDEPENDS:golang-github-gofrs-flock-devel = " \
 go-filesystem \
 "
