# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus_names"
PV = "4.2.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-zbus_names+default-devel \
 rust-zbus_names-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zbus_names-4.2.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2ea051d0dd39e5690bfdc97e70b0994c3f31b5435552f70f2388ea402727a09"

URI_x86_64_v2_rust-zbus_names+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_names+default-devel-4.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_names+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_names+default-devel}"
SRC_URI[x86_64_v2_rust-zbus_names+default-devel.sha256sum] = "e40ec1a6ab1d2f31ec76c59ee5eefa05eeb85dbc0ce5b9789f418b793edbab4d"

URI_x86_64_v2_rust-zbus_names-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus_names-devel-4.2.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus_names-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus_names-devel}"
SRC_URI[x86_64_v2_rust-zbus_names-devel.sha256sum] = "5d1cfce950ccc05feb850de58f5b3c8fa72b0ab8ca33ab24b3021cf7e6cd50ae"

URI_aarch64_rust-zbus_names+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_names+default-devel-4.2.0-2.el10_1.noarch.rpm;name=aarch64_rust-zbus_names+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_names+default-devel}"
SRC_URI[aarch64_rust-zbus_names+default-devel.sha256sum] = "97abe6ad702a59be92546cc058db41df55d789784feb5abca819f563f2abfea3"

URI_aarch64_rust-zbus_names-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus_names-devel-4.2.0-2.el10_1.noarch.rpm;name=aarch64_rust-zbus_names-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus_names-devel}"
SRC_URI[aarch64_rust-zbus_names-devel.sha256sum] = "e27915c565cbe95280342f840761404acbc3242b476d22f3b9c9f2f72032f526"

RDEPENDS:rust-zbus_names+default-devel = " \
 cargo \
 rust-zbus_names-devel \
 "
RDEPENDS:rust-zbus_names-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-static_assertions+default-devel \
 rust-winnow+default-devel \
 rust-zvariant+enumflags2-devel \
 rust-zvariant-devel \
 "
