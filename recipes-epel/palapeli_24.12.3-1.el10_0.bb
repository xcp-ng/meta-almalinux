# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "palapeli"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 palapeli \
 palapeli-devel \
 palapeli-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/palapeli-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f0d6650fc66d2fcc0b1af34cc4b821f4c5be8e6d1463344bb1f6af8ede668ba"

URI_x86_64_v2_palapeli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_palapeli}"
SRC_URI[x86_64_v2_palapeli.sha256sum] = "0ef205d6f49f71b8efe914dc5f667d1dc06aa8b4b39cc2b5ec2a89f29c9a2555"

URI_x86_64_v2_palapeli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_palapeli-devel}"
SRC_URI[x86_64_v2_palapeli-devel.sha256sum] = "4da68e34711e6879ff530125b21c427302283ebad6c154341deff8103a385889"

URI_x86_64_v2_palapeli-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/palapeli-libs-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_palapeli-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_palapeli-libs}"
SRC_URI[x86_64_v2_palapeli-libs.sha256sum] = "57b8a9d2e8554f4ffcf7946cb893790cf0d2c4b0fac19659ebc8d83e75b45629"

URI_aarch64_palapeli = "${EPEL_MIRROR}/aarch64/Packages/p/palapeli-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_palapeli;unpack=0"
SRC_URI:append = " ${URI_aarch64_palapeli}"
SRC_URI[aarch64_palapeli.sha256sum] = "bb5e64ba9d6a9118aa4fdca5887e05bacbd5e4e05c1eac65cbd293f94a88b820"

URI_aarch64_palapeli-devel = "${EPEL_MIRROR}/aarch64/Packages/p/palapeli-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_palapeli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_palapeli-devel}"
SRC_URI[aarch64_palapeli-devel.sha256sum] = "5c908ca4d12b3c6a90ef37640a7bd5891c36ea027e0701b71096173baa2c4f69"

URI_aarch64_palapeli-libs = "${EPEL_MIRROR}/aarch64/Packages/p/palapeli-libs-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_palapeli-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_palapeli-libs}"
SRC_URI[aarch64_palapeli-libs.sha256sum] = "b866552c3a1172c318ac13cbb89ffa1fb7a757812fd50d9c255df393a0bd33ec"

RDEPENDS:palapeli = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 palapeli-libs \
 qhull \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:palapeli-devel = " \
 cmake-filesystem \
 palapeli-libs \
 "
RDEPENDS:palapeli-libs = " \
 glibc \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 libstdc++ \
 palapeli \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
