# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XS-Parse-Keyword-epel"
PV = "0.39"
PR = "7.el10_0.1"
PACKAGES = " \
 perl-XS-Parse-Keyword-Builder \
 perl-XS-Parse-Keyword-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XS-Parse-Keyword-epel-0.39-7.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cda85311a46b54c8fa8d0291372a978e963ac1b504a2252d6cf413ad6ce833fa"

URI_x86_64_v2_perl-XS-Parse-Keyword-Builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Keyword-Builder-0.39-7.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Keyword-Builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Keyword-Builder}"
SRC_URI[x86_64_v2_perl-XS-Parse-Keyword-Builder.sha256sum] = "6ec60a7cabb7c9ccebab4fa59cbddb97f243ed9785b3e03f595675ebee95790a"

URI_x86_64_v2_perl-XS-Parse-Keyword-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Keyword-tests-0.39-7.el10_0.1.alma_altarch.1.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Keyword-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Keyword-tests}"
SRC_URI[x86_64_v2_perl-XS-Parse-Keyword-tests.sha256sum] = "594a3164e39ba96400963d5e39e802b4d37701d9a07f9d3da3f3435ab7d744fe"

URI_aarch64_perl-XS-Parse-Keyword-Builder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Keyword-Builder-0.39-7.el10_0.1.aarch64.rpm;name=aarch64_perl-XS-Parse-Keyword-Builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Keyword-Builder}"
SRC_URI[aarch64_perl-XS-Parse-Keyword-Builder.sha256sum] = "da4876683106dfe9dad7788a32eb5025ca779d96a6d4f395d8eecee3c8e4a6bd"

URI_aarch64_perl-XS-Parse-Keyword-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Keyword-tests-0.39-7.el10_0.1.aarch64.rpm;name=aarch64_perl-XS-Parse-Keyword-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Keyword-tests}"
SRC_URI[aarch64_perl-XS-Parse-Keyword-tests.sha256sum] = "090cb8f8656e949c62642031b03550c184966379795181cbe0d92100e6f45f2e"

RDEPENDS:perl-XS-Parse-Keyword-Builder = " \
 perl-XS-Parse-Keyword \
 perl-XS-Parse-Keyword-Builder \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-XS-Parse-Keyword-tests = " \
 bash \
 glibc \
 perl-B \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-XS-Parse-Keyword \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
