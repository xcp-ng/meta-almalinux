# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kongress"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kongress \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kongress-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3748718ab94c19f13032eb78ed7293265dff652d12aaf1ec85c81bd79d7676d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kongress-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kongress;unpack=0"
SRC_URI[x86_64_v2_kongress.sha256sum] = "75cff1ffff409c2a70b670688386c9d151125f9bc4313bb3ad4fa3692e4eef75"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kongress-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kongress;unpack=0"
SRC_URI[aarch64_kongress.sha256sum] = "0d8d628c81c33293a0bdc29a9ffc1f8bbcc23a68f5b21f6b7aa4793c687eca7e"

RDEPENDS:kongress = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kosmindoormap \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtpositioning \
 "
