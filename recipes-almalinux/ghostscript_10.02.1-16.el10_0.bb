# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghostscript"
PV = "10.02.1"
PR = "16.el10_0"
PACKAGES = " \
 ghostscript \
 ghostscript-doc \
 ghostscript-tools-dvipdf \
 ghostscript-tools-fonts \
 ghostscript-tools-printing \
 libgs \
 libgs-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ghostscript-10.02.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9534859d6d5ae053d91dd148076b9f79bbcb3d8d242c674a6e36c78ceb906201"

URI_x86_64_v2_ghostscript = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ghostscript-10.02.1-16.el10_0.x86_64_v2.rpm;name=x86_64_v2_ghostscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghostscript}"
SRC_URI[x86_64_v2_ghostscript.sha256sum] = "249e016f49607eee1be9916d78ec7572ac30481c9388dff8448f6d495fce8036"

URI_x86_64_v2_ghostscript-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ghostscript-doc-10.02.1-16.el10_0.noarch.rpm;name=x86_64_v2_ghostscript-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghostscript-doc}"
SRC_URI[x86_64_v2_ghostscript-doc.sha256sum] = "3f1b60a67eecc30c597d1f768163d3503fffbb49da34031d04739bd07ba6e87e"

URI_x86_64_v2_ghostscript-tools-dvipdf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ghostscript-tools-dvipdf-10.02.1-16.el10_0.noarch.rpm;name=x86_64_v2_ghostscript-tools-dvipdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghostscript-tools-dvipdf}"
SRC_URI[x86_64_v2_ghostscript-tools-dvipdf.sha256sum] = "fc9fab2864c9319a7e8c74d89d24b8812d80358b77c307fef386ada0406b8ac5"

URI_x86_64_v2_ghostscript-tools-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ghostscript-tools-fonts-10.02.1-16.el10_0.noarch.rpm;name=x86_64_v2_ghostscript-tools-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghostscript-tools-fonts}"
SRC_URI[x86_64_v2_ghostscript-tools-fonts.sha256sum] = "f241758178d18373dc0c9cb3749b477f152865d9168e3e2375f35b116091e34d"

URI_x86_64_v2_ghostscript-tools-printing = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ghostscript-tools-printing-10.02.1-16.el10_0.noarch.rpm;name=x86_64_v2_ghostscript-tools-printing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghostscript-tools-printing}"
SRC_URI[x86_64_v2_ghostscript-tools-printing.sha256sum] = "346e1a416a0a1bb35398d5cd665d457d5a38821bde5b90a62107f4b7ab631bfa"

URI_x86_64_v2_libgs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgs-10.02.1-16.el10_0.x86_64_v2.rpm;name=x86_64_v2_libgs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgs}"
SRC_URI[x86_64_v2_libgs.sha256sum] = "5bab3ef6c94d5988bdd36313118a923b0fc66a95e933fba02c16b3e940401641"

URI_x86_64_v2_libgs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgs-devel-10.02.1-16.el10_0.x86_64_v2.rpm;name=x86_64_v2_libgs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgs-devel}"
SRC_URI[x86_64_v2_libgs-devel.sha256sum] = "d16566fe80d285e98af88a655cb2f2afb5e0d03e3a1eb5ada10148e3fd9dfaed"

URI_aarch64_ghostscript = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ghostscript-10.02.1-16.el10_0.aarch64.rpm;name=aarch64_ghostscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghostscript}"
SRC_URI[aarch64_ghostscript.sha256sum] = "01ee75eccb824dcf8d2f2ef107457950adc1b751a37da853191c6ec9f6f1ec17"

URI_aarch64_ghostscript-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ghostscript-doc-10.02.1-16.el10_0.noarch.rpm;name=aarch64_ghostscript-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghostscript-doc}"
SRC_URI[aarch64_ghostscript-doc.sha256sum] = "3f1b60a67eecc30c597d1f768163d3503fffbb49da34031d04739bd07ba6e87e"

URI_aarch64_ghostscript-tools-dvipdf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ghostscript-tools-dvipdf-10.02.1-16.el10_0.noarch.rpm;name=aarch64_ghostscript-tools-dvipdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghostscript-tools-dvipdf}"
SRC_URI[aarch64_ghostscript-tools-dvipdf.sha256sum] = "fc9fab2864c9319a7e8c74d89d24b8812d80358b77c307fef386ada0406b8ac5"

URI_aarch64_ghostscript-tools-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ghostscript-tools-fonts-10.02.1-16.el10_0.noarch.rpm;name=aarch64_ghostscript-tools-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghostscript-tools-fonts}"
SRC_URI[aarch64_ghostscript-tools-fonts.sha256sum] = "f241758178d18373dc0c9cb3749b477f152865d9168e3e2375f35b116091e34d"

URI_aarch64_ghostscript-tools-printing = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ghostscript-tools-printing-10.02.1-16.el10_0.noarch.rpm;name=aarch64_ghostscript-tools-printing;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghostscript-tools-printing}"
SRC_URI[aarch64_ghostscript-tools-printing.sha256sum] = "346e1a416a0a1bb35398d5cd665d457d5a38821bde5b90a62107f4b7ab631bfa"

URI_aarch64_libgs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgs-10.02.1-16.el10_0.aarch64.rpm;name=aarch64_libgs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgs}"
SRC_URI[aarch64_libgs.sha256sum] = "b9452ebcb9c5f6bffac06ac224d33f27cc94e81929f2c1ed6c85631940126bb2"

URI_aarch64_libgs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgs-devel-10.02.1-16.el10_0.aarch64.rpm;name=aarch64_libgs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgs-devel}"
SRC_URI[aarch64_libgs-devel.sha256sum] = "ee07c23033ac1d0753b6cd11d987014d52a720eb56f31e39d032d1f0e0537a34"

RDEPENDS:ghostscript = " \
 bash \
 ghostscript-tools-fonts \
 ghostscript-tools-printing \
 glibc \
 jbig2dec-libs \
 libgs \
 "
RDEPENDS:ghostscript-doc = " \
 ghostscript \
 "
RDEPENDS:ghostscript-tools-dvipdf = " \
 bash \
 ghostscript \
 texlive-dvips \
 "
RDEPENDS:ghostscript-tools-fonts = " \
 bash \
 ghostscript \
 "
RDEPENDS:ghostscript-tools-printing = " \
 bash \
 ghostscript \
 "
RDEPENDS:libgs = " \
 adobe-mappings-cmap \
 adobe-mappings-cmap-deprecated \
 adobe-mappings-pdf \
 cups-libs \
 fontconfig \
 freetype \
 glibc \
 google-droid-sans-fonts \
 jbig2dec-libs \
 lcms2 \
 libijs \
 libjpeg-turbo \
 libpaper \
 libpng \
 libtiff \
 openjpeg2 \
 urw-base35-fonts \
 zlib-ng-compat \
 "
RDEPENDS:libgs-devel = " \
 libgs \
 "
