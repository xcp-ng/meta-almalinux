# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "telnet"
PE = "1"
PV = "0.17"
PR = "94.el10"
PACKAGES = " \
 telnet \
 telnet-server \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/telnet-0.17-94.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6dfe2ea81904d6eeff8b69b4b08ffb96a6204ce75479b02ff3949c3084ee1ee6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/telnet-0.17-94.el10.x86_64_v2.rpm;name=x86_64_v2_telnet;unpack=0"
SRC_URI[x86_64_v2_telnet.sha256sum] = "eb19ad3df359a98f58c082701d68d7e0dff6944265aeddabf81ea76adeaf75fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/telnet-server-0.17-94.el10.x86_64_v2.rpm;name=x86_64_v2_telnet-server;unpack=0"
SRC_URI[x86_64_v2_telnet-server.sha256sum] = "4f75265745eee44e2af1fd39affd7be2aa92c69756121120f7d70d0004899e1c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/telnet-0.17-94.el10.aarch64.rpm;name=aarch64_telnet;unpack=0"
SRC_URI[aarch64_telnet.sha256sum] = "686262328d0a8fefe5d58f396b809d8ce47b71e99d00c2e58d177756b4ec64d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/telnet-server-0.17-94.el10.aarch64.rpm;name=aarch64_telnet-server;unpack=0"
SRC_URI[aarch64_telnet-server.sha256sum] = "54f8f8f2c66b288da69f7c20af66f549334fcf374b6a33e02402d4524b230a8f"

RDEPENDS:telnet = " \
 glibc \
 ncurses-libs \
 "
RDEPENDS:telnet-server = " \
 bash \
 glibc \
 systemd \
 "
