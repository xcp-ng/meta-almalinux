# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pykmip"
PV = "0.10.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-pykmip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pykmip-0.10.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f27b416626e035031957e6563a48a3ff439ca6382edf4c0f3fbb350c71ac184"

URI_x86_64_v2_python3-pykmip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pykmip-0.10.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pykmip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pykmip}"
SRC_URI[x86_64_v2_python3-pykmip.sha256sum] = "1496217077a65606976739205f6efe98b4cf3a060a7798714e61b9b7691f0f4c"

URI_aarch64_python3-pykmip = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pykmip-0.10.0-2.el10_2.noarch.rpm;name=aarch64_python3-pykmip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pykmip}"
SRC_URI[aarch64_python3-pykmip.sha256sum] = "aca34bd08bc7cd9c645323605c6ceb720615cd34d54175886c7d103b11090de4"

RDEPENDS:python3-pykmip = " \
 python3 \
 python3-cryptography \
 python3-requests \
 python3-six \
 python3-sqlalchemy \
 "
