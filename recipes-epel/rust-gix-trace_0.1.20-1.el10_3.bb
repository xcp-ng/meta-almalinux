# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-trace"
PV = "0.1.20"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-trace+default-devel \
 rust-gix-trace+document-features-devel \
 rust-gix-trace+tracing-detail-devel \
 rust-gix-trace+tracing-devel \
 rust-gix-trace-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-trace-0.1.20-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df941c867c5758e3372e4f9102bff4dfd8c482a4fe3c75e62bcdd3cc9d006a90"

URI_x86_64_v2_rust-gix-trace+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+default-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+default-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+default-devel.sha256sum] = "b90ae98915ed12fec196b7292d81aafd7c78676d53c5f7e84111ef6cf841a0b3"

URI_x86_64_v2_rust-gix-trace+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+document-features-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+document-features-devel.sha256sum] = "814bdf22eeb96f95dba05d45729e2a37d09c007bb94f7e055fc63dd59372e055"

URI_x86_64_v2_rust-gix-trace+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+tracing-detail-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+tracing-detail-devel.sha256sum] = "d3fddca5105d4cf22a386bd07937180b601d4f1e470768cae220b6aec3aa9e75"

URI_x86_64_v2_rust-gix-trace+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace+tracing-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix-trace+tracing-devel.sha256sum] = "12663c4a492b77d1e03b0df561efc79976f1b661682fe51b4a23305acc8d8c15"

URI_x86_64_v2_rust-gix-trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-trace-devel-0.1.20-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-trace-devel}"
SRC_URI[x86_64_v2_rust-gix-trace-devel.sha256sum] = "c4fb3bd7d4f4692311b20c059bb2173756b2a75c980e7785bf82d7922fba6aa9"

URI_aarch64_rust-gix-trace+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+default-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-gix-trace+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+default-devel}"
SRC_URI[aarch64_rust-gix-trace+default-devel.sha256sum] = "97118debb1366ac226c606944237bbc1b2f400180f634413b63c4e438ebbe6bc"

URI_aarch64_rust-gix-trace+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+document-features-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-gix-trace+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+document-features-devel}"
SRC_URI[aarch64_rust-gix-trace+document-features-devel.sha256sum] = "dbe09f62e4f882174ea52954196f782f56e4912cc027baef1c779e19746b5dc0"

URI_aarch64_rust-gix-trace+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+tracing-detail-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-gix-trace+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix-trace+tracing-detail-devel.sha256sum] = "695c650223f5bd31fb16b90751053f6f9b54f6313c222e9ad4d4e3e2166897cb"

URI_aarch64_rust-gix-trace+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace+tracing-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-gix-trace+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace+tracing-devel}"
SRC_URI[aarch64_rust-gix-trace+tracing-devel.sha256sum] = "c274fa1470af55182cc9ab5d00c0515e0c5fc4c29dd6f04a8d087edfc773adb6"

URI_aarch64_rust-gix-trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-trace-devel-0.1.20-1.el10_3.noarch.rpm;name=aarch64_rust-gix-trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-trace-devel}"
SRC_URI[aarch64_rust-gix-trace-devel.sha256sum] = "b9db498d201f7588008523266b1413698e316ec4aa3d9d66d42a157746572801"

RDEPENDS:rust-gix-trace+default-devel = " \
 cargo \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+tracing-detail-devel = " \
 cargo \
 rust-gix-trace-devel \
 "
RDEPENDS:rust-gix-trace+tracing-devel = " \
 cargo \
 rust-gix-trace-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-gix-trace-devel = " \
 cargo \
 rust \
 "
