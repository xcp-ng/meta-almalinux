# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-FindPerl"
PV = "0.016"
PR = "12.el10_2"
PACKAGES = " \
 perl-Devel-FindPerl \
 perl-Devel-FindPerl-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-FindPerl-0.016-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fd191f942b463289191057e22b9089a83c1330465db5b4984a013e4651ada3ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-FindPerl-0.016-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-FindPerl;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-FindPerl.sha256sum] = "b0929b41eaad5d03d47ead4a0dc67e0fa2a8ee93feb834cd3367a0e93d315846"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-FindPerl-tests-0.016-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-FindPerl-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-FindPerl-tests.sha256sum] = "9e02eac796b343d1c10df4af4d8e748048c441720185ca73ec7c84140582eb64"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-FindPerl-0.016-12.el10_2.noarch.rpm;name=aarch64_perl-Devel-FindPerl;unpack=0"
SRC_URI[aarch64_perl-Devel-FindPerl.sha256sum] = "24b955854b7b10d4223a74c6c5001d472cf3445e32f82acc12a951f440cbe36e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-FindPerl-tests-0.016-12.el10_2.noarch.rpm;name=aarch64_perl-Devel-FindPerl-tests;unpack=0"
SRC_URI[aarch64_perl-Devel-FindPerl-tests.sha256sum] = "e35779d4ca64c18c39a8ae420f48d4662f2220b31d3791210e33d8f2e87e5ab4"

RDEPENDS:perl-Devel-FindPerl = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-Devel-FindPerl-tests = " \
 bash \
 perl-Devel-FindPerl \
 perl-IPC-Open3 \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
