# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-FTP-RetrHandle"
PV = "0.2"
PR = "45.el10_1"
PACKAGES = " \
 perl-Net-FTP-RetrHandle \
 perl-Net-FTP-RetrHandle-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-FTP-RetrHandle-0.2-45.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f5c05738c85121969ba61fcccf682b84cb3359649f2ef5c93cea0a408738306"

URI_x86_64_v2_perl-Net-FTP-RetrHandle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-RetrHandle-0.2-45.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-RetrHandle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-RetrHandle}"
SRC_URI[x86_64_v2_perl-Net-FTP-RetrHandle.sha256sum] = "e3fcddb64d38135dd02daff7de094b5d43baa742d247cf0be645643bb5a249fb"

URI_x86_64_v2_perl-Net-FTP-RetrHandle-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-FTP-RetrHandle-tests-0.2-45.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-FTP-RetrHandle-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-FTP-RetrHandle-tests}"
SRC_URI[x86_64_v2_perl-Net-FTP-RetrHandle-tests.sha256sum] = "61475f39e40d4495eb8d160d4630085f0080bab5dba240dfd90598f9c11be1cd"

URI_aarch64_perl-Net-FTP-RetrHandle = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-RetrHandle-0.2-45.el10_1.noarch.rpm;name=aarch64_perl-Net-FTP-RetrHandle;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-RetrHandle}"
SRC_URI[aarch64_perl-Net-FTP-RetrHandle.sha256sum] = "416cbc1830ed1ba53cecad2a7e9032da1350c077a320cee4e7263f3fcfbc4d41"

URI_aarch64_perl-Net-FTP-RetrHandle-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-FTP-RetrHandle-tests-0.2-45.el10_1.noarch.rpm;name=aarch64_perl-Net-FTP-RetrHandle-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-FTP-RetrHandle-tests}"
SRC_URI[aarch64_perl-Net-FTP-RetrHandle-tests.sha256sum] = "0fdb411d0c775e0fd6445006e0a5fa5a88a4d7e1b91793dcc1ee06ef1de7b25c"

RDEPENDS:perl-Net-FTP-RetrHandle = " \
 perl-Carp \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-base \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Net-FTP-RetrHandle-tests = " \
 bash \
 perl-Net-FTP-RetrHandle \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
