# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "disciplining-minipod"
PV = "3.10.4"
PR = "1.el10_3"
PACKAGES = " \
 liboscillator-disciplining \
 liboscillator-disciplining-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/disciplining-minipod-3.10.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "07e257b5f36f622f21a4f7a9ab3a0895fba6470fd5f53ee92ba781a9c82def0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboscillator-disciplining-3.10.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboscillator-disciplining;unpack=0"
SRC_URI[x86_64_v2_liboscillator-disciplining.sha256sum] = "34d64e24f39088f966d967560d0e227822b18a74d57b31f0bd6de6cfe468a5e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liboscillator-disciplining-devel-3.10.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liboscillator-disciplining-devel;unpack=0"
SRC_URI[x86_64_v2_liboscillator-disciplining-devel.sha256sum] = "f6d89e6a637ec35c082086435520b0de52afb987ec030508da14d91870c49b61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/liboscillator-disciplining-3.10.4-1.el10_3.aarch64.rpm;name=aarch64_liboscillator-disciplining;unpack=0"
SRC_URI[aarch64_liboscillator-disciplining.sha256sum] = "ac1b281378dc584ae8473fb85733181df36fd4992ff275ef0614adff53dbe2e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/liboscillator-disciplining-devel-3.10.4-1.el10_3.aarch64.rpm;name=aarch64_liboscillator-disciplining-devel;unpack=0"
SRC_URI[aarch64_liboscillator-disciplining-devel.sha256sum] = "e61c01ffc3933fa5283cd8809638697f2595910f0f542f4dc6aa18f1decfa241"

RDEPENDS:liboscillator-disciplining = " \
 glibc \
 "
RDEPENDS:liboscillator-disciplining-devel = " \
 liboscillator-disciplining \
 pkgconf-pkg-config \
 "
