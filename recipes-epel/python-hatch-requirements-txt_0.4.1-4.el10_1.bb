# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-hatch-requirements-txt"
PV = "0.4.1"
PR = "4.el10_1"
PACKAGES = " \
 python3-hatch-requirements-txt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-hatch-requirements-txt-0.4.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a2a678ccb9489e6c6f4abccf0fc01a135ddb1bd5dab5ad5210e7044643c3807"

URI_x86_64_v2_python3-hatch-requirements-txt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-hatch-requirements-txt-0.4.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-hatch-requirements-txt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hatch-requirements-txt}"
SRC_URI[x86_64_v2_python3-hatch-requirements-txt.sha256sum] = "fedd04d20cf8ee05e46877993ac4420d9abe863063c1cf63bc7fbbd705b6cb19"

URI_aarch64_python3-hatch-requirements-txt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-hatch-requirements-txt-0.4.1-4.el10_1.noarch.rpm;name=aarch64_python3-hatch-requirements-txt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hatch-requirements-txt}"
SRC_URI[aarch64_python3-hatch-requirements-txt.sha256sum] = "a239548a542b404e807cdeb2662fb3e5b1526df7cd01bb336f30c91bc764945c"

RDEPENDS:python3-hatch-requirements-txt = " \
 python3 \
 python3-hatchling \
 python3-packaging \
 "
