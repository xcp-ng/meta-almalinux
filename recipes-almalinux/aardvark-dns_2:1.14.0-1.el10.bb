# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aardvark-dns"
PE = "2"
PV = "1.14.0"
PR = "1.el10"
PACKAGES = " \
 aardvark-dns \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/aardvark-dns-1.14.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47926f1aeb906d1b9c6869e1c84cdf1488b90fc9c492e017e8f34da29a8c2f13"

URI_x86_64_v2_aardvark-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aardvark-dns-1.14.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_aardvark-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aardvark-dns}"
SRC_URI[x86_64_v2_aardvark-dns.sha256sum] = "49aa5be4bc3ceb52eba96683f155fe4e7bd44b58482c379a4fbffffa5c8ab02b"

URI_aarch64_aardvark-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aardvark-dns-1.14.0-1.el10.aarch64.rpm;name=aarch64_aardvark-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_aardvark-dns}"
SRC_URI[aarch64_aardvark-dns.sha256sum] = "dcb23db28397b1f52fd6024e43e079f2ad9ae6bd4591328bb2796e377b43ff56"

RDEPENDS:aardvark-dns = " \
 glibc \
 libgcc \
 "
