# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-firewall"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-firewall \
 plasma-firewall-firewalld \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-firewall-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07f45a86ea019a1010a5b6fbeb6ab4d8c76e462c8af19fb695003853c32cc4c1"

URI_x86_64_v2_plasma-firewall = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-firewall}"
SRC_URI[x86_64_v2_plasma-firewall.sha256sum] = "c530f3eaca146f7fb6a77a6596ebb00e884626f48818187898226f3727335b66"

URI_x86_64_v2_plasma-firewall-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-firewalld-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-firewall-firewalld}"
SRC_URI[x86_64_v2_plasma-firewall-firewalld.sha256sum] = "bf76ce299886e1a74bbbc2f5e1b64b98e06eb243e779d6db478df80035ac8c10"

URI_aarch64_plasma-firewall = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-firewall;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-firewall}"
SRC_URI[aarch64_plasma-firewall.sha256sum] = "df5386e3bead7b9fe7d69c6425ff4760f72515bbb6e3e16b4fb6a1a6d290ddcc"

URI_aarch64_plasma-firewall-firewalld = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-firewalld-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-firewall-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-firewall-firewalld}"
SRC_URI[aarch64_plasma-firewall-firewalld.sha256sum] = "1e7a607807aa5c5b8081f44c8e90923e1faac5d4bf085986dbef2e99706fc9f5"

RDEPENDS:plasma-firewall = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall-firewalld \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-firewall-firewalld = " \
 firewalld \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall \
 qt6-qtbase \
 "
