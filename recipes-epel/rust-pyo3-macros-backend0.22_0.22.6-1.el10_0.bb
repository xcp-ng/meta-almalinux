# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-macros-backend0.22"
PV = "0.22.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-macros-backend0.22+default-devel \
 rust-pyo3-macros-backend0.22+experimental-async-devel \
 rust-pyo3-macros-backend0.22+gil-refs-devel \
 rust-pyo3-macros-backend0.22-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-macros-backend0.22-0.22.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80c9bf0e55a17e8f29fe37b84990995485137b2787223c718ef0f994e3bdd92a"

URI_x86_64_v2_rust-pyo3-macros-backend0.22+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.22+default-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.22+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.22+default-devel.sha256sum] = "1651c554b39d0a4953f5a027d46ab1e99d6c39a4a6f8d00fce4b30267eaa3a7a"

URI_x86_64_v2_rust-pyo3-macros-backend0.22+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.22+experimental-async-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.22+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.22+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.22+experimental-async-devel.sha256sum] = "fa47881f549477d606da96d6d56b52d7abd34ed62feaad840f48c22919aa69ba"

URI_x86_64_v2_rust-pyo3-macros-backend0.22+gil-refs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.22+gil-refs-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.22+gil-refs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.22+gil-refs-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.22+gil-refs-devel.sha256sum] = "c4abe627edceb342d42bfc73e0da52a775d4f761276bd5c475c7000b35e2c3da"

URI_x86_64_v2_rust-pyo3-macros-backend0.22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-macros-backend0.22-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-macros-backend0.22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-macros-backend0.22-devel}"
SRC_URI[x86_64_v2_rust-pyo3-macros-backend0.22-devel.sha256sum] = "7b3e7ee1840b2dcc7efa74558b64613ce106ef51b55ecbdad98f2550a35df9bb"

URI_aarch64_rust-pyo3-macros-backend0.22+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.22+default-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.22+default-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.22+default-devel.sha256sum] = "02a068c6a1285dc3a9dbe911df8533f5dee7df45f5f61986f451d034775c0fb0"

URI_aarch64_rust-pyo3-macros-backend0.22+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.22+experimental-async-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.22+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.22+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.22+experimental-async-devel.sha256sum] = "09dcb14bb8e1515d6e9f32459d6153869d2b1f33da2d0d6d3662250c38d8956d"

URI_aarch64_rust-pyo3-macros-backend0.22+gil-refs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.22+gil-refs-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.22+gil-refs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.22+gil-refs-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.22+gil-refs-devel.sha256sum] = "11ce50f1b05471bfebc7a072e8e5bd08a358979b3d532a360e2c855cf6b0c339"

URI_aarch64_rust-pyo3-macros-backend0.22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-macros-backend0.22-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-macros-backend0.22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-macros-backend0.22-devel}"
SRC_URI[aarch64_rust-pyo3-macros-backend0.22-devel.sha256sum] = "eaa5dbbcd0524a56da60f15a254d31ff743024ae45f1d9d3d44f98e1be215876"

RDEPENDS:rust-pyo3-macros-backend0.22+default-devel = " \
 cargo \
 rust-pyo3-macros-backend0.22-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.22+experimental-async-devel = " \
 cargo \
 rust-pyo3-macros-backend0.22-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.22+gil-refs-devel = " \
 cargo \
 rust-pyo3-macros-backend0.22-devel \
 "
RDEPENDS:rust-pyo3-macros-backend0.22-devel = " \
 cargo \
 rust-heck+default-devel \
 rust-proc-macro2-devel \
 rust-pyo3-build-config0.22+default-devel \
 rust-pyo3-build-config0.22+resolve-config-devel \
 rust-quote-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+derive-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2-devel \
 "
