# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mongo-c-driver"
PV = "1.30.6"
PR = "1.el10_0"
PACKAGES = " \
 libbson \
 libbson-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mongo-c-driver-1.30.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cbc71f06c547d1b6f569fe8e71f61bf89bf7f332c917ac20de2325fe86dde46"

URI_x86_64_v2_libbson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-1.30.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbson}"
SRC_URI[x86_64_v2_libbson.sha256sum] = "49cc973400a8b14ecd1797a9f843d3b02f1c748ca07b5829f1dc7ffbe65c8f20"

URI_x86_64_v2_libbson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-devel-1.30.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbson-devel}"
SRC_URI[x86_64_v2_libbson-devel.sha256sum] = "1387f047ad5f37ff23ca7b4855303daa7b5798a21aacb7ac2ccecb15a8f433db"

URI_x86_64_v2_mongo-c-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-1.30.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mongo-c-driver}"
SRC_URI[x86_64_v2_mongo-c-driver.sha256sum] = "3fcd8b22fecc437109559a6cb9143141e31b71b774c23688d7fed0d89b2a5938"

URI_x86_64_v2_mongo-c-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-devel-1.30.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mongo-c-driver-devel}"
SRC_URI[x86_64_v2_mongo-c-driver-devel.sha256sum] = "d25bfa1740da69c0c38a4357f7ec89c8484fb1a1ff2cb709bad00100b0cadf69"

URI_x86_64_v2_mongo-c-driver-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-libs-1.30.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mongo-c-driver-libs}"
SRC_URI[x86_64_v2_mongo-c-driver-libs.sha256sum] = "f153497339dc02586a20a7622cb6548116b14c1196a82034f91af0d5f8ebc218"

URI_aarch64_libbson = "${EPEL_MIRROR}/aarch64/Packages/l/libbson-1.30.6-1.el10_0.aarch64.rpm;name=aarch64_libbson;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbson}"
SRC_URI[aarch64_libbson.sha256sum] = "b2661e9be720ef69ef295deb8c6d287162528eca183a9749ddc212d06dcb09f4"

URI_aarch64_libbson-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbson-devel-1.30.6-1.el10_0.aarch64.rpm;name=aarch64_libbson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbson-devel}"
SRC_URI[aarch64_libbson-devel.sha256sum] = "5284c1f7b8e7f51fd81f3e68d1890aa22c9009f8203fb2ebd8ee72b0efbeeeef"

URI_aarch64_mongo-c-driver = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-1.30.6-1.el10_0.aarch64.rpm;name=aarch64_mongo-c-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver}"
SRC_URI[aarch64_mongo-c-driver.sha256sum] = "f89962fd01ad6d4ee1809802001c4ad8a00d3868dba2e319a351d987bc4efd49"

URI_aarch64_mongo-c-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-devel-1.30.6-1.el10_0.aarch64.rpm;name=aarch64_mongo-c-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver-devel}"
SRC_URI[aarch64_mongo-c-driver-devel.sha256sum] = "d72517b1625daa6722790ef11125d5bd592c6fe6dabe8deb438f20b26958219e"

URI_aarch64_mongo-c-driver-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-libs-1.30.6-1.el10_0.aarch64.rpm;name=aarch64_mongo-c-driver-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver-libs}"
SRC_URI[aarch64_mongo-c-driver-libs.sha256sum] = "4a81b8cf2109d1b3756bab25e26412c7e330a116b4f978026e725fc8b7c87b73"

RDEPENDS:libbson = " \
 glibc \
 "
RDEPENDS:libbson-devel = " \
 cmake-filesystem \
 libbson \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver = " \
 glibc \
 mongo-c-driver-libs \
 "
RDEPENDS:mongo-c-driver-devel = " \
 cmake-filesystem \
 libbson-devel \
 libmongocrypt-devel \
 libzstd-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver-libs = " \
 cyrus-sasl-lib \
 glibc \
 libbson \
 libmongocrypt \
 libzstd \
 openssl-libs \
 snappy \
 utf8proc \
 zlib-ng-compat \
 "
