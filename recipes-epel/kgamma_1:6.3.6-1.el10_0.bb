# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgamma"
PE = "1"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 kgamma \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgamma-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf0914daca491c3698194d79cc19636dcb788ffd19975e32b4e1a9a5750e2b8d"

URI_x86_64_v2_kgamma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgamma-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgamma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgamma}"
SRC_URI[x86_64_v2_kgamma.sha256sum] = "f3fb6377ba09e92dad75489988fe1539eedb51e41bb1eb609fc0967e5e13945d"

URI_aarch64_kgamma = "${EPEL_MIRROR}/aarch64/Packages/k/kgamma-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_kgamma;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgamma}"
SRC_URI[aarch64_kgamma.sha256sum] = "dc8c774fa429022534fc190fd75787f4159b7827a0e4199ad7b0d9060651b10e"

RDEPENDS:kgamma = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libX11 \
 libXxf86vm \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
