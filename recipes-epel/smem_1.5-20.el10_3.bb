# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smem"
PV = "1.5"
PR = "20.el10_3"
PACKAGES = " \
 smem \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/smem-1.5-20.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7f1b43666a6c4b490717abf71cb6d2006748f31f6f5633795957cd2c89af75b"

URI_x86_64_v2_smem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/smem-1.5-20.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_smem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_smem}"
SRC_URI[x86_64_v2_smem.sha256sum] = "5edfe968e708cc56cd66e0d929088ff027f54e064a38216b3d5da168cbf16988"

URI_aarch64_smem = "${EPEL_MIRROR}/aarch64/Packages/s/smem-1.5-20.el10_3.aarch64.rpm;name=aarch64_smem;unpack=0"
SRC_URI:append = " ${URI_aarch64_smem}"
SRC_URI[aarch64_smem.sha256sum] = "35659de0fb79b296a76a3ef37c07bdfce515c6c539971247e8eef5f0a95d0628"

RDEPENDS:smem = " \
 glibc \
 python3 \
 "
