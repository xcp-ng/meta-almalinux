# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-base"
PV = "1.26.7"
PR = "2.el10_2"
PACKAGES = " \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 gstreamer1-plugins-base-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-base-1.26.7-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5de6ffd2d4410f326af3f78d819ee80826fd85350862b75f090f1064d9245c9"

URI_x86_64_v2_gstreamer1-plugins-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-1.26.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base.sha256sum] = "e118f01f6c78ae92a6e9f577eacf9c0a3ee15aace09a7fd0fdf6a8c5d2afca80"

URI_x86_64_v2_gstreamer1-plugins-base-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-devel-1.26.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base-devel}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-devel.sha256sum] = "cf46e744649885660d0f4eebf773b84b487622b495f3e866c13cc9af87157da6"

URI_x86_64_v2_gstreamer1-plugins-base-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-tools-1.26.7-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-base-tools}"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-tools.sha256sum] = "3c83b331b3096ff7790a587ae60736f6dfdc2de75d89d2a1c383352c8fe843cd"

URI_aarch64_gstreamer1-plugins-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-1.26.7-2.el10_2.aarch64.rpm;name=aarch64_gstreamer1-plugins-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base}"
SRC_URI[aarch64_gstreamer1-plugins-base.sha256sum] = "91c555636787b17a48fdbf40adcda77ead5e4a2f1352eca122e8c1c1869860a0"

URI_aarch64_gstreamer1-plugins-base-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-devel-1.26.7-2.el10_2.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base-devel}"
SRC_URI[aarch64_gstreamer1-plugins-base-devel.sha256sum] = "f892174eb9b251b9c57bec3b6b6087dbbf36a5120ed0436de77358f7d952e0b3"

URI_aarch64_gstreamer1-plugins-base-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-tools-1.26.7-2.el10_2.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-base-tools}"
SRC_URI[aarch64_gstreamer1-plugins-base-tools.sha256sum] = "a64a7974876c46b5c32731cd5abd28ff90a2b2b1332ca988c53d294a7e7ab435"

RDEPENDS:gstreamer1-plugins-base = " \
 alsa-lib \
 cairo \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 iso-codes \
 libX11 \
 libX11-xcb \
 libXext \
 libXi \
 libXv \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libgudev \
 libjpeg-turbo \
 libogg \
 libpng \
 libtheora \
 libvorbis \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxcb \
 mesa-libgbm \
 opus \
 orc \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-base-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 libX11-devel \
 libdrm-devel \
 libglvnd-devel \
 libgudev-devel \
 mesa-libgbm-devel \
 orc-devel \
 pkgconf-pkg-config \
 wayland-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:gstreamer1-plugins-base-tools = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 "
