# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata0.18"
PV = "0.18.1"
PR = "3.el10_2"
PACKAGES = " \
 rust-cargo_metadata0.18+builder-devel \
 rust-cargo_metadata0.18+default-devel \
 rust-cargo_metadata0.18+derive_builder-devel \
 rust-cargo_metadata0.18+unstable-devel \
 rust-cargo_metadata0.18-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata0.18-0.18.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b76dbc8212225195ce5606d8fe089ea3eb0f619a76941d847cd10decd9007b33"

URI_x86_64_v2_rust-cargo_metadata0.18+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18+builder-devel-0.18.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18+builder-devel.sha256sum] = "fe0e9a68048e5b5c3e05603f662bb8c5c5219c8097804f2919b041dd4229faa1"

URI_x86_64_v2_rust-cargo_metadata0.18+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18+default-devel-0.18.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18+default-devel.sha256sum] = "f53687b2e7704af372e65fcd3a6788adad025325fbcd08ac6de135727c8fc6d5"

URI_x86_64_v2_rust-cargo_metadata0.18+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18+derive_builder-devel-0.18.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18+derive_builder-devel.sha256sum] = "60bf517eeed5256ae25ebc2e116a60de382c3bfbda9c5bd44482fb9f02d77f0e"

URI_x86_64_v2_rust-cargo_metadata0.18+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18+unstable-devel-0.18.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18+unstable-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18+unstable-devel.sha256sum] = "ab89425a34a51ba619f0f6d273f9c05c0aae08d98c2bab328e9c57ac030b7883"

URI_x86_64_v2_rust-cargo_metadata0.18-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.18-devel-0.18.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.18-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.18-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.18-devel.sha256sum] = "06c9c2e88f1dcca5d3b5eb75340eb247431993a9cae2b5e279908b67e64a33a2"

URI_aarch64_rust-cargo_metadata0.18+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18+builder-devel-0.18.1-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.18+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18+builder-devel.sha256sum] = "90bcebc0cb770b33c772006aa430926afaa0258d55e8cc0f2766c96840b0a381"

URI_aarch64_rust-cargo_metadata0.18+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18+default-devel-0.18.1-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.18+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18+default-devel.sha256sum] = "b80e48f48d816f57feee273485506f80ad8999b0147e183376f7ca8a05332cee"

URI_aarch64_rust-cargo_metadata0.18+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18+derive_builder-devel-0.18.1-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.18+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18+derive_builder-devel.sha256sum] = "9e6e8b263163325388e37e34ae2723aadd9e00ef286a24bc7ac042b6fdb3d441"

URI_aarch64_rust-cargo_metadata0.18+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18+unstable-devel-0.18.1-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.18+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18+unstable-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18+unstable-devel.sha256sum] = "63bf9eb51317c31ae8567b2b022fea0e357d8d755420dbdf27ae046b307013d9"

URI_aarch64_rust-cargo_metadata0.18-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.18-devel-0.18.1-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.18-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.18-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.18-devel.sha256sum] = "50b4c88849fdd65eed93846984917e2b6a6ee2389556d538249f4bf5cdb435bc"

RDEPENDS:rust-cargo_metadata0.18+builder-devel = " \
 cargo \
 rust-cargo_metadata0.18+derive_builder-devel \
 rust-cargo_metadata0.18-devel \
 "
RDEPENDS:rust-cargo_metadata0.18+default-devel = " \
 cargo \
 rust-cargo_metadata0.18-devel \
 "
RDEPENDS:rust-cargo_metadata0.18+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata0.18-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata0.18+unstable-devel = " \
 cargo \
 rust-cargo_metadata0.18-devel \
 "
RDEPENDS:rust-cargo_metadata0.18-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform0.1+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror1+default-devel \
 "
