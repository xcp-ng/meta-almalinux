# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtvirtualkeyboard"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtvirtualkeyboard \
 qt6-qtvirtualkeyboard-devel \
 qt6-qtvirtualkeyboard-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtvirtualkeyboard-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5dd06a7694efb5c85750b739447806141963d48a2c7bc3a6f663234e352e689"

URI_x86_64_v2_qt6-qtvirtualkeyboard = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtvirtualkeyboard}"
SRC_URI[x86_64_v2_qt6-qtvirtualkeyboard.sha256sum] = "974d3526600f2e1647eaf0f2790fa3da4201a77171bf93e461c02a36ada878e2"

URI_x86_64_v2_qt6-qtvirtualkeyboard-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtvirtualkeyboard-devel}"
SRC_URI[x86_64_v2_qt6-qtvirtualkeyboard-devel.sha256sum] = "aa81da5876f3f5c8cd398117298dced1a8647218efcde3f23aa911bf0cd0dd04"

URI_x86_64_v2_qt6-qtvirtualkeyboard-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtvirtualkeyboard-examples-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtvirtualkeyboard-examples}"
SRC_URI[x86_64_v2_qt6-qtvirtualkeyboard-examples.sha256sum] = "00e2d567d971d3fa9a4e38917d6f9cb941d142c612f9a7f1b3b6a4029fc6d6b6"

URI_aarch64_qt6-qtvirtualkeyboard = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtvirtualkeyboard-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtvirtualkeyboard}"
SRC_URI[aarch64_qt6-qtvirtualkeyboard.sha256sum] = "7aa52b6a56260669cd790563f30fc3a71c1cd6decb9744124caccc8cb18496a4"

URI_aarch64_qt6-qtvirtualkeyboard-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtvirtualkeyboard-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtvirtualkeyboard-devel}"
SRC_URI[aarch64_qt6-qtvirtualkeyboard-devel.sha256sum] = "075c8910ab328cda028192220ea7f74a221df84d9de0b2bc0f2114f41995e73a"

URI_aarch64_qt6-qtvirtualkeyboard-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtvirtualkeyboard-examples-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtvirtualkeyboard-examples}"
SRC_URI[aarch64_qt6-qtvirtualkeyboard-examples.sha256sum] = "c66bfefad451a0a3589146e528808958406e981c87317079ba2ece0945402129"

RDEPENDS:qt6-qtvirtualkeyboard = " \
 glibc \
 hunspell \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 "
RDEPENDS:qt6-qtvirtualkeyboard-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtvirtualkeyboard \
 qt6-qtvirtualkeyboard-devel \
 "
RDEPENDS:qt6-qtvirtualkeyboard-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtvirtualkeyboard \
 "
