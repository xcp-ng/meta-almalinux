# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-chzyer-readline"
PV = "1.5.1"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-chzyer-readline-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-chzyer-readline-1.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ca842aba6a1c695aba4bda01009b72514577f15b6011c91e7d1700253b7a4ce"

URI_x86_64_v2_golang-github-chzyer-readline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-chzyer-readline-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-chzyer-readline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-chzyer-readline-devel}"
SRC_URI[x86_64_v2_golang-github-chzyer-readline-devel.sha256sum] = "7d2b8d88a25753fddc26ebaf771eb7b29b3adcbc04bd5123a6091af601a2647b"

URI_aarch64_golang-github-chzyer-readline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-chzyer-readline-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_golang-github-chzyer-readline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-chzyer-readline-devel}"
SRC_URI[aarch64_golang-github-chzyer-readline-devel.sha256sum] = "a5736fd14eb97e428edd340dd338c97b2ca2d3703bcea1baf759d011f2ad82b9"

RDEPENDS:golang-github-chzyer-readline-devel = " \
 go-filesystem \
 "
