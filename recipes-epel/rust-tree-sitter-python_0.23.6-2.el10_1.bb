# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-python"
PV = "0.23.6"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree-sitter-python+default-devel \
 rust-tree-sitter-python-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-python-0.23.6-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19cfcfaf711f2c21f1dfb996c0679affa24afd15289f2c9413120874bb820ae1"

URI_x86_64_v2_rust-tree-sitter-python+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-python+default-devel-0.23.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-python+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-python+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-python+default-devel.sha256sum] = "0a0e0310d8ef9c29b261742b7d628b4ecf7f2334b523de83f5fd30574883857b"

URI_x86_64_v2_rust-tree-sitter-python-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-python-devel-0.23.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-python-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-python-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-python-devel.sha256sum] = "bb27f124b1b8b0eb5ca7ccb22bed29d060ba251af95f8802adfdf8d31d57ab3d"

URI_aarch64_rust-tree-sitter-python+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-python+default-devel-0.23.6-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-python+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-python+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-python+default-devel.sha256sum] = "5702fe32c3b2ad8425f284d54bfc20aaaf9e5391900a0773da37ef141d32e690"

URI_aarch64_rust-tree-sitter-python-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-python-devel-0.23.6-2.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-python-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-python-devel}"
SRC_URI[aarch64_rust-tree-sitter-python-devel.sha256sum] = "3f0c3eebfd731583e2567b2e2033c63c045a8e1ff7c65a233c5a2ad6998d8110"

RDEPENDS:rust-tree-sitter-python+default-devel = " \
 cargo \
 rust-tree-sitter-python-devel \
 "
RDEPENDS:rust-tree-sitter-python-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
