# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mock_instant"
PV = "0.5.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-mock_instant+default-devel \
 rust-mock_instant-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mock_instant-0.5.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "407f8c8f0f1dd3fe676c2bc0b8c82c71432529b3655de3ec06f4aea9d86b182c"

URI_x86_64_v2_rust-mock_instant+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant+default-devel-0.5.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant+default-devel}"
SRC_URI[x86_64_v2_rust-mock_instant+default-devel.sha256sum] = "4e69ac713d5010b7967c7afeb2c65a434503888bcdd38805100466737423f948"

URI_x86_64_v2_rust-mock_instant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mock_instant-devel-0.5.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mock_instant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mock_instant-devel}"
SRC_URI[x86_64_v2_rust-mock_instant-devel.sha256sum] = "e03af48f6d44db776b467d2acd2d1b30e8c146f5d367ae68c0020a3978f92896"

URI_aarch64_rust-mock_instant+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant+default-devel-0.5.3-1.el10_1.noarch.rpm;name=aarch64_rust-mock_instant+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant+default-devel}"
SRC_URI[aarch64_rust-mock_instant+default-devel.sha256sum] = "6a6e6846435e85cc33b2f7c02a21c7d0fd5ad2252472e368704cd0d42ab295c5"

URI_aarch64_rust-mock_instant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mock_instant-devel-0.5.3-1.el10_1.noarch.rpm;name=aarch64_rust-mock_instant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mock_instant-devel}"
SRC_URI[aarch64_rust-mock_instant-devel.sha256sum] = "9ad207a6ea53cd65f95659ef573a8162b0bf6bf7b561d55919cc3ce937b09cc5"

RDEPENDS:rust-mock_instant+default-devel = " \
 cargo \
 rust-mock_instant-devel \
 "
RDEPENDS:rust-mock_instant-devel = " \
 cargo \
 "
