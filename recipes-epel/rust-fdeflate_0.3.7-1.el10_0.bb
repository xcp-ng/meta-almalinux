# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fdeflate"
PV = "0.3.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-fdeflate+default-devel \
 rust-fdeflate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fdeflate-0.3.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c43b6aa38f8da25b6eb6f6bcac0f11d940c89d8dff0e6d6650e7b8c3b62d8d31"

URI_x86_64_v2_rust-fdeflate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fdeflate+default-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fdeflate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fdeflate+default-devel}"
SRC_URI[x86_64_v2_rust-fdeflate+default-devel.sha256sum] = "ee88dc2a731312652c67da70c34f20746becc322ba9eed74391932ab10cb4450"

URI_x86_64_v2_rust-fdeflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fdeflate-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fdeflate-devel}"
SRC_URI[x86_64_v2_rust-fdeflate-devel.sha256sum] = "d8159fabd646b9ead51837013e6f9a1dcafb031d8a4e13b4d3534945817a4073"

URI_aarch64_rust-fdeflate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fdeflate+default-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-fdeflate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fdeflate+default-devel}"
SRC_URI[aarch64_rust-fdeflate+default-devel.sha256sum] = "cf5f871ede4d1d061ca91ec038cd6b12ce65d8547f96c4b1424c6d87823d4fe4"

URI_aarch64_rust-fdeflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fdeflate-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-fdeflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fdeflate-devel}"
SRC_URI[aarch64_rust-fdeflate-devel.sha256sum] = "98fbf3de1211a2dbb87de0895b866f5d48177e7b5b9edbb01aabf40b503fb3a1"

RDEPENDS:rust-fdeflate+default-devel = " \
 cargo \
 rust-fdeflate-devel \
 "
RDEPENDS:rust-fdeflate-devel = " \
 cargo \
 rust \
 rust-simd-adler32+default-devel \
 "
