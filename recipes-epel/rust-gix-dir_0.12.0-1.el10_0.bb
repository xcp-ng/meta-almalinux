# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-dir"
PV = "0.12.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-dir+default-devel \
 rust-gix-dir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-dir-0.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b43d730ba9b7e6f602928638e5530d4b84e914d7afbaf054a3ebc32fe5534d94"

URI_x86_64_v2_rust-gix-dir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir+default-devel-0.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir+default-devel}"
SRC_URI[x86_64_v2_rust-gix-dir+default-devel.sha256sum] = "60412c46478cd41ea16c7a336d91e8aca8007495153000604b7f1bbf45afddde"

URI_x86_64_v2_rust-gix-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir-devel-0.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir-devel}"
SRC_URI[x86_64_v2_rust-gix-dir-devel.sha256sum] = "28ae56e3da66d1399ae86890acd2a2c340b08ae2b932785271467b9ccf3ba633"

URI_aarch64_rust-gix-dir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir+default-devel-0.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir+default-devel}"
SRC_URI[aarch64_rust-gix-dir+default-devel.sha256sum] = "c8eae68b957692864fd491dbcd593e57ed562fdad5b6f4b948c0402bdb05ae5f"

URI_aarch64_rust-gix-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir-devel-0.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir-devel}"
SRC_URI[aarch64_rust-gix-dir-devel.sha256sum] = "7d712571c398b613d15c6541b3c462f172d28f1595357d2bdbf3d5246327d686"

RDEPENDS:rust-gix-dir+default-devel = " \
 cargo \
 rust-gix-dir-devel \
 "
RDEPENDS:rust-gix-dir-devel = " \
 bash \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-discover+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-ignore+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-utils+bstr-devel \
 rust-gix-utils+default-devel \
 rust-gix-worktree-devel \
 rust-thiserror+default-devel \
 "
