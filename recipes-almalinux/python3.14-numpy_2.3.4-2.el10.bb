# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-numpy"
PV = "2.3.4"
PR = "2.el10"
PACKAGES = " \
 python3.14-numpy \
 python3.14-numpy-f2py \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-numpy-2.3.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4e8a520bb8a642c5bfb541c92546b399ef7873b4a4234d39115dfcd8301db8b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-numpy-2.3.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-numpy;unpack=0"
SRC_URI[x86_64_v2_python3.14-numpy.sha256sum] = "620b4c9fbc9679964f63b28560d74b6bd04ead0675d411bf227b6193e752d0b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-numpy-f2py-2.3.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-numpy-f2py;unpack=0"
SRC_URI[x86_64_v2_python3.14-numpy-f2py.sha256sum] = "0faddccb8f78899dfa16974ead69428c5218376f2818264a9364a696e6732809"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-numpy-2.3.4-2.el10.aarch64.rpm;name=aarch64_python3.14-numpy;unpack=0"
SRC_URI[aarch64_python3.14-numpy.sha256sum] = "f36ad1b3dd1d210c23e71dc2e9979aa040397cdfdcc9f0008d19ea0049b44d76"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-numpy-f2py-2.3.4-2.el10.aarch64.rpm;name=aarch64_python3.14-numpy-f2py;unpack=0"
SRC_URI[aarch64_python3.14-numpy-f2py.sha256sum] = "73fb46d0deef65e9c1c0b03e156fc809ef567a8850a7738bb68cea69ee5df1bc"

RDEPENDS:python3.14-numpy = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3.14 \
 python3.14-numpy-f2py \
 "
RDEPENDS:python3.14-numpy-f2py = " \
 python3.14 \
 python3.14-devel \
 python3.14-numpy \
 "
