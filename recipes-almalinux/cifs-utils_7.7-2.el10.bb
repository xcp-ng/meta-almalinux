# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cifs-utils"
PV = "7.7"
PR = "2.el10"
PACKAGES = " \
 cifs-utils \
 cifs-utils-devel \
 pam_cifscreds \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cifs-utils-7.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "78337e983071195762c93794de94ac4876f3b0b24d51a1d920aefaaeaf0398c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cifs-utils-7.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_cifs-utils;unpack=0"
SRC_URI[x86_64_v2_cifs-utils.sha256sum] = "bb235c642eaa09a79162339a98522a17ccefc30fba0c4e89f4f9044a70db2135"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cifs-utils-devel-7.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_cifs-utils-devel;unpack=0"
SRC_URI[x86_64_v2_cifs-utils-devel.sha256sum] = "267b151f756d6c9b830c9367e4c0678d5537bc495fd271406c2dc6a80c1ae543"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam_cifscreds-7.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_pam_cifscreds;unpack=0"
SRC_URI[x86_64_v2_pam_cifscreds.sha256sum] = "965cf60ce1cbe288d0fa5f6e170d86ce742fb24976706bc9383ccc54b48f863e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cifs-utils-7.7-2.el10.aarch64.rpm;name=aarch64_cifs-utils;unpack=0"
SRC_URI[aarch64_cifs-utils.sha256sum] = "44cb2d6523dc1608fee2cd52851f4ec8aa42a9616cd6333831834b49ce96b9dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cifs-utils-devel-7.7-2.el10.aarch64.rpm;name=aarch64_cifs-utils-devel;unpack=0"
SRC_URI[aarch64_cifs-utils-devel.sha256sum] = "1c096c665a710dcc132bb3d267cc00af417bf8ab645d4be7c04f03d1b5a8c666"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam_cifscreds-7.7-2.el10.aarch64.rpm;name=aarch64_pam_cifscreds;unpack=0"
SRC_URI[aarch64_pam_cifscreds.sha256sum] = "8e424e277768b3e400114d0c7ed680ab1c3cc5b0ca2bbf44e971cd62e91e228a"

RDEPENDS:cifs-utils = " \
 alternatives \
 bash \
 glibc \
 keyutils \
 keyutils-libs \
 krb5-libs \
 libcap-ng \
 libtalloc \
 libwbclient \
 "
RDEPENDS:cifs-utils-devel = " \
 "
RDEPENDS:pam_cifscreds = " \
 glibc \
 keyutils-libs \
 libtalloc \
 pam-libs \
 "
