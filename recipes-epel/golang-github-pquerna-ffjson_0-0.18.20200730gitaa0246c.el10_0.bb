# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pquerna-ffjson"
PV = "0"
PR = "0.18.20200730gitaa0246c.el10_0"
PACKAGES = " \
 golang-github-pquerna-ffjson \
 golang-github-pquerna-ffjson-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pquerna-ffjson-0-0.18.20200730gitaa0246c.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd7443f29dd2db6057287ff16c639f1e317a058e8dfaecbb79517c04beeccd7e"

URI_aarch64_golang-github-pquerna-ffjson = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pquerna-ffjson-0-0.18.20200730gitaa0246c.el10_0.aarch64.rpm;name=aarch64_golang-github-pquerna-ffjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pquerna-ffjson}"
SRC_URI[aarch64_golang-github-pquerna-ffjson.sha256sum] = "67ef980ee83d84936cbedeea8bc4026b0cbfce51c4613eb84b7e5edf0f47db44"

URI_aarch64_golang-github-pquerna-ffjson-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pquerna-ffjson-devel-0-0.18.20200730gitaa0246c.el10_0.noarch.rpm;name=aarch64_golang-github-pquerna-ffjson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pquerna-ffjson-devel}"
SRC_URI[aarch64_golang-github-pquerna-ffjson-devel.sha256sum] = "c5b442efb4255cd68a9d09c552c437e793dc7fd395e408b5b6f33fb2c28018b9"

RDEPENDS:golang-github-pquerna-ffjson = " \
 glibc \
 "
RDEPENDS:golang-github-pquerna-ffjson-devel = " \
 go-filesystem \
 "
