# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfabric"
PV = "2.3.1"
PR = "1.el10"
PACKAGES = " \
 libfabric \
 libfabric-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libfabric-2.3.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d47e153846828544ae19213fd9549d84b55ba24a3c3f7fa05698e8ffc7e0d03a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libfabric-2.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libfabric;unpack=0"
SRC_URI[x86_64_v2_libfabric.sha256sum] = "2309c5abda9db62fa9acabcab77ffc2230ff37dbbb4ad211547790e3c9fbc4a4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfabric-devel-2.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libfabric-devel;unpack=0"
SRC_URI[x86_64_v2_libfabric-devel.sha256sum] = "398d0ad876525833974e1f7ae8995a42a4e8372019adb456991ffbf2d6d07f86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libfabric-2.3.1-1.el10.aarch64.rpm;name=aarch64_libfabric;unpack=0"
SRC_URI[aarch64_libfabric.sha256sum] = "35177b31d371a8327d6cc16589bd101df1ce28afe1e7a3c5fc6a8ae1f70956c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfabric-devel-2.3.1-1.el10.aarch64.rpm;name=aarch64_libfabric-devel;unpack=0"
SRC_URI[aarch64_libfabric-devel.sha256sum] = "49b45d78317d63d403b9d50441668a17122af615906f66ddbde1b4b0d28dac9d"

RDEPENDS:libfabric:x86_64_v2 = " \
 glibc \
 libibverbs \
 libnl3 \
 librdmacm \
"
RDEPENDS:libfabric:aarch64 = " \
 glibc \
 libatomic \
 libibverbs \
 libnl3 \
 librdmacm \
"
RDEPENDS:libfabric-devel = " \
 libfabric \
 pkgconf-pkg-config \
 "
