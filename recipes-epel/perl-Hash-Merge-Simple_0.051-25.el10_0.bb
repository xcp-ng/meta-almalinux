# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Hash-Merge-Simple"
PV = "0.051"
PR = "25.el10_0"
PACKAGES = " \
 perl-Hash-Merge-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Hash-Merge-Simple-0.051-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a01bbd3e4bb6a4f44f28fd8fa2f79ff37f4ba6864ca3a841155a13c3929ddbdd"

URI_x86_64_v2_perl-Hash-Merge-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Hash-Merge-Simple-0.051-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Hash-Merge-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Hash-Merge-Simple}"
SRC_URI[x86_64_v2_perl-Hash-Merge-Simple.sha256sum] = "510e6c99b1fb2066646e32929b36e5565472e8f1097cebcb3ae3eb9e2b81468c"

URI_aarch64_perl-Hash-Merge-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Hash-Merge-Simple-0.051-25.el10_0.noarch.rpm;name=aarch64_perl-Hash-Merge-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Hash-Merge-Simple}"
SRC_URI[aarch64_perl-Hash-Merge-Simple.sha256sum] = "1232cdf80cb39abee7d85faaf9cf1cc6505a45ccb69e9dfe00a5cada8500ba39"

RDEPENDS:perl-Hash-Merge-Simple = " \
 perl-Clone \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
