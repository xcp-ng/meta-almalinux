# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cswrap"
PV = "2.2.6"
PR = "1.el10_3"
PACKAGES = " \
 csexec \
 cswrap \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cswrap-2.2.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c8ff5d1a684446da63e78a54678fce75d5625065ab2bd42f17039a59469bd2eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/csexec-2.2.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_csexec;unpack=0"
SRC_URI[x86_64_v2_csexec.sha256sum] = "334002018bae60415597f30b432e698dcab2e1f1f7fcf4fcfd092f80adc46442"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cswrap-2.2.6-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cswrap;unpack=0"
SRC_URI[x86_64_v2_cswrap.sha256sum] = "03aed017a45a16ad428b5add09a388138aa45a758effdbf9e59c5e32f4c2038c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/csexec-2.2.6-1.el10_3.aarch64.rpm;name=aarch64_csexec;unpack=0"
SRC_URI[aarch64_csexec.sha256sum] = "55819c3c26696e4995fc0e98ab3109fcbf85eb1ca27b464333248ce20dfbe325"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cswrap-2.2.6-1.el10_3.aarch64.rpm;name=aarch64_cswrap;unpack=0"
SRC_URI[aarch64_cswrap.sha256sum] = "d346bad69553ab9137e0027cd54314e3795bdd6d8f2c3e58aca251a9cf5ced9a"

RDEPENDS:csexec = " \
 glibc \
 "
RDEPENDS:cswrap = " \
 glibc \
 "
