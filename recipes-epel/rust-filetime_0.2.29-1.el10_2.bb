# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-filetime"
PV = "0.2.29"
PR = "1.el10_2"
PACKAGES = " \
 rust-filetime+default-devel \
 rust-filetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-filetime-0.2.29-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c4b1702dca746c4b4e86d097c2a4164f801c389fcc862b7050b4311da93412a"

URI_x86_64_v2_rust-filetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filetime+default-devel-0.2.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filetime+default-devel}"
SRC_URI[x86_64_v2_rust-filetime+default-devel.sha256sum] = "7891965bc9103fb9a6146b07580186f5d2d17ae503a9f11a6b7d716154cfad65"

URI_x86_64_v2_rust-filetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-filetime-devel-0.2.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-filetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-filetime-devel}"
SRC_URI[x86_64_v2_rust-filetime-devel.sha256sum] = "abcd0d1e15ca2234276d1b6dab0353d2a86f88f432374f2b6ff4ed77f0b9dc6d"

URI_aarch64_rust-filetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filetime+default-devel-0.2.29-1.el10_2.noarch.rpm;name=aarch64_rust-filetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filetime+default-devel}"
SRC_URI[aarch64_rust-filetime+default-devel.sha256sum] = "d0a49dc8320ed515e440d7a5340edd90962565e4b1b2c9f410aa0c0211abbcf7"

URI_aarch64_rust-filetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-filetime-devel-0.2.29-1.el10_2.noarch.rpm;name=aarch64_rust-filetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-filetime-devel}"
SRC_URI[aarch64_rust-filetime-devel.sha256sum] = "0e3162e8e1b05822381bb52d718d79b17c2315508845dcdf7794d76b664adb7b"

RDEPENDS:rust-filetime+default-devel = " \
 cargo \
 rust-filetime-devel \
 "
RDEPENDS:rust-filetime-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 "
