# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kauth"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kauth \
 kf6-kauth-devel \
 kf6-kauth-doc \
 kf6-kauth-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kauth-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b70bc5120fe4ad022da0c3cc1507088f30389db6a50ec0ed8a8d1ca06b017e12"

URI_x86_64_v2_kf6-kauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth}"
SRC_URI[x86_64_v2_kf6-kauth.sha256sum] = "06b5cd5674c93099d9c48457e13d1e9d90efea9e0b909237f859d381666cc5fa"

URI_x86_64_v2_kf6-kauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-devel}"
SRC_URI[x86_64_v2_kf6-kauth-devel.sha256sum] = "7c0cabae813a2a864dd48e29605d4092e5ccc5ef37bdfa0b48ebb620e96c5bd0"

URI_x86_64_v2_kf6-kauth-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kauth-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-doc}"
SRC_URI[x86_64_v2_kf6-kauth-doc.sha256sum] = "69556fb4a28316b5ed37ab03ab6a89249f3b1156566253f2ac96063020383666"

URI_x86_64_v2_kf6-kauth-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kauth-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kauth-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kauth-html}"
SRC_URI[x86_64_v2_kf6-kauth-html.sha256sum] = "3ce414367f18c0ba39edb3cc827a1537432a1277404c8876ff1abf804c6e2094"

URI_aarch64_kf6-kauth = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth}"
SRC_URI[aarch64_kf6-kauth.sha256sum] = "0d6695135d0cc64f40293b07122736c214faa632c5a1790439f65a8fc684ad53"

URI_aarch64_kf6-kauth-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-devel}"
SRC_URI[aarch64_kf6-kauth-devel.sha256sum] = "d24bafeceb2d267aa0b8f8487fa512b2de5c8d50a9a6353a06b6a344abc55cfe"

URI_aarch64_kf6-kauth-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kauth-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-doc}"
SRC_URI[aarch64_kf6-kauth-doc.sha256sum] = "c540f578bd91a473878641ac08f9ec504437610ce133db7005ddd323c134507c"

URI_aarch64_kf6-kauth-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kauth-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kauth-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kauth-html}"
SRC_URI[aarch64_kf6-kauth-html.sha256sum] = "a619390d9ec9851a0363d3573d4185ca66191e4234e5c183b40b2bde0042341e"

RDEPENDS:kf6-kauth = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kwindowsystem \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kauth-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons-devel \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kauth-doc = " \
 "
RDEPENDS:kf6-kauth-html = " \
 "
