# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordered-stream"
PV = "0.2.0"
PR = "6.el10_2"
PACKAGES = " \
 rust-ordered-stream+default-devel \
 rust-ordered-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordered-stream-0.2.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2ddcd573d29d4ea6e248a25de9963b3c1f244844fd0f347acbec7160dc47c72"

URI_x86_64_v2_rust-ordered-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-stream+default-devel-0.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-stream+default-devel}"
SRC_URI[x86_64_v2_rust-ordered-stream+default-devel.sha256sum] = "14fb6505e7f1c8bf1d341080529c469816e1b101b6c3fdbca09f1333943dd757"

URI_x86_64_v2_rust-ordered-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-stream-devel-0.2.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-stream-devel}"
SRC_URI[x86_64_v2_rust-ordered-stream-devel.sha256sum] = "0d3ba33edf4b8e6e846d3df25600a082d29cb87fed62c3e865cc32e3dc1c699a"

URI_aarch64_rust-ordered-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-stream+default-devel-0.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-ordered-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-stream+default-devel}"
SRC_URI[aarch64_rust-ordered-stream+default-devel.sha256sum] = "2d1ca8aaf99377a2027757b2b967bf377b4b79be6267025a26a4d8c4eda1f9c4"

URI_aarch64_rust-ordered-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-stream-devel-0.2.0-6.el10_2.noarch.rpm;name=aarch64_rust-ordered-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-stream-devel}"
SRC_URI[aarch64_rust-ordered-stream-devel.sha256sum] = "1cba683f6c1227f92d03905231d6d0335adba62edbb802b21571ee877a182267"

RDEPENDS:rust-ordered-stream+default-devel = " \
 cargo \
 rust-ordered-stream-devel \
 "
RDEPENDS:rust-ordered-stream-devel = " \
 cargo \
 rust-futures-core+default-devel \
 rust-pin-project-lite+default-devel \
 "
