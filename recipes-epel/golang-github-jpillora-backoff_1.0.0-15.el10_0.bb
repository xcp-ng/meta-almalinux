# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-jpillora-backoff"
PV = "1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-jpillora-backoff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-jpillora-backoff-1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a03d99eaa89dc015803287de1a4ace6af5cd5b4bed241a8deef0a414e33e764"

URI_x86_64_v2_golang-github-jpillora-backoff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-jpillora-backoff-devel-1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-jpillora-backoff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-jpillora-backoff-devel}"
SRC_URI[x86_64_v2_golang-github-jpillora-backoff-devel.sha256sum] = "836a1ad552e6af07534c2db06377b7718fa0f0164e509278f8509ee32108a385"

URI_aarch64_golang-github-jpillora-backoff-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-jpillora-backoff-devel-1.0.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-jpillora-backoff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-jpillora-backoff-devel}"
SRC_URI[aarch64_golang-github-jpillora-backoff-devel.sha256sum] = "0c50bcb1cf01f4af3b9c4007915dbc4b09ae629bc355c5ce7dcb14203f40171e"

RDEPENDS:golang-github-jpillora-backoff-devel = " \
 go-filesystem \
 "
