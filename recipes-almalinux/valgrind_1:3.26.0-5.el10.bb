# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valgrind"
PE = "1"
PV = "3.26.0"
PR = "5.el10"
PACKAGES = " \
 valgrind \
 valgrind-devel \
 valgrind-docs \
 valgrind-gdb \
 valgrind-scripts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valgrind-3.26.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b63cca38793ad8f8341012b2d8b976df4779e86ebc831ac9406e7b5af5c4f27"

URI_x86_64_v2_valgrind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-3.26.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind}"
SRC_URI[x86_64_v2_valgrind.sha256sum] = "3f85fdb2146a2b334fde4f111d798d8ba5454eb59947c57d5e720a4ec62329f1"

URI_x86_64_v2_valgrind-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-devel-3.26.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-devel}"
SRC_URI[x86_64_v2_valgrind-devel.sha256sum] = "dc2d7e149a870790c243f8fd02c82933b2c55da34b2d5877b83f9f1884756e78"

URI_x86_64_v2_valgrind-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-docs-3.26.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-docs}"
SRC_URI[x86_64_v2_valgrind-docs.sha256sum] = "277c3dd6e15c35e728a38f1eb852b995ac5f2ba700f960cf849b0a5be538fe05"

URI_x86_64_v2_valgrind-gdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-gdb-3.26.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-gdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-gdb}"
SRC_URI[x86_64_v2_valgrind-gdb.sha256sum] = "5d3b69f1cc2688045dd6db1233f5abcbf211d21369af1187ee615c2a199c0830"

URI_x86_64_v2_valgrind-scripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valgrind-scripts-3.26.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_valgrind-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_valgrind-scripts}"
SRC_URI[x86_64_v2_valgrind-scripts.sha256sum] = "148451cf47988510684495711f58f978cb1a361335f2e1678502e01fb2f86c0d"

URI_aarch64_valgrind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-3.26.0-5.el10.aarch64.rpm;name=aarch64_valgrind;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind}"
SRC_URI[aarch64_valgrind.sha256sum] = "f358f1a61caaa46805fe8e4880a8b32cafff216b068a35e9163251a1b8f1b7f2"

URI_aarch64_valgrind-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-devel-3.26.0-5.el10.aarch64.rpm;name=aarch64_valgrind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-devel}"
SRC_URI[aarch64_valgrind-devel.sha256sum] = "97bc245efc051f738e92967f0f75503833509d4157ff9b07a66687e26f41c2cf"

URI_aarch64_valgrind-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-docs-3.26.0-5.el10.aarch64.rpm;name=aarch64_valgrind-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-docs}"
SRC_URI[aarch64_valgrind-docs.sha256sum] = "1c4971c460676b02c3796b1567ad0bab0f021bd19e481c26227f32bf93d56607"

URI_aarch64_valgrind-gdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-gdb-3.26.0-5.el10.aarch64.rpm;name=aarch64_valgrind-gdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-gdb}"
SRC_URI[aarch64_valgrind-gdb.sha256sum] = "326a127c05bc97c17e2ed8f51f70caec3107878e0d45e0e8e95cdfead531527b"

URI_aarch64_valgrind-scripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valgrind-scripts-3.26.0-5.el10.aarch64.rpm;name=aarch64_valgrind-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_valgrind-scripts}"
SRC_URI[aarch64_valgrind-scripts.sha256sum] = "3f04b32934ded2b1840a6c883dfd7ccfeb8289c25dac2e8db5a7cd42eff85ba6"

RDEPENDS:valgrind = " \
 glibc \
 "
RDEPENDS:valgrind-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:valgrind-docs = " \
 "
RDEPENDS:valgrind-gdb = " \
 bash \
 glibc \
 libgcc \
 valgrind \
 "
RDEPENDS:valgrind-scripts = " \
 perl-interpreter \
 python3 \
 "
