# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portable-atomic-util"
PV = "0.2.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 rust-portable-atomic-util+serde-devel \
 rust-portable-atomic-util+std-devel \
 rust-portable-atomic-util-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-portable-atomic-util-0.2.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1de40e0aa79eef603fc91ef349736c1efec2c565ec95646ddd7b2f6811215488"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+alloc-devel-0.2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util+alloc-devel.sha256sum] = "2635b0fc6e0ecf59a33bbba1fcfa03f73e24bedb0aaada9d7e468182dfab4e35"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+default-devel-0.2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util+default-devel.sha256sum] = "a7ccfc42da1f5b7bc0b8e04526e86b8d472bf9e8a4c2b7bd7ea781bad090f066"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+serde-devel-0.2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util+serde-devel.sha256sum] = "85bf511a678ef7a879b570a9f99d0f08c0f64434d34ac2a73106d821c3639d5e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+std-devel-0.2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util+std-devel.sha256sum] = "5d160a904a393ddf6a2a473c8de21f22077cc21d5af110ab6efa118f77d8c299"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util-devel-0.2.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util-devel.sha256sum] = "060f69cb06ca78edabb3436c69e4d8061c0677b88f5e46d2548bb6e784a6ca3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+alloc-devel-0.2.8-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util+alloc-devel.sha256sum] = "58fd87ab3366decfcaaee901350c5697cd6d194ce498cf842ce8a8960e20cf71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+default-devel-0.2.8-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util+default-devel.sha256sum] = "290e14429c603305339a6b617c8bae88f57d38a8cb82662167052a25aafd14dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+serde-devel-0.2.8-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util+serde-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util+serde-devel.sha256sum] = "11748356534d14ad4fbfa8abf1353492679eecb314fff9189b4836d6be7662a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+std-devel-0.2.8-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util+std-devel.sha256sum] = "49794c3b969d42211d73d82d0aa5f20ee7300020acb6ef13a8efbc115a018c7e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util-devel-0.2.8-1.el10_2.noarch.rpm;name=aarch64_rust-portable-atomic-util-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util-devel.sha256sum] = "e978c01b70c14cd108aed29fb671b1c9b5306083379d55f48b67080c0597618a"

RDEPENDS:rust-portable-atomic-util+alloc-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+default-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+serde-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-portable-atomic-util+std-devel = " \
 cargo \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util-devel = " \
 cargo \
 rust \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
