# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "givaro"
PV = "4.2.1"
PR = "1.el10_0"
PACKAGES = " \
 givaro \
 givaro-devel \
 givaro-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/givaro-4.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a4b1ea5ad83daa60267b969422133c16ee98ccc4606ec4d1332c1e55b1431e3"

URI_x86_64_v2_givaro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/givaro-4.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_givaro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_givaro}"
SRC_URI[x86_64_v2_givaro.sha256sum] = "c89ee501c2dc79a6aa161bb87083a8021760ebaa378582deeae1e6d3387c9413"

URI_x86_64_v2_givaro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/givaro-devel-4.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_givaro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_givaro-devel}"
SRC_URI[x86_64_v2_givaro-devel.sha256sum] = "3ad4998512d2e2a1d6e9137a1ea801c03091c0b1f43396b135abcb0795bdcdd6"

URI_x86_64_v2_givaro-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/givaro-static-4.2.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_givaro-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_givaro-static}"
SRC_URI[x86_64_v2_givaro-static.sha256sum] = "8c5f837b83127e667ec1e9c33a886fc3c574c777ada74e280671c70699ddf88c"

URI_aarch64_givaro = "${EPEL_MIRROR}/aarch64/Packages/g/givaro-4.2.1-1.el10_0.aarch64.rpm;name=aarch64_givaro;unpack=0"
SRC_URI:append = " ${URI_aarch64_givaro}"
SRC_URI[aarch64_givaro.sha256sum] = "32b52ff1b2cd16c9ca7d5bad07750613f76c311094a4b09014f08320b26ccfb1"

URI_aarch64_givaro-devel = "${EPEL_MIRROR}/aarch64/Packages/g/givaro-devel-4.2.1-1.el10_0.aarch64.rpm;name=aarch64_givaro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_givaro-devel}"
SRC_URI[aarch64_givaro-devel.sha256sum] = "f1e7b0e77d05c354f4392f0a1ab1b18eff31aee6d49ff3f42f7a79cad1aad12e"

URI_aarch64_givaro-static = "${EPEL_MIRROR}/aarch64/Packages/g/givaro-static-4.2.1-1.el10_0.aarch64.rpm;name=aarch64_givaro-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_givaro-static}"
SRC_URI[aarch64_givaro-static.sha256sum] = "db687c50d3ec2d784d83fa3f6ec24f29b9b2bec2be1fec0eef1e6836bbf816d1"

RDEPENDS:givaro = " \
 glibc \
 gmp \
 gmp-c++ \
 libgcc \
 libstdc++ \
 "
RDEPENDS:givaro-devel = " \
 bash \
 givaro \
 pkgconf-pkg-config \
 "
RDEPENDS:givaro-static = " \
 givaro-devel \
 "
