# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcpreplay"
PV = "4.6.1"
PR = "1.el10_3"
PACKAGES = " \
 tcpreplay \
 tcpreplay-devel \
 tcpreplay-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tcpreplay-4.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fc8916eb25c90c33323718226d938f51a8720a7a325d4a15f43b3a4e36159706"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcpreplay-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcpreplay;unpack=0"
SRC_URI[x86_64_v2_tcpreplay.sha256sum] = "1cb775787408504d049d018956fa5104caf760511788d0d04c3ba199d13e0861"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcpreplay-devel-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcpreplay-devel;unpack=0"
SRC_URI[x86_64_v2_tcpreplay-devel.sha256sum] = "5d4e2c33676d2fc11e03111cc51cbf655c639d77f433fbf20fc41640f323a2c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcpreplay-static-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcpreplay-static;unpack=0"
SRC_URI[x86_64_v2_tcpreplay-static.sha256sum] = "ef0a2abfcc9b3437187ef670ad26a8e2d9fb6da3518e40e50920304d43de4b18"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tcpreplay-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_tcpreplay;unpack=0"
SRC_URI[aarch64_tcpreplay.sha256sum] = "400d5f5ca669f44252332db16bfe816d713e1844974e3ab0153e51229fd1d245"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tcpreplay-devel-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_tcpreplay-devel;unpack=0"
SRC_URI[aarch64_tcpreplay-devel.sha256sum] = "2020972bc5f44b5b488644dbcfdb0cddf91ddd0f438436567157c52db5093240"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tcpreplay-static-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_tcpreplay-static;unpack=0"
SRC_URI[aarch64_tcpreplay-static.sha256sum] = "e15104d7b8ddc3959f4b28dacd55c0c07461fb4b23b11c8d593bb93f1f460281"

RDEPENDS:tcpreplay = " \
 glibc \
 libpcap \
 tcpdump \
 "
RDEPENDS:tcpreplay-devel = " \
 pkgconf-pkg-config \
 tcpreplay \
 "
RDEPENDS:tcpreplay-static = " \
 tcpreplay-devel \
 "
