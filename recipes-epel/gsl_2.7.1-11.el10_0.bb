# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsl"
PV = "2.7.1"
PR = "11.el10_0"
PACKAGES = " \
 gsl \
 gsl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gsl-2.7.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "98465032d4dd90c47af211ab9805710a9b891add83e5b5d5a911660593af77dd"

URI_x86_64_v2_gsl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsl-2.7.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsl}"
SRC_URI[x86_64_v2_gsl.sha256sum] = "99a297e155fd21ccd93fac4902d102949ec8afa4566a2c1b181bc7ea534062c2"

URI_x86_64_v2_gsl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsl-devel-2.7.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsl-devel}"
SRC_URI[x86_64_v2_gsl-devel.sha256sum] = "61bdfeda8050f409f116bd97027cbf957f6a3b2ef69bff74f2ccb4218a641eb4"

URI_aarch64_gsl = "${EPEL_MIRROR}/aarch64/Packages/g/gsl-2.7.1-11.el10_0.aarch64.rpm;name=aarch64_gsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsl}"
SRC_URI[aarch64_gsl.sha256sum] = "92a3cb1b43017f8317c570cd0dc1e0faf2343b8b183fda1376e1baea1a9ae9b8"

URI_aarch64_gsl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gsl-devel-2.7.1-11.el10_0.aarch64.rpm;name=aarch64_gsl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsl-devel}"
SRC_URI[aarch64_gsl-devel.sha256sum] = "265a78ecce48f2978eb453c4405af00dd0e1cce3ee3d62ed1e465903e66566f3"

RDEPENDS:gsl = " \
 glibc \
 "
RDEPENDS:gsl-devel = " \
 automake \
 bash \
 gsl \
 pkgconf-pkg-config \
 "
