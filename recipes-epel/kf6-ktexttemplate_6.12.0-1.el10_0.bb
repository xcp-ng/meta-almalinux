# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexttemplate"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-ktexttemplate \
 kf6-ktexttemplate-devel \
 kf6-ktexttemplate-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexttemplate-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "177228e163eff5ec64dc8e30807593eb5bc59e08d0281e4ac66496197798352a"

URI_x86_64_v2_kf6-ktexttemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate}"
SRC_URI[x86_64_v2_kf6-ktexttemplate.sha256sum] = "037b75cae1444894c138862803f7288de00051c19c869e263e36ce3f5a21d26e"

URI_x86_64_v2_kf6-ktexttemplate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-devel}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-devel.sha256sum] = "587456a71401773d6d56bab49d989a52f8c5e9bd65cd2e0fbbfda25d839e5d6a"

URI_x86_64_v2_kf6-ktexttemplate-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexttemplate-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-doc}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-doc.sha256sum] = "b1991d4158faa0f0eeea56e8da02964d4e8b25fcdcbc1016c66a5f13ecab0d12"

URI_aarch64_kf6-ktexttemplate = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ktexttemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate}"
SRC_URI[aarch64_kf6-ktexttemplate.sha256sum] = "386a83a321d7a87c16e9fd908a2d09dab4486a0daa1abbfab1628f99931efcff"

URI_aarch64_kf6-ktexttemplate-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ktexttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-devel}"
SRC_URI[aarch64_kf6-ktexttemplate-devel.sha256sum] = "dbc7a6abda4ad294c050614e0787ca0ffddadac6c47845e3b7e55291dbda2350"

URI_aarch64_kf6-ktexttemplate-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-ktexttemplate-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-doc}"
SRC_URI[aarch64_kf6-ktexttemplate-doc.sha256sum] = "1cfc93fdb6058cdc5d6d9db8226c4bd39dc736673b5a8212c5b01c792623c833"

RDEPENDS:kf6-ktexttemplate = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ktexttemplate-devel = " \
 cmake-filesystem \
 kf6-ktexttemplate \
 "
RDEPENDS:kf6-ktexttemplate-doc = " \
 "
