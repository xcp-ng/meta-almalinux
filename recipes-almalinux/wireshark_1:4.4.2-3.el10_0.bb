# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wireshark"
PE = "1"
PV = "4.4.2"
PR = "3.el10_0"
PACKAGES = " \
 wireshark \
 wireshark-cli \
 wireshark-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wireshark-4.4.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7db7d9281e2064843dcc3a725b93cf352466ff55dfdb0eebd65003ec0b31058"

URI_x86_64_v2_wireshark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireshark-4.4.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_wireshark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireshark}"
SRC_URI[x86_64_v2_wireshark.sha256sum] = "29dd4bc9374c41b59fae7d643668eb201518772b382bff4c31521d2ad45a937e"

URI_x86_64_v2_wireshark-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireshark-cli-4.4.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_wireshark-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireshark-cli}"
SRC_URI[x86_64_v2_wireshark-cli.sha256sum] = "8c8991726afee32f06230f68f6412c05a5985d220a7991a78cc537e3f97aea0a"

URI_x86_64_v2_wireshark-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/wireshark-devel-4.4.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_wireshark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireshark-devel}"
SRC_URI[x86_64_v2_wireshark-devel.sha256sum] = "e69b4a8568c7ca2d3121a8a85a776ab27a3bc12457806b03560db4d0cd0ff5eb"

URI_aarch64_wireshark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireshark-4.4.2-3.el10_0.aarch64.rpm;name=aarch64_wireshark;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireshark}"
SRC_URI[aarch64_wireshark.sha256sum] = "afa1d9b5c9e4546dd12bcec1fbafd16c65f9fa624570daf0fb1908926532179b"

URI_aarch64_wireshark-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireshark-cli-4.4.2-3.el10_0.aarch64.rpm;name=aarch64_wireshark-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireshark-cli}"
SRC_URI[aarch64_wireshark-cli.sha256sum] = "ffc074109f8d68a5921ab7648e3f4b732331cef56f02b3f2cd38ab401a2ee7c6"

URI_aarch64_wireshark-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/wireshark-devel-4.4.2-3.el10_0.aarch64.rpm;name=aarch64_wireshark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireshark-devel}"
SRC_URI[aarch64_wireshark-devel.sha256sum] = "f18cf738ceb748d71ba20c32cbbb25aa89794f9e6340f961d58b9bef038edaa1"

RDEPENDS:wireshark = " \
 glib2 \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libgcrypt \
 libnl3 \
 libpcap \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 speexdsp \
 wireshark-cli \
 xdg-utils \
 "
RDEPENDS:wireshark-cli = " \
 bash \
 c-ares \
 glib2 \
 glibc \
 gnutls \
 krb5-libs \
 libcap \
 libgcc \
 libgcrypt \
 libnghttp2 \
 libnl3 \
 libpcap \
 libsmi \
 libssh \
 libxml2 \
 libzstd \
 pcre2 \
 shadow-utils \
 speexdsp \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:wireshark-devel = " \
 glib2-devel \
 glibc-devel \
 pkgconf-pkg-config \
 wireshark \
 wireshark-cli \
 "
