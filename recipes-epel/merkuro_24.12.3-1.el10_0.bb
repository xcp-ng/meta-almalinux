# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "merkuro"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 merkuro \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/merkuro-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a034a4948a2f611c9a3dedffb16464e42dffccc2545b3eea38517f6577311c08"

URI_x86_64_v2_merkuro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/merkuro-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_merkuro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_merkuro}"
SRC_URI[x86_64_v2_merkuro.sha256sum] = "9a79427c0a833adf7cec9485db7b746a53830229cfd39df18cf53cbcd6a3cb6e"

URI_aarch64_merkuro = "${EPEL_MIRROR}/aarch64/Packages/m/merkuro-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_merkuro;unpack=0"
SRC_URI:append = " ${URI_aarch64_merkuro}"
SRC_URI[aarch64_merkuro.sha256sum] = "be1cfa9f96ca08c01b004af03526d72fc3c211f52b66c919345b9ba2103af4a5"

RDEPENDS:merkuro = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgmepp \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kidentitymanagement \
 kmailtransport \
 kmbox \
 kmime \
 libgcc \
 libkdepim \
 libkleo \
 libstdc++ \
 mailcommon \
 messagelib \
 mimetreeparser \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
