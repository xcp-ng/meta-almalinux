# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdesu"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kdesu \
 kf6-kdesu-devel \
 kf6-kdesu-doc \
 kf6-kdesu-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdesu-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e45d816272a443b63147f8538555413271a2d8c4d01a1e46682ed54a6671445"

URI_x86_64_v2_kf6-kdesu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu}"
SRC_URI[x86_64_v2_kf6-kdesu.sha256sum] = "8436734421748e03179f00722ad4eeb5318549afcd27edbcd103ab826daad593"

URI_x86_64_v2_kf6-kdesu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu-devel}"
SRC_URI[x86_64_v2_kf6-kdesu-devel.sha256sum] = "4c2df4d8cbea480edba0d3c0bd18b146f662b895b247847ce53f924b87e185e1"

URI_x86_64_v2_kf6-kdesu-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdesu-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu-doc}"
SRC_URI[x86_64_v2_kf6-kdesu-doc.sha256sum] = "df75bdcc8894aed4ac9cbc1d08491f394abd091904d2ebcab3f3feb1c790e4c1"

URI_x86_64_v2_kf6-kdesu-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdesu-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu-html}"
SRC_URI[x86_64_v2_kf6-kdesu-html.sha256sum] = "09d2de632a99634fd420c09c90ef230a5623ba5753277adc1bc184c4e919abb5"

URI_aarch64_kf6-kdesu = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdesu;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu}"
SRC_URI[aarch64_kf6-kdesu.sha256sum] = "7abaf98dd3abae1b9323ebf3b1e116ee967e35304df00d7036f40a46e0a6e94f"

URI_aarch64_kf6-kdesu-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kdesu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu-devel}"
SRC_URI[aarch64_kf6-kdesu-devel.sha256sum] = "ee869cc66803ad7c263475753f0161ed6f86ba4f2326578f71b74657f0194852"

URI_aarch64_kf6-kdesu-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdesu-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu-doc}"
SRC_URI[aarch64_kf6-kdesu-doc.sha256sum] = "4fcdc710e10a1e926848f7d1ec126a9d5607a891927d7352bae050c7681497e2"

URI_aarch64_kf6-kdesu-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kdesu-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu-html}"
SRC_URI[aarch64_kf6-kdesu-html.sha256sum] = "4d18f3a4c43f614ae69de0049bf8071ffbea80cdd7b83b17b13c03f987ccac47"

RDEPENDS:kf6-kdesu = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpty \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 sudo \
 "
RDEPENDS:kf6-kdesu-devel = " \
 cmake-filesystem \
 kf6-kdesu \
 kf6-kpty-devel \
 "
RDEPENDS:kf6-kdesu-doc = " \
 "
RDEPENDS:kf6-kdesu-html = " \
 "
