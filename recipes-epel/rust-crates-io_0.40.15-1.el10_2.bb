# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crates-io"
PV = "0.40.15"
PR = "1.el10_2"
PACKAGES = " \
 rust-crates-io+default-devel \
 rust-crates-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crates-io-0.40.15-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ecb3500eabba30ca747d9e0eb321bb2c129ecc8176813eafa746ce27043d6438"

URI_x86_64_v2_rust-crates-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io+default-devel-0.40.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crates-io+default-devel}"
SRC_URI[x86_64_v2_rust-crates-io+default-devel.sha256sum] = "169c273ad56298a09526398e1e3e8a82b1d71070535c1359603c8b3885644bce"

URI_x86_64_v2_rust-crates-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crates-io-devel-0.40.15-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crates-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crates-io-devel}"
SRC_URI[x86_64_v2_rust-crates-io-devel.sha256sum] = "2e1abbe237a48bb5a4a1f1f0f43c7b419748d72e48c52c027e7cbfeb31bd39cd"

URI_aarch64_rust-crates-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io+default-devel-0.40.15-1.el10_2.noarch.rpm;name=aarch64_rust-crates-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crates-io+default-devel}"
SRC_URI[aarch64_rust-crates-io+default-devel.sha256sum] = "e90a295799866bdfda739a29e24cc2c36f18da0b7e903cd4b7395468d3caaad2"

URI_aarch64_rust-crates-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crates-io-devel-0.40.15-1.el10_2.noarch.rpm;name=aarch64_rust-crates-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crates-io-devel}"
SRC_URI[aarch64_rust-crates-io-devel.sha256sum] = "ac8e5a885dca5858a6900c93b99f985ead83bc816b4674b95a69a6c972ae9cf9"

RDEPENDS:rust-crates-io+default-devel = " \
 cargo \
 rust-crates-io-devel \
 "
RDEPENDS:rust-crates-io-devel = " \
 cargo \
 rust \
 rust-curl+default-devel \
 rust-percent-encoding+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 rust-url+default-devel \
 "
