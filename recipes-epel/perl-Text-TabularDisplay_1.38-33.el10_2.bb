# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-TabularDisplay"
PV = "1.38"
PR = "33.el10_2"
PACKAGES = " \
 perl-Text-TabularDisplay \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-TabularDisplay-1.38-33.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1f3bda52274eef5adb1df5a5fd541843ce71cb75ee29303bc8dda4a92125767"

URI_x86_64_v2_perl-Text-TabularDisplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-TabularDisplay-1.38-33.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-TabularDisplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-TabularDisplay}"
SRC_URI[x86_64_v2_perl-Text-TabularDisplay.sha256sum] = "fb3ab08821c954f2d6eb25a450537ff9da136d7a7839038df270ffb355046c05"

URI_aarch64_perl-Text-TabularDisplay = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-TabularDisplay-1.38-33.el10_2.noarch.rpm;name=aarch64_perl-Text-TabularDisplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-TabularDisplay}"
SRC_URI[aarch64_perl-Text-TabularDisplay.sha256sum] = "79709d8e0c1057c06c6e4b3432e56822e69640be2b2c1136d5c62b3243569dfb"

RDEPENDS:perl-Text-TabularDisplay = " \
 perl-libs \
 perl-vars \
 "
