# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-rw"
PV = "0.20050109"
PR = "34.el10"
PACKAGES = " \
 hunspell-rw \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-rw-0.20050109-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "782bf897f7ac5e0f556e6e72fd867d25bd1869076626de8768e2c5f520bf6f7e"

URI_x86_64_v2_hunspell-rw = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-rw-0.20050109-34.el10.noarch.rpm;name=x86_64_v2_hunspell-rw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-rw}"
SRC_URI[x86_64_v2_hunspell-rw.sha256sum] = "74de4c22a781662a99cb9f777bcc5faf5135f618da8f212955648ee96a40e314"

URI_aarch64_hunspell-rw = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-rw-0.20050109-34.el10.noarch.rpm;name=aarch64_hunspell-rw;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-rw}"
SRC_URI[aarch64_hunspell-rw.sha256sum] = "74de4c22a781662a99cb9f777bcc5faf5135f618da8f212955648ee96a40e314"

RDEPENDS:hunspell-rw = " \
 hunspell \
 "
