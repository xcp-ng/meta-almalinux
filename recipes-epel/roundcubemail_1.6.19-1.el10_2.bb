# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "roundcubemail"
PV = "1.6.19"
PR = "1.el10_2"
PACKAGES = " \
 roundcubemail \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/roundcubemail-1.6.19-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0f478f33f158ec650ec8f3062e31070820127a093405a9e46d33a78b655dedba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roundcubemail-1.6.19-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_roundcubemail;unpack=0"
SRC_URI[x86_64_v2_roundcubemail.sha256sum] = "f06391b15ead0502c05c119e2fd3afd78329af4d287d8031760be91f135e3143"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/roundcubemail-1.6.19-1.el10_2.noarch.rpm;name=aarch64_roundcubemail;unpack=0"
SRC_URI[aarch64_roundcubemail.sha256sum] = "4dc113dda5e1e02835b44f7af6f0ba6298583914cd5e645a981ec950260cb5b5"

RDEPENDS:roundcubemail = " \
 bash \
 httpd-filesystem \
 mailcap \
 nginx-filesystem \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-date \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-hash \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-posix \
 virtual/php-reflection \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-sockets \
 virtual/php-spl \
 virtual/php-tokenizer \
 virtual/php-zip \
 virtual/php_httpd_ \
 virtual/php_language__ge_7.3 \
 virtual/webserver \
 "
