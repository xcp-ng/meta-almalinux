# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-russross-blackfriday-2"
PV = "2.1.0"
PR = "13.el10_0"
PACKAGES = " \
 compat-golang-github-russross-blackfriday-2-devel \
 golang-gopkg-russross-blackfriday-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-russross-blackfriday-2-2.1.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6c75f19afa3c0c97f99aa52fd43a2b47a309b171f6e6de051ae989133c8d80c"

URI_x86_64_v2_compat-golang-github-russross-blackfriday-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-russross-blackfriday-2-devel-2.1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-russross-blackfriday-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-russross-blackfriday-2-devel}"
SRC_URI[x86_64_v2_compat-golang-github-russross-blackfriday-2-devel.sha256sum] = "ac77a1b50028dad4fe18a009482e2081f18ebf4012d8167ff51252ea07344a3c"

URI_x86_64_v2_golang-gopkg-russross-blackfriday-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-russross-blackfriday-2-devel-2.1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-russross-blackfriday-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-russross-blackfriday-2-devel}"
SRC_URI[x86_64_v2_golang-gopkg-russross-blackfriday-2-devel.sha256sum] = "eb71405f70f2a9e5a94e2691c81d9d4cd9ce8cb31e9b4684e92705c1d043fbcf"

URI_aarch64_compat-golang-github-russross-blackfriday-2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-russross-blackfriday-2-devel-2.1.0-13.el10_0.noarch.rpm;name=aarch64_compat-golang-github-russross-blackfriday-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-russross-blackfriday-2-devel}"
SRC_URI[aarch64_compat-golang-github-russross-blackfriday-2-devel.sha256sum] = "4c1745a2604c6d535203353fb3cc849a61849e72d449a283d6243354194b2415"

URI_aarch64_golang-gopkg-russross-blackfriday-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-russross-blackfriday-2-devel-2.1.0-13.el10_0.noarch.rpm;name=aarch64_golang-gopkg-russross-blackfriday-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-russross-blackfriday-2-devel}"
SRC_URI[aarch64_golang-gopkg-russross-blackfriday-2-devel.sha256sum] = "c0466fe5a1388453f7019756e0a5099fc95a6ba02007d2e04b7cf162b1f9931c"

RDEPENDS:compat-golang-github-russross-blackfriday-2-devel = " \
 go-filesystem \
 golang-gopkg-russross-blackfriday-2-devel \
 "
RDEPENDS:golang-gopkg-russross-blackfriday-2-devel = " \
 go-filesystem \
 "
