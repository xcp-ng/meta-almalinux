# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rpm-macros"
PV = "3.12"
PR = "11.el10"
PACKAGES = " \
 python-rpm-macros \
 python-srpm-macros \
 python3-rpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-rpm-macros-3.12-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fef0248ef61d1f120b156a6c3cc1910c120afb9e7a9d64d2f7be3008c97106f"

URI_x86_64_v2_python-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-rpm-macros-3.12-11.el10.noarch.rpm;name=x86_64_v2_python-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-rpm-macros}"
SRC_URI[x86_64_v2_python-rpm-macros.sha256sum] = "4de062ca2ee3a839429d82bd51bd95dec89ffb819bfdbe22abb4429285bf637e"

URI_x86_64_v2_python-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-srpm-macros-3.12-11.el10.noarch.rpm;name=x86_64_v2_python-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-srpm-macros}"
SRC_URI[x86_64_v2_python-srpm-macros.sha256sum] = "9407f3815a6838cb1cb4691d623bad32658714b15ee3d98a482741ed3dc51953"

URI_x86_64_v2_python3-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-rpm-macros-3.12-11.el10.noarch.rpm;name=x86_64_v2_python3-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpm-macros}"
SRC_URI[x86_64_v2_python3-rpm-macros.sha256sum] = "fd90ab20274bea3018f82bf2093f45e8ff8720b9bfc1e4a796a2fce80e7e0640"

URI_aarch64_python-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-rpm-macros-3.12-11.el10.noarch.rpm;name=aarch64_python-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-rpm-macros}"
SRC_URI[aarch64_python-rpm-macros.sha256sum] = "4de062ca2ee3a839429d82bd51bd95dec89ffb819bfdbe22abb4429285bf637e"

URI_aarch64_python-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-srpm-macros-3.12-11.el10.noarch.rpm;name=aarch64_python-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-srpm-macros}"
SRC_URI[aarch64_python-srpm-macros.sha256sum] = "9407f3815a6838cb1cb4691d623bad32658714b15ee3d98a482741ed3dc51953"

URI_aarch64_python3-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-rpm-macros-3.12-11.el10.noarch.rpm;name=aarch64_python3-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpm-macros}"
SRC_URI[aarch64_python3-rpm-macros.sha256sum] = "fd90ab20274bea3018f82bf2093f45e8ff8720b9bfc1e4a796a2fce80e7e0640"

RDEPENDS:python-rpm-macros = " \
 python-srpm-macros \
 "
RDEPENDS:python-srpm-macros = " \
 bash \
 redhat-rpm-config \
 "
RDEPENDS:python3-rpm-macros = " \
 python-rpm-macros \
 python-srpm-macros \
 "
