# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "binutils"
PV = "2.41"
PR = "65.el10.alma.1"
PACKAGES = " \
 binutils \
 binutils-devel \
 binutils-gold \
 binutils-gprofng \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/binutils-2.41-65.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80914bec019b912373036b1f5f048e38596287169c99440ba80544c7bb605f88"

URI_x86_64_v2_binutils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-2.41-65.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils}"
SRC_URI[x86_64_v2_binutils.sha256sum] = "a85554fc4795e8f6f94d93161942df581cf6ab42f668a65bedeb18377c3d0845"
RPROVIDES:binutils:x86_64_v2 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libgprofng.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_x86_64_v2_binutils-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/binutils-devel-2.41-65.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-devel}"
SRC_URI[x86_64_v2_binutils-devel.sha256sum] = "75d6f6b17dabd2583e7a64425914e723e47c6a2349ddd5b73e6a71d778b784b0"

URI_x86_64_v2_binutils-gold = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/binutils-gold-2.41-65.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-gold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-gold}"
SRC_URI[x86_64_v2_binutils-gold.sha256sum] = "89dba87d126aa3c0757ef4bd169b6764ef9bb52bf9c421baedb18851e6e77611"

URI_x86_64_v2_binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/binutils-gprofng-2.41-65.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_binutils-gprofng}"
SRC_URI[x86_64_v2_binutils-gprofng.sha256sum] = "282b0eed928fb8c89319859a1d989d07c6e59460941052c65cc68cb462a7a0e0"

URI_aarch64_binutils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-2.41-65.el10.alma.1.aarch64.rpm;name=aarch64_binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils}"
SRC_URI[aarch64_binutils.sha256sum] = "47e12a1721b2281c89f15f283107c6faaa87c072bdea5f899174cc00cfab4311"
RPROVIDES:binutils:aarch64 = "virtual/libctf.so.0_LIBCTF_1.0__64bit_ virtual/libctf.so.0_LIBCTF_1.1__64bit_ virtual/libctf.so.0_LIBCTF_1.2__64bit_ virtual/libctf.so.0___64bit_ virtual/libgprofng.so.0___64bit_ virtual/libsframe.so.1___64bit_"

URI_aarch64_binutils-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/binutils-devel-2.41-65.el10.alma.1.aarch64.rpm;name=aarch64_binutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-devel}"
SRC_URI[aarch64_binutils-devel.sha256sum] = "f82046a4a8d3d6c370f5f22e6a5e4b3a2e9f326a74fa11b71949c178b5489877"

URI_aarch64_binutils-gold = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/binutils-gold-2.41-65.el10.alma.1.aarch64.rpm;name=aarch64_binutils-gold;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-gold}"
SRC_URI[aarch64_binutils-gold.sha256sum] = "8788b676baedae0d9474f77ba6efed58ed839316cda0a3c20fe6baf4b5d40006"

URI_aarch64_binutils-gprofng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/binutils-gprofng-2.41-65.el10.alma.1.aarch64.rpm;name=aarch64_binutils-gprofng;unpack=0"
SRC_URI:append = " ${URI_aarch64_binutils-gprofng}"
SRC_URI[aarch64_binutils-gprofng.sha256sum] = "bb7c1ad6b2d94debbd9c443f10081fd844cf45c2b7c111e74e174bbf278fc4ec"

RDEPENDS:binutils = " \
 alternatives \
 bash \
 binutils-gold \
 elfutils-debuginfod-client \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:binutils-devel = " \
 binutils \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
RDEPENDS:binutils-gold = " \
 bash \
 binutils \
 glibc \
 jansson \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:binutils-gprofng = " \
 binutils \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 virtual/libgprofng.so.0___64bit_ \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libgprofng.so.0___64bit_ rpm/virtual/libsframe.so.1___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libctf.so.0_LIBCTF_1.0__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.1__64bit_ rpm/virtual/libctf.so.0_LIBCTF_1.2__64bit_ rpm/virtual/libctf.so.0___64bit_ rpm/virtual/libgprofng.so.0___64bit_ rpm/virtual/libsframe.so.1___64bit_"
