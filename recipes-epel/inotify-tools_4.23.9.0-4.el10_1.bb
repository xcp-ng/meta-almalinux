# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "inotify-tools"
PV = "4.23.9.0"
PR = "4.el10_1"
PACKAGES = " \
 inotify-tools \
 inotify-tools-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/inotify-tools-4.23.9.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aea6264e3debe09d1349c35c11df9aeb1df727ec6db7192bf061d30d993d6043"

URI_x86_64_v2_inotify-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/inotify-tools-4.23.9.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_inotify-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_inotify-tools}"
SRC_URI[x86_64_v2_inotify-tools.sha256sum] = "d4c687a7c86a795b8c56100bb7426cc1c940073fc3959a19fc2dbdb6282a6036"

URI_x86_64_v2_inotify-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/inotify-tools-devel-4.23.9.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_inotify-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_inotify-tools-devel}"
SRC_URI[x86_64_v2_inotify-tools-devel.sha256sum] = "01c8406d5f9a05a77205b96e813744e37147776d97e293f92d07eb2d28ce63b0"

URI_aarch64_inotify-tools = "${EPEL_MIRROR}/aarch64/Packages/i/inotify-tools-4.23.9.0-4.el10_1.aarch64.rpm;name=aarch64_inotify-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_inotify-tools}"
SRC_URI[aarch64_inotify-tools.sha256sum] = "99116bc1fe7b335c001f37d40f29c6934dea0d94459b2f5aade9cf0c9abe08b8"

URI_aarch64_inotify-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/i/inotify-tools-devel-4.23.9.0-4.el10_1.aarch64.rpm;name=aarch64_inotify-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_inotify-tools-devel}"
SRC_URI[aarch64_inotify-tools-devel.sha256sum] = "0bd73fbfbb4092195eb654f342b2d0d2776598e06203c233a1e7d8edaafd3e04"

RDEPENDS:inotify-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:inotify-tools-devel = " \
 inotify-tools \
 "
