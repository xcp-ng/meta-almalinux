# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amtk"
PV = "5.6.1"
PR = "7.el10_0"
PACKAGES = " \
 amtk \
 amtk-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/amtk-5.6.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "725f7c3918804f8b8215018acc6810965c15e0e18bdc021daa84849ae164f9c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amtk-5.6.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amtk;unpack=0"
SRC_URI[x86_64_v2_amtk.sha256sum] = "f06e4db4cf2e962fa59c7b7f81ed3e8c26836f01455c862e835b3c0f8d9cd68a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amtk-devel-5.6.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amtk-devel;unpack=0"
SRC_URI[x86_64_v2_amtk-devel.sha256sum] = "a77e89a226198061ed647a7c27619a86cc709afd96815efea7affbb62406ecc0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/amtk-5.6.1-7.el10_0.aarch64.rpm;name=aarch64_amtk;unpack=0"
SRC_URI[aarch64_amtk.sha256sum] = "57223d474461d1680eb16494102337708cbcf2c2731c95b7f62ebbf602b39d51"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/amtk-devel-5.6.1-7.el10_0.aarch64.rpm;name=aarch64_amtk-devel;unpack=0"
SRC_URI[aarch64_amtk-devel.sha256sum] = "a76e68f6c1fc05d28c1c96b435858546195ca50e87a93f226fc387d1215cb411"

RDEPENDS:amtk = " \
 glib2 \
 glibc \
 gtk3 \
 "
RDEPENDS:amtk-devel = " \
 amtk \
 glib2-devel \
 gtk3-devel \
 pkgconf-pkg-config \
 "
