# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wireplumber"
PV = "0.5.10"
PR = "1.el10"
PACKAGES = " \
 wireplumber \
 wireplumber-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wireplumber-0.5.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "224c7490268cfa3ee4df0a2abea533f12dd6b31299a6444f092a5c6f38b39013"

URI_x86_64_v2_wireplumber = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireplumber-0.5.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_wireplumber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireplumber}"
SRC_URI[x86_64_v2_wireplumber.sha256sum] = "3ef20bfd52b9ec124213582357bd77e62d37c2c7d5a9d8c03bb29655a08d6556"

URI_x86_64_v2_wireplumber-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wireplumber-libs-0.5.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_wireplumber-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wireplumber-libs}"
SRC_URI[x86_64_v2_wireplumber-libs.sha256sum] = "6714fb836ebd05f5c65ce53bec6e5782131ee844410fe5c89a64cb7ef5fe1981"

URI_aarch64_wireplumber = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireplumber-0.5.10-1.el10.aarch64.rpm;name=aarch64_wireplumber;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireplumber}"
SRC_URI[aarch64_wireplumber.sha256sum] = "92f4af48c192c896feb5e1910bc3bb5a6feae7593a5144c3b81a2aca025a11c9"

URI_aarch64_wireplumber-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wireplumber-libs-0.5.10-1.el10.aarch64.rpm;name=aarch64_wireplumber-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_wireplumber-libs}"
SRC_URI[aarch64_wireplumber-libs.sha256sum] = "e9329cf4812bb8b57b0d89d9c5384f79a5f59411644c83af08bf5314948aefa8"

RDEPENDS:wireplumber = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 pipewire-libs \
 wireplumber-libs \
 "
RDEPENDS:wireplumber-libs = " \
 glib2 \
 glibc \
 libgcc \
 lua-libs \
 pipewire-libs \
 systemd-libs \
 "
