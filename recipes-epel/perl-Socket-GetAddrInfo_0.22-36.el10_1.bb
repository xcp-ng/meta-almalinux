# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Socket-GetAddrInfo"
PV = "0.22"
PR = "36.el10_1"
PACKAGES = " \
 perl-Socket-GetAddrInfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Socket-GetAddrInfo-0.22-36.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e4d65b7ffeaf2174ffa968934479c9c1efc9a5fcd9b75e984699d4d8843c34c"

URI_x86_64_v2_perl-Socket-GetAddrInfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Socket-GetAddrInfo-0.22-36.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Socket-GetAddrInfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Socket-GetAddrInfo}"
SRC_URI[x86_64_v2_perl-Socket-GetAddrInfo.sha256sum] = "8920620b3abeb4b0d38fd578cad48d2df969e775622ab83ce8e0b15992dd18ee"

URI_aarch64_perl-Socket-GetAddrInfo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Socket-GetAddrInfo-0.22-36.el10_1.noarch.rpm;name=aarch64_perl-Socket-GetAddrInfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Socket-GetAddrInfo}"
SRC_URI[aarch64_perl-Socket-GetAddrInfo.sha256sum] = "a7074a18c42df9ca47bbe68188119b13ae9e8e66db34da0d26ebd1d068ccd78a"

RDEPENDS:perl-Socket-GetAddrInfo = " \
 perl-Carp \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-Socket-GetAddrInfo \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
