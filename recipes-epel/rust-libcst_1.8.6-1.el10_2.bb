# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libcst"
PV = "1.8.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-libcst+default-devel \
 rust-libcst+trace-devel \
 rust-libcst-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libcst-1.8.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb888bab5a419018e5dfc16da5b9f9d7c8be2df591023c7fa6d3b74183baa2e8"

URI_x86_64_v2_rust-libcst+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst+default-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcst+default-devel}"
SRC_URI[x86_64_v2_rust-libcst+default-devel.sha256sum] = "a2fd5fb223665410aa0bc09607f736a611ae6e1e0ce8affee6100783c003c760"

URI_x86_64_v2_rust-libcst+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst+trace-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcst+trace-devel}"
SRC_URI[x86_64_v2_rust-libcst+trace-devel.sha256sum] = "b5472bd5d8a8e02758ebd778a10b442f4671119dc8b70079f4e63480be1906ee"

URI_x86_64_v2_rust-libcst-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst-devel-1.8.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcst-devel}"
SRC_URI[x86_64_v2_rust-libcst-devel.sha256sum] = "b24dd7c7bb11848a1d8af41433b36a30b053fe86754bb88ee823bbf90be1a7c7"

URI_aarch64_rust-libcst+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst+default-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-libcst+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcst+default-devel}"
SRC_URI[aarch64_rust-libcst+default-devel.sha256sum] = "b22887cef5396272e88ba885c5a99f0b5baa8fb67852798b2795d82d10bd74e7"

URI_aarch64_rust-libcst+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst+trace-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-libcst+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcst+trace-devel}"
SRC_URI[aarch64_rust-libcst+trace-devel.sha256sum] = "d7bc7b9bacd971deb897124e5526b33a5c9115db4d318989437bee2440d4b804"

URI_aarch64_rust-libcst-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst-devel-1.8.6-1.el10_2.noarch.rpm;name=aarch64_rust-libcst-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcst-devel}"
SRC_URI[aarch64_rust-libcst-devel.sha256sum] = "e719259e6b03e427a1dd058e1e97bd378b693aacf01e18b9557c4f2200bd0aef"

RDEPENDS:rust-libcst+default-devel = " \
 cargo \
 rust-libcst-devel \
 "
RDEPENDS:rust-libcst+trace-devel = " \
 cargo \
 rust-libcst-devel \
 rust-peg+trace-devel \
 "
RDEPENDS:rust-libcst-devel = " \
 cargo \
 rust \
 rust-annotate-snippets0.11+default-devel \
 rust-libcst_derive+default-devel \
 rust-memchr+default-devel \
 rust-paste+default-devel \
 rust-peg+default-devel \
 rust-regex+default-devel \
 rust-thiserror+default-devel \
 "
