# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdialog"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdialog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdialog-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "062ba2261e5fcb453652843778dc587a0f1d402f7b1235d622928fc6411cc58e"

URI_x86_64_v2_kdialog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdialog-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdialog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdialog}"
SRC_URI[x86_64_v2_kdialog.sha256sum] = "17ae765d663647e5b3a40c2377f9182ac603e712f93e6d34bac1d93f040b5d15"

URI_aarch64_kdialog = "${EPEL_MIRROR}/aarch64/Packages/k/kdialog-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdialog;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdialog}"
SRC_URI[aarch64_kdialog.sha256sum] = "d1b65e9e36d976fe7f51365092552a33307ca48023c923ef29c4d1ff040b8c7c"

RDEPENDS:kdialog = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
