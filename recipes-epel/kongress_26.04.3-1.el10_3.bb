# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kongress"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kongress \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kongress-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ff85f49583b99482de8b6f87acf7595ac20bd405e83725a9900a32639cd2db1"

URI_x86_64_v2_kongress = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kongress-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kongress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kongress}"
SRC_URI[x86_64_v2_kongress.sha256sum] = "d31a213f0643f3eabaaf154eea7edb11c8bd1dd92a9baaa7a451236849a681a5"

URI_aarch64_kongress = "${EPEL_MIRROR}/aarch64/Packages/k/kongress-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kongress;unpack=0"
SRC_URI:append = " ${URI_aarch64_kongress}"
SRC_URI[aarch64_kongress.sha256sum] = "893e8cfc8ac573a3b73621d611f09ef82e8875553d173c3e0ff4275918ccc7c4"

RDEPENDS:kongress = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kosmindoormap \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtpositioning \
 "
