# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-rational"
PV = "0.4.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-num-rational+default-devel \
 rust-num-rational+num-bigint-devel \
 rust-num-rational+num-bigint-std-devel \
 rust-num-rational+serde-devel \
 rust-num-rational+std-devel \
 rust-num-rational-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-rational-0.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fa4d8d1b448caae993cac2b219d6d044f9c8df4e70cfa1811c26690fb11ffb9"

URI_x86_64_v2_rust-num-rational+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-rational+default-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-rational+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-rational+default-devel}"
SRC_URI[x86_64_v2_rust-num-rational+default-devel.sha256sum] = "b44277cb56e93c89d8608d2a0cdce9feb65e202395433362aa36c3da200021f6"

URI_x86_64_v2_rust-num-rational+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-rational+num-bigint-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-rational+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-rational+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-num-rational+num-bigint-devel.sha256sum] = "b55c1ab7b0631c071abc11397006913ba57bd67c466102563ffb41878959a414"

URI_x86_64_v2_rust-num-rational+num-bigint-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-rational+num-bigint-std-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-rational+num-bigint-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-rational+num-bigint-std-devel}"
SRC_URI[x86_64_v2_rust-num-rational+num-bigint-std-devel.sha256sum] = "96db09e5ca28ae7141c5350e7786b08fee3040f43150e3201f82e4606dea2a5f"

URI_x86_64_v2_rust-num-rational+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-rational+serde-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-rational+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-rational+serde-devel}"
SRC_URI[x86_64_v2_rust-num-rational+serde-devel.sha256sum] = "8ec9fcd114f5202811f5357ec97d2272854362bd7f7c778ab0c9e950b3274d4a"

URI_x86_64_v2_rust-num-rational+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-rational+std-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-rational+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-rational+std-devel}"
SRC_URI[x86_64_v2_rust-num-rational+std-devel.sha256sum] = "fe90b6d104680f37d5c139b0dcebf95015d272b6abfd99bf0db0b516916a5df3"

URI_x86_64_v2_rust-num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-rational-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-rational-devel}"
SRC_URI[x86_64_v2_rust-num-rational-devel.sha256sum] = "2ff36bf557cab890b3436d5bf7605e3efc7bb1339c93b56c7f7ea389908cd0e7"

URI_aarch64_rust-num-rational+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-rational+default-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-num-rational+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-rational+default-devel}"
SRC_URI[aarch64_rust-num-rational+default-devel.sha256sum] = "7bfbd8a4179cf4755aeb97467f1fb189656dcb39475519f658838a8ad4c8f51b"

URI_aarch64_rust-num-rational+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-rational+num-bigint-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-num-rational+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-rational+num-bigint-devel}"
SRC_URI[aarch64_rust-num-rational+num-bigint-devel.sha256sum] = "cdca90d6b93ab137ef955614200118668591fef17b300c179c7ca0b2d00298e8"

URI_aarch64_rust-num-rational+num-bigint-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-rational+num-bigint-std-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-num-rational+num-bigint-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-rational+num-bigint-std-devel}"
SRC_URI[aarch64_rust-num-rational+num-bigint-std-devel.sha256sum] = "264fd077cb17528fa6e154171693c2d47cbeaef0eebc6b5c23502f600eb647ce"

URI_aarch64_rust-num-rational+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-rational+serde-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-num-rational+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-rational+serde-devel}"
SRC_URI[aarch64_rust-num-rational+serde-devel.sha256sum] = "f24fff10a03161fa514571ef84ebdba6f96ff27b01f59b310c4806152d745f14"

URI_aarch64_rust-num-rational+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-rational+std-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-num-rational+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-rational+std-devel}"
SRC_URI[aarch64_rust-num-rational+std-devel.sha256sum] = "589786c4aa6a2341424c43cf1ae5cc51949bd140d5fdd29ffbd4618b0ff52436"

URI_aarch64_rust-num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-rational-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-rational-devel}"
SRC_URI[aarch64_rust-num-rational-devel.sha256sum] = "ef9e82eb89b866a779becb17dfeb1ed73d521b88777463b722e1553061622c0e"

RDEPENDS:rust-num-rational+default-devel = " \
 cargo \
 rust-num-rational+num-bigint-devel \
 rust-num-rational+std-devel \
 rust-num-rational-devel \
 "
RDEPENDS:rust-num-rational+num-bigint-devel = " \
 cargo \
 rust-num-bigint-devel \
 rust-num-rational-devel \
 "
RDEPENDS:rust-num-rational+num-bigint-std-devel = " \
 cargo \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 rust-num-rational-devel \
 "
RDEPENDS:rust-num-rational+serde-devel = " \
 cargo \
 rust-num-rational-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-rational+std-devel = " \
 cargo \
 rust-num-bigint+std-devel \
 rust-num-bigint-devel \
 rust-num-integer+std-devel \
 rust-num-rational-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-rational-devel = " \
 cargo \
 rust \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
