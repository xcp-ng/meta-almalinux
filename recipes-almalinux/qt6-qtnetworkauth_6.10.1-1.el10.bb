# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtnetworkauth"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtnetworkauth \
 qt6-qtnetworkauth-devel \
 qt6-qtnetworkauth-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtnetworkauth-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcca43aa9fa9be80e62fb177c06d2f8fbbbc28c9a460f5c90a5722fc56c00762"

URI_x86_64_v2_qt6-qtnetworkauth = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtnetworkauth-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtnetworkauth}"
SRC_URI[x86_64_v2_qt6-qtnetworkauth.sha256sum] = "99a954333e0495bc3df86f7a928d4343e17d24913fe80574fea79039d7c1265d"

URI_x86_64_v2_qt6-qtnetworkauth-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtnetworkauth-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtnetworkauth-devel}"
SRC_URI[x86_64_v2_qt6-qtnetworkauth-devel.sha256sum] = "ccf3b874f041b3bb0805032b2e1b9c80a8fd35c1e6d83128187327702f8c9378"

URI_x86_64_v2_qt6-qtnetworkauth-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtnetworkauth-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtnetworkauth-examples}"
SRC_URI[x86_64_v2_qt6-qtnetworkauth-examples.sha256sum] = "222bec089496303f144f5839ddfd571c47f3db027db6bba709d5a5698aad02cc"

URI_aarch64_qt6-qtnetworkauth = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtnetworkauth-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtnetworkauth}"
SRC_URI[aarch64_qt6-qtnetworkauth.sha256sum] = "f2f2a991851f5efcc3ecefe5f7611f8dab33d4241f5e69d38ba9e43162e59510"

URI_aarch64_qt6-qtnetworkauth-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtnetworkauth-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtnetworkauth-devel}"
SRC_URI[aarch64_qt6-qtnetworkauth-devel.sha256sum] = "43e93ab13e2a05007e84014f1b4538b3ef25188c049f16267d40272a9cec3a0e"

URI_aarch64_qt6-qtnetworkauth-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtnetworkauth-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtnetworkauth-examples}"
SRC_URI[aarch64_qt6-qtnetworkauth-examples.sha256sum] = "18a34d1dcfdb81217c67b10d01fb57a46d91af8d16da1e6279dd9f9d199b654f"

RDEPENDS:qt6-qtnetworkauth = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6-qtnetworkauth-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtnetworkauth \
 "
RDEPENDS:qt6-qtnetworkauth-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtnetworkauth \
 "
