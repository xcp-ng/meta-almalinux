# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-feedparser"
PV = "6.0.11"
PR = "5.el10_0"
PACKAGES = " \
 python-feedparser-doc \
 python3-feedparser \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-feedparser-6.0.11-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5f634529b22abb11fcf02c2aa7655757d39ecfda391b9edb284677e5857ad54b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-feedparser-doc-6.0.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-feedparser-doc;unpack=0"
SRC_URI[x86_64_v2_python-feedparser-doc.sha256sum] = "acfa6b3b26e84379138eb427ceeb2d5b34794102c94178ded28c52adccdebfb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-feedparser-6.0.11-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-feedparser;unpack=0"
SRC_URI[x86_64_v2_python3-feedparser.sha256sum] = "4c30881fb0227eb894e548e0519881aa8cd6b3b3ebf7ffc528787138e935017d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-feedparser-doc-6.0.11-5.el10_0.noarch.rpm;name=aarch64_python-feedparser-doc;unpack=0"
SRC_URI[aarch64_python-feedparser-doc.sha256sum] = "dfd8494d42e87535d22c5b39779d00eaebb1bc8856f40b0e747bdbc7f08aae3e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-feedparser-6.0.11-5.el10_0.noarch.rpm;name=aarch64_python3-feedparser;unpack=0"
SRC_URI[aarch64_python3-feedparser.sha256sum] = "13f64496acae0009ce244f7d0725e60156e0f999613d41a0345447adce4a1da2"

RDEPENDS:python-feedparser-doc = " \
 "
RDEPENDS:python3-feedparser = " \
 python3 \
 python3-sgmllib3k \
 "
