# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "minuet"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 minuet \
 minuet-data \
 minuet-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/minuet-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d546cc93498ffbc92912b0195379282625f3481f0ffc11de780e8ee1ae2ece26"

URI_x86_64_v2_minuet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minuet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minuet}"
SRC_URI[x86_64_v2_minuet.sha256sum] = "245e70ff69ad107692f0837f13d02719a21f758861d0b017fba48319d9ef3c44"

URI_x86_64_v2_minuet-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-data-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_minuet-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minuet-data}"
SRC_URI[x86_64_v2_minuet-data.sha256sum] = "7b635a348fb1c57a6aa0932c44e99c20ac29322df7dba271aaffcc65f1cccc5e"

URI_x86_64_v2_minuet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minuet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minuet-devel}"
SRC_URI[x86_64_v2_minuet-devel.sha256sum] = "82426457cfe65af26e39bc260106a00672d9f42e859208f17726caeda7bfb9fc"

URI_aarch64_minuet = "${EPEL_MIRROR}/aarch64/Packages/m/minuet-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_minuet;unpack=0"
SRC_URI:append = " ${URI_aarch64_minuet}"
SRC_URI[aarch64_minuet.sha256sum] = "b3c5727a0efc11c75587378fe9b2a50332438743b83c99f32f9cd1442cff523b"

URI_aarch64_minuet-data = "${EPEL_MIRROR}/aarch64/Packages/m/minuet-data-25.12.3-1.el10_2.noarch.rpm;name=aarch64_minuet-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_minuet-data}"
SRC_URI[aarch64_minuet-data.sha256sum] = "091f262afedf92d9d84a735b4bd53aa5f232d856a933ee06d4967e78905a96a4"

URI_aarch64_minuet-devel = "${EPEL_MIRROR}/aarch64/Packages/m/minuet-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_minuet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_minuet-devel}"
SRC_URI[aarch64_minuet-devel.sha256sum] = "c3c06e097c46c16a7e1cb0543aad41fd5e86f53f0339c6310b3e5eb541900d2b"

RDEPENDS:minuet = " \
 fluidsynth-libs \
 glibc \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 minuet-data \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:minuet-data = " \
 minuet \
 "
RDEPENDS:minuet-devel = " \
 minuet \
 "
