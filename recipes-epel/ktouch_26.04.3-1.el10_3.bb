# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktouch"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ktouch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktouch-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dd6dcdde6528ef0fad9df7936d84689d33d5556651a9e5c0f39feae76944e8a"

URI_x86_64_v2_ktouch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktouch-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktouch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktouch}"
SRC_URI[x86_64_v2_ktouch.sha256sum] = "6432b9d80afe55080082e58c077a65e247f24e6fceb5a1ab77ead964068819df"

URI_aarch64_ktouch = "${EPEL_MIRROR}/aarch64/Packages/k/ktouch-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ktouch;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktouch}"
SRC_URI[aarch64_ktouch.sha256sum] = "a2204a99df33cc24c2df28f6361fc390a8b2aea2bc24d3e3a10c0ac7520cabff"

RDEPENDS:ktouch = " \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kqtquickcharts \
 libX11 \
 libstdc++ \
 libxcb \
 libxml2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
