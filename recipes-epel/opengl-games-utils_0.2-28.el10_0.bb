# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opengl-games-utils"
PV = "0.2"
PR = "28.el10_0"
PACKAGES = " \
 opengl-games-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/opengl-games-utils-0.2-28.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bfcb36470fcb95aa356cb9dfe4737a4d790ee7a819a30c6c2b83476a95346b41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opengl-games-utils-0.2-28.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_opengl-games-utils;unpack=0"
SRC_URI[x86_64_v2_opengl-games-utils.sha256sum] = "980a77ec2f3e6ec98636d9e9aba73f1887b7098b086ab027f00c1ab647ebdebf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opengl-games-utils-0.2-28.el10_0.noarch.rpm;name=aarch64_opengl-games-utils;unpack=0"
SRC_URI[aarch64_opengl-games-utils.sha256sum] = "16eee3637e8196921733659db081af5e618d33496939c135d1cedf6dda22e212"

RDEPENDS:opengl-games-utils = " \
 bash \
 glx-utils \
 zenity \
 "
