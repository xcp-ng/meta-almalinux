# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vmaf"
PV = "3.0.0"
PR = "2.el10_0"
PACKAGES:x86_64_v2 = " \
 libvmaf \
 libvmaf-devel \
 vmaf \
 vmaf-models \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/v/vmaf-3.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c611f10ef68767b415d613cfb3b039acec4167bbf8d740660ea32e82cd34fc53"

URI_x86_64_v2_libvmaf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvmaf-3.0.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvmaf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvmaf}"
SRC_URI[x86_64_v2_libvmaf.sha256sum] = "49fe2fe041511ebc456dc78e2fce45bc4d0d33ea22ed825561e358d9185db1a2"

URI_x86_64_v2_libvmaf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvmaf-devel-3.0.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvmaf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvmaf-devel}"
SRC_URI[x86_64_v2_libvmaf-devel.sha256sum] = "186b695d9d02ab0bb4e06e807f2c36c256ab79c44a63fdb031731912b3eb5423"

URI_x86_64_v2_vmaf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vmaf-3.0.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vmaf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vmaf}"
SRC_URI[x86_64_v2_vmaf.sha256sum] = "b88133a6af35dd6d20cf981203d2ab67d58885e9db4566c2d8a90c062ab91be1"

URI_x86_64_v2_vmaf-models = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vmaf-models-3.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_vmaf-models;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vmaf-models}"
SRC_URI[x86_64_v2_vmaf-models.sha256sum] = "66547436403438ce23cea85c732ce4d5d114660e2e62e395754854caa979a305"

RDEPENDS:libvmaf = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libvmaf-devel = " \
 libvmaf \
 pkgconf-pkg-config \
 "
RDEPENDS:vmaf = " \
 glibc \
 libvmaf \
 "
RDEPENDS:vmaf-models = " \
 libvmaf \
 "
