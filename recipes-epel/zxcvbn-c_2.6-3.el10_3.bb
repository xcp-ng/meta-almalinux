# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zxcvbn-c"
PV = "2.6"
PR = "3.el10_3"
PACKAGES = " \
 zxcvbn-c \
 zxcvbn-c-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/z/zxcvbn-c-2.6-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ee7e25657d6638c0d62250c08106f1a8c45c87a4cf48bfa2d545c7afea8f72ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zxcvbn-c-2.6-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zxcvbn-c;unpack=0"
SRC_URI[x86_64_v2_zxcvbn-c.sha256sum] = "c0180396d5d1a24cecf1a7f6bcd5d6c7aca3a27e174b645b62d3ab01da41f8f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zxcvbn-c-devel-2.6-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zxcvbn-c-devel;unpack=0"
SRC_URI[x86_64_v2_zxcvbn-c-devel.sha256sum] = "1bab676326c116f2fb1bc10b890a3a5087b276b2863e3ed9300f3ae047b3bbc9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zxcvbn-c-2.6-3.el10_3.aarch64.rpm;name=aarch64_zxcvbn-c;unpack=0"
SRC_URI[aarch64_zxcvbn-c.sha256sum] = "08b5c46077756ad839f142458622c125c2fa0facbec2dc7a9e70f9c718b2ee49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/z/zxcvbn-c-devel-2.6-3.el10_3.aarch64.rpm;name=aarch64_zxcvbn-c-devel;unpack=0"
SRC_URI[aarch64_zxcvbn-c-devel.sha256sum] = "575c646b07d6b7f8cb1ba40300a0cade20f8217905af4ff8f5c9924382ac1ab0"

RDEPENDS:zxcvbn-c = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:zxcvbn-c-devel = " \
 zxcvbn-c \
 "
