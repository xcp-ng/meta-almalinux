# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-datadog"
PV = "4.2.0"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-datadog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-datadog-4.2.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d20c22ed28df27d1d26a93a984f06fd01cc72c7879549ef67877814b5882fe3"

URI_x86_64_v2_golang-github-datadog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-datadog-devel-4.2.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-datadog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-datadog-devel}"
SRC_URI[x86_64_v2_golang-github-datadog-devel.sha256sum] = "a6d9005b3ba048868022439ee161d3dab864c88188573e7b116f49518f45ad51"

URI_aarch64_golang-github-datadog-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-datadog-devel-4.2.0-12.el10_0.noarch.rpm;name=aarch64_golang-github-datadog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-datadog-devel}"
SRC_URI[aarch64_golang-github-datadog-devel.sha256sum] = "e6ada8e754de613cb4e20fabf6afae1c7c0d2921e36b9fb7ff279553c17b653c"

RDEPENDS:golang-github-datadog-devel = " \
 go-filesystem \
 "
