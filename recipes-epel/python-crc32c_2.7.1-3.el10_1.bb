# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-crc32c"
PV = "2.7.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-crc32c \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-crc32c-2.7.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ba10331a01a50724e7ed739a08f2112d0aa24cd213304617d405662317b5f22"

URI_x86_64_v2_python3-crc32c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-crc32c-2.7.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-crc32c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-crc32c}"
SRC_URI[x86_64_v2_python3-crc32c.sha256sum] = "7d24e2bbbc5e94de31cedbbc400645bd33a469ae6ba017bbd349e3aa949681d9"

URI_aarch64_python3-crc32c = "${EPEL_MIRROR}/aarch64/Packages/p/python3-crc32c-2.7.1-3.el10_1.aarch64.rpm;name=aarch64_python3-crc32c;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-crc32c}"
SRC_URI[aarch64_python3-crc32c.sha256sum] = "e2960f1e42e4cef8c8158d65308627b565a59bb05cfdaf9eaec8d9919ae9a11e"

RDEPENDS:python3-crc32c = " \
 glibc \
 python3 \
 "
