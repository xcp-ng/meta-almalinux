# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tox"
PV = "4.26.0"
PR = "1.el10_1"
PACKAGES = " \
 tox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tox-4.26.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b36756ec859eda5683456c5f7335d1c70ec0f6d5e672aee2263d113e1c4e5a37"

URI_x86_64_v2_tox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tox-4.26.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tox}"
SRC_URI[x86_64_v2_tox.sha256sum] = "cee9d814122be90c1a177a31448b2c176df9c679d73694762010669aa46637d0"

URI_aarch64_tox = "${EPEL_MIRROR}/aarch64/Packages/t/tox-4.26.0-1.el10_1.noarch.rpm;name=aarch64_tox;unpack=0"
SRC_URI:append = " ${URI_aarch64_tox}"
SRC_URI[aarch64_tox.sha256sum] = "0dffb594105679148ccd4273b152fffc3c3c30e3f3b6baafe163f7748b83592f"

RDEPENDS:tox = " \
 python3 \
 python3-cachetools \
 python3-chardet \
 python3-colorama \
 python3-filelock \
 python3-packaging \
 python3-platformdirs \
 python3-pluggy \
 python3-pyproject-api \
 python3-virtualenv \
 "
