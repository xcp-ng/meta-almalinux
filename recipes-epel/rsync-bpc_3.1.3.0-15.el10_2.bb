# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsync-bpc"
PV = "3.1.3.0"
PR = "15.el10_2"
PACKAGES = " \
 rsync-bpc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rsync-bpc-3.1.3.0-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f07e943ffe76d0cc50057842c2b176e6328d2552787f640829e21d6df393a8b5"

URI_x86_64_v2_rsync-bpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rsync-bpc-3.1.3.0-15.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rsync-bpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync-bpc}"
SRC_URI[x86_64_v2_rsync-bpc.sha256sum] = "df3cd7ce6934374d15f321c49809a4c68f325ddfaa31b63639d2f0e13c3c6ea2"

URI_aarch64_rsync-bpc = "${EPEL_MIRROR}/aarch64/Packages/r/rsync-bpc-3.1.3.0-15.el10_2.aarch64.rpm;name=aarch64_rsync-bpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync-bpc}"
SRC_URI[aarch64_rsync-bpc.sha256sum] = "1d47583ddf172d10b7cc32229ada56fa354321941f7a29e0b8e5dd69461ffaff"

RDEPENDS:rsync-bpc = " \
 glibc \
 libacl \
 popt \
 "
