# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-vendor-tools"
PV = "0.12.0"
PR = "1.el10_2"
PACKAGES = " \
 go-vendor-tools \
 go-vendor-tools+all \
 go-vendor-tools-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/go-vendor-tools-0.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "111504c869e2379c315e840ccbf8d288b0ce125c79f4d9306d0c3b18bd34136e"

URI_x86_64_v2_go-vendor-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools}"
SRC_URI[x86_64_v2_go-vendor-tools.sha256sum] = "505b9f0502340c355ab3165c1d5ed271dd94f21dd16c1c54b29b20e7d828a6c8"

URI_x86_64_v2_go-vendor-tools+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools+all-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools+all}"
SRC_URI[x86_64_v2_go-vendor-tools+all.sha256sum] = "03de33204f699b25e7472771817ed4b8a635ab19a54203593622c4246d77f6a6"

URI_x86_64_v2_go-vendor-tools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-vendor-tools-doc-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_go-vendor-tools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-vendor-tools-doc}"
SRC_URI[x86_64_v2_go-vendor-tools-doc.sha256sum] = "8fdd36a3307865069acc8082733775fc8d0de00a82a60362d6e332198f7233bd"

URI_aarch64_go-vendor-tools = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools-0.12.0-1.el10_2.noarch.rpm;name=aarch64_go-vendor-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools}"
SRC_URI[aarch64_go-vendor-tools.sha256sum] = "0fb51a955130046e1f4084e0541b93a568c6aa4b83ed3db9072b3d90e22c0b78"

URI_aarch64_go-vendor-tools+all = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools+all-0.12.0-1.el10_2.noarch.rpm;name=aarch64_go-vendor-tools+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools+all}"
SRC_URI[aarch64_go-vendor-tools+all.sha256sum] = "e4a92be460c2f593219d437b161443282b0ab01238f2ab00ef839656cbf928f1"

URI_aarch64_go-vendor-tools-doc = "${EPEL_MIRROR}/aarch64/Packages/g/go-vendor-tools-doc-0.12.0-1.el10_2.noarch.rpm;name=aarch64_go-vendor-tools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-vendor-tools-doc}"
SRC_URI[aarch64_go-vendor-tools-doc.sha256sum] = "e8d41468b958ea5f7d5e3070c77acd1a0ae8a5500f7ebd5377d9f58dfe2f2234"

RDEPENDS:go-vendor-tools = " \
 python3 \
 python3-license-expression \
 "
RDEPENDS:go-vendor-tools+all = " \
 go-vendor-tools \
 python3 \
 python3-argcomplete \
 python3-specfile \
 python3-tomlkit \
 python3-zstarfile \
 "
RDEPENDS:go-vendor-tools-doc = " \
 "
