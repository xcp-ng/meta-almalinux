# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdnssd"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdnssd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdnssd-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e92fb5ce469453f55255d7e4484d9b7eed9d89199488d2f9375ceb72e382e1bb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdnssd-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdnssd;unpack=0"
SRC_URI[x86_64_v2_kdnssd.sha256sum] = "b41ee47e0ad705fbe51ab61eb796377031630d2b7e78d122e10fc70fb2fbcabe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdnssd-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdnssd;unpack=0"
SRC_URI[aarch64_kdnssd.sha256sum] = "174d2159911d2a993054c75920c18bf38371d0ced08e2a3c11f2a733b281ab99"

RDEPENDS:kdnssd = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
