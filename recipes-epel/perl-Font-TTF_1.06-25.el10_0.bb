# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Font-TTF"
PV = "1.06"
PR = "25.el10_0"
PACKAGES = " \
 perl-Font-TTF \
 perl-Font-TTF-XMLparse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Font-TTF-1.06-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "436945288e820407febb12b581975b4a6efc8275614bc282169385736f21a1a5"

URI_x86_64_v2_perl-Font-TTF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Font-TTF-1.06-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Font-TTF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Font-TTF}"
SRC_URI[x86_64_v2_perl-Font-TTF.sha256sum] = "8fd134ce4952c8d107df3cb3dfdfe48c2a2fb25935965058ded8236f4275750c"

URI_x86_64_v2_perl-Font-TTF-XMLparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Font-TTF-XMLparse-1.06-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Font-TTF-XMLparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Font-TTF-XMLparse}"
SRC_URI[x86_64_v2_perl-Font-TTF-XMLparse.sha256sum] = "6efebf55e7e939ca9e95cf429cd7b96036a427ec6c04cca7b015b40466a47b3b"

URI_aarch64_perl-Font-TTF = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Font-TTF-1.06-25.el10_0.noarch.rpm;name=aarch64_perl-Font-TTF;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Font-TTF}"
SRC_URI[aarch64_perl-Font-TTF.sha256sum] = "19213ee337574bbd8fa1ac471d6fad12040dea56658b07becbd0b04e4de80bc6"

URI_aarch64_perl-Font-TTF-XMLparse = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Font-TTF-XMLparse-1.06-25.el10_0.noarch.rpm;name=aarch64_perl-Font-TTF-XMLparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Font-TTF-XMLparse}"
SRC_URI[aarch64_perl-Font-TTF-XMLparse.sha256sum] = "944573251535928c82c32112d611b2517f7ec6000aa56de667b1b090774dc150"

RDEPENDS:perl-Font-TTF = " \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Font-TTF \
 perl-IO \
 perl-IO-String \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Font-TTF-XMLparse = " \
 perl-Exporter \
 perl-XML-Parser \
 perl-libs \
 perl-vars \
 "
