# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpassword"
PV = "7.5.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-rpassword+default-devel \
 rust-rpassword-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rpassword-7.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c131f25dadd0009384f66df97568bb295e51a749e4166b3586a89b7fcb630b3"

URI_x86_64_v2_rust-rpassword+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpassword+default-devel-7.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpassword+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpassword+default-devel}"
SRC_URI[x86_64_v2_rust-rpassword+default-devel.sha256sum] = "2ca824b9b9e9862ff26c700826401ae068bf10a474acbfc360c0c8c50d1a592e"

URI_x86_64_v2_rust-rpassword-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpassword-devel-7.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpassword-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpassword-devel}"
SRC_URI[x86_64_v2_rust-rpassword-devel.sha256sum] = "ee3cccf2e06c82e6879eba1f0171c221e53b07172e4bed49ec01d02a31978189"

URI_aarch64_rust-rpassword+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpassword+default-devel-7.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-rpassword+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpassword+default-devel}"
SRC_URI[aarch64_rust-rpassword+default-devel.sha256sum] = "d81606afa5eb27285ad9a872fb2aa7f93aa91567bcfce17c9b677221de6e5a06"

URI_aarch64_rust-rpassword-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpassword-devel-7.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-rpassword-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpassword-devel}"
SRC_URI[aarch64_rust-rpassword-devel.sha256sum] = "c6d6026d2e6029a7aa70effaa24e9e1f93fe0aa6db4e01dbef75345e5ee15580"

RDEPENDS:rust-rpassword+default-devel = " \
 cargo \
 rust-rpassword-devel \
 "
RDEPENDS:rust-rpassword-devel = " \
 bash \
 cargo \
 rust \
 rust-libc+default-devel \
 rust-rtoolbox+default-devel \
 "
