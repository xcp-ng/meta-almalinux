# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl"
PV = "0.10.81"
PR = "1.el10_2"
PACKAGES = " \
 rust-openssl+bindgen-devel \
 rust-openssl+default-devel \
 rust-openssl+v101-devel \
 rust-openssl+v102-devel \
 rust-openssl+v110-devel \
 rust-openssl+v111-devel \
 rust-openssl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-0.10.81-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac0fd8eae001a3c5fd239abfe85b99c176130f88da8e2ff7096a07e9bcc05939"

URI_x86_64_v2_rust-openssl+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+bindgen-devel-0.10.81-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+bindgen-devel}"
SRC_URI[x86_64_v2_rust-openssl+bindgen-devel.sha256sum] = "a1e1d947ab83e2e3e5dcd7a1978a4e1478991a94b8d785d9414c57a61d16d74a"

URI_x86_64_v2_rust-openssl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+default-devel-0.10.81-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+default-devel}"
SRC_URI[x86_64_v2_rust-openssl+default-devel.sha256sum] = "51177f802ffe9d0a328e2fe84a2302b8c539b56e862aa55fe3fcf49de46c7973"

URI_x86_64_v2_rust-openssl+v101-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v101-devel-0.10.81-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v101-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v101-devel}"
SRC_URI[x86_64_v2_rust-openssl+v101-devel.sha256sum] = "09abb4ac65dc62f7c1a1ccd78438798cf21c65c451e6860ee6499c86284cd8a4"

URI_x86_64_v2_rust-openssl+v102-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v102-devel-0.10.81-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v102-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v102-devel}"
SRC_URI[x86_64_v2_rust-openssl+v102-devel.sha256sum] = "a17fd9c50c9f4a2657157a6fc10a47f05c4ecbd65784e035fc2be63b9ead4bc7"

URI_x86_64_v2_rust-openssl+v110-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v110-devel-0.10.81-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v110-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v110-devel}"
SRC_URI[x86_64_v2_rust-openssl+v110-devel.sha256sum] = "166269aa732b8ddca4e68d7e6a3934a491b27ae6122e3043868d2cba93387ad4"

URI_x86_64_v2_rust-openssl+v111-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl+v111-devel-0.10.81-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl+v111-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl+v111-devel}"
SRC_URI[x86_64_v2_rust-openssl+v111-devel.sha256sum] = "da9b1661105b85b6168a99f5a999ac18c4d4e1bf64a99b4fa001bb2df3722c4f"

URI_x86_64_v2_rust-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-devel-0.10.81-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-devel}"
SRC_URI[x86_64_v2_rust-openssl-devel.sha256sum] = "b569d9c1e6d76f90e76812fdc37eada6718a331ee3046979e345570f535159b5"

URI_aarch64_rust-openssl+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+bindgen-devel-0.10.81-1.el10_2.noarch.rpm;name=aarch64_rust-openssl+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+bindgen-devel}"
SRC_URI[aarch64_rust-openssl+bindgen-devel.sha256sum] = "ba65538a66a75f9494b335c428a91b40f89241fbaef717e3e876def46c058d7b"

URI_aarch64_rust-openssl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+default-devel-0.10.81-1.el10_2.noarch.rpm;name=aarch64_rust-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+default-devel}"
SRC_URI[aarch64_rust-openssl+default-devel.sha256sum] = "c6e8ccf67b0b2987d1726bf5354583f01a1ad1d13504df27bbab51ca3b9c8293"

URI_aarch64_rust-openssl+v101-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v101-devel-0.10.81-1.el10_2.noarch.rpm;name=aarch64_rust-openssl+v101-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v101-devel}"
SRC_URI[aarch64_rust-openssl+v101-devel.sha256sum] = "66cfcc69e4759da36fc67b40be14f7ead45daefb7b7d7cb47a02fd1e3b022f9e"

URI_aarch64_rust-openssl+v102-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v102-devel-0.10.81-1.el10_2.noarch.rpm;name=aarch64_rust-openssl+v102-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v102-devel}"
SRC_URI[aarch64_rust-openssl+v102-devel.sha256sum] = "32aac4387c24a7b393d301813c913bd459242b77b0d90120b934181651bd6bb0"

URI_aarch64_rust-openssl+v110-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v110-devel-0.10.81-1.el10_2.noarch.rpm;name=aarch64_rust-openssl+v110-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v110-devel}"
SRC_URI[aarch64_rust-openssl+v110-devel.sha256sum] = "01b35378e406f7f6f61fab25dc0ba48a21660e5309fde5b0a04e919825a6d852"

URI_aarch64_rust-openssl+v111-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl+v111-devel-0.10.81-1.el10_2.noarch.rpm;name=aarch64_rust-openssl+v111-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl+v111-devel}"
SRC_URI[aarch64_rust-openssl+v111-devel.sha256sum] = "0ab3971d919df07010cd2afbb4582e3f11004e136a855b8b3687d2d2c509c4fb"

URI_aarch64_rust-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-devel-0.10.81-1.el10_2.noarch.rpm;name=aarch64_rust-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-devel}"
SRC_URI[aarch64_rust-openssl-devel.sha256sum] = "4a44f17166800dc74ef5ee528ce43268fc84c71b58f1ec372d459bcf8354d132"

RDEPENDS:rust-openssl+bindgen-devel = " \
 cargo \
 rust-openssl-devel \
 rust-openssl-sys+bindgen-devel \
 "
RDEPENDS:rust-openssl+default-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v101-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v102-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v110-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl+v111-devel = " \
 cargo \
 rust-openssl-devel \
 "
RDEPENDS:rust-openssl-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-foreign-types0.3+default-devel \
 rust-libc+default-devel \
 rust-openssl-macros+default-devel \
 rust-openssl-sys+default-devel \
 "
