# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-m17n"
PV = "1.4.29"
PR = "6.el10"
PACKAGES = " \
 ibus-m17n \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-m17n-1.4.29-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ef65d2f551dba49e126f2d445e6ecbf4ac9e9515bad41c14f44373c8e12c624"

URI_x86_64_v2_ibus-m17n = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-m17n-1.4.29-6.el10.x86_64_v2.rpm;name=x86_64_v2_ibus-m17n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-m17n}"
SRC_URI[x86_64_v2_ibus-m17n.sha256sum] = "388ba262b66f4f0d9c319b24da01a32fc6e68ea4b3b9e0503306b43f13f09dee"

URI_aarch64_ibus-m17n = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-m17n-1.4.29-6.el10.aarch64.rpm;name=aarch64_ibus-m17n;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-m17n}"
SRC_URI[aarch64_ibus-m17n.sha256sum] = "91cc39bcb69b550ca58b55c99a056a5cd129e9264bcf686f57bdf7129ae04d29"

RDEPENDS:ibus-m17n = " \
 glib2 \
 glibc \
 gtk3 \
 ibus \
 ibus-libs \
 m17n-lib \
 "
