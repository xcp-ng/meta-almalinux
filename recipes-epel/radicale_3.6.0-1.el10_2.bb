# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "radicale"
PV = "3.6.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-radicale3 \
 radicale3 \
 radicale3-InfCloud \
 radicale3-InfCloud-fontware \
 radicale3-httpd \
 radicale3-logwatch \
 radicale3-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/radicale-3.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a98a907b8fbe2917b44d0a3b4bd592d152dd978e5a8fe018a520e3ae057ac015"

URI_x86_64_v2_python3-radicale3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-radicale3-3.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-radicale3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-radicale3}"
SRC_URI[x86_64_v2_python3-radicale3.sha256sum] = "70d6c99c9d2fae5b4bff9d870b483e6ec06a7ea1aa804c4a295b868b522bbda5"

URI_x86_64_v2_radicale3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-3.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3}"
SRC_URI[x86_64_v2_radicale3.sha256sum] = "de480bd29412b6d91135f2c4d1333f8f4486e6a8b8508283d1a7257f460dd549"

URI_x86_64_v2_radicale3-InfCloud = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-InfCloud-3.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-InfCloud;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-InfCloud}"
SRC_URI[x86_64_v2_radicale3-InfCloud.sha256sum] = "786e15665025b159fe5bca3c9fea70fdd0ce7c1d42438494d04e9020164c580e"

URI_x86_64_v2_radicale3-InfCloud-fontware = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-InfCloud-fontware-3.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-InfCloud-fontware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-InfCloud-fontware}"
SRC_URI[x86_64_v2_radicale3-InfCloud-fontware.sha256sum] = "a2acffa69e534dca14ffeb63fbcead32424a6956c9b237fe73725d42e7b8d0dd"

URI_x86_64_v2_radicale3-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-httpd-3.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-httpd}"
SRC_URI[x86_64_v2_radicale3-httpd.sha256sum] = "3385ec96b8ed2f96244d665e6273bc68790666b9ed63e913d225f47fda32fc62"

URI_x86_64_v2_radicale3-logwatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-logwatch-3.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-logwatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-logwatch}"
SRC_URI[x86_64_v2_radicale3-logwatch.sha256sum] = "ec488ac7caebace6b78a77d9bbe552d198cb0b3681af6fa9605a67fbaacae580"

URI_x86_64_v2_radicale3-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/radicale3-selinux-3.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_radicale3-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_radicale3-selinux}"
SRC_URI[x86_64_v2_radicale3-selinux.sha256sum] = "05eaae9ad194233f416d338e4db36c011b1978fe6a231f2f69b397d43db2c69f"

URI_aarch64_python3-radicale3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-radicale3-3.6.0-1.el10_2.noarch.rpm;name=aarch64_python3-radicale3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-radicale3}"
SRC_URI[aarch64_python3-radicale3.sha256sum] = "592694434950e4061f955218501ff9ed56572541acfc70e1eda340a248c57545"

URI_aarch64_radicale3 = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-3.6.0-1.el10_2.noarch.rpm;name=aarch64_radicale3;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3}"
SRC_URI[aarch64_radicale3.sha256sum] = "73057a245e1473fe0b4a2a390728fbfc25bd2c07a0428ef96f0294c4a8f8571a"

URI_aarch64_radicale3-InfCloud = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-InfCloud-3.6.0-1.el10_2.noarch.rpm;name=aarch64_radicale3-InfCloud;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-InfCloud}"
SRC_URI[aarch64_radicale3-InfCloud.sha256sum] = "12a754bc71653ce31993385f264348b6ec14f78e122847278dbebfb0ac0968e1"

URI_aarch64_radicale3-InfCloud-fontware = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-InfCloud-fontware-3.6.0-1.el10_2.noarch.rpm;name=aarch64_radicale3-InfCloud-fontware;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-InfCloud-fontware}"
SRC_URI[aarch64_radicale3-InfCloud-fontware.sha256sum] = "2b6284c0beec3b9548ff91e152a27249d92f24a6048874b4583d0db14fd9008e"

URI_aarch64_radicale3-httpd = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-httpd-3.6.0-1.el10_2.noarch.rpm;name=aarch64_radicale3-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-httpd}"
SRC_URI[aarch64_radicale3-httpd.sha256sum] = "2778edbcf1e0132c07b2b62629575e2f798810163cd6ff4f89f5219d075d76bf"

URI_aarch64_radicale3-logwatch = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-logwatch-3.6.0-1.el10_2.noarch.rpm;name=aarch64_radicale3-logwatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-logwatch}"
SRC_URI[aarch64_radicale3-logwatch.sha256sum] = "65867167c54e00a40f4e41f0db291786210a667aceda87e9b3e978d4cad93618"

URI_aarch64_radicale3-selinux = "${EPEL_MIRROR}/aarch64/Packages/r/radicale3-selinux-3.6.0-1.el10_2.noarch.rpm;name=aarch64_radicale3-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_radicale3-selinux}"
SRC_URI[aarch64_radicale3-selinux.sha256sum] = "4e885f62a67d9d6055335f61b2d0e66b02afbcd8e1e6e41fcc261985d3a5f7b3"

RDEPENDS:python3-radicale3 = " \
 bash \
 python3 \
 python3-defusedxml \
 python3-packaging \
 python3-passlib \
 python3-pika \
 python3-requests \
 python3-vobject \
 "
RDEPENDS:radicale3 = " \
 bash \
 python3 \
 python3-radicale3 \
 shadow-utils \
 systemd \
 "
RDEPENDS:radicale3-InfCloud = " \
 ed \
 python3-radicale3 \
 "
RDEPENDS:radicale3-InfCloud-fontware = " \
 radicale3-InfCloud \
 "
RDEPENDS:radicale3-httpd = " \
 bash \
 httpd \
 python3-mod_wsgi \
 radicale3 \
 "
RDEPENDS:radicale3-logwatch = " \
 logwatch \
 radicale3 \
 "
RDEPENDS:radicale3-selinux = " \
 bash \
 policycoreutils \
 policycoreutils-python-utils \
 radicale3 \
 selinux-policy \
 "
