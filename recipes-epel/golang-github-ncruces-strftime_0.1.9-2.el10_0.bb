# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-ncruces-strftime"
PV = "0.1.9"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-ncruces-strftime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-ncruces-strftime-0.1.9-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62c7e1c108d52407dc270c95da663958e324bc26866f0821eefe2f8ee651b2e7"

URI_x86_64_v2_golang-github-ncruces-strftime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-ncruces-strftime-devel-0.1.9-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-ncruces-strftime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-ncruces-strftime-devel}"
SRC_URI[x86_64_v2_golang-github-ncruces-strftime-devel.sha256sum] = "3cddf619451e337c5021ba91005a653125b181389d926d367df766b202919488"

URI_aarch64_golang-github-ncruces-strftime-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-ncruces-strftime-devel-0.1.9-2.el10_0.noarch.rpm;name=aarch64_golang-github-ncruces-strftime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-ncruces-strftime-devel}"
SRC_URI[aarch64_golang-github-ncruces-strftime-devel.sha256sum] = "91bb530de55e56754d77aed62e4bc68b7d2007d295b937bb8ec6ee8147c62fab"

RDEPENDS:golang-github-ncruces-strftime-devel = " \
 go-filesystem \
 "
