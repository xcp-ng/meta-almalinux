# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pie"
PV = "1.4.8"
PR = "1.el10_2"
PACKAGES = " \
 pie \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pie-1.4.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e395edfb9f8839eed60d5b20b5b499d67fbf47ab7ae5ac8bf33462a0d4f2c09f"

URI_x86_64_v2_pie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pie-1.4.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pie}"
SRC_URI[x86_64_v2_pie.sha256sum] = "818ecdac9e5f486a002e65039220e7275f3ae5558fbfd5c8a55bcf378a6693c1"

URI_aarch64_pie = "${EPEL_MIRROR}/aarch64/Packages/p/pie-1.4.8-1.el10_2.noarch.rpm;name=aarch64_pie;unpack=0"
SRC_URI:append = " ${URI_aarch64_pie}"
SRC_URI[aarch64_pie.sha256sum] = "fc8b27510e49558e3d4599cdf384a550292a375ff6b3da39e2744b751510921e"

RDEPENDS:pie = " \
 bash \
 ca-certificates \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-mbstring \
 virtual/php-phar \
 virtual/php-posix \
 virtual/php-zip \
 virtual/php_language__ge_8.1 \
 "
