# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "triehash"
PV = "0.3"
PR = "15.el10_0"
PACKAGES = " \
 triehash \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/triehash-0.3-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e09af0ed292118883f5d2f8e6e9e5f8c035669f6fd30c4954b76dd83af21a48"

URI_x86_64_v2_triehash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/triehash-0.3-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_triehash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_triehash}"
SRC_URI[x86_64_v2_triehash.sha256sum] = "dfc7828bb1a063b55018359c124dca1247d929d7614ff60e8a935f37fdb6eac2"

URI_aarch64_triehash = "${EPEL_MIRROR}/aarch64/Packages/t/triehash-0.3-15.el10_0.noarch.rpm;name=aarch64_triehash;unpack=0"
SRC_URI:append = " ${URI_aarch64_triehash}"
SRC_URI[aarch64_triehash.sha256sum] = "a8d5209864bcdeb32f37d5a16b330cc703898cadddf417a6b018cdbd4b8eaf5d"

RDEPENDS:triehash = " \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
