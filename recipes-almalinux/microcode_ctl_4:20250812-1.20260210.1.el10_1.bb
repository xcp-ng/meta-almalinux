# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "microcode_ctl"
PE = "4"
PV = "20250812"
PR = "1.20260210.1.el10_1"
PACKAGES = " \
 microcode_ctl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/microcode_ctl-20250812-1.20260210.1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0fd20562a0a4362d96d2447de30cdedca28c367e554b8e71689ef2e78325109"

URI_x86_64_v2_microcode_ctl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/microcode_ctl-20250812-1.20260210.1.el10_1.noarch.rpm;name=x86_64_v2_microcode_ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_microcode_ctl}"
SRC_URI[x86_64_v2_microcode_ctl.sha256sum] = "1d8e5cc60d05e3278fee9db70d744d79491816cf5114a415afe7b7e2dfd448b6"

URI_aarch64_microcode_ctl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/microcode_ctl-20250812-1.20260210.1.el10_1.noarch.rpm;name=aarch64_microcode_ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_microcode_ctl}"
SRC_URI[aarch64_microcode_ctl.sha256sum] = "1d8e5cc60d05e3278fee9db70d744d79491816cf5114a415afe7b7e2dfd448b6"

RDEPENDS:microcode_ctl = " \
 bash \
 dracut \
 systemd \
 virtual/coreutils \
 "
