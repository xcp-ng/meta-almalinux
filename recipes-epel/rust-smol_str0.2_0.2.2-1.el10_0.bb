# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-smol_str0.2"
PV = "0.2.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-smol_str0.2+arbitrary-devel \
 rust-smol_str0.2+default-devel \
 rust-smol_str0.2+serde-devel \
 rust-smol_str0.2+std-devel \
 rust-smol_str0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-smol_str0.2-0.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0556d9fcbe7a455d4ff8a33ae0cd173caeb4cf14a77ac91d1b7ebeaa9da9aa84"

URI_x86_64_v2_rust-smol_str0.2+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.2+arbitrary-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.2+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.2+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.2+arbitrary-devel.sha256sum] = "c980466ed89a486b634d28241a318b8c33514cca5231bc231d333ccf76a36987"

URI_x86_64_v2_rust-smol_str0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.2+default-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.2+default-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.2+default-devel.sha256sum] = "adc685beb2a012eb6b898e89b1c1cf764718b7b1ebef03b5d945393de5306e61"

URI_x86_64_v2_rust-smol_str0.2+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.2+serde-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.2+serde-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.2+serde-devel.sha256sum] = "fc183bf98204e1e19f2b216a2233fa2dbbf2492814cd40d0ebe66d7d17bf25d5"

URI_x86_64_v2_rust-smol_str0.2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.2+std-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.2+std-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.2+std-devel.sha256sum] = "44dbc33dbd76ee39eb8d2d36bf577d454a8af311bfa1ebdf31dacc61b215a2ef"

URI_x86_64_v2_rust-smol_str0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-smol_str0.2-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-smol_str0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-smol_str0.2-devel}"
SRC_URI[x86_64_v2_rust-smol_str0.2-devel.sha256sum] = "1ef2391e27716927999bd3c922c0dbc00919c9c3cb55220cff9d841c26f117ba"

URI_aarch64_rust-smol_str0.2+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.2+arbitrary-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.2+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.2+arbitrary-devel}"
SRC_URI[aarch64_rust-smol_str0.2+arbitrary-devel.sha256sum] = "5be1715ef2da211b2fb0f1c8e4e95a77d47fdefbb58ac3fedac0d1e75253b56c"

URI_aarch64_rust-smol_str0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.2+default-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.2+default-devel}"
SRC_URI[aarch64_rust-smol_str0.2+default-devel.sha256sum] = "5b08ba9c5d3e579a66961c8480b4606216c913440c04b993ebe81d07135abc5f"

URI_aarch64_rust-smol_str0.2+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.2+serde-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.2+serde-devel}"
SRC_URI[aarch64_rust-smol_str0.2+serde-devel.sha256sum] = "74d6d45b71e19181bbc59c95017383dcc3f8c0688585edf60b3a1e819b0d3a03"

URI_aarch64_rust-smol_str0.2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.2+std-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.2+std-devel}"
SRC_URI[aarch64_rust-smol_str0.2+std-devel.sha256sum] = "b434481cd9488b7b11e5daf8d27546ad8c292274b13a547a1a6333ef40dfdf20"

URI_aarch64_rust-smol_str0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-smol_str0.2-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-smol_str0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-smol_str0.2-devel}"
SRC_URI[aarch64_rust-smol_str0.2-devel.sha256sum] = "7c3f59c7aa3aaf688f98052c33dadec587b110d70b543de1311a1dae4711df38"

RDEPENDS:rust-smol_str0.2+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-smol_str0.2-devel \
 "
RDEPENDS:rust-smol_str0.2+default-devel = " \
 cargo \
 rust-smol_str0.2+std-devel \
 rust-smol_str0.2-devel \
 "
RDEPENDS:rust-smol_str0.2+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-smol_str0.2-devel \
 "
RDEPENDS:rust-smol_str0.2+std-devel = " \
 cargo \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-smol_str0.2-devel \
 "
RDEPENDS:rust-smol_str0.2-devel = " \
 cargo \
 "
