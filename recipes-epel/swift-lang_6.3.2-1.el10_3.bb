# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "swift-lang"
PV = "6.3.2"
PR = "1.el10_3"
PACKAGES = " \
 swift-lang \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/swift-lang-6.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1df12e4ef8941751de934a9b627a263ab281095273d97c1046610ded07c1bb25"

URI_x86_64_v2_swift-lang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/swift-lang-6.3.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_swift-lang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_swift-lang}"
SRC_URI[x86_64_v2_swift-lang.sha256sum] = "b57c0bc831195ac9f6a46689f50085cfa86a50b4f8e609997f86419114101ae8"

URI_aarch64_swift-lang = "${EPEL_MIRROR}/aarch64/Packages/s/swift-lang-6.3.2-1.el10_3.aarch64.rpm;name=aarch64_swift-lang;unpack=0"
SRC_URI:append = " ${URI_aarch64_swift-lang}"
SRC_URI[aarch64_swift-lang.sha256sum] = "7c251579181ce9aab2f0e37d57193d256ca2d025ac432442f400b03760535f4e"

RDEPENDS:swift-lang = " \
 gcc \
 glibc \
 glibc-devel \
 libedit \
 libgcc \
 libstdc++ \
 libuuid \
 libxml2 \
 lld \
 ncurses-libs \
 python3 \
 python3-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
