# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samurai"
PV = "1.3"
PR = "1.el10_3"
PACKAGES = " \
 samurai \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/samurai-1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cee3f8ae14bbda28a849baacf8f5eb5ed340f3124cfb9f420ba4413bd6b18d0a"

URI_x86_64_v2_samurai = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/samurai-1.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_samurai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samurai}"
SRC_URI[x86_64_v2_samurai.sha256sum] = "605bf993e393149906c3c0a9a58abde34274a2613fa863ad8afbdc51f55a2ae9"

URI_aarch64_samurai = "${EPEL_MIRROR}/aarch64/Packages/s/samurai-1.3-1.el10_3.aarch64.rpm;name=aarch64_samurai;unpack=0"
SRC_URI:append = " ${URI_aarch64_samurai}"
SRC_URI[aarch64_samurai.sha256sum] = "37b28c91b6c6dbff979501eb975ed41d42cc4b5ea34a4d9ec44e40bc2c4c77bb"

RDEPENDS:samurai = " \
 glibc \
 "
