# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-tet"
PV = "0.20050108"
PR = "35.el10"
PACKAGES = " \
 hunspell-tet \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-tet-0.20050108-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "905dfc16da165811ebc414bb0ba838d0296b0ee73c3ba6fa13c4d70a99824bea"

URI_x86_64_v2_hunspell-tet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-tet-0.20050108-35.el10.noarch.rpm;name=x86_64_v2_hunspell-tet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-tet}"
SRC_URI[x86_64_v2_hunspell-tet.sha256sum] = "7370c90f912750da40e920819886e0b17ecb015d97a9199de8431cba44665422"

URI_aarch64_hunspell-tet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-tet-0.20050108-35.el10.noarch.rpm;name=aarch64_hunspell-tet;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-tet}"
SRC_URI[aarch64_hunspell-tet.sha256sum] = "7370c90f912750da40e920819886e0b17ecb015d97a9199de8431cba44665422"

RDEPENDS:hunspell-tet = " \
 hunspell-filesystem \
 "
