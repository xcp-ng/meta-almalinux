# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Package-Variant"
PV = "1.003002"
PR = "29.el10_2"
PACKAGES = " \
 perl-Package-Variant \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Package-Variant-1.003002-29.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64ad5604a4ef9f1fe8e80b9d87a348ab52df094236b4f19f8ec5ea8e1a999a62"

URI_x86_64_v2_perl-Package-Variant = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Package-Variant-1.003002-29.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Package-Variant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Package-Variant}"
SRC_URI[x86_64_v2_perl-Package-Variant.sha256sum] = "b28efb2f1314b2d0d87acd3870369706456ea485e821ddb964892da9e91a6efa"

URI_aarch64_perl-Package-Variant = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Package-Variant-1.003002-29.el10_2.noarch.rpm;name=aarch64_perl-Package-Variant;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Package-Variant}"
SRC_URI[aarch64_perl-Package-Variant.sha256sum] = "00e1594b4df0f84ab4aadb1d6db7689d7e1ad3725f668fd9f488837eb439ad00"

RDEPENDS:perl-Package-Variant = " \
 perl-Carp \
 perl-Import-Into \
 perl-Module-Runtime \
 perl-libs \
 perl-strictures \
 "
