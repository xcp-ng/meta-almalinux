# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-utf16_iter"
PV = "1.0.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-utf16_iter+default-devel \
 rust-utf16_iter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-utf16_iter-1.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "197846fd7805d33f1b8d3091a400ac4b0458550b2e8012b7c7fb9ee72bc08065"

URI_x86_64_v2_rust-utf16_iter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf16_iter+default-devel-1.0.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf16_iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf16_iter+default-devel}"
SRC_URI[x86_64_v2_rust-utf16_iter+default-devel.sha256sum] = "2fe335d95647ddc95e048593573c1fe5acfd934df2e225785d2f53f58499da91"

URI_x86_64_v2_rust-utf16_iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf16_iter-devel-1.0.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf16_iter-devel}"
SRC_URI[x86_64_v2_rust-utf16_iter-devel.sha256sum] = "66fc9d4d42f0534c93886da1881a01044462dcf006d20d1d9ced6ec5f9e17828"

URI_aarch64_rust-utf16_iter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf16_iter+default-devel-1.0.5-1.el10_1.noarch.rpm;name=aarch64_rust-utf16_iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf16_iter+default-devel}"
SRC_URI[aarch64_rust-utf16_iter+default-devel.sha256sum] = "64100a1c2d3734f39a30bd30e2caa790465bdd43068dc8d91f9bcee3d52aeb3f"

URI_aarch64_rust-utf16_iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf16_iter-devel-1.0.5-1.el10_1.noarch.rpm;name=aarch64_rust-utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf16_iter-devel}"
SRC_URI[aarch64_rust-utf16_iter-devel.sha256sum] = "8a78cd0c9db29bb4c109d45a02756d71c8549a801d544739b4ff40fcbff30a11"

RDEPENDS:rust-utf16_iter+default-devel = " \
 cargo \
 rust-utf16_iter-devel \
 "
RDEPENDS:rust-utf16_iter-devel = " \
 cargo \
 "
