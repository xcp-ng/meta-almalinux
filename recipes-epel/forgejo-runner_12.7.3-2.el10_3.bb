# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "forgejo-runner"
PV = "12.7.3"
PR = "2.el10_3"
PACKAGES = " \
 forgejo-runner \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/forgejo-runner-12.7.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afc510b1b727fb5e99a0cb4ef1a5c37fefaf0ec34c0698b80647a59b5402c9f8"

URI_x86_64_v2_forgejo-runner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/forgejo-runner-12.7.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_forgejo-runner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_forgejo-runner}"
SRC_URI[x86_64_v2_forgejo-runner.sha256sum] = "4cd73502bb3f9ba721d055feecdada5a8e81a97061470962b356e6d7272a6e7a"

URI_aarch64_forgejo-runner = "${EPEL_MIRROR}/aarch64/Packages/f/forgejo-runner-12.7.3-2.el10_3.aarch64.rpm;name=aarch64_forgejo-runner;unpack=0"
SRC_URI:append = " ${URI_aarch64_forgejo-runner}"
SRC_URI[aarch64_forgejo-runner.sha256sum] = "6cfd8b476c70252723586deca5723d0d29f571d8057b558b9c5027a38be7721e"

RDEPENDS:forgejo-runner = " \
 bash \
 git-core \
 git-lfs \
 glibc \
 shadow-utils \
 "
