# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Darwin-InitObjC"
PV = "0.001"
PR = "1.el10_1"
PACKAGES = " \
 perl-Darwin-InitObjC \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Darwin-InitObjC-0.001-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c370ac550aa210957f735240d126c3f56926996a9327175f51b9e3a2d3d1fcf3"

URI_x86_64_v2_perl-Darwin-InitObjC = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Darwin-InitObjC-0.001-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Darwin-InitObjC;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Darwin-InitObjC}"
SRC_URI[x86_64_v2_perl-Darwin-InitObjC.sha256sum] = "27da4b0df0970ecde33654510fd9027ed873bd00c850be08d3a1780ad32a8fe5"

URI_aarch64_perl-Darwin-InitObjC = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Darwin-InitObjC-0.001-1.el10_1.noarch.rpm;name=aarch64_perl-Darwin-InitObjC;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Darwin-InitObjC}"
SRC_URI[aarch64_perl-Darwin-InitObjC.sha256sum] = "4ca9f9e0302775f5531a143164e448734b0f9f155a1c28e0da2fb510b592f1f5"

RDEPENDS:perl-Darwin-InitObjC = " \
 perl-DynaLoader \
 perl-libs \
 "
