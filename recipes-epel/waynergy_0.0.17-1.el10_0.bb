# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "waynergy"
PV = "0.0.17"
PR = "1.el10_0"
PACKAGES = " \
 waynergy \
 waynergy-kde \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/waynergy-0.0.17-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e24c196217747ef59cca74c11a4e32de9b0ffe23615411929dfa8f40e9e53ad5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waynergy-0.0.17-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_waynergy;unpack=0"
SRC_URI[x86_64_v2_waynergy.sha256sum] = "8679fbdd5fabad25ce18070bbcd11778f78060f0d3fa91458c7c66f805c80988"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/waynergy-kde-0.0.17-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_waynergy-kde;unpack=0"
SRC_URI[x86_64_v2_waynergy-kde.sha256sum] = "de9d48fa4b11ee769722fd26932ce21c4f59638443aa3afc5ced2c0b75c30728"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/waynergy-0.0.17-1.el10_0.aarch64.rpm;name=aarch64_waynergy;unpack=0"
SRC_URI[aarch64_waynergy.sha256sum] = "aa20669e306ea6013c8aea02497427a014f9f96a675197a49b99e27c09794a85"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/waynergy-kde-0.0.17-1.el10_0.noarch.rpm;name=aarch64_waynergy-kde;unpack=0"
SRC_URI[aarch64_waynergy-kde.sha256sum] = "df10d692da2de708208f6a2c793179689967451aa0f8da9544e6254a26779e74"

RDEPENDS:waynergy = " \
 glibc \
 libretls \
 libwayland-client \
 libxkbcommon \
 wl-clipboard \
 "
RDEPENDS:waynergy-kde = " \
 waynergy \
 "
