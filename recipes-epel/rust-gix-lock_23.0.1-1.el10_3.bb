# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-lock"
PV = "23.0.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-lock+default-devel \
 rust-gix-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-lock-23.0.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf792f6f37277e4f67ec4aacb947c6780c8589f7c2e4039109b82ae8e3b875e0"

URI_x86_64_v2_rust-gix-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-lock+default-devel-23.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-lock+default-devel}"
SRC_URI[x86_64_v2_rust-gix-lock+default-devel.sha256sum] = "d8b228c7ebfff4e2bb36e3e39ebc839488705dc9cc90a81e5ba7b23d5f7602dd"

URI_x86_64_v2_rust-gix-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-lock-devel-23.0.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-lock-devel}"
SRC_URI[x86_64_v2_rust-gix-lock-devel.sha256sum] = "bc6709219017e94fa6f5db085b4ad3dc6fe1e48d8ed456dd5298b3b0c9b66649"

URI_aarch64_rust-gix-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-lock+default-devel-23.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-lock+default-devel}"
SRC_URI[aarch64_rust-gix-lock+default-devel.sha256sum] = "92ae8ee0abe62c1490b0959b57d0798fa4e4f7d5861e11a38640ddf3312e8d90"

URI_aarch64_rust-gix-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-lock-devel-23.0.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-lock-devel}"
SRC_URI[aarch64_rust-gix-lock-devel.sha256sum] = "c6a4f1b2b098831900e75ea419a1a9bd59ca377acb5babe87758874d3210edf8"

RDEPENDS:rust-gix-lock+default-devel = " \
 cargo \
 rust-gix-lock-devel \
 "
RDEPENDS:rust-gix-lock-devel = " \
 cargo \
 rust \
 rust-gix-tempfile-devel \
 rust-gix-utils-devel \
 rust-thiserror+default-devel \
 "
