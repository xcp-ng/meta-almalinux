# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-ucd-hangul"
PV = "0.9.0"
PR = "5.el10_1"
PACKAGES = " \
 rust-unic-ucd-hangul+default-devel \
 rust-unic-ucd-hangul-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-ucd-hangul-0.9.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b427d0e2b5057dac03d70373cf93807a2329a995d95c4066322fc3047143621f"

URI_x86_64_v2_rust-unic-ucd-hangul+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-hangul+default-devel-0.9.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-hangul+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-hangul+default-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-hangul+default-devel.sha256sum] = "89eeebbda756960d9985c9561fe74668fb05ea879abcd73a0c45114d1168d524"

URI_x86_64_v2_rust-unic-ucd-hangul-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-hangul-devel-0.9.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-hangul-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-hangul-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-hangul-devel.sha256sum] = "86a15ed95ae1d7b8f33968cb0789b8e1cd16cbdaa960f73c0b8b060a605171d7"

URI_aarch64_rust-unic-ucd-hangul+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-hangul+default-devel-0.9.0-5.el10_1.noarch.rpm;name=aarch64_rust-unic-ucd-hangul+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-hangul+default-devel}"
SRC_URI[aarch64_rust-unic-ucd-hangul+default-devel.sha256sum] = "d6c1db0f313a4a910c526b4cf6e50a3acbb119c6819f0f4379db572ae3536508"

URI_aarch64_rust-unic-ucd-hangul-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-hangul-devel-0.9.0-5.el10_1.noarch.rpm;name=aarch64_rust-unic-ucd-hangul-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-hangul-devel}"
SRC_URI[aarch64_rust-unic-ucd-hangul-devel.sha256sum] = "4eb9d801e9d26fc4f1e578ce484a734aa87a9bfabe9d01722f9864422aac0552"

RDEPENDS:rust-unic-ucd-hangul+default-devel = " \
 cargo \
 rust-unic-ucd-hangul-devel \
 "
RDEPENDS:rust-unic-ucd-hangul-devel = " \
 cargo \
 rust-unic-ucd-version+default-devel \
 "
