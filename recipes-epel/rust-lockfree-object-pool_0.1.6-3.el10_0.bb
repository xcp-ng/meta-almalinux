# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lockfree-object-pool"
PV = "0.1.6"
PR = "3.el10_0"
PACKAGES = " \
 rust-lockfree-object-pool+default-devel \
 rust-lockfree-object-pool-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lockfree-object-pool-0.1.6-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "95842ee255a0af6ad66893e77fd87660f41ea74798ef7bc52fcfefa786d4237f"

URI_x86_64_v2_rust-lockfree-object-pool+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lockfree-object-pool+default-devel-0.1.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lockfree-object-pool+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lockfree-object-pool+default-devel}"
SRC_URI[x86_64_v2_rust-lockfree-object-pool+default-devel.sha256sum] = "a4ab2f0e9b8cdf5f65be277a51c3b5ac923a57f85b69492107f3e7669a8ba61f"

URI_x86_64_v2_rust-lockfree-object-pool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lockfree-object-pool-devel-0.1.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lockfree-object-pool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lockfree-object-pool-devel}"
SRC_URI[x86_64_v2_rust-lockfree-object-pool-devel.sha256sum] = "872a82d1ee37b415c946e111e7e6ec11c0a82ebec0db043b5b0c4bdf49b1da08"

URI_aarch64_rust-lockfree-object-pool+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lockfree-object-pool+default-devel-0.1.6-3.el10_0.noarch.rpm;name=aarch64_rust-lockfree-object-pool+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lockfree-object-pool+default-devel}"
SRC_URI[aarch64_rust-lockfree-object-pool+default-devel.sha256sum] = "cc2d58a426ed2e6aa508c31afbcebb6daee20186a1cfbe93347bdeb3709b718d"

URI_aarch64_rust-lockfree-object-pool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lockfree-object-pool-devel-0.1.6-3.el10_0.noarch.rpm;name=aarch64_rust-lockfree-object-pool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lockfree-object-pool-devel}"
SRC_URI[aarch64_rust-lockfree-object-pool-devel.sha256sum] = "2190038f72cde5e916496c3d4cc6187d02df79a6878e84940e5c2022eadb85af"

RDEPENDS:rust-lockfree-object-pool+default-devel = " \
 cargo \
 rust-lockfree-object-pool-devel \
 "
RDEPENDS:rust-lockfree-object-pool-devel = " \
 cargo \
 "
