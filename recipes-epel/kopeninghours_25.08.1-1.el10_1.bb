# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kopeninghours"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kopeninghours \
 kopeninghours-devel \
 kopeninghours-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kopeninghours-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fccb3447773548767a1c5c9ac5686fc095ecc67454dab54b83fda4c2e1c64d5e"

URI_x86_64_v2_kopeninghours = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours}"
SRC_URI[x86_64_v2_kopeninghours.sha256sum] = "e95efd721c598b07c1e56e96438147d320f3330c4852791116415c92e22186ad"

URI_x86_64_v2_kopeninghours-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours-devel}"
SRC_URI[x86_64_v2_kopeninghours-devel.sha256sum] = "4ce1af059b4faa2db1a00fa7d1c083542f56b1cc1799fe034ef9068420d9f76d"

URI_x86_64_v2_kopeninghours-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kopeninghours-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kopeninghours-doc}"
SRC_URI[x86_64_v2_kopeninghours-doc.sha256sum] = "aa4a18edfc978e7da2974449e8f03c9543110b61e2471a0a847830a455611d47"

URI_aarch64_kopeninghours = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kopeninghours;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours}"
SRC_URI[aarch64_kopeninghours.sha256sum] = "17aa5bb533be2e46482e269b547b109a2bbebd73051fc10e1de9d8ee2d9c0b2f"

URI_aarch64_kopeninghours-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kopeninghours-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours-devel}"
SRC_URI[aarch64_kopeninghours-devel.sha256sum] = "fc92731df4a54bd7c40c2499743a2e6f399cedd9246ae5e4d6a7fed27b1f639f"

URI_aarch64_kopeninghours-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kopeninghours-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kopeninghours-doc}"
SRC_URI[aarch64_kopeninghours-doc.sha256sum] = "eee7790d2534404cccaaf4ec5bca37c000a109c07cea5cbdbf4bc26a4eb868b9"

RDEPENDS:kopeninghours = " \
 boost-python3 \
 glibc \
 kf6-filesystem \
 kf6-kholidays \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kopeninghours-devel = " \
 cmake-filesystem \
 kopeninghours \
 "
RDEPENDS:kopeninghours-doc = " \
 "
