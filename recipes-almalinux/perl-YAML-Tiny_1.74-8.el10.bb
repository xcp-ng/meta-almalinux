# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-YAML-Tiny"
PV = "1.74"
PR = "8.el10"
PACKAGES = " \
 perl-YAML-Tiny \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-YAML-Tiny-1.74-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e7940a4e8a1f813282a82e4b4535e48744c674b643cbd0317649db34269a491"

URI_x86_64_v2_perl-YAML-Tiny = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-YAML-Tiny-1.74-8.el10.noarch.rpm;name=x86_64_v2_perl-YAML-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-YAML-Tiny}"
SRC_URI[x86_64_v2_perl-YAML-Tiny.sha256sum] = "19afed3b82db8ca67a1203204da0210f8fd1b714548d8367a494d422b402032f"

URI_aarch64_perl-YAML-Tiny = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-YAML-Tiny-1.74-8.el10.noarch.rpm;name=aarch64_perl-YAML-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-YAML-Tiny}"
SRC_URI[aarch64_perl-YAML-Tiny.sha256sum] = "19afed3b82db8ca67a1203204da0210f8fd1b714548d8367a494d422b402032f"

RDEPENDS:perl-YAML-Tiny = " \
 perl-B \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-Scalar-List-Utils \
 perl-libs \
 "
