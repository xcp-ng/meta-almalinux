# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klickety"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 klickety \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/klickety-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "92cac1ddd2349121fc62276a295f6767f9d2b485cbb4d9d1acea70fd4db0a8cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klickety-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klickety;unpack=0"
SRC_URI[x86_64_v2_klickety.sha256sum] = "be3d95a22ffaa2d17e5dd2c9b1fa8bc40d6a9ba37ef76fa738925ddc0c7334c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/klickety-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_klickety;unpack=0"
SRC_URI[aarch64_klickety.sha256sum] = "99fbb9b8e90fae9950efe48225ca7e4086f4b452dedf7a668b149ea751417ad5"

RDEPENDS:klickety = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
