# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-uvloop"
PV = "0.21.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-uvloop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-uvloop-0.21.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2fd00fce879c8d31a7d60d21f2be7ce2bba2b7edb30f76c88a5be97d43b1349c"

URI_x86_64_v2_python3-uvloop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uvloop-0.21.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-uvloop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-uvloop}"
SRC_URI[x86_64_v2_python3-uvloop.sha256sum] = "9a01e955ef9b861dacab832accb2c952444ec7c0464b70625a43f0714609146e"

URI_aarch64_python3-uvloop = "${EPEL_MIRROR}/aarch64/Packages/p/python3-uvloop-0.21.0-1.el10_1.aarch64.rpm;name=aarch64_python3-uvloop;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-uvloop}"
SRC_URI[aarch64_python3-uvloop.sha256sum] = "49bac914441edd17813f1b60d68104f9c3919e810343346bdc98bc0ddf15e674"

RDEPENDS:python3-uvloop = " \
 glibc \
 libuv \
 python3 \
 "
