# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "astyle"
PV = "3.6.6"
PR = "2.el10_0"
PACKAGES = " \
 astyle \
 astyle-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/astyle-3.6.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2206f571c32280954522e6e7a7ae9057840c1a36ccf083b8e803a7f6f8aa165f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/astyle-3.6.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_astyle;unpack=0"
SRC_URI[x86_64_v2_astyle.sha256sum] = "3a7351eab7377d8aef08e91630ac3c856df826886a1c87eb95eba691037fbef8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/astyle-devel-3.6.6-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_astyle-devel;unpack=0"
SRC_URI[x86_64_v2_astyle-devel.sha256sum] = "7f942e12f406e7d2474691dbae2142c628188d01f55e7ad4fa10a5f4137feb34"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/astyle-3.6.6-2.el10_0.aarch64.rpm;name=aarch64_astyle;unpack=0"
SRC_URI[aarch64_astyle.sha256sum] = "4ebc15a2e6e65c1af955f74afc870471f0841517dcf084b7229aa8063ffe4139"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/astyle-devel-3.6.6-2.el10_0.aarch64.rpm;name=aarch64_astyle-devel;unpack=0"
SRC_URI[aarch64_astyle-devel.sha256sum] = "c31ce3aec4f8e074fb29b20341d901486b5f26f8481a0b0b2d35f0df3ec22dfc"

RDEPENDS:astyle = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:astyle-devel = " \
 astyle \
 "
