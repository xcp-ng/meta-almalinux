# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hplip"
PV = "3.23.12"
PR = "10.el10"
PACKAGES = " \
 hplip \
 hplip-common \
 hplip-libs \
 libsane-hpaio \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hplip-3.23.12-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6a2182c3bcbb455144a381a7528c67d81e1170b7f7afd642be860a5bb93e0fa"

URI_x86_64_v2_hplip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hplip-3.23.12-10.el10.x86_64_v2.rpm;name=x86_64_v2_hplip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hplip}"
SRC_URI[x86_64_v2_hplip.sha256sum] = "2763a78773249b2f3d91eae6781cb0a81334903bd614d723ac44c88b9934f4a8"

URI_x86_64_v2_hplip-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hplip-common-3.23.12-10.el10.x86_64_v2.rpm;name=x86_64_v2_hplip-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hplip-common}"
SRC_URI[x86_64_v2_hplip-common.sha256sum] = "0341bb7042d9bdcb764b9d2636d83c25bd330a7fa3bfa18fcc5fbdfd95120903"

URI_x86_64_v2_hplip-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hplip-libs-3.23.12-10.el10.x86_64_v2.rpm;name=x86_64_v2_hplip-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hplip-libs}"
SRC_URI[x86_64_v2_hplip-libs.sha256sum] = "2d8f17af88c12ad2215b8b1aa6e610b8ad9d8fa89aaff2b60c5bda18fd7fcc8d"

URI_x86_64_v2_libsane-hpaio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsane-hpaio-3.23.12-10.el10.x86_64_v2.rpm;name=x86_64_v2_libsane-hpaio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsane-hpaio}"
SRC_URI[x86_64_v2_libsane-hpaio.sha256sum] = "1bdf41013a5a9c8142ccbcc244ce4528dd2af161fd0f3088ebf1fb2ac5815ce4"

URI_aarch64_hplip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hplip-3.23.12-10.el10.aarch64.rpm;name=aarch64_hplip;unpack=0"
SRC_URI:append = " ${URI_aarch64_hplip}"
SRC_URI[aarch64_hplip.sha256sum] = "a92fa9a3283e8e7b368fd706456650887716d69e8ba3e7d6790ca8dbd0bd9088"

URI_aarch64_hplip-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hplip-common-3.23.12-10.el10.aarch64.rpm;name=aarch64_hplip-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_hplip-common}"
SRC_URI[aarch64_hplip-common.sha256sum] = "ad36f2afe09de7d23409a1eeb0cd181fdfe3d07fcbe9b5e893d1b337ab4a32c1"

URI_aarch64_hplip-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hplip-libs-3.23.12-10.el10.aarch64.rpm;name=aarch64_hplip-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_hplip-libs}"
SRC_URI[aarch64_hplip-libs.sha256sum] = "1155992de1798843438b6d1b2064ba8e6ed3b737d50b865d040359a076dc2bbf"

URI_aarch64_libsane-hpaio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsane-hpaio-3.23.12-10.el10.aarch64.rpm;name=aarch64_libsane-hpaio;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsane-hpaio}"
SRC_URI[aarch64_libsane-hpaio.sha256sum] = "50d5f0f8276d7b247eb12801c780a466c4337c629c196fb3b22753020f444020"

RDEPENDS:hplip = " \
 bash \
 cups \
 cups-libs \
 curl \
 dbus-libs \
 gawk \
 glibc \
 gnupg2 \
 hplip-libs \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 python3 \
 python3-dbus \
 systemd \
 tar \
 usbutils \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:hplip-common = " \
 "
RDEPENDS:hplip-libs = " \
 avahi \
 avahi-libs \
 cups-libs \
 dbus-libs \
 glibc \
 hplip-common \
 libusb1 \
 net-snmp-libs \
 openssl-libs \
 python3 \
 sane-backends-libs \
 "
RDEPENDS:libsane-hpaio = " \
 avahi \
 avahi-libs \
 cups-libs \
 dbus-libs \
 glibc \
 hplip-libs \
 libusb1 \
 net-snmp-libs \
 openssl-libs \
 sane-backends \
 "
