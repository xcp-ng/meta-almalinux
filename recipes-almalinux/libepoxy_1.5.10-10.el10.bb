# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libepoxy"
PV = "1.5.10"
PR = "10.el10"
PACKAGES = " \
 libepoxy \
 libepoxy-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libepoxy-1.5.10-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48a87b7b7b53e55b3357b4a92952b75a9cbd7e8aa04d897b42d1e29bbd425e95"

URI_x86_64_v2_libepoxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libepoxy-1.5.10-10.el10.x86_64_v2.rpm;name=x86_64_v2_libepoxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libepoxy}"
SRC_URI[x86_64_v2_libepoxy.sha256sum] = "c5bd0919139570c93567fd117e9d72f9aacdea3e17fdcb77731613494dbf9193"

URI_x86_64_v2_libepoxy-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libepoxy-devel-1.5.10-10.el10.x86_64_v2.rpm;name=x86_64_v2_libepoxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libepoxy-devel}"
SRC_URI[x86_64_v2_libepoxy-devel.sha256sum] = "7267c15775fb5c4f225a1ef52bf56f3f9ae94087685d93687d341d729721b664"

URI_aarch64_libepoxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libepoxy-1.5.10-10.el10.aarch64.rpm;name=aarch64_libepoxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_libepoxy}"
SRC_URI[aarch64_libepoxy.sha256sum] = "30d13b7d822f5abe764ffa10876324396d4fae6da31c7b69aafa4a0768878e77"

URI_aarch64_libepoxy-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libepoxy-devel-1.5.10-10.el10.aarch64.rpm;name=aarch64_libepoxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libepoxy-devel}"
SRC_URI[aarch64_libepoxy-devel.sha256sum] = "5d3a2fc624490424d7f8698048d698a9f23e51012cb5fbcd480c92727a610c32"

RDEPENDS:libepoxy = " \
 glibc \
 "
RDEPENDS:libepoxy-devel = " \
 libX11-devel \
 libepoxy \
 libglvnd-devel \
 pkgconf-pkg-config \
 "
