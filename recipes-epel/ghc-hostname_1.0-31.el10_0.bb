# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hostname"
PV = "1.0"
PR = "31.el10_0"
PACKAGES = " \
 ghc-hostname \
 ghc-hostname-devel \
 ghc-hostname-doc \
 ghc-hostname-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-hostname-1.0-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9ef67f480bf472359ee778aa249e2364ef26c55fdb73d77db0e16e5f18985f72"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hostname-1.0-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hostname;unpack=0"
SRC_URI[x86_64_v2_ghc-hostname.sha256sum] = "bc9674b8ab47cb4f7358aa4a3fbea401b22123aaa40cd66e2b1e508e02a0351f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hostname-devel-1.0-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hostname-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-hostname-devel.sha256sum] = "6a42d97cbcfe9031c9e58587f391c4e07687463015b12f556946f56e4b3a19c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hostname-doc-1.0-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hostname-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-hostname-doc.sha256sum] = "4578b4c9c5b7e5b03378218124984f8bdd27925c75a3789667ce8f38c55f78ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hostname-prof-1.0-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hostname-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-hostname-prof.sha256sum] = "546c9a7e15aea6070a27296463c67c90d7adda53ba2bfe3661524ccf0e2c28e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-hostname-1.0-31.el10_0.aarch64.rpm;name=aarch64_ghc-hostname;unpack=0"
SRC_URI[aarch64_ghc-hostname.sha256sum] = "c990e8a412141386825bd196873d1c2e2c0a9ea138fbb4d308d2ac477d61ec00"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-hostname-devel-1.0-31.el10_0.aarch64.rpm;name=aarch64_ghc-hostname-devel;unpack=0"
SRC_URI[aarch64_ghc-hostname-devel.sha256sum] = "1d746f161a94f3d3efa7386dae5197d5ee9d2b9cd62019eb1435a46b545ae8e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-hostname-doc-1.0-31.el10_0.noarch.rpm;name=aarch64_ghc-hostname-doc;unpack=0"
SRC_URI[aarch64_ghc-hostname-doc.sha256sum] = "1c2a8e060443d8889a1c037038108e4629f2b4ec004f62ca2349edba3919896f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-hostname-prof-1.0-31.el10_0.aarch64.rpm;name=aarch64_ghc-hostname-prof;unpack=0"
SRC_URI[aarch64_ghc-hostname-prof.sha256sum] = "16d699300f86273f09311bf071d49d2fd1dda546dc2f09842cd0a7a095a3d430"

RDEPENDS:ghc-hostname = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hostname-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-hostname \
 "
RDEPENDS:ghc-hostname-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hostname-prof = " \
 ghc-base-prof \
 ghc-hostname-devel \
 "
