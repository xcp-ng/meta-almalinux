# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mpmath"
PV = "1.3.0"
PR = "13.el10_1"
PACKAGES = " \
 python3-mpmath \
 python3-mpmath+gmpy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mpmath-1.3.0-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a18fd79eed968241a0acc55038134617f3951cf1de01d1d46dd78c89bcfde94e"

URI_x86_64_v2_python3-mpmath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mpmath-1.3.0-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mpmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mpmath}"
SRC_URI[x86_64_v2_python3-mpmath.sha256sum] = "605c1e770ee8f8dba2ce811c6e7e05fb2107bb225f0f47eb34efa7f9211d6e0c"

URI_x86_64_v2_python3-mpmath+gmpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mpmath+gmpy-1.3.0-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mpmath+gmpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mpmath+gmpy}"
SRC_URI[x86_64_v2_python3-mpmath+gmpy.sha256sum] = "3c16dd884de4833960781148bea26970b5850476c1ce66ab0e3fff1e10cc03ca"

URI_aarch64_python3-mpmath = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mpmath-1.3.0-13.el10_1.noarch.rpm;name=aarch64_python3-mpmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mpmath}"
SRC_URI[aarch64_python3-mpmath.sha256sum] = "45a6f6ee5608fdf7b1ee28c398825d32f99fcecc77196c8c50281cac8ef93f2e"

URI_aarch64_python3-mpmath+gmpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mpmath+gmpy-1.3.0-13.el10_1.noarch.rpm;name=aarch64_python3-mpmath+gmpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mpmath+gmpy}"
SRC_URI[aarch64_python3-mpmath+gmpy.sha256sum] = "3655dab63eaf78c518d393d987a3588fb32eca65588455fb122dc21fb9ab0bb2"

RDEPENDS:python3-mpmath = " \
 python3 \
 "
RDEPENDS:python3-mpmath+gmpy = " \
 python3 \
 python3-gmpy2 \
 python3-mpmath \
 "
