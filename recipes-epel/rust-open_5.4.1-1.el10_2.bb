# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-open"
PV = "5.4.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-open+default-devel \
 rust-open-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-open-5.4.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f09c16e485c362783ab0f9c7c8e71b119e16a1656d3719a2ce1eea3ed89ccc1"

URI_x86_64_v2_rust-open+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open+default-devel-5.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-open+default-devel}"
SRC_URI[x86_64_v2_rust-open+default-devel.sha256sum] = "515d95151cdf004cbf3963deee78d126b66a3421c624233c837de1b25783c85c"

URI_x86_64_v2_rust-open-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open-devel-5.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-open-devel}"
SRC_URI[x86_64_v2_rust-open-devel.sha256sum] = "5558917abae6de81e5e556f9906a3eb346470996421b026ce6ab8d1634537278"

URI_aarch64_rust-open+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-open+default-devel-5.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-open+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-open+default-devel}"
SRC_URI[aarch64_rust-open+default-devel.sha256sum] = "6f4e6506d4adb2e1ef6e0ab7a4ae4163fdd0de93b76449c11ab365c406ed3dd0"

URI_aarch64_rust-open-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-open-devel-5.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-open-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-open-devel}"
SRC_URI[aarch64_rust-open-devel.sha256sum] = "bf56c733216cc3dc5e3ce6b6135e59d15f7b9269a23e16dd58d3cf5223a164cd"

RDEPENDS:rust-open+default-devel = " \
 cargo \
 rust-open-devel \
 "
RDEPENDS:rust-open-devel = " \
 cargo \
 rust \
 rust-is-wsl+default-devel \
 rust-libc+default-devel \
 "
