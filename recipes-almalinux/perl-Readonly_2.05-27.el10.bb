# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Readonly"
PV = "2.05"
PR = "27.el10"
PACKAGES = " \
 perl-Readonly \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Readonly-2.05-27.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f0c7af7b31c3ef9696551318efd97519270e4474c20d0d8f2f6322988bcba963"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Readonly-2.05-27.el10.noarch.rpm;name=x86_64_v2_perl-Readonly;unpack=0"
SRC_URI[x86_64_v2_perl-Readonly.sha256sum] = "a1f5d72b5fbe6be78c1d1da786191d504c911a5c4dbcba1a1932c088d057c5b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Readonly-2.05-27.el10.noarch.rpm;name=aarch64_perl-Readonly;unpack=0"
SRC_URI[aarch64_perl-Readonly.sha256sum] = "a1f5d72b5fbe6be78c1d1da786191d504c911a5c4dbcba1a1932c088d057c5b3"

RDEPENDS:perl-Readonly = " \
 perl-Carp \
 perl-Exporter \
 perl-Storable \
 perl-libs \
 perl-vars \
 "
