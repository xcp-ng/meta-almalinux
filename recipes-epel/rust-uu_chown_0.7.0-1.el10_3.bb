# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_chown"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_chown+default-devel \
 rust-uu_chown-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_chown-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c6db89a362ad4b6344e82fdea4c957d787c6c63454c9318e9979d85d3f0240d"

URI_x86_64_v2_rust-uu_chown+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chown+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chown+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chown+default-devel}"
SRC_URI[x86_64_v2_rust-uu_chown+default-devel.sha256sum] = "364d9086efe221bd171bb88b7982f67258a9e9307b8d399b2ff19c964b26f0af"

URI_x86_64_v2_rust-uu_chown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_chown-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_chown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_chown-devel}"
SRC_URI[x86_64_v2_rust-uu_chown-devel.sha256sum] = "e77c3c13ed27c2943994344b2060a7391bd1e372699861a7e1e94942cfd5f506"

URI_aarch64_rust-uu_chown+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chown+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chown+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chown+default-devel}"
SRC_URI[aarch64_rust-uu_chown+default-devel.sha256sum] = "8aed7aae85c4bde6fab24286e6987a7b114b5cecf799874ee50fef46a64972ec"

URI_aarch64_rust-uu_chown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_chown-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_chown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_chown-devel}"
SRC_URI[aarch64_rust-uu_chown-devel.sha256sum] = "d366bb814ce1be951a9f709e08a593b7b5ca3a3958833339219392dd8acfe8c2"

RDEPENDS:rust-uu_chown+default-devel = " \
 cargo \
 rust-uu_chown-devel \
 "
RDEPENDS:rust-uu_chown-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+entries-devel \
 rust-uucore+fs-devel \
 rust-uucore+perms-devel \
 rust-uucore+safe-traversal-devel \
 "
