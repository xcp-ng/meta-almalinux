# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squashfs-tools-ng"
PV = "1.3.2"
PR = "1.el10_0"
PACKAGES = " \
 squashfs-tools-ng \
 squashfs-tools-ng-devel \
 squashfs-tools-ng-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/squashfs-tools-ng-1.3.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62177a03a194d42616e5715804eb0ad13533668fdfb83505794a0aa95c5e7b4b"

URI_x86_64_v2_squashfs-tools-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squashfs-tools-ng-1.3.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squashfs-tools-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squashfs-tools-ng}"
SRC_URI[x86_64_v2_squashfs-tools-ng.sha256sum] = "065bf2d8f5fa87dd4162b6b4ea19b21c564f4d2fd6d13785c646bdf0193a20d0"

URI_x86_64_v2_squashfs-tools-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squashfs-tools-ng-devel-1.3.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squashfs-tools-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squashfs-tools-ng-devel}"
SRC_URI[x86_64_v2_squashfs-tools-ng-devel.sha256sum] = "d8836685fd512ecad2cf97d465e0efbbdc2cf9be5a08a985443e484d4364e76e"

URI_x86_64_v2_squashfs-tools-ng-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squashfs-tools-ng-libs-1.3.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squashfs-tools-ng-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squashfs-tools-ng-libs}"
SRC_URI[x86_64_v2_squashfs-tools-ng-libs.sha256sum] = "22d688d02746c33f3f715f6af619f958429473c74d60122a639ad115ab20b4ca"

URI_aarch64_squashfs-tools-ng = "${EPEL_MIRROR}/aarch64/Packages/s/squashfs-tools-ng-1.3.2-1.el10_0.aarch64.rpm;name=aarch64_squashfs-tools-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_squashfs-tools-ng}"
SRC_URI[aarch64_squashfs-tools-ng.sha256sum] = "4b429cd0a238bda13a146875063daffe280b4dda196769973331783136aab75e"

URI_aarch64_squashfs-tools-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/s/squashfs-tools-ng-devel-1.3.2-1.el10_0.aarch64.rpm;name=aarch64_squashfs-tools-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_squashfs-tools-ng-devel}"
SRC_URI[aarch64_squashfs-tools-ng-devel.sha256sum] = "fc9fbc24917d51a96b187ce75df86db1b2be3e4eac639d53227a249cc84d1f89"

URI_aarch64_squashfs-tools-ng-libs = "${EPEL_MIRROR}/aarch64/Packages/s/squashfs-tools-ng-libs-1.3.2-1.el10_0.aarch64.rpm;name=aarch64_squashfs-tools-ng-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_squashfs-tools-ng-libs}"
SRC_URI[aarch64_squashfs-tools-ng-libs.sha256sum] = "20219927b70f7b9acdc675c311d5817482e960a30859ab67ea7865a0ed2f8d31"

RDEPENDS:squashfs-tools-ng = " \
 glibc \
 libselinux \
 libzstd \
 lzo \
 squashfs-tools-ng-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:squashfs-tools-ng-devel = " \
 libzstd-devel \
 lz4-devel \
 pkgconf-pkg-config \
 squashfs-tools-ng-libs \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:squashfs-tools-ng-libs = " \
 glibc \
 libzstd \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "
