# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-haxr"
PV = "3000.11.5"
PR = "6.el10_0"
PACKAGES = " \
 ghc-haxr \
 ghc-haxr-devel \
 ghc-haxr-doc \
 ghc-haxr-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-haxr-3000.11.5-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa1dbf228cfe28156f0328b68dd699c72a2744a2e10e21361ed9b118a35592f1"

URI_x86_64_v2_ghc-haxr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haxr-3000.11.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haxr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haxr}"
SRC_URI[x86_64_v2_ghc-haxr.sha256sum] = "a881c48320b760930c98f65cc1549b96096db500ae080d44af8205d5bfa2b9d0"

URI_x86_64_v2_ghc-haxr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haxr-devel-3000.11.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haxr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haxr-devel}"
SRC_URI[x86_64_v2_ghc-haxr-devel.sha256sum] = "46cdeb461659d7160c19ee1a36b647fed56f1df89a3bf1430393f84f247fb916"

URI_x86_64_v2_ghc-haxr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haxr-doc-3000.11.5-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-haxr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haxr-doc}"
SRC_URI[x86_64_v2_ghc-haxr-doc.sha256sum] = "cd170dd4331e6e71ed5bbfdd73e2732d249299fddfb4a9c0acc634f9280e7593"

URI_x86_64_v2_ghc-haxr-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haxr-prof-3000.11.5-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haxr-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haxr-prof}"
SRC_URI[x86_64_v2_ghc-haxr-prof.sha256sum] = "1ed237528fcd693ce84577d927b40c44ca18e9beb30869a802737bd1552b7924"

URI_aarch64_ghc-haxr = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haxr-3000.11.5-6.el10_0.aarch64.rpm;name=aarch64_ghc-haxr;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haxr}"
SRC_URI[aarch64_ghc-haxr.sha256sum] = "30c866b30ed4dc4dfa12527fd1a4e3a91f1d02abb56fa8b05bcb9b2b76d6eeb8"

URI_aarch64_ghc-haxr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haxr-devel-3000.11.5-6.el10_0.aarch64.rpm;name=aarch64_ghc-haxr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haxr-devel}"
SRC_URI[aarch64_ghc-haxr-devel.sha256sum] = "4f0bc45c55a00f28017d38c107cc305c430e0fe8e694830daf31db7d7fb006ff"

URI_aarch64_ghc-haxr-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haxr-doc-3000.11.5-6.el10_0.noarch.rpm;name=aarch64_ghc-haxr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haxr-doc}"
SRC_URI[aarch64_ghc-haxr-doc.sha256sum] = "6fef949b99e6d5af316edcfd1eb9683b5354717eab0afd70b14448d189597a49"

URI_aarch64_ghc-haxr-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haxr-prof-3000.11.5-6.el10_0.aarch64.rpm;name=aarch64_ghc-haxr-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haxr-prof}"
SRC_URI[aarch64_ghc-haxr-prof.sha256sum] = "80c19967bd08fddabdea2ba2f9423acc4dd9c0cf2d899e3edc5547467af77717"

RDEPENDS:ghc-haxr = " \
 ghc-HaXml \
 ghc-HsOpenSSL \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-bifunctors \
 ghc-binary \
 ghc-blaze-builder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-common \
 ghc-http-streams \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-io-streams \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-openssl-streams \
 ghc-os-string \
 ghc-parsec \
 ghc-polyparse \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 ghc-zlib-bindings \
 glibc \
 gmp \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-haxr-devel = " \
 ghc-HaXml-devel \
 ghc-HsOpenSSL-devel \
 ghc-array-devel \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-base64-bytestring-devel \
 ghc-blaze-builder-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-haxr \
 ghc-http-streams-devel \
 ghc-http-types-devel \
 ghc-io-streams-devel \
 ghc-mtl-devel \
 ghc-network-devel \
 ghc-network-uri-devel \
 ghc-old-locale-devel \
 ghc-old-time-devel \
 ghc-template-haskell-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-utf8-string-devel \
 "
RDEPENDS:ghc-haxr-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-haxr-prof = " \
 ghc-HaXml-prof \
 ghc-HsOpenSSL-prof \
 ghc-array-prof \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-base64-bytestring-prof \
 ghc-blaze-builder-prof \
 ghc-bytestring-prof \
 ghc-haxr-devel \
 ghc-http-streams-prof \
 ghc-http-types-prof \
 ghc-io-streams-prof \
 ghc-mtl-prof \
 ghc-network-prof \
 ghc-network-uri-prof \
 ghc-old-locale-prof \
 ghc-old-time-prof \
 ghc-template-haskell-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-utf8-string-prof \
 "
