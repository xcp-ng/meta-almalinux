# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pim-data-exporter"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 pim-data-exporter \
 pim-data-exporter-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pim-data-exporter-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "77a84688788feff6c27cdcd4d702f988e98fd703fd49cebc36b5c440a7ac887e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter;unpack=0"
SRC_URI[x86_64_v2_pim-data-exporter.sha256sum] = "166e80f1d7d6df562bd6d49ecc473eff36348780f17a1c70b13ebff8c0e9205f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pim-data-exporter-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pim-data-exporter-libs;unpack=0"
SRC_URI[x86_64_v2_pim-data-exporter-libs.sha256sum] = "50536bd7a744f0ec0f5344f8bf985612e0b9fe1c0584e2b8bc09954273eab039"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_pim-data-exporter;unpack=0"
SRC_URI[aarch64_pim-data-exporter.sha256sum] = "13500b837b24299f7d05b33d4496e6abadbdd8bbe12d355322e14044824d6a8b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pim-data-exporter-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_pim-data-exporter-libs;unpack=0"
SRC_URI[aarch64_pim-data-exporter-libs.sha256sum] = "db8e10baeaf3d147ca25309a16519296be4c3d996dbdeccb47e1d42a06e45719"

RDEPENDS:pim-data-exporter = " \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kitemviews \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter-libs \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pim-data-exporter-libs = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kmime \
 kidentitymanagement \
 kmailtransport \
 libgcc \
 libstdc++ \
 mailcommon \
 pim-data-exporter \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
