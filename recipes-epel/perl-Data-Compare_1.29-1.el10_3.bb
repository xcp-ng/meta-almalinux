# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Compare"
PV = "1.29"
PR = "1.el10_3"
PACKAGES = " \
 perl-Data-Compare \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Compare-1.29-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aca3bd67fa8b851fe85114492003e18b09b4d3ab512b21e02e5b1f7bcc2bffde"

URI_x86_64_v2_perl-Data-Compare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Compare-1.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Compare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Compare}"
SRC_URI[x86_64_v2_perl-Data-Compare.sha256sum] = "52c9ff429240ab5734a71fa38f665501c1e41ef8057ab33b17278c9f6df0626f"

URI_aarch64_perl-Data-Compare = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Compare-1.29-1.el10_3.noarch.rpm;name=aarch64_perl-Data-Compare;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Compare}"
SRC_URI[aarch64_perl-Data-Compare.sha256sum] = "58b9fffe0e1307805030baec219323f5f37337188a2a83a6698b637f0be5c582"

RDEPENDS:perl-Data-Compare = " \
 perl-Carp \
 perl-Clone \
 perl-Data-Compare \
 perl-Exporter \
 perl-File-Find-Rule \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-vars \
 "
