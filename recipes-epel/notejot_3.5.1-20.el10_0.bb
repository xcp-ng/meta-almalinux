# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "notejot"
PV = "3.5.1"
PR = "20.el10_0"
PACKAGES = " \
 notejot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/notejot-3.5.1-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1f02fb019d832038b046f973beb20b3d456a9e0fbd8325674cffcd9e9a0a72b"

URI_x86_64_v2_notejot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/notejot-3.5.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_notejot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_notejot}"
SRC_URI[x86_64_v2_notejot.sha256sum] = "1cb8e3a782bb2659f51c753b03bc80794db3c6814d3c4d085e122747f70bd5fd"

URI_aarch64_notejot = "${EPEL_MIRROR}/aarch64/Packages/n/notejot-3.5.1-20.el10_0.aarch64.rpm;name=aarch64_notejot;unpack=0"
SRC_URI:append = " ${URI_aarch64_notejot}"
SRC_URI[aarch64_notejot.sha256sum] = "07bafa60a2e33e7722f19f43d8e5238a571e4aef42d6152aa4ae0adc67446c9d"

RDEPENDS:notejot = " \
 glib2 \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 json-glib \
 libadwaita \
 libgee \
 "
