# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntpstat"
PV = "0.6"
PR = "13.el10"
PACKAGES = " \
 ntpstat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ntpstat-0.6-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51858dffa179be2c1a7e92502028ee4ebd2d1493da5edfc36101be3616d4e9e5"

URI_x86_64_v2_ntpstat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ntpstat-0.6-13.el10.noarch.rpm;name=x86_64_v2_ntpstat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntpstat}"
SRC_URI[x86_64_v2_ntpstat.sha256sum] = "cecac2840352d8be1349db7e2f77ba0a9466ba4f1c3de5d4b07d8a1d5bdf657c"

URI_aarch64_ntpstat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ntpstat-0.6-13.el10.noarch.rpm;name=aarch64_ntpstat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntpstat}"
SRC_URI[aarch64_ntpstat.sha256sum] = "cecac2840352d8be1349db7e2f77ba0a9466ba4f1c3de5d4b07d8a1d5bdf657c"

RDEPENDS:ntpstat = " \
 bash \
 virtual/ntpsec_or_chrony \
 "
