# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rsa"
PV = "4.9"
PR = "7.el10_0"
PACKAGES = " \
 python3-rsa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rsa-4.9-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ca2025d915f8b36206860df131136e1f5deb8b736a61ffcd03f6797b87176df"

URI_x86_64_v2_python3-rsa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rsa-4.9-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rsa}"
SRC_URI[x86_64_v2_python3-rsa.sha256sum] = "50139b95fed4a1ff891e4586ddb40c11b21ec612ce6f93f116c86b99a2f5468c"

URI_aarch64_python3-rsa = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rsa-4.9-7.el10_0.noarch.rpm;name=aarch64_python3-rsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rsa}"
SRC_URI[aarch64_python3-rsa.sha256sum] = "acbb8602d9ed5e7ef986fbc503b0149af8cd3789a088d0483f68b8a5bffd21d4"

RDEPENDS:python3-rsa = " \
 python3 \
 python3-pyasn1 \
 python3-setuptools \
 "
