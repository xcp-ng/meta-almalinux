# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust_decimal"
PV = "1.39.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rust_decimal+align16-devel \
 rust-rust_decimal+c-repr-devel \
 rust-rust_decimal+default-devel \
 rust-rust_decimal+legacy-ops-devel \
 rust-rust_decimal+macros-devel \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal+maths-nopanic-devel \
 rust-rust_decimal+proptest-devel \
 rust-rust_decimal+rand-0_9-devel \
 rust-rust_decimal+rand-devel \
 rust-rust_decimal+rkyv-devel \
 rust-rust_decimal+rkyv-safe-devel \
 rust-rust_decimal+serde-arbitrary-precision-devel \
 rust-rust_decimal+serde-bincode-devel \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal+serde-float-devel \
 rust-rust_decimal+serde-str-devel \
 rust-rust_decimal+serde-with-arbitrary-precision-devel \
 rust-rust_decimal+serde-with-float-devel \
 rust-rust_decimal+serde-with-str-devel \
 rust-rust_decimal+serde_json-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust_decimal-1.39.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1943ccea5a717d8828dae866fc87c3923c68a166db2057fedc8f90fc43401f9f"

URI_x86_64_v2_rust-rust_decimal+align16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+align16-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+align16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+align16-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+align16-devel.sha256sum] = "e3917ee7fcae6c1f6038963f6a39f101824f550ecf6700f33e3143fb241da96c"

URI_x86_64_v2_rust-rust_decimal+c-repr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+c-repr-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+c-repr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+c-repr-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+c-repr-devel.sha256sum] = "8b369eb3a280b58dbc90acef841111e6ba1cdcae317a6786ee36c900d2aec1b6"

URI_x86_64_v2_rust-rust_decimal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+default-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+default-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+default-devel.sha256sum] = "919929c05dbb108ed60fb356d1ba840713da1b9c79f189e7f0819cbf7b385772"

URI_x86_64_v2_rust-rust_decimal+legacy-ops-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+legacy-ops-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+legacy-ops-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+legacy-ops-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+legacy-ops-devel.sha256sum] = "aba5a2ab87a1d36e8a5a4074392c9cee8e9b59b17a7b7136930968cf76f520b3"

URI_x86_64_v2_rust-rust_decimal+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+macros-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+macros-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+macros-devel.sha256sum] = "8f0e46f3142223fa004230a0c737a4ac42319939f17fa9f0bc9004e5c3ddae51"

URI_x86_64_v2_rust-rust_decimal+maths-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+maths-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+maths-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+maths-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+maths-devel.sha256sum] = "4c50361cbea69f5852e2147eac2c5598ea5c00fa3a6bea4f1252f0e280161e79"

URI_x86_64_v2_rust-rust_decimal+maths-nopanic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+maths-nopanic-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+maths-nopanic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+maths-nopanic-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+maths-nopanic-devel.sha256sum] = "f3d63cf57c8258e2b8003a63e6bba6acebe559c6960eb6b27a1f67eda1d4c740"

URI_x86_64_v2_rust-rust_decimal+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+proptest-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+proptest-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+proptest-devel.sha256sum] = "8c59449d04c2135265b58e3800476d0bd72d94e8e518b2bb0f95af313d8a1654"

URI_x86_64_v2_rust-rust_decimal+rand-0_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rand-0_9-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rand-0_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rand-0_9-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rand-0_9-devel.sha256sum] = "2588a8b6c94310cfa0f58e265ff84301e3033a2cb804de6c3193057749df4b8d"

URI_x86_64_v2_rust-rust_decimal+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rand-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rand-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rand-devel.sha256sum] = "237f1f94390c5a0a8aa988c72990ef46ebcabb84d24d3056e72864976096c8f9"

URI_x86_64_v2_rust-rust_decimal+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rkyv-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rkyv-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rkyv-devel.sha256sum] = "1f04e87520bc16db4e8a440290e119b5c9b54f694d3dcb13ed7b24c484ce3ec7"

URI_x86_64_v2_rust-rust_decimal+rkyv-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+rkyv-safe-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+rkyv-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+rkyv-safe-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+rkyv-safe-devel.sha256sum] = "f210da048579286d36eb8a59e9a89412f81c3f4abf0e551c16f6810a569ac12e"

URI_x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-arbitrary-precision-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-arbitrary-precision-devel.sha256sum] = "ad3dcfd36ec17c76c3995c61ca6e9b9c7e85f6a00bb6881e3379cd99a14b3077"

URI_x86_64_v2_rust-rust_decimal+serde-bincode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-bincode-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-bincode-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-bincode-devel.sha256sum] = "0c58bf754acd56ac6946c91cb65af59393207db7f6724ea2377c29f89b36eded"

URI_x86_64_v2_rust-rust_decimal+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-devel.sha256sum] = "5bd2725a363f59d8e545ec0d3b29f78173b22cbd1ab571c800f4a986dc835ef1"

URI_x86_64_v2_rust-rust_decimal+serde-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-float-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-float-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-float-devel.sha256sum] = "4c07548965f4ba65ffd9baedcf57d4cf1b3c4bc1023d6d2bd8a40e1cb572f069"

URI_x86_64_v2_rust-rust_decimal+serde-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-str-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-str-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-str-devel.sha256sum] = "d13c1ebb3b17d7696333c717854086f8049f02e3bb434a109e0b5e95efb27342"

URI_x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-arbitrary-precision-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-arbitrary-precision-devel.sha256sum] = "84363eef4e8a255eada3dac0231dd0462491d0ec8c31d45a115acfe9214dba7b"

URI_x86_64_v2_rust-rust_decimal+serde-with-float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-float-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-float-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-float-devel.sha256sum] = "ebe67680cbfdbff883520724b7e98888716dfcc76bf082e250efafdc67f4c509"

URI_x86_64_v2_rust-rust_decimal+serde-with-str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde-with-str-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde-with-str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde-with-str-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde-with-str-devel.sha256sum] = "2b9e893b438de35c4a6c36afa7dbb09882b7ca95a4d60d6fcf85dbb263c7590e"

URI_x86_64_v2_rust-rust_decimal+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+serde_json-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+serde_json-devel.sha256sum] = "fdcb0cfcf33a61ca5c9111f6c2b923659cecb9d0dc4341951dca8f8a9d69661c"

URI_x86_64_v2_rust-rust_decimal+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal+std-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal+std-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal+std-devel.sha256sum] = "a24ebf9036e2260768d0c5aa79a3adc38562516cab8c16307a37118e462745d2"

URI_x86_64_v2_rust-rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal-devel-1.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal-devel.sha256sum] = "3b2252ec2feecc9444845b982626c5b72b9d3fe3813f5c93c6363fd52569bb35"

URI_aarch64_rust-rust_decimal+align16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+align16-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+align16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+align16-devel}"
SRC_URI[aarch64_rust-rust_decimal+align16-devel.sha256sum] = "80d0aaa6cb81e790994148c4f97a89676122756cc24ccf0a688463b63b0d6d25"

URI_aarch64_rust-rust_decimal+c-repr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+c-repr-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+c-repr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+c-repr-devel}"
SRC_URI[aarch64_rust-rust_decimal+c-repr-devel.sha256sum] = "f60b7a305b6e5284e9e83f01a199dc31e002d561782b2c466ff098b3f6f66286"

URI_aarch64_rust-rust_decimal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+default-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+default-devel}"
SRC_URI[aarch64_rust-rust_decimal+default-devel.sha256sum] = "65058603af7042725c1c1ef4b278ed3b2cd64a27ac07d0dde4507b8e2fca1ea9"

URI_aarch64_rust-rust_decimal+legacy-ops-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+legacy-ops-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+legacy-ops-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+legacy-ops-devel}"
SRC_URI[aarch64_rust-rust_decimal+legacy-ops-devel.sha256sum] = "a0ab0cbcefb75fb080c25b62ab435b02237004ac8d4cdba45d2d7aa8f8e5a274"

URI_aarch64_rust-rust_decimal+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+macros-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+macros-devel}"
SRC_URI[aarch64_rust-rust_decimal+macros-devel.sha256sum] = "70528140391964588060219c43acdb13d916ce6a018d11c01eca7c7af386553f"

URI_aarch64_rust-rust_decimal+maths-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+maths-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+maths-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+maths-devel}"
SRC_URI[aarch64_rust-rust_decimal+maths-devel.sha256sum] = "fb34d70730280e1174c099dbf22bf95b6500b72d63846d9a46824fb5656b7faa"

URI_aarch64_rust-rust_decimal+maths-nopanic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+maths-nopanic-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+maths-nopanic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+maths-nopanic-devel}"
SRC_URI[aarch64_rust-rust_decimal+maths-nopanic-devel.sha256sum] = "edb06811e9b527e15e5c9caa465b72f68b7880be67a177c3d11f302ccaeb6db6"

URI_aarch64_rust-rust_decimal+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+proptest-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+proptest-devel}"
SRC_URI[aarch64_rust-rust_decimal+proptest-devel.sha256sum] = "dd587f969af7330c2e8c31b529cc3d4ab336a204b7f2875f3a81cdf785afb530"

URI_aarch64_rust-rust_decimal+rand-0_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rand-0_9-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+rand-0_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rand-0_9-devel}"
SRC_URI[aarch64_rust-rust_decimal+rand-0_9-devel.sha256sum] = "ba25c7b15275681ebb8e3c1e844469dff58f4e5bd6303a9c4697cf6730d288fc"

URI_aarch64_rust-rust_decimal+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rand-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rand-devel}"
SRC_URI[aarch64_rust-rust_decimal+rand-devel.sha256sum] = "1e8dc7d92507548a983a85e256b61d17b1343ee582b7bca32fd31ce19ea62a9c"

URI_aarch64_rust-rust_decimal+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rkyv-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rkyv-devel}"
SRC_URI[aarch64_rust-rust_decimal+rkyv-devel.sha256sum] = "5ff4620ac6a70e1a72796bef33a6ad2aa0b17cb52d09558c0ecf66a639295a7a"

URI_aarch64_rust-rust_decimal+rkyv-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+rkyv-safe-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+rkyv-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+rkyv-safe-devel}"
SRC_URI[aarch64_rust-rust_decimal+rkyv-safe-devel.sha256sum] = "9fc5095bfc91f5331c53dffbdf54a5dbbb72860dd696954c9ef698ed20c86a3d"

URI_aarch64_rust-rust_decimal+serde-arbitrary-precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-arbitrary-precision-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+serde-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-arbitrary-precision-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-arbitrary-precision-devel.sha256sum] = "b0b7d879d15e73130f2974b46dad2a842f53b140db1856a5837149d798d5b17b"

URI_aarch64_rust-rust_decimal+serde-bincode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-bincode-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+serde-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-bincode-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-bincode-devel.sha256sum] = "d492744cbf012daba8ce1e179a8ac5e19f4a8115af34a0d7449e5b396d697e9b"

URI_aarch64_rust-rust_decimal+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-devel.sha256sum] = "18853bbf6844b7e68f57bb4a088ff6bcdba22061d30d4b317e3972d9b1b5732b"

URI_aarch64_rust-rust_decimal+serde-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-float-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+serde-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-float-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-float-devel.sha256sum] = "86a5f90c4f7413920db77d3810c1656ba95b73c2184cb45d927cab60bcf59bcf"

URI_aarch64_rust-rust_decimal+serde-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-str-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+serde-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-str-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-str-devel.sha256sum] = "cc3b58eeb28f7989fe6ced52b7524fb77d2a7dd00048bd17a434c1a42016dfb0"

URI_aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-arbitrary-precision-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-arbitrary-precision-devel.sha256sum] = "e84bfbd02f23ea1b38b714d1233a2db2d4cd5aac0d4cfbb25303abac42f3d871"

URI_aarch64_rust-rust_decimal+serde-with-float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-float-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-float-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-float-devel.sha256sum] = "b91217ccf8881391fbfc797a92d1003e303c35137f9108fbc7387a8ec64b82ec"

URI_aarch64_rust-rust_decimal+serde-with-str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde-with-str-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+serde-with-str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde-with-str-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde-with-str-devel.sha256sum] = "17314e6f03cba25a8c119a26d69f17bef94587affe0601bb2acb2e448b1fc216"

URI_aarch64_rust-rust_decimal+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+serde_json-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+serde_json-devel}"
SRC_URI[aarch64_rust-rust_decimal+serde_json-devel.sha256sum] = "b7f4410d56d8053916086a758b415e3fce811f5c137eda970fa264029e618cbf"

URI_aarch64_rust-rust_decimal+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal+std-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal+std-devel}"
SRC_URI[aarch64_rust-rust_decimal+std-devel.sha256sum] = "e5248200f90acb86608290ee2f109ce001d112390da6fe058c4f2432d243f803"

URI_aarch64_rust-rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal-devel-1.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal-devel}"
SRC_URI[aarch64_rust-rust_decimal-devel.sha256sum] = "6430ee3c799a33cfcc8c3a156d4932f3c9bc2194c878c17ca5551885d7254ffd"

RDEPENDS:rust-rust_decimal+align16-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+c-repr-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+default-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal+std-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+legacy-ops-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+macros-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal+maths-devel = " \
 cargo \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+maths-nopanic-devel = " \
 cargo \
 rust-rust_decimal+maths-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+proptest-devel = " \
 cargo \
 rust-proptest+std-devel \
 rust-proptest-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rand-0_9-devel = " \
 cargo \
 rust-rand-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rand-devel = " \
 cargo \
 rust-rand0.8-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rkyv-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+rkyv-safe-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-arbitrary-precision-devel = " \
 cargo \
 rust-rust_decimal+serde-with-arbitrary-precision-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-bincode-devel = " \
 cargo \
 rust-rust_decimal+serde-str-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rust_decimal+serde-float-devel = " \
 cargo \
 rust-rust_decimal+serde-with-float-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-str-devel = " \
 cargo \
 rust-rust_decimal+serde-with-str-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-arbitrary-precision-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 rust-serde_json+arbitrary_precision-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-float-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde-with-str-devel = " \
 cargo \
 rust-rust_decimal+serde-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-rust_decimal+serde_json-devel = " \
 cargo \
 rust-rust_decimal-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal+std-devel = " \
 cargo \
 rust-arrayvec+std-devel \
 rust-bytes+std-devel \
 rust-bytes-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 rust-rust_decimal-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-serde_json+std-devel \
 rust-serde_json-devel \
 "
RDEPENDS:rust-rust_decimal-devel = " \
 cargo \
 rust \
 rust-arrayvec-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
