# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvma"
PV = "9.8.80"
PR = "1.el10"
PACKAGES = " \
 libvma \
 libvma-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvma-9.8.80-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9d0cc4cd0260b8e6bb2797cc6dcf33fcf5410d2366cd1397fce46cbcfd6980f"

URI_x86_64_v2_libvma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvma-9.8.80-1.el10.x86_64_v2.rpm;name=x86_64_v2_libvma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvma}"
SRC_URI[x86_64_v2_libvma.sha256sum] = "d4e0cde48e37f41d8dd5d454e4baf5c278cdc7c29297837e6f920f0ae209bacf"

URI_x86_64_v2_libvma-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvma-utils-9.8.80-1.el10.x86_64_v2.rpm;name=x86_64_v2_libvma-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvma-utils}"
SRC_URI[x86_64_v2_libvma-utils.sha256sum] = "d34020c07aedbc4750f623d48816249cfe5cd381a92263fd071573e5ed2aff52"

URI_aarch64_libvma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvma-9.8.80-1.el10.aarch64.rpm;name=aarch64_libvma;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvma}"
SRC_URI[aarch64_libvma.sha256sum] = "a6524f2e1bf1836f8bbf8ea41ffcffc3af70e7d908ffdf6518482d7b1a61029c"

URI_aarch64_libvma-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvma-utils-9.8.80-1.el10.aarch64.rpm;name=aarch64_libvma-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvma-utils}"
SRC_URI[aarch64_libvma-utils.sha256sum] = "7686a6cbb3a8b936882934259a5822de4c37fe709f56e9b945123a414f1e8b9d"

RDEPENDS:libvma = " \
 bash \
 glibc \
 libgcc \
 libibverbs \
 libnl3 \
 librdmacm \
 libstdc++ \
 "
RDEPENDS:libvma-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 libvma \
 "
