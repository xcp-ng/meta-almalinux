# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spamassassin-dqs"
PV = "1.5.1"
PR = "4.el10_1"
PACKAGES = " \
 spamassassin-dqs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spamassassin-dqs-1.5.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "668645db7e8f762efbc84479ff9a4f617f5aff1a23b676b8a3630987f8b7095a"

URI_x86_64_v2_spamassassin-dqs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamassassin-dqs-1.5.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_spamassassin-dqs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spamassassin-dqs}"
SRC_URI[x86_64_v2_spamassassin-dqs.sha256sum] = "64941c4ad212d7d0f0ec9c72b3c3166a5e51b9ffa9188633e1f1215b25cd0b8e"

URI_aarch64_spamassassin-dqs = "${EPEL_MIRROR}/aarch64/Packages/s/spamassassin-dqs-1.5.1-4.el10_1.noarch.rpm;name=aarch64_spamassassin-dqs;unpack=0"
SRC_URI:append = " ${URI_aarch64_spamassassin-dqs}"
SRC_URI[aarch64_spamassassin-dqs.sha256sum] = "5e42589f734a521a8acce55f105d349fcf820729520db8326b913f6824d0defd"

RDEPENDS:spamassassin-dqs = " \
 bash \
 perl-Digest-SHA \
 perl-Net-DNS \
 perl-Socket \
 perl-libs \
 spamassassin \
 "
