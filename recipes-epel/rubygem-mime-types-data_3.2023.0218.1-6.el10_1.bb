# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-mime-types-data"
PV = "3.2023.0218.1"
PR = "6.el10_1"
PACKAGES = " \
 rubygem-mime-types-data \
 rubygem-mime-types-data-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-mime-types-data-3.2023.0218.1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bae2ce33df4683d1e4ddee93b89457722046a48d9afa8b815d3281964d17983"

URI_x86_64_v2_rubygem-mime-types-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mime-types-data-3.2023.0218.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mime-types-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mime-types-data}"
SRC_URI[x86_64_v2_rubygem-mime-types-data.sha256sum] = "84788fefa3c2345f32dd3ee844847ecfe38e298ed76d3438e7b27815ba73f23e"

URI_x86_64_v2_rubygem-mime-types-data-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mime-types-data-doc-3.2023.0218.1-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mime-types-data-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mime-types-data-doc}"
SRC_URI[x86_64_v2_rubygem-mime-types-data-doc.sha256sum] = "5f81e1a2f15644e9f04953f43d728aa1d1f86169f6331e60c40bc68e8cf4f8d4"

URI_aarch64_rubygem-mime-types-data = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mime-types-data-3.2023.0218.1-6.el10_1.noarch.rpm;name=aarch64_rubygem-mime-types-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mime-types-data}"
SRC_URI[aarch64_rubygem-mime-types-data.sha256sum] = "eedf7c36db867c6d55bdc3a084dfff0dfb2c6d6dbe9318922819fe306fb6acbf"

URI_aarch64_rubygem-mime-types-data-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mime-types-data-doc-3.2023.0218.1-6.el10_1.noarch.rpm;name=aarch64_rubygem-mime-types-data-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mime-types-data-doc}"
SRC_URI[aarch64_rubygem-mime-types-data-doc.sha256sum] = "ceeac311317595dbfe0c56660cd11fec8784cbf176c07dd0cd2590078ea03dcd"

RDEPENDS:rubygem-mime-types-data = " \
 rubygems \
 "
RDEPENDS:rubygem-mime-types-data-doc = " \
 rubygem-mime-types-data \
 "
