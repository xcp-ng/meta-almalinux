# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-SysRandom-XS"
PV = "0.011"
PR = "3.el10_2"
PACKAGES = " \
 perl-Crypt-SysRandom-XS \
 perl-Crypt-SysRandom-XS-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-SysRandom-XS-0.011-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e0417369ed4c03875545372d154730abcd71b00f509b6d6faa72616de03c6652"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SysRandom-XS-0.011-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Crypt-SysRandom-XS;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-SysRandom-XS.sha256sum] = "904f31f3ad8f8289b4b457f657a1a10a1101ac37c9208afe1708d5fb387444f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-SysRandom-XS-tests-0.011-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-SysRandom-XS-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Crypt-SysRandom-XS-tests.sha256sum] = "152d0662b016bae1ee1b34f448ab0a7e338650b88d1f330b3056e77283a583e9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SysRandom-XS-0.011-3.el10_2.aarch64.rpm;name=aarch64_perl-Crypt-SysRandom-XS;unpack=0"
SRC_URI[aarch64_perl-Crypt-SysRandom-XS.sha256sum] = "1c4ad882282eaff0ae2427d1616fb4c2a22ab8df96ece2f1e633a0a02e9f0a59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-SysRandom-XS-tests-0.011-3.el10_2.noarch.rpm;name=aarch64_perl-Crypt-SysRandom-XS-tests;unpack=0"
SRC_URI[aarch64_perl-Crypt-SysRandom-XS-tests.sha256sum] = "8ec028832160a9cadba69eb0c8ed6b4335aee636c4abd5ca3763ca4ff7564181"

RDEPENDS:perl-Crypt-SysRandom-XS = " \
 glibc \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Crypt-SysRandom-XS-tests = " \
 bash \
 perl-Crypt-SysRandom-XS \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
