# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zopfli"
PV = "0.8.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-zopfli+default-devel \
 rust-zopfli+gzip-devel \
 rust-zopfli+std-devel \
 rust-zopfli+zlib-devel \
 rust-zopfli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zopfli-0.8.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02361dcc2748966b68beebb7d1b3c34cce1b76197facbf9e03f0330441b46027"

URI_x86_64_v2_rust-zopfli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+default-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+default-devel}"
SRC_URI[x86_64_v2_rust-zopfli+default-devel.sha256sum] = "ad01fa633a146af0fe3b540e8f98e0a434800fb20b2a070532fb242e93be178f"

URI_x86_64_v2_rust-zopfli+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+gzip-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+gzip-devel}"
SRC_URI[x86_64_v2_rust-zopfli+gzip-devel.sha256sum] = "d92440caa4366d8cbdbbdca2c537c54abc39ec8bfee9f16f85d5dcd2cc70fef1"

URI_x86_64_v2_rust-zopfli+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+std-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+std-devel}"
SRC_URI[x86_64_v2_rust-zopfli+std-devel.sha256sum] = "c39cad042530eb706c3f49b05d4d2f80e7afb7fc0b6a925167e0ee7905cf46dc"

URI_x86_64_v2_rust-zopfli+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli+zlib-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli+zlib-devel}"
SRC_URI[x86_64_v2_rust-zopfli+zlib-devel.sha256sum] = "5d96f5a0a736e170910af785525b4c3a064592eae6f6489b53a7a08d2ecdc002"

URI_x86_64_v2_rust-zopfli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zopfli-devel-0.8.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zopfli-devel}"
SRC_URI[x86_64_v2_rust-zopfli-devel.sha256sum] = "750c0c7bf320436d5a3940201d93fff7b33c672b81d9de51ae1965ad5cd155da"

URI_aarch64_rust-zopfli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+default-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zopfli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+default-devel}"
SRC_URI[aarch64_rust-zopfli+default-devel.sha256sum] = "47d98a7d6b1f10dfab96518143b4e19f3385246512d33141113196acbdc5b38d"

URI_aarch64_rust-zopfli+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+gzip-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zopfli+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+gzip-devel}"
SRC_URI[aarch64_rust-zopfli+gzip-devel.sha256sum] = "7d0fdf739d6bd6c9bab93def2e091bd9bb91da444ec5f5f290fbd8f05629f250"

URI_aarch64_rust-zopfli+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+std-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zopfli+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+std-devel}"
SRC_URI[aarch64_rust-zopfli+std-devel.sha256sum] = "f00e3d953c7f170f578541f10daad54cfa564834332e0bd363f604ec78204d46"

URI_aarch64_rust-zopfli+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli+zlib-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zopfli+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli+zlib-devel}"
SRC_URI[aarch64_rust-zopfli+zlib-devel.sha256sum] = "3f86a1a553abf1e20c005f0e0ec919c13faf278eb358891a6f75b38d85fc0733"

URI_aarch64_rust-zopfli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zopfli-devel-0.8.2-1.el10_0.noarch.rpm;name=aarch64_rust-zopfli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zopfli-devel}"
SRC_URI[aarch64_rust-zopfli-devel.sha256sum] = "0a8e573289372001235d402a0f10aa28389840ea18a39fd76b61fb422374cdea"

RDEPENDS:rust-zopfli+default-devel = " \
 cargo \
 rust-zopfli+gzip-devel \
 rust-zopfli+std-devel \
 rust-zopfli+zlib-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli+gzip-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli+std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-log+default-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli+zlib-devel = " \
 cargo \
 rust-simd-adler32-devel \
 rust-zopfli-devel \
 "
RDEPENDS:rust-zopfli-devel = " \
 cargo \
 rust \
 rust-bumpalo+default-devel \
 "
