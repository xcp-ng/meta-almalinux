# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bomber"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 bomber \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bomber-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8f9ab76d1e5911230e7e95be637e074a9909fd00ade4f99439343104fc99097"

URI_x86_64_v2_bomber = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bomber-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bomber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bomber}"
SRC_URI[x86_64_v2_bomber.sha256sum] = "9dfca6b69db89b0848af130555da23fba2f7d8a2f75b80a51a10d571ab02eccb"

URI_aarch64_bomber = "${EPEL_MIRROR}/aarch64/Packages/b/bomber-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_bomber;unpack=0"
SRC_URI:append = " ${URI_aarch64_bomber}"
SRC_URI[aarch64_bomber.sha256sum] = "16c59622e556dc1ca9d5ae50837c32e39d306c5f6e723b9d446427357bd8199b"

RDEPENDS:bomber = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
