# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-downcast-rs1"
PV = "1.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-downcast-rs1+default-devel \
 rust-downcast-rs1+std-devel \
 rust-downcast-rs1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-downcast-rs1-1.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c8d5615d0e36119869ca7a7a26b9bd8840306444ae71da276588c5aa64edb3"

URI_x86_64_v2_rust-downcast-rs1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs1+default-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs1+default-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs1+default-devel.sha256sum] = "d823c6c86851387d4c78eb67e492b8c1b36c51451ca25482adbad595fbad8b05"

URI_x86_64_v2_rust-downcast-rs1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs1+std-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs1+std-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs1+std-devel.sha256sum] = "1616c19e87be028232832244e83256f436d15c5a9ceb4fcdff064cf54c62f1c8"

URI_x86_64_v2_rust-downcast-rs1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-downcast-rs1-devel-1.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-downcast-rs1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-downcast-rs1-devel}"
SRC_URI[x86_64_v2_rust-downcast-rs1-devel.sha256sum] = "dd1297c3d7eda7cc0d0c9ff01fa1854b8993020549e93ff45272e3257e9bd680"

URI_aarch64_rust-downcast-rs1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs1+default-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-downcast-rs1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs1+default-devel}"
SRC_URI[aarch64_rust-downcast-rs1+default-devel.sha256sum] = "86d4e8f89990baf9dba83f8cef0ed7192b77bf85291df5cb3b6b01a627b2fdb0"

URI_aarch64_rust-downcast-rs1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs1+std-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-downcast-rs1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs1+std-devel}"
SRC_URI[aarch64_rust-downcast-rs1+std-devel.sha256sum] = "b6afc4bedc78da12c8cdf74ffc133839a6c1948523b4865cce552ddd9be1be20"

URI_aarch64_rust-downcast-rs1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-downcast-rs1-devel-1.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-downcast-rs1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-downcast-rs1-devel}"
SRC_URI[aarch64_rust-downcast-rs1-devel.sha256sum] = "a3f4d17a68ab2ca7459201dba6bef189415cd3fee5f8883115eaf64450e94de0"

RDEPENDS:rust-downcast-rs1+default-devel = " \
 cargo \
 rust-downcast-rs1+std-devel \
 rust-downcast-rs1-devel \
 "
RDEPENDS:rust-downcast-rs1+std-devel = " \
 cargo \
 rust-downcast-rs1-devel \
 "
RDEPENDS:rust-downcast-rs1-devel = " \
 cargo \
 "
