# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nm"
PV = "6.7.3"
PR = "1.1.el10_3"
PACKAGES = " \
 plasma-nm \
 plasma-nm-l2tp \
 plasma-nm-openconnect \
 plasma-nm-openswan \
 plasma-nm-openvpn \
 plasma-nm-pptp \
 plasma-nm-strongswan \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-nm-6.7.3-1.1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e96010aea91da87d6f5255637d41f13d7ddc0076686665486dde7f69c71e9fec"

URI_x86_64_v2_plasma-nm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-6.7.3-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm}"
SRC_URI[x86_64_v2_plasma-nm.sha256sum] = "c0ce562299499f5df900166fbab4c16dd9789227520eed82425caa597468539c"

URI_x86_64_v2_plasma-nm-l2tp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-l2tp-6.7.3-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-l2tp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-l2tp}"
SRC_URI[x86_64_v2_plasma-nm-l2tp.sha256sum] = "0521f12a7da1b02ba19fa77324ec8508c14b3bc1624db4e45bb5bcd8c64cfe72"

URI_x86_64_v2_plasma-nm-openconnect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openconnect-6.7.3-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openconnect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openconnect}"
SRC_URI[x86_64_v2_plasma-nm-openconnect.sha256sum] = "2399283c4f81783ab1dceab6a1e6def7062556212fdb7f55dfaa6dab2c01eabf"

URI_x86_64_v2_plasma-nm-openswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openswan-6.7.3-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openswan}"
SRC_URI[x86_64_v2_plasma-nm-openswan.sha256sum] = "8a423175cb37b9f97659cbe25d9e967d10c267698a3b42bccc2f1f48efa3b971"

URI_x86_64_v2_plasma-nm-openvpn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-openvpn-6.7.3-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-openvpn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-openvpn}"
SRC_URI[x86_64_v2_plasma-nm-openvpn.sha256sum] = "d4081ce69f52dc495aff5bc6df816e2cfae66192407513cbf97899c5cd8da311"

URI_x86_64_v2_plasma-nm-pptp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-pptp-6.7.3-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-pptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-pptp}"
SRC_URI[x86_64_v2_plasma-nm-pptp.sha256sum] = "5ac0bd9e47d951ac39ad862c3bf814d4329a67c8e8156e506750ad3ff49c3c7f"

URI_x86_64_v2_plasma-nm-strongswan = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nm-strongswan-6.7.3-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nm-strongswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-nm-strongswan}"
SRC_URI[x86_64_v2_plasma-nm-strongswan.sha256sum] = "1cdc2b48e78d0198d5fd88765f003055e43577ab18654bbd2963c633458f137a"

URI_aarch64_plasma-nm = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-6.7.3-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm}"
SRC_URI[aarch64_plasma-nm.sha256sum] = "138a4bf4b4a1459e1d35687333c1b798dae6ec88d39e8041ab8867837e898779"

URI_aarch64_plasma-nm-l2tp = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-l2tp-6.7.3-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-l2tp;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-l2tp}"
SRC_URI[aarch64_plasma-nm-l2tp.sha256sum] = "3016771fb8e6bb2cb3a4bbba459cca13dc9aa00c4d9e7a20f2e50c9901ce14cc"

URI_aarch64_plasma-nm-openconnect = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openconnect-6.7.3-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-openconnect;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openconnect}"
SRC_URI[aarch64_plasma-nm-openconnect.sha256sum] = "e5910e4f54d33509af8be48bffbc4dd4f2e958774c6809499a353b6ab3517bcc"

URI_aarch64_plasma-nm-openswan = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openswan-6.7.3-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-openswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openswan}"
SRC_URI[aarch64_plasma-nm-openswan.sha256sum] = "821fb8411ea3a382927d2bb10fa58f2fe5838b566d3478cef2d357e46e6e6be7"

URI_aarch64_plasma-nm-openvpn = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-openvpn-6.7.3-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-openvpn;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-openvpn}"
SRC_URI[aarch64_plasma-nm-openvpn.sha256sum] = "60a4ae27e613e9cfb7ffb74764417649df6d4f321851cf4b94e9760d70926428"

URI_aarch64_plasma-nm-pptp = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-pptp-6.7.3-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-pptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-pptp}"
SRC_URI[aarch64_plasma-nm-pptp.sha256sum] = "4b3849ba6b29a0794a213a67cfd7db05b5a8ca6d04884faa01b840b1e9733a0c"

URI_aarch64_plasma-nm-strongswan = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-nm-strongswan-6.7.3-1.1.el10_3.aarch64.rpm;name=aarch64_plasma-nm-strongswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-nm-strongswan}"
SRC_URI[aarch64_plasma-nm-strongswan.sha256sum] = "aba05ddb8e25866993a128116d1101f1beb369cd24862a75f9ec2af63b8683e0"

RDEPENDS:plasma-nm = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-prison \
 kf6-solid \
 libplasma \
 libstdc++ \
 openssl-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qtkeychain-qt6 \
 "
RDEPENDS:plasma-nm-l2tp = " \
 NetworkManager-l2tp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openconnect = " \
 NetworkManager-openconnect \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 openconnect \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:plasma-nm-openswan = " \
 NetworkManager-libreswan \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-openvpn = " \
 NetworkManager-libnm \
 NetworkManager-openvpn \
 glib2 \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-pptp = " \
 NetworkManager-pptp \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-nm-strongswan = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-networkmanager-qt \
 libstdc++ \
 plasma-nm \
 qt6-qtbase \
 qt6-qtbase-gui \
 strongswan \
 "
