# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-linktime-proc-macro"
PV = "0.2.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-linktime-proc-macro+ctor-devel \
 rust-linktime-proc-macro+default-devel \
 rust-linktime-proc-macro+dtor-devel \
 rust-linktime-proc-macro+link_section-devel \
 rust-linktime-proc-macro+scattered_collect-devel \
 rust-linktime-proc-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-linktime-proc-macro-0.2.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b96edfe26a658834884bfa7d45eef9f96d1d2a7a3aaee7342abe6f34d1499089"

URI_x86_64_v2_rust-linktime-proc-macro+ctor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+ctor-devel-0.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+ctor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linktime-proc-macro+ctor-devel}"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+ctor-devel.sha256sum] = "c7be860ad4b1ee868dcf0d2e5f4534ad6113dcb195f92fe8ba0bba5d0b85ff50"

URI_x86_64_v2_rust-linktime-proc-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+default-devel-0.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linktime-proc-macro+default-devel}"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+default-devel.sha256sum] = "4cb38abf571c917b446a6336ea1d18bc565c30e8cc0537666aa59f419af51330"

URI_x86_64_v2_rust-linktime-proc-macro+dtor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+dtor-devel-0.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+dtor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linktime-proc-macro+dtor-devel}"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+dtor-devel.sha256sum] = "f92d650a549ea4a0ae2a81e663b781a6c42488bd4c64f2589f8020629a5b9c33"

URI_x86_64_v2_rust-linktime-proc-macro+link_section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+link_section-devel-0.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+link_section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linktime-proc-macro+link_section-devel}"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+link_section-devel.sha256sum] = "43ceeb8081f9415b95a734eea58c3efa2a66a8954b3b7125951c2b17f3cdfd78"

URI_x86_64_v2_rust-linktime-proc-macro+scattered_collect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro+scattered_collect-devel-0.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro+scattered_collect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linktime-proc-macro+scattered_collect-devel}"
SRC_URI[x86_64_v2_rust-linktime-proc-macro+scattered_collect-devel.sha256sum] = "55919ccc1d020037339417cd85faf3519ec9cdfd48ce4e9f69e4a6d7f5659a7b"

URI_x86_64_v2_rust-linktime-proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-linktime-proc-macro-devel-0.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-linktime-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-linktime-proc-macro-devel}"
SRC_URI[x86_64_v2_rust-linktime-proc-macro-devel.sha256sum] = "1569ede327ba5b04a7884af5ee5dafb0c1671ec7a8b8b9cfb9ccad276b1b4fc5"

URI_aarch64_rust-linktime-proc-macro+ctor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+ctor-devel-0.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+ctor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linktime-proc-macro+ctor-devel}"
SRC_URI[aarch64_rust-linktime-proc-macro+ctor-devel.sha256sum] = "bc8cc5eff6ae69cc1f4e3a8361f3d22f02e95d7f1c38e4b6fb1ddfa3dd6f1310"

URI_aarch64_rust-linktime-proc-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+default-devel-0.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linktime-proc-macro+default-devel}"
SRC_URI[aarch64_rust-linktime-proc-macro+default-devel.sha256sum] = "fe6dc7494b1c9314d23eaa19332bb4f6b1dee13138a9494316720fd0c82f9732"

URI_aarch64_rust-linktime-proc-macro+dtor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+dtor-devel-0.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+dtor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linktime-proc-macro+dtor-devel}"
SRC_URI[aarch64_rust-linktime-proc-macro+dtor-devel.sha256sum] = "7b9ddc014b12cb39b30082165c0c77503cc1f5f0118d3e18993ee365d7ad9587"

URI_aarch64_rust-linktime-proc-macro+link_section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+link_section-devel-0.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+link_section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linktime-proc-macro+link_section-devel}"
SRC_URI[aarch64_rust-linktime-proc-macro+link_section-devel.sha256sum] = "fccc70ce2c5cbbd23306ae4ff46358e8c174ef980316df3d0704ce93bdac1a33"

URI_aarch64_rust-linktime-proc-macro+scattered_collect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro+scattered_collect-devel-0.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro+scattered_collect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linktime-proc-macro+scattered_collect-devel}"
SRC_URI[aarch64_rust-linktime-proc-macro+scattered_collect-devel.sha256sum] = "b06e390ad6049dd7246292ed26cd25a1611db4adec0c09563bc442ec80a4e1e2"

URI_aarch64_rust-linktime-proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-linktime-proc-macro-devel-0.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-linktime-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-linktime-proc-macro-devel}"
SRC_URI[aarch64_rust-linktime-proc-macro-devel.sha256sum] = "00cfff88b3b023b51736c8e7aa66451b8c5d0be5b93478572f1dd8d1868775bd"

RDEPENDS:rust-linktime-proc-macro+ctor-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro+default-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro+dtor-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro+link_section-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro+scattered_collect-devel = " \
 cargo \
 rust-linktime-proc-macro-devel \
 "
RDEPENDS:rust-linktime-proc-macro-devel = " \
 cargo \
 "
