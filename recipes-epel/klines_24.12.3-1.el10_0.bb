# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klines"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 klines \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/klines-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0abf1fad29a9af8fb221dcba0668058c104854c78b0bb662e86834dd5bea7ef5"

URI_x86_64_v2_klines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klines-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_klines}"
SRC_URI[x86_64_v2_klines.sha256sum] = "230c11002e69f4325bdea2828c911b5f95313c72bd6da5a054c4ca85cf9bee3d"

URI_aarch64_klines = "${EPEL_MIRROR}/aarch64/Packages/k/klines-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_klines;unpack=0"
SRC_URI:append = " ${URI_aarch64_klines}"
SRC_URI[aarch64_klines.sha256sum] = "46469f59920f18340c56071c5655249d49a49aa27605915e1ac8d154103aa3d9"

RDEPENDS:klines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
