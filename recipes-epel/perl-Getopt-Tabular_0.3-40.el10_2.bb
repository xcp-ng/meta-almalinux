# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Getopt-Tabular"
PV = "0.3"
PR = "40.el10_2"
PACKAGES = " \
 perl-Getopt-Tabular \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Getopt-Tabular-0.3-40.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "51316ad06e9d857bf8abcf7ba5f73c008774b496e0fe5cafbc95b93154581ee8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Getopt-Tabular-0.3-40.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Getopt-Tabular;unpack=0"
SRC_URI[x86_64_v2_perl-Getopt-Tabular.sha256sum] = "e874f5ed5304a2343ec716d144a933ba892e29a782827758cbd7c17e3eda3658"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Getopt-Tabular-0.3-40.el10_2.noarch.rpm;name=aarch64_perl-Getopt-Tabular;unpack=0"
SRC_URI[aarch64_perl-Getopt-Tabular.sha256sum] = "b109945123b8be8791730ed7e2ac7807ac86bd14d30c4c97762ee18fdee55cda"

RDEPENDS:perl-Getopt-Tabular = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
