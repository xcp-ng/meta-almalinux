# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skladnik"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 skladnik \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/skladnik-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "932e4a3f7510fe6653102ff9f18b415735729f6a16a00def4f0107f9ea6c8749"

URI_x86_64_v2_skladnik = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/skladnik-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_skladnik;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skladnik}"
SRC_URI[x86_64_v2_skladnik.sha256sum] = "4e7ebf5e5ae0f81bbcaf3e2a149abcbfd1969740c8a9bb1fa4776a40ab2a1a1f"

URI_aarch64_skladnik = "${EPEL_MIRROR}/aarch64/Packages/s/skladnik-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_skladnik;unpack=0"
SRC_URI:append = " ${URI_aarch64_skladnik}"
SRC_URI[aarch64_skladnik.sha256sum] = "4679a47ecdee66089cd12ce5eecc0df706afd15b7fb1a5d295508deb3485bb9c"

RDEPENDS:skladnik = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
