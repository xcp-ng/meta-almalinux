# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_sha224sum"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_sha224sum+default-devel \
 rust-uu_sha224sum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_sha224sum-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0090cda5f52beb9cff4a5cc8296fc5c3bee2698f298102d93039401b3c9a8fb"

URI_x86_64_v2_rust-uu_sha224sum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha224sum+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha224sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha224sum+default-devel}"
SRC_URI[x86_64_v2_rust-uu_sha224sum+default-devel.sha256sum] = "8546f24e90347f30ea539ee584be2b6cbace2ca5153415d232d658978333d5b4"

URI_x86_64_v2_rust-uu_sha224sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha224sum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha224sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha224sum-devel}"
SRC_URI[x86_64_v2_rust-uu_sha224sum-devel.sha256sum] = "c0cc1b0fb8522ec443a787f31cc60da6d1f02876eb123f14047e84143bb052e5"

URI_aarch64_rust-uu_sha224sum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha224sum+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha224sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha224sum+default-devel}"
SRC_URI[aarch64_rust-uu_sha224sum+default-devel.sha256sum] = "bc784e4caae0ba6e73ea456132895cebfd9b8b5ad34ec2e6108ce39bda0477f7"

URI_aarch64_rust-uu_sha224sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha224sum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha224sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha224sum-devel}"
SRC_URI[aarch64_rust-uu_sha224sum-devel.sha256sum] = "325dddc511c8358f9503e224a9b19df52639955779cd40129b34715742881e61"

RDEPENDS:rust-uu_sha224sum+default-devel = " \
 cargo \
 rust-uu_sha224sum-devel \
 "
RDEPENDS:rust-uu_sha224sum-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uu_checksum_common+default-devel \
 rust-uucore+checksum-devel \
 rust-uucore+default-devel \
 rust-uucore+encoding-devel \
 rust-uucore+hardware-devel \
 rust-uucore+sum-devel \
 "
