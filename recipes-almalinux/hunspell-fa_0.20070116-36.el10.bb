# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-fa"
PV = "0.20070116"
PR = "36.el10"
PACKAGES = " \
 hunspell-fa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-fa-0.20070116-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34efb41705d97c35d01cee517aa7be9bf03fde4ffa7be1da00faf32321917ad8"

URI_x86_64_v2_hunspell-fa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-fa-0.20070116-36.el10.noarch.rpm;name=x86_64_v2_hunspell-fa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-fa}"
SRC_URI[x86_64_v2_hunspell-fa.sha256sum] = "12bc62dc739dcd54e0b9848a9c9492b10815b82d47e9090e605e9a95058518e2"

URI_aarch64_hunspell-fa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-fa-0.20070116-36.el10.noarch.rpm;name=aarch64_hunspell-fa;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-fa}"
SRC_URI[aarch64_hunspell-fa.sha256sum] = "12bc62dc739dcd54e0b9848a9c9492b10815b82d47e9090e605e9a95058518e2"

RDEPENDS:hunspell-fa = " \
 hunspell-filesystem \
 "
