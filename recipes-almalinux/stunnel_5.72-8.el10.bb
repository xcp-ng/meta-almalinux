# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stunnel"
PV = "5.72"
PR = "8.el10"
PACKAGES = " \
 stunnel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/stunnel-5.72-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "087f7135187314ca5265f941713999907085ade0265b5589422e533c478ca097"

URI_x86_64_v2_stunnel = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/stunnel-5.72-8.el10.x86_64_v2.rpm;name=x86_64_v2_stunnel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stunnel}"
SRC_URI[x86_64_v2_stunnel.sha256sum] = "42cf1de635d5dfd61607e1e245fe1d3f525c95ff26b2ebd17393ab882b758e19"

URI_aarch64_stunnel = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/stunnel-5.72-8.el10.aarch64.rpm;name=aarch64_stunnel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stunnel}"
SRC_URI[aarch64_stunnel.sha256sum] = "27b1c4ed28b672ad572f7b0917c29a1c202676a7562a6bcfe4db83e5187b8c10"

RDEPENDS:stunnel = " \
 bash \
 glibc \
 openssl-libs \
 systemd \
 systemd-libs \
 "
