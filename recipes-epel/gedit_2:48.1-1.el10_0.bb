# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gedit"
PE = "2"
PV = "48.1"
PR = "1.el10_0"
PACKAGES = " \
 gedit \
 gedit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gedit-48.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4bff13504838ea2df4354c59f3b3b81310573385f95df37ac164e6dedef676b"

URI_x86_64_v2_gedit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit}"
SRC_URI[x86_64_v2_gedit.sha256sum] = "138e6c85a214650ad93f4ebbe3e60c2ec136fb8e7ffb8eaba984bf12ab10edb5"

URI_x86_64_v2_gedit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gedit-devel-48.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gedit-devel}"
SRC_URI[x86_64_v2_gedit-devel.sha256sum] = "0b465c6835face4dc5f273c22f521fa2166e965bb74768871ac8733fa365cca6"

URI_aarch64_gedit = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit}"
SRC_URI[aarch64_gedit.sha256sum] = "dcf897009e32b81c46e27c137fb4c81ee3dc82e32929560481aa74555e54dfce"

URI_aarch64_gedit-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gedit-devel-48.1-1.el10_0.aarch64.rpm;name=aarch64_gedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gedit-devel}"
SRC_URI[aarch64_gedit-devel.sha256sum] = "b5a66fa10bc3bdc24b5c7f5aae589ac1ceef1b033305471b5cd5e1107a8a8d46"

RDEPENDS:gedit = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gobject-introspection \
 gsettings-desktop-schemas \
 gspell \
 gtk3 \
 libgcc \
 libgedit-amtk \
 libgedit-gfls \
 libgedit-gtksourceview \
 libgedit-tepl \
 libpeas1 \
 libpeas1-gtk \
 libpeas1-loader-python3 \
 pango \
 python3 \
 python3-gobject \
 "
RDEPENDS:gedit-devel = " \
 gedit \
 glib2-devel \
 gtk3-devel \
 libgedit-tepl-devel \
 libpeas1-devel \
 pkgconf-pkg-config \
 "
