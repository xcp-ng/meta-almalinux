# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libz-ng-sys"
PV = "1.1.21"
PR = "1.el10_0"
PACKAGES = " \
 rust-libz-ng-sys+default-devel \
 rust-libz-ng-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libz-ng-sys-1.1.21-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2ffe0f0e92172475e5fd90eda518074e21af54475e80fa6faa3dc93736cad53f"

URI_x86_64_v2_rust-libz-ng-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-ng-sys+default-devel-1.1.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-ng-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-ng-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libz-ng-sys+default-devel.sha256sum] = "87027245ecf1f605bbbfd19c8d860035f889cee705b03a7eac139e8a10284a13"

URI_x86_64_v2_rust-libz-ng-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libz-ng-sys-devel-1.1.21-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libz-ng-sys-devel}"
SRC_URI[x86_64_v2_rust-libz-ng-sys-devel.sha256sum] = "e2fbba642472a4f668d8188b77c264ec837d47df56163541ae94b5b8a7ce1542"

URI_aarch64_rust-libz-ng-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-ng-sys+default-devel-1.1.21-1.el10_0.noarch.rpm;name=aarch64_rust-libz-ng-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-ng-sys+default-devel}"
SRC_URI[aarch64_rust-libz-ng-sys+default-devel.sha256sum] = "81187cdbfba7f6eed6baea530110f6a1a1f10d56f4098fc2861e2420e0fd3cae"

URI_aarch64_rust-libz-ng-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libz-ng-sys-devel-1.1.21-1.el10_0.noarch.rpm;name=aarch64_rust-libz-ng-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libz-ng-sys-devel}"
SRC_URI[aarch64_rust-libz-ng-sys-devel.sha256sum] = "a6bbd53ae6b72d2707eb361417d4d285298d00c32c57d2f205f5a53148d0e968"

RDEPENDS:rust-libz-ng-sys+default-devel = " \
 cargo \
 rust-libz-ng-sys-devel \
 "
RDEPENDS:rust-libz-ng-sys-devel = " \
 cargo \
 rust-libc+default-devel \
 zlib-ng-devel \
 "
