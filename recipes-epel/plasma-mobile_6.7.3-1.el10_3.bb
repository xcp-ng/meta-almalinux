# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-mobile"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-lookandfeel-fedora-mobile \
 plasma-mobile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-mobile-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4da88ae218661c48e4c543cb0d2bd251ee0164b95a353c71f58050bd5319139"

URI_x86_64_v2_plasma-lookandfeel-fedora-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-lookandfeel-fedora-mobile-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-lookandfeel-fedora-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-lookandfeel-fedora-mobile}"
SRC_URI[x86_64_v2_plasma-lookandfeel-fedora-mobile.sha256sum] = "2a858f2e985eb68828e42f1ab529503425e64c241adf5e009c151d7a18024e77"

URI_x86_64_v2_plasma-mobile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-mobile-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-mobile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-mobile}"
SRC_URI[x86_64_v2_plasma-mobile.sha256sum] = "9a45f80d9a74f9edd43aeb218a7b24958338a04bc6cdc579c925676bad2266dd"

URI_aarch64_plasma-lookandfeel-fedora-mobile = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-lookandfeel-fedora-mobile-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma-lookandfeel-fedora-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-lookandfeel-fedora-mobile}"
SRC_URI[aarch64_plasma-lookandfeel-fedora-mobile.sha256sum] = "de3e342d80d0a54cf0e97e3fdea5f622d3ef3f7a7d316d4db0db6a48e9c27719"

URI_aarch64_plasma-mobile = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-mobile-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-mobile;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-mobile}"
SRC_URI[aarch64_plasma-mobile.sha256sum] = "34fb87abd75b2874705a47ad4f88e80043d04b178abd83d7b4a736c11cad7875"

RDEPENDS:plasma-lookandfeel-fedora-mobile = " \
 plasma-mobile \
 "
RDEPENDS:plasma-mobile = " \
 bash \
 glibc \
 kf6-bluez-qt \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-solid \
 kpipewire \
 kscreen \
 kwayland \
 kwin \
 kwin-libs \
 layer-shell-qt \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 plasma-activities \
 plasma-lookandfeel-fedora-mobile \
 plasma-milou \
 plasma-nano \
 plasma-nm \
 plasma-pa \
 plasma-workspace \
 qcoro-qt6 \
 qqc2-breeze-style \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 qt6-qtwayland \
 systemd-libs \
 virtual/system-backgrounds-kde \
 "
