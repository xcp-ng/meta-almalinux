# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcanlock"
PV = "3.3.3"
PR = "2.el10_3"
PACKAGES = " \
 canlock \
 libcanlock \
 libcanlock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcanlock-3.3.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6512e46efcfdc66c95481fdabce508872351aaa9be09ea3cbfd079266e30d865"

URI_x86_64_v2_canlock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/canlock-3.3.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_canlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_canlock}"
SRC_URI[x86_64_v2_canlock.sha256sum] = "4e9589e318881343c5fa34866eaaa70c49a383ba9b3243744051c530d90e733d"

URI_x86_64_v2_libcanlock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcanlock-3.3.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcanlock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcanlock}"
SRC_URI[x86_64_v2_libcanlock.sha256sum] = "9a6fe7cdc4e4571627c921be60b15f753a266885c5888b0d45b3cde2ac64a598"

URI_x86_64_v2_libcanlock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcanlock-devel-3.3.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcanlock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcanlock-devel}"
SRC_URI[x86_64_v2_libcanlock-devel.sha256sum] = "fa08e6899d41850f7646ea033f7c39e023a8cfce213487afb3d950b358627e2f"

URI_aarch64_canlock = "${EPEL_MIRROR}/aarch64/Packages/c/canlock-3.3.3-2.el10_3.aarch64.rpm;name=aarch64_canlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_canlock}"
SRC_URI[aarch64_canlock.sha256sum] = "4f290b25e0603c970096710d7735508700da6184004855d965439627d968dc5b"

URI_aarch64_libcanlock = "${EPEL_MIRROR}/aarch64/Packages/l/libcanlock-3.3.3-2.el10_3.aarch64.rpm;name=aarch64_libcanlock;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcanlock}"
SRC_URI[aarch64_libcanlock.sha256sum] = "d00991f98221db3661ebe4b84e1cebaa7fe159f5d6904b0c50c2929b617ca1a6"

URI_aarch64_libcanlock-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcanlock-devel-3.3.3-2.el10_3.aarch64.rpm;name=aarch64_libcanlock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcanlock-devel}"
SRC_URI[aarch64_libcanlock-devel.sha256sum] = "892805be8a9318f34e62f2a4ac150fec4fd42051f39241a47451ce9c20067a06"

RDEPENDS:canlock = " \
 glibc \
 libcanlock \
 "
RDEPENDS:libcanlock = " \
 glibc \
 "
RDEPENDS:libcanlock-devel = " \
 libcanlock \
 pkgconf-pkg-config \
 "
