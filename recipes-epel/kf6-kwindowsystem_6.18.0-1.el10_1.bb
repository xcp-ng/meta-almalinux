# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwindowsystem"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kwindowsystem \
 kf6-kwindowsystem-devel \
 kf6-kwindowsystem-doc \
 kf6-kwindowsystem-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwindowsystem-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c79d4ad22a898b91e1ec9674c2280875246cb09f9c47aa5fcae04d5864d7785"

URI_x86_64_v2_kf6-kwindowsystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem}"
SRC_URI[x86_64_v2_kf6-kwindowsystem.sha256sum] = "c0eeabd5f860c15865ec562ca8afcf14380f903f5ad51ac554f04c167cec6680"

URI_x86_64_v2_kf6-kwindowsystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-devel}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-devel.sha256sum] = "60c6928b53701ffae5496db436587fe6592d95fe17738faae57ccbcc9cbb7d64"

URI_x86_64_v2_kf6-kwindowsystem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwindowsystem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-doc}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-doc.sha256sum] = "ce6efc45fb1273866cedf230516d3013eaa2b1a5bc0df1019ba0342105550a87"

URI_x86_64_v2_kf6-kwindowsystem-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwindowsystem-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-html}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-html.sha256sum] = "625264e782fa693f0fc20cf7666f2373ec4f9db71cb4fe7b8a6de2df1797c280"

URI_aarch64_kf6-kwindowsystem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kwindowsystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem}"
SRC_URI[aarch64_kf6-kwindowsystem.sha256sum] = "a6ea1c0b15a24828976e32c920f9d76095bfb60d02586a6b0a6460c492157942"

URI_aarch64_kf6-kwindowsystem-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kwindowsystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-devel}"
SRC_URI[aarch64_kf6-kwindowsystem-devel.sha256sum] = "0d9f5bb77a5c87899925a0ea6de351bcfb7c77a9c32f4ed100f9fdedc3c3ad53"

URI_aarch64_kf6-kwindowsystem-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kwindowsystem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-doc}"
SRC_URI[aarch64_kf6-kwindowsystem-doc.sha256sum] = "ff9cc13f57549272b9e189c4828a0bc490009e09b5f3f77fbc6bad6771864049"

URI_aarch64_kf6-kwindowsystem-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kwindowsystem-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-html}"
SRC_URI[aarch64_kf6-kwindowsystem-html.sha256sum] = "6fb85ce86fb8510021f066831df15498a6126df56f7f4391082e8291bdbdc951"

RDEPENDS:kf6-kwindowsystem = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libXfixes \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 xcb-util-keysyms \
 "
RDEPENDS:kf6-kwindowsystem-devel = " \
 cmake-filesystem \
 kf6-kwindowsystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwindowsystem-doc = " \
 "
RDEPENDS:kf6-kwindowsystem-html = " \
 "
