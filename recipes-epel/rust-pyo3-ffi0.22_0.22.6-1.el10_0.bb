# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-ffi0.22"
PV = "0.22.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-ffi0.22+abi3-devel \
 rust-pyo3-ffi0.22+abi3-py310-devel \
 rust-pyo3-ffi0.22+abi3-py311-devel \
 rust-pyo3-ffi0.22+abi3-py312-devel \
 rust-pyo3-ffi0.22+abi3-py37-devel \
 rust-pyo3-ffi0.22+abi3-py38-devel \
 rust-pyo3-ffi0.22+abi3-py39-devel \
 rust-pyo3-ffi0.22+default-devel \
 rust-pyo3-ffi0.22+extension-module-devel \
 rust-pyo3-ffi0.22-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-ffi0.22-0.22.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f402ba34f23b525fedb7498bee36b95ae6f3e189eae30909f5bd1a94e40edef"

URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22+abi3-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22+abi3-devel.sha256sum] = "98eb7a93204014e2d418261fff248a130d0d4e4aa25d8695c794db4e4dfee407"

URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22+abi3-py310-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22+abi3-py310-devel.sha256sum] = "8a797e400ed61ac5888ebf2c3cdd2358a9d4dbb2d344a0947ef902caa31e0465"

URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22+abi3-py311-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22+abi3-py311-devel.sha256sum] = "dc6fab1a29d8b47b50d9a86c6019877908b7695768a02d9788e50541e2a09f14"

URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22+abi3-py312-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22+abi3-py312-devel.sha256sum] = "c06b3c35fa728e242bbd842534efc0231bb9a7effe3c975259af6bf790d2dc04"

URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22+abi3-py37-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22+abi3-py37-devel.sha256sum] = "9ed8c5a700ef4344e0ac12200a80e1d0af48e9573d38cff2d1664b0d77dac58b"

URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22+abi3-py38-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22+abi3-py38-devel.sha256sum] = "316f2dd33e26de280f0cd8b2686d3917945cc85e59c9df4541b08c36fda1b163"

URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22+abi3-py39-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22+abi3-py39-devel.sha256sum] = "00b2f55dcbc8532ab341e3fe04017fb48842c64e1f2f4e2bd5f645a8d5fc01f0"

URI_x86_64_v2_rust-pyo3-ffi0.22+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22+default-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22+default-devel.sha256sum] = "b03614d510b8175621198989ffd5e9089c3d0f819885801a83f485110cf065ac"

URI_x86_64_v2_rust-pyo3-ffi0.22+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22+extension-module-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22+extension-module-devel.sha256sum] = "81273bbf1de7c5568b7eba783d7db4046510c8fa1d297faa4b0105c30dc85e7b"

URI_x86_64_v2_rust-pyo3-ffi0.22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-ffi0.22-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-ffi0.22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-ffi0.22-devel}"
SRC_URI[x86_64_v2_rust-pyo3-ffi0.22-devel.sha256sum] = "0fc8dd66bb6383dfce6c34c74a247f2780e7de3119116e6eaf0c2c40e8a80661"

URI_aarch64_rust-pyo3-ffi0.22+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22+abi3-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22+abi3-devel.sha256sum] = "9cb191e5de6908666431d5664aed580e152444a47fefdf9e6ddd5743d5a99855"

URI_aarch64_rust-pyo3-ffi0.22+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22+abi3-py310-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22+abi3-py310-devel.sha256sum] = "4dd90ed6c9e632252a0e7fb6c73c1cc19715cf41ceced0c9a7a02f86593b812f"

URI_aarch64_rust-pyo3-ffi0.22+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22+abi3-py311-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22+abi3-py311-devel.sha256sum] = "e3d90aba4107b604ec2dc92d396bf8cc0fe8385814466984111d059b219b13cd"

URI_aarch64_rust-pyo3-ffi0.22+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22+abi3-py312-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22+abi3-py312-devel.sha256sum] = "cc7b2c16ca772251128917686dbd95425e0e7e4c91cb97cad03f8b9ffa03ff51"

URI_aarch64_rust-pyo3-ffi0.22+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22+abi3-py37-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22+abi3-py37-devel.sha256sum] = "543654a050189c7c44669be0b22d5951f734ec26b4a343af3aa07cafe284cccd"

URI_aarch64_rust-pyo3-ffi0.22+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22+abi3-py38-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22+abi3-py38-devel.sha256sum] = "d3433511ea76af0a4787840ae98df37a815f46e79a7740a9703cd3a4e7002c45"

URI_aarch64_rust-pyo3-ffi0.22+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22+abi3-py39-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22+abi3-py39-devel.sha256sum] = "6abcf13d12d788ae2d3a7b20e08bafd4f09f17d5a2aff3c0f55b2e709da7caec"

URI_aarch64_rust-pyo3-ffi0.22+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22+default-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22+default-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22+default-devel.sha256sum] = "10cf54a72d052622b4a498b25549b499193859324c5d9328fedcf5c0a16d4afa"

URI_aarch64_rust-pyo3-ffi0.22+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22+extension-module-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22+extension-module-devel.sha256sum] = "c51ecca834f593ed3bebed3c0847e96c1afcbea5f90df4686db2c401ae3508f1"

URI_aarch64_rust-pyo3-ffi0.22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-ffi0.22-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-ffi0.22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-ffi0.22-devel}"
SRC_URI[aarch64_rust-pyo3-ffi0.22-devel.sha256sum] = "7ce19b1fd250d073b7d3d8ba7bd7b534e7a08fa064d8e7f614a4c0806f2036cd"

RDEPENDS:rust-pyo3-ffi0.22+abi3-devel = " \
 cargo \
 rust-pyo3-ffi0.22-devel \
 "
RDEPENDS:rust-pyo3-ffi0.22+abi3-py310-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py311-devel \
 rust-pyo3-ffi0.22-devel \
 "
RDEPENDS:rust-pyo3-ffi0.22+abi3-py311-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py312-devel \
 rust-pyo3-ffi0.22-devel \
 "
RDEPENDS:rust-pyo3-ffi0.22+abi3-py312-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-devel \
 rust-pyo3-ffi0.22-devel \
 "
RDEPENDS:rust-pyo3-ffi0.22+abi3-py37-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py38-devel \
 rust-pyo3-ffi0.22-devel \
 "
RDEPENDS:rust-pyo3-ffi0.22+abi3-py38-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py39-devel \
 rust-pyo3-ffi0.22-devel \
 "
RDEPENDS:rust-pyo3-ffi0.22+abi3-py39-devel = " \
 cargo \
 rust-pyo3-ffi0.22+abi3-py310-devel \
 rust-pyo3-ffi0.22-devel \
 "
RDEPENDS:rust-pyo3-ffi0.22+default-devel = " \
 cargo \
 rust-pyo3-ffi0.22-devel \
 "
RDEPENDS:rust-pyo3-ffi0.22+extension-module-devel = " \
 cargo \
 rust-pyo3-ffi0.22-devel \
 "
RDEPENDS:rust-pyo3-ffi0.22-devel = " \
 cargo \
 python3-devel \
 rust-libc+default-devel \
 rust-pyo3-build-config0.22+default-devel \
 rust-pyo3-build-config0.22+resolve-config-devel \
 "
