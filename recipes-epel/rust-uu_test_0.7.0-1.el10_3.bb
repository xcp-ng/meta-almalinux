# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_test"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_test+default-devel \
 rust-uu_test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_test-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd6c7b92530266c14bca438e4beb977b36d81859b490b2e6678af2c772be3c6e"

URI_x86_64_v2_rust-uu_test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_test+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_test+default-devel}"
SRC_URI[x86_64_v2_rust-uu_test+default-devel.sha256sum] = "15ffc9de075e48fde9c142fbc9c8e6ab7a525899f99d7829262554468d368f1c"

URI_x86_64_v2_rust-uu_test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_test-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_test-devel}"
SRC_URI[x86_64_v2_rust-uu_test-devel.sha256sum] = "6d34897fad23069d91700e6bee8a15257b2357dc536cb17acf39f1a5c5099582"

URI_aarch64_rust-uu_test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_test+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_test+default-devel}"
SRC_URI[aarch64_rust-uu_test+default-devel.sha256sum] = "459c2c99e8f3ce18bc50786de6fd579efe95667064cf712774711c09e2e1df23"

URI_aarch64_rust-uu_test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_test-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_test-devel}"
SRC_URI[aarch64_rust-uu_test-devel.sha256sum] = "ca3104a6341fa85b28d39d5807efb8c6e098f8708817edc98850fd6b56604c03"

RDEPENDS:rust-uu_test+default-devel = " \
 cargo \
 rust-uu_test-devel \
 "
RDEPENDS:rust-uu_test-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+process-devel \
 "
