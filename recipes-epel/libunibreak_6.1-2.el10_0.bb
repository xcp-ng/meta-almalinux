# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libunibreak"
PV = "6.1"
PR = "2.el10_0"
PACKAGES = " \
 libunibreak \
 libunibreak-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libunibreak-6.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6eb465cbd9e94abcd59c25911d54776e7f89539b56c351f90f7da7e289b5df4"

URI_x86_64_v2_libunibreak = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libunibreak-6.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libunibreak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libunibreak}"
SRC_URI[x86_64_v2_libunibreak.sha256sum] = "ca74a5a1a53a521a26b24c986cb1fa356cf23a6b0b5a36f6b2689e9daf71501a"

URI_x86_64_v2_libunibreak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libunibreak-devel-6.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libunibreak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libunibreak-devel}"
SRC_URI[x86_64_v2_libunibreak-devel.sha256sum] = "8891dc8da56a55b78f4d40f76337de4d85db4027ee5dacb823fe8515a110a48f"

URI_aarch64_libunibreak = "${EPEL_MIRROR}/aarch64/Packages/l/libunibreak-6.1-2.el10_0.aarch64.rpm;name=aarch64_libunibreak;unpack=0"
SRC_URI:append = " ${URI_aarch64_libunibreak}"
SRC_URI[aarch64_libunibreak.sha256sum] = "25e39d0c72c01279aaab440bf0ee35c85716423be9df88f04ac96de3fec9a954"

URI_aarch64_libunibreak-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libunibreak-devel-6.1-2.el10_0.aarch64.rpm;name=aarch64_libunibreak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libunibreak-devel}"
SRC_URI[aarch64_libunibreak-devel.sha256sum] = "72c064c0c1dc820b9c9feca8ba92f29e2f34e6e55d39608a5d8b5a91ec73386d"

RDEPENDS:libunibreak = " \
 glibc \
 "
RDEPENDS:libunibreak-devel = " \
 libunibreak \
 pkgconf-pkg-config \
 "
