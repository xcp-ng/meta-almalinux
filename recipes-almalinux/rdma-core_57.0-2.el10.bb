# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rdma-core"
PV = "57.0"
PR = "2.el10"
PACKAGES = " \
 ibacm \
 infiniband-diags \
 iwpmd \
 libibumad \
 libibverbs \
 libibverbs-utils \
 librdmacm \
 librdmacm-utils \
 python3-pyverbs \
 rdma-core \
 rdma-core-devel \
 srp_daemon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rdma-core-57.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9626079b6fdedaf0c4a70c883afa51a1ff94567b99f920d4c7ee83c1cdf9c1cc"

URI_x86_64_v2_ibacm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ibacm-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ibacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibacm}"
SRC_URI[x86_64_v2_ibacm.sha256sum] = "49ddd6c6ace12879b241bdfd6f6d74752a816e5b28acdf39e7d3c626d982daf3"

URI_x86_64_v2_infiniband-diags = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/infiniband-diags-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_infiniband-diags;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_infiniband-diags}"
SRC_URI[x86_64_v2_infiniband-diags.sha256sum] = "9c52c57075e212571b2224903c2f707a0294a11d1072e14e351896f49c9bbb77"

URI_x86_64_v2_iwpmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iwpmd-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iwpmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iwpmd}"
SRC_URI[x86_64_v2_iwpmd.sha256sum] = "66050656c3b6ffcf350413dcacf4162bcecea42d0ffee9c03c783c023f9a1654"

URI_x86_64_v2_libibumad = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibumad-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libibumad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibumad}"
SRC_URI[x86_64_v2_libibumad.sha256sum] = "7f0af319c2bfbc6b44748f1ff90b42b050bd6342d1012dab886fd10ba45378b9"

URI_x86_64_v2_libibverbs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libibverbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibverbs}"
SRC_URI[x86_64_v2_libibverbs.sha256sum] = "1147200323cbbe01f691c5f0fe0cc9aa260b6715cf62467206bb967e8eedaad7"

URI_x86_64_v2_libibverbs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libibverbs-utils-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libibverbs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libibverbs-utils}"
SRC_URI[x86_64_v2_libibverbs-utils.sha256sum] = "fc9bff445aaa6234da7fbd4162dba53eded5e4a6f4ca2dc1fd3d2afe88d87141"

URI_x86_64_v2_librdmacm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_librdmacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdmacm}"
SRC_URI[x86_64_v2_librdmacm.sha256sum] = "eeca09d19916f607bf74212a310ccae658222663d092f48d1bf73f5902369369"

URI_x86_64_v2_librdmacm-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/librdmacm-utils-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_librdmacm-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librdmacm-utils}"
SRC_URI[x86_64_v2_librdmacm-utils.sha256sum] = "ada36b867d54477e8430118de4bd3393f4984dd0acc7998b651913190a61b59e"

URI_x86_64_v2_python3-pyverbs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyverbs-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyverbs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyverbs}"
SRC_URI[x86_64_v2_python3-pyverbs.sha256sum] = "65be3525aacbdff81fddc2463810578149b6b4aecbbedd013a33c54dd198fda1"

URI_x86_64_v2_rdma-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rdma-core-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rdma-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rdma-core}"
SRC_URI[x86_64_v2_rdma-core.sha256sum] = "1816715c6d1eba9efe654e5462696f83946683dc8854cc7a650cb1b8d3c17f75"

URI_x86_64_v2_rdma-core-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rdma-core-devel-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rdma-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rdma-core-devel}"
SRC_URI[x86_64_v2_rdma-core-devel.sha256sum] = "bc3d5ee95ce89680c5af8c36f016347238e05f2c157c0a91fe5ad8947bf4ae92"

URI_x86_64_v2_srp_daemon = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/srp_daemon-57.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_srp_daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_srp_daemon}"
SRC_URI[x86_64_v2_srp_daemon.sha256sum] = "12359ef293ca81c73292cd03f3099e9e193571125362b6798274fce812bcfb54"

URI_aarch64_ibacm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ibacm-57.0-2.el10.aarch64.rpm;name=aarch64_ibacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibacm}"
SRC_URI[aarch64_ibacm.sha256sum] = "084b68def30b990b99680c5f7d930480c2e9d4bce43bde55f0e0dbdf99d28b15"

URI_aarch64_infiniband-diags = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/infiniband-diags-57.0-2.el10.aarch64.rpm;name=aarch64_infiniband-diags;unpack=0"
SRC_URI:append = " ${URI_aarch64_infiniband-diags}"
SRC_URI[aarch64_infiniband-diags.sha256sum] = "4041aefaa9a3bc7201c9e86f884d098ef0351882164441dbebef66444401bbce"

URI_aarch64_iwpmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iwpmd-57.0-2.el10.aarch64.rpm;name=aarch64_iwpmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_iwpmd}"
SRC_URI[aarch64_iwpmd.sha256sum] = "0595ecbb758a55e0cc121ab37e45274e5efffb9a64300512c9055383a7e66266"

URI_aarch64_libibumad = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibumad-57.0-2.el10.aarch64.rpm;name=aarch64_libibumad;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibumad}"
SRC_URI[aarch64_libibumad.sha256sum] = "cb62dd8bf3bdd97706b44636c888a15873182573c01b37023564620770c1e813"

URI_aarch64_libibverbs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-57.0-2.el10.aarch64.rpm;name=aarch64_libibverbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibverbs}"
SRC_URI[aarch64_libibverbs.sha256sum] = "661134061ed4936450aa426a74437623b31ce05d39929099d7c8a535ca846d10"

URI_aarch64_libibverbs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libibverbs-utils-57.0-2.el10.aarch64.rpm;name=aarch64_libibverbs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libibverbs-utils}"
SRC_URI[aarch64_libibverbs-utils.sha256sum] = "5dc5860021a9ca0e4afd902b45905411d4bfe9b5d5f7cc3cd8ce7787bd9b05b9"

URI_aarch64_librdmacm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-57.0-2.el10.aarch64.rpm;name=aarch64_librdmacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdmacm}"
SRC_URI[aarch64_librdmacm.sha256sum] = "1b7fd445757eb2fa379474549e9cc4a6c7870691c54afa893fed5802fe18ded1"

URI_aarch64_librdmacm-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/librdmacm-utils-57.0-2.el10.aarch64.rpm;name=aarch64_librdmacm-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_librdmacm-utils}"
SRC_URI[aarch64_librdmacm-utils.sha256sum] = "fafa91f4fbd765bb5a89853759fd9c9282c41fd6cc46be5c95cec24b4aa2b744"

URI_aarch64_python3-pyverbs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyverbs-57.0-2.el10.aarch64.rpm;name=aarch64_python3-pyverbs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyverbs}"
SRC_URI[aarch64_python3-pyverbs.sha256sum] = "23552e777d0d49d1ad335feaa58bb3272c19e646069cee194fe8fab2dec61f5a"

URI_aarch64_rdma-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rdma-core-57.0-2.el10.aarch64.rpm;name=aarch64_rdma-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_rdma-core}"
SRC_URI[aarch64_rdma-core.sha256sum] = "1d84873fb91d1ec2daedabb4ba9788a70bf75a1a81417cbf7500b2294fc0d3b0"

URI_aarch64_rdma-core-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rdma-core-devel-57.0-2.el10.aarch64.rpm;name=aarch64_rdma-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rdma-core-devel}"
SRC_URI[aarch64_rdma-core-devel.sha256sum] = "56f26b7d5abbdf7cb2838d67de375e75c2418edf0271062187a2d6d832e6c9e9"

URI_aarch64_srp_daemon = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/srp_daemon-57.0-2.el10.aarch64.rpm;name=aarch64_srp_daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_srp_daemon}"
SRC_URI[aarch64_srp_daemon.sha256sum] = "fa21e08654f5707f91a7022229031a8df3980ea5f663016b8518a70201ca9cb9"

RDEPENDS:ibacm = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:infiniband-diags = " \
 bash \
 glibc \
 libibumad \
 perl-Getopt-Std \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:iwpmd = " \
 bash \
 glibc \
 libnl3 \
 systemd \
 systemd-libs \
 "
RDEPENDS:libibumad = " \
 glibc \
 "
RDEPENDS:libibverbs = " \
 glibc \
 libnl3 \
 "
RDEPENDS:libibverbs-utils = " \
 glibc \
 libibverbs \
 "
RDEPENDS:librdmacm = " \
 glibc \
 libibverbs \
 libnl3 \
 "
RDEPENDS:librdmacm-utils = " \
 glibc \
 libibverbs \
 librdmacm \
 "
RDEPENDS:python3-pyverbs = " \
 glibc \
 libibverbs \
 librdmacm \
 python3 \
 python3-libs \
 "
RDEPENDS:rdma-core = " \
 bash \
 glibc \
 libnl3 \
 pciutils \
 systemd-libs \
 "
RDEPENDS:rdma-core-devel = " \
 infiniband-diags \
 libibumad \
 libibverbs \
 librdmacm \
 pkgconf-pkg-config \
 rdma-core-devel \
 "
RDEPENDS:srp_daemon = " \
 bash \
 glibc \
 libibumad \
 libibverbs \
 systemd \
 "
