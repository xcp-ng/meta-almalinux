# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "prometheus-podman-exporter"
PV = "1.17.2"
PR = "1.el10_1"
PACKAGES = " \
 prometheus-podman-exporter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/prometheus-podman-exporter-1.17.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb87d4b0ab1855cf72255a8bee99995c9d8713434c89a14d551a083a3f655532"

URI_x86_64_v2_prometheus-podman-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/prometheus-podman-exporter-1.17.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_prometheus-podman-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_prometheus-podman-exporter}"
SRC_URI[x86_64_v2_prometheus-podman-exporter.sha256sum] = "9738ac08997f294d43666aa5ced9f4a909687b85f88a0f56b5034b4610228f3f"

URI_aarch64_prometheus-podman-exporter = "${EPEL_MIRROR}/aarch64/Packages/p/prometheus-podman-exporter-1.17.2-1.el10_1.aarch64.rpm;name=aarch64_prometheus-podman-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_prometheus-podman-exporter}"
SRC_URI[aarch64_prometheus-podman-exporter.sha256sum] = "85cf797d75b4f86527356ced8170559e2966fc2df782eb4d3e2727183ae76e85"

RDEPENDS:prometheus-podman-exporter = " \
 bash \
 glibc \
 gpgme \
 "
