# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lark"
PV = "1.1.7"
PR = "5.el10"
PACKAGES = " \
 python3-lark \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-lark-1.1.7-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "851b0aa28a0a846a3479c7886d3b25dea28d02a435c80b762ee8c0d7252311da"

URI_x86_64_v2_python3-lark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lark-1.1.7-5.el10.noarch.rpm;name=x86_64_v2_python3-lark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lark}"
SRC_URI[x86_64_v2_python3-lark.sha256sum] = "af7470289ab685204ba2e8e18deec0c994a55d71a07188e24c6b749a34308fc1"

URI_aarch64_python3-lark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lark-1.1.7-5.el10.noarch.rpm;name=aarch64_python3-lark;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lark}"
SRC_URI[aarch64_python3-lark.sha256sum] = "af7470289ab685204ba2e8e18deec0c994a55d71a07188e24c6b749a34308fc1"

RDEPENDS:python3-lark = " \
 python3 \
 "
