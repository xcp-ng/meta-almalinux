# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slotmap"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-slotmap+default-devel \
 rust-slotmap+serde-devel \
 rust-slotmap+std-devel \
 rust-slotmap+unstable-devel \
 rust-slotmap-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-slotmap-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b83d5eee62392bd6f2456d2c17966fac513736f9effbbc639efe055443018b7d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap+default-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-slotmap+default-devel.sha256sum] = "db8c91ebb297aad09b47f5f6400c1fb8d9e481dcaddd7f584c90ac29f9461658"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap+serde-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-slotmap+serde-devel.sha256sum] = "99db622bc8d8403021b01669af87ef409a4a566962d62de6219c029327c2ad59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap+std-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-slotmap+std-devel.sha256sum] = "508b7062bf2d0e17e1bbb5b48c0f67611576c36811b67bda77e51de351d28687"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap+unstable-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-slotmap+unstable-devel.sha256sum] = "dd1bf40683ca5854d31d71f435da46709c60611f142225ee4f3674c2ad6b6ca1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slotmap-devel-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slotmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-slotmap-devel.sha256sum] = "b8d87ec6fb9a41099796b87c45567485cde6a13b3518175e8bdfb1040491d785"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap+default-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-slotmap+default-devel;unpack=0"
SRC_URI[aarch64_rust-slotmap+default-devel.sha256sum] = "7b7a4c64bd315e89502b30c3441392545da2d11c8a125ffee2092872ff2147ee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap+serde-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-slotmap+serde-devel;unpack=0"
SRC_URI[aarch64_rust-slotmap+serde-devel.sha256sum] = "8da8114f1eb9286882b5f9e5abd4d4cf3dcfcefba6106420b3f0c84e47b4ab4d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap+std-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-slotmap+std-devel;unpack=0"
SRC_URI[aarch64_rust-slotmap+std-devel.sha256sum] = "ead6dd8340b4100a9ed3a9015e225b9e1606e066afebc7707dcb8b2d8d732f5f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap+unstable-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-slotmap+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-slotmap+unstable-devel.sha256sum] = "37c65ec5ac7cf7dbc01c53b805d8d1a5c3894de3cc07ddf69c8eac905ffdea4c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-slotmap-devel-1.1.1-1.el10_2.noarch.rpm;name=aarch64_rust-slotmap-devel;unpack=0"
SRC_URI[aarch64_rust-slotmap-devel.sha256sum] = "3490ef8527dae44ca5a6d4e7d55ab863ee11e0d901c8cdce6dbbb2923a08e53b"

RDEPENDS:rust-slotmap+default-devel = " \
 cargo \
 rust-slotmap+std-devel \
 rust-slotmap-devel \
 "
RDEPENDS:rust-slotmap+serde-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-slotmap-devel \
 "
RDEPENDS:rust-slotmap+std-devel = " \
 cargo \
 rust-slotmap-devel \
 "
RDEPENDS:rust-slotmap+unstable-devel = " \
 cargo \
 rust-slotmap-devel \
 "
RDEPENDS:rust-slotmap-devel = " \
 cargo \
 rust \
 rust-version_check+default-devel \
 "
