# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fence-agents"
PV = "4.16.0"
PR = "21.el10_2.6"
PACKAGES:x86_64_v2 = " \
 fence-agents-aliyun \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-aws \
 fence-agents-azure-arm \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-gce \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-openstack \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
 fence-virtd \
 fence-virtd-cpg \
 fence-virtd-libvirt \
 fence-virtd-multicast \
 fence-virtd-serial \
 fence-virtd-tcp \
 ha-cloud-support \
"
PACKAGES:aarch64 = " \
 fence-agents-all \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-common \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibm-powervs \
 fence-agents-ibm-vpc \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-kubevirt \
 fence-agents-lpar \
 fence-agents-mpath \
 fence-agents-nutanix-ahv \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-virsh \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fence-agents-4.16.0-21.el10_2.6.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d54836e7660e9cacb86df9bb58dd804a56fbd8500adb54218272d910b00e11bb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aliyun-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aliyun;unpack=0"
SRC_URI[x86_64_v2_fence-agents-aliyun.sha256sum] = "d59be4d31f5e229080dfb0484cd388df4b4ad51679a1b3511e899b57411da266"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-all-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-all;unpack=0"
SRC_URI[x86_64_v2_fence-agents-all.sha256sum] = "f4d193ecdda157d3dc84c579b0de897dde639b4a25ce659004d1f334b5807882"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-amt-ws-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-amt-ws;unpack=0"
SRC_URI[x86_64_v2_fence-agents-amt-ws.sha256sum] = "03fc7a9d93fe2d6bbbaabbed113a00d5c1231d6ccfa761c6c31996a0567389cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-apc;unpack=0"
SRC_URI[x86_64_v2_fence-agents-apc.sha256sum] = "bc17e98eea4bb641164f4695b6417521ddce10872cef0934698708f403e563c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-apc-snmp-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-apc-snmp;unpack=0"
SRC_URI[x86_64_v2_fence-agents-apc-snmp.sha256sum] = "499d74868d52f9e9857b9eccf7c3cc9106fcf29039c21738ac3aa090570f35df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-aws-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-aws;unpack=0"
SRC_URI[x86_64_v2_fence-agents-aws.sha256sum] = "713fd49dbf3056d91781d184cee0c8e0716815ecf8da23a6f9e2345dafe077ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-azure-arm-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-azure-arm;unpack=0"
SRC_URI[x86_64_v2_fence-agents-azure-arm.sha256sum] = "d984d5c430ec00481eeb043fb3c823472e402eaae55f1265deb98dd66ab3328d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-bladecenter-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-bladecenter;unpack=0"
SRC_URI[x86_64_v2_fence-agents-bladecenter.sha256sum] = "cba4cd920d90720a3ea327e46a261736f89db50a9d9f40a9f804b642eb27bae5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-brocade-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-brocade;unpack=0"
SRC_URI[x86_64_v2_fence-agents-brocade.sha256sum] = "32d30ed8e46dfdf03aae31c9e8c3a6313b5fade6499066eb459bf2d48daadca9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-mds-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-cisco-mds;unpack=0"
SRC_URI[x86_64_v2_fence-agents-cisco-mds.sha256sum] = "45ed3fba1816bfba10babf60d9d857ed0f4b97c7ba4a28d4f1741da3a8c3d54f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-cisco-ucs-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-cisco-ucs;unpack=0"
SRC_URI[x86_64_v2_fence-agents-cisco-ucs.sha256sum] = "11dbdf7eec71f85907d58b86d00030ba757ceab1bf8f449770f110090daa3446"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-common-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-common;unpack=0"
SRC_URI[x86_64_v2_fence-agents-common.sha256sum] = "3cfcad2d946c53313bbeb4bf8943b8619eec5e303321efea12c1af91f6ae5404"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-drac5-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-drac5;unpack=0"
SRC_URI[x86_64_v2_fence-agents-drac5.sha256sum] = "ec3adefa0a7e1905670784a490c8ef5750970d1a6bf9f0d67b6c8e3dd14e0fd0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eaton-snmp-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-eaton-snmp;unpack=0"
SRC_URI[x86_64_v2_fence-agents-eaton-snmp.sha256sum] = "f30830e29d0e3efe65769e45f22c7b3d0053a79f5adf5aa81e68a61fd5b68e71"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-emerson-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-emerson;unpack=0"
SRC_URI[x86_64_v2_fence-agents-emerson.sha256sum] = "b854ad7421034f3c1f1560e70c01aa2e61c1a704be32e658d9a140a041216e93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-eps-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-eps;unpack=0"
SRC_URI[x86_64_v2_fence-agents-eps.sha256sum] = "11329b1dc861d7844206583bc9fcf3f908debd6c7420da6a2c9851387c6c143f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-gce-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-gce;unpack=0"
SRC_URI[x86_64_v2_fence-agents-gce.sha256sum] = "785e21f8d79295f2721445d22ed0281a335d1e8e8e7b63aeb9d46cac10e0f09e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-heuristics-ping-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-heuristics-ping;unpack=0"
SRC_URI[x86_64_v2_fence-agents-heuristics-ping.sha256sum] = "cf36709c3ef4d17d7a9322eb810804c202ae43e99faa1017f7b9f17a2349a6dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-hpblade-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-hpblade;unpack=0"
SRC_URI[x86_64_v2_fence-agents-hpblade.sha256sum] = "fbe374072e0f5ad8513d88b59d41536b75c2347c85dcf4a9a8a2c6435d7a2f62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-powervs-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ibm-powervs;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ibm-powervs.sha256sum] = "a0af088c182d35628ffa3d9cd7b94401ba16646b1855d7b6e2bcde26894d6e86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibm-vpc-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ibm-vpc;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ibm-vpc.sha256sum] = "14f8ce7da067c81537ea9722db6baed183a09c065f455ed7e9f73cf5207302eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ibmblade-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ibmblade;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ibmblade.sha256sum] = "73cc2ccbf1bbf292b90f69d00b7c03cb21cf1afcf4874d4abec30b9c2a74b972"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ifmib-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ifmib;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ifmib.sha256sum] = "6738b072823f27760b12ad787ecb60592e6182d0aa524e761a97a6808edf4bce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-moonshot-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ilo-moonshot;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ilo-moonshot.sha256sum] = "e27b184c69e71300e8b96bda3a56d4f2bb97c1bc596371509b0a4138359cd1a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-mp-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ilo-mp;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ilo-mp.sha256sum] = "62322eb948b5a9716f57349fb40d3116c07f08143c303e6dc4a96ac91425daad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo-ssh-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ilo-ssh;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ilo-ssh.sha256sum] = "b17714c50d380f5f035d6f9d5a65795a71f00d127f5502fbc24a2e2cf6e1f054"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ilo2-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ilo2;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ilo2.sha256sum] = "d04427012384dcd67cea7483ec73b017e8395abf3f0969919923e42f1e90f387"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-intelmodular-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-intelmodular;unpack=0"
SRC_URI[x86_64_v2_fence-agents-intelmodular.sha256sum] = "fca8f4033e140918688851e22efc97792f50a65377de35879633a3dbdf62cb27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipdu-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ipdu;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ipdu.sha256sum] = "702048571cf783840f220a017ede4e41d01a602aa0720c12ea7f3fca52d19354"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-ipmilan-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-ipmilan;unpack=0"
SRC_URI[x86_64_v2_fence-agents-ipmilan.sha256sum] = "4dcd1894f19e81d8f545bfeb508e0e4af0483706f7ec94cbb2d7feeba50858b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kdump-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kdump;unpack=0"
SRC_URI[x86_64_v2_fence-agents-kdump.sha256sum] = "5462617295f69e0cc8ed58d81f4da5db7212f7bbf17ca1b3649cec5dc748cbe7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-kubevirt-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-kubevirt;unpack=0"
SRC_URI[x86_64_v2_fence-agents-kubevirt.sha256sum] = "2752e5faa69c84f8df415b951359c27a7736d6c0d4fd86b4d5f73951621cddea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-lpar-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-lpar;unpack=0"
SRC_URI[x86_64_v2_fence-agents-lpar.sha256sum] = "c18247088e7dac3184a88fb70418b77f154c6cfe0a146f5f0a7201af03c3e5bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-mpath-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-mpath;unpack=0"
SRC_URI[x86_64_v2_fence-agents-mpath.sha256sum] = "714188e9908436a4579fe845bd7b83703aa7cc8a25062bd9c28cc1a11a08952d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-nutanix-ahv-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-nutanix-ahv;unpack=0"
SRC_URI[x86_64_v2_fence-agents-nutanix-ahv.sha256sum] = "e395685acbfba635787de5d49a08a729b228f1f1db70cbf2a8cc255a5a8c4c00"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-openstack-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-openstack;unpack=0"
SRC_URI[x86_64_v2_fence-agents-openstack.sha256sum] = "22cfc8796f4269c1edb0cd964a14d39551666719c695fc8236a958c58e103d41"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-redfish-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-agents-redfish;unpack=0"
SRC_URI[x86_64_v2_fence-agents-redfish.sha256sum] = "69b88550c11a19d402594b255f59c4d97ec63fccdc36ff94e3b445d3959dddee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rhevm-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-rhevm;unpack=0"
SRC_URI[x86_64_v2_fence-agents-rhevm.sha256sum] = "94bc8f0c6b546b38a0c118450a63bbdc98df78225fe0dd860b218664060383a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsa-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-rsa;unpack=0"
SRC_URI[x86_64_v2_fence-agents-rsa.sha256sum] = "ad911f4a7bbd46022a69bea14d8a0f868fbba9624d2aabd2a9e2c32c0a8df68f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-rsb-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-rsb;unpack=0"
SRC_URI[x86_64_v2_fence-agents-rsb.sha256sum] = "225021a10ab0ebb1fcc3e7c72c164b0bc50b31f8f23604e897bc80f67d144157"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-sbd-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-sbd;unpack=0"
SRC_URI[x86_64_v2_fence-agents-sbd.sha256sum] = "6ce8d26b113798ea10414b340f61f7574739879a7af6b0318f0ef0ddb69a8fd8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-scsi-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-scsi;unpack=0"
SRC_URI[x86_64_v2_fence-agents-scsi.sha256sum] = "028e528044bd276feadbc052d66207240422bb9f30d1bdd3217523089a8ce175"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-virsh-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-virsh;unpack=0"
SRC_URI[x86_64_v2_fence-agents-virsh.sha256sum] = "ee3d75ac7edbf5742fadebe52a3c2016182f6f2666456d00a41e150184eb604d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-rest-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-vmware-rest;unpack=0"
SRC_URI[x86_64_v2_fence-agents-vmware-rest.sha256sum] = "8505b99d390723caad68a6593aeccc75f2fe9d9bbfa104fb97b5d6d5c83e444d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-vmware-soap-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-vmware-soap;unpack=0"
SRC_URI[x86_64_v2_fence-agents-vmware-soap.sha256sum] = "5a5e641f1af0ed812d97d7899b8b79df9da864bd98d99091c097dce4156ada46"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-agents-wti-4.16.0-21.el10_2.6.noarch.rpm;name=x86_64_v2_fence-agents-wti;unpack=0"
SRC_URI[x86_64_v2_fence-agents-wti.sha256sum] = "38b7c389f8dda783541b0a2563f68a88a5ed5787a7e654b1c20c188bf1586a60"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virt-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-virt;unpack=0"
SRC_URI[x86_64_v2_fence-virt.sha256sum] = "693ac1c970744061c324e09ca7c7c1cd78c89657ecf9c4f88faaf110a7a9929d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd;unpack=0"
SRC_URI[x86_64_v2_fence-virtd.sha256sum] = "0e7d08d070268b835acf3b662af64b2c44ac7281de0ffa7ff20ce46707a1167a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-cpg-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-cpg;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-cpg.sha256sum] = "1bb30eb359726a99810df409867908cafcadd00145ab97282e2bff0dfa2f1138"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-libvirt-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-libvirt;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-libvirt.sha256sum] = "aba843dae1648f56cb4bdfeecb6759df7759af85246454d44dd2c4f73cc454ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-multicast-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-multicast;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-multicast.sha256sum] = "c8b5eff9116fa3471fe24f5f96c9802f1724bcf275225a12b3622bf35394a543"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-serial-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-serial;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-serial.sha256sum] = "bcddd86a2199bb2b89f9d626a8a6c531dc5b546f51efea69041b82f2278c2394"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fence-virtd-tcp-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_fence-virtd-tcp;unpack=0"
SRC_URI[x86_64_v2_fence-virtd-tcp.sha256sum] = "9e49d9ae7a36aa07e7fef436678d6b6babb46c3ed3c5c1032562f22fda96e393"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ha-cloud-support-4.16.0-21.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_ha-cloud-support;unpack=0"
SRC_URI[x86_64_v2_ha-cloud-support.sha256sum] = "ae5d708d829b255811f23371423da845d94442636efdbf1235a0e93a4313dab3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-all-4.16.0-21.el10_2.6.aarch64.rpm;name=aarch64_fence-agents-all;unpack=0"
SRC_URI[aarch64_fence-agents-all.sha256sum] = "742f9a2468f31a4054fd7e5c7cebaaad3f165b11f44c9a16835134b2a5c58149"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-amt-ws-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-amt-ws;unpack=0"
SRC_URI[aarch64_fence-agents-amt-ws.sha256sum] = "03fc7a9d93fe2d6bbbaabbed113a00d5c1231d6ccfa761c6c31996a0567389cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-apc;unpack=0"
SRC_URI[aarch64_fence-agents-apc.sha256sum] = "bc17e98eea4bb641164f4695b6417521ddce10872cef0934698708f403e563c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-apc-snmp-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-apc-snmp;unpack=0"
SRC_URI[aarch64_fence-agents-apc-snmp.sha256sum] = "499d74868d52f9e9857b9eccf7c3cc9106fcf29039c21738ac3aa090570f35df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-bladecenter-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-bladecenter;unpack=0"
SRC_URI[aarch64_fence-agents-bladecenter.sha256sum] = "cba4cd920d90720a3ea327e46a261736f89db50a9d9f40a9f804b642eb27bae5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-brocade-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-brocade;unpack=0"
SRC_URI[aarch64_fence-agents-brocade.sha256sum] = "32d30ed8e46dfdf03aae31c9e8c3a6313b5fade6499066eb459bf2d48daadca9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-mds-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-cisco-mds;unpack=0"
SRC_URI[aarch64_fence-agents-cisco-mds.sha256sum] = "45ed3fba1816bfba10babf60d9d857ed0f4b97c7ba4a28d4f1741da3a8c3d54f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-cisco-ucs-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-cisco-ucs;unpack=0"
SRC_URI[aarch64_fence-agents-cisco-ucs.sha256sum] = "11dbdf7eec71f85907d58b86d00030ba757ceab1bf8f449770f110090daa3446"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-common-4.16.0-21.el10_2.6.aarch64.rpm;name=aarch64_fence-agents-common;unpack=0"
SRC_URI[aarch64_fence-agents-common.sha256sum] = "ac506a8748739743790d225ec824123aac3f89639bae345c69aeaddba91c186d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-drac5-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-drac5;unpack=0"
SRC_URI[aarch64_fence-agents-drac5.sha256sum] = "ec3adefa0a7e1905670784a490c8ef5750970d1a6bf9f0d67b6c8e3dd14e0fd0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eaton-snmp-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-eaton-snmp;unpack=0"
SRC_URI[aarch64_fence-agents-eaton-snmp.sha256sum] = "f30830e29d0e3efe65769e45f22c7b3d0053a79f5adf5aa81e68a61fd5b68e71"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-emerson-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-emerson;unpack=0"
SRC_URI[aarch64_fence-agents-emerson.sha256sum] = "b854ad7421034f3c1f1560e70c01aa2e61c1a704be32e658d9a140a041216e93"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-eps-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-eps;unpack=0"
SRC_URI[aarch64_fence-agents-eps.sha256sum] = "11329b1dc861d7844206583bc9fcf3f908debd6c7420da6a2c9851387c6c143f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-heuristics-ping-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-heuristics-ping;unpack=0"
SRC_URI[aarch64_fence-agents-heuristics-ping.sha256sum] = "cf36709c3ef4d17d7a9322eb810804c202ae43e99faa1017f7b9f17a2349a6dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-hpblade-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-hpblade;unpack=0"
SRC_URI[aarch64_fence-agents-hpblade.sha256sum] = "fbe374072e0f5ad8513d88b59d41536b75c2347c85dcf4a9a8a2c6435d7a2f62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-powervs-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ibm-powervs;unpack=0"
SRC_URI[aarch64_fence-agents-ibm-powervs.sha256sum] = "a0af088c182d35628ffa3d9cd7b94401ba16646b1855d7b6e2bcde26894d6e86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibm-vpc-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ibm-vpc;unpack=0"
SRC_URI[aarch64_fence-agents-ibm-vpc.sha256sum] = "14f8ce7da067c81537ea9722db6baed183a09c065f455ed7e9f73cf5207302eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ibmblade-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ibmblade;unpack=0"
SRC_URI[aarch64_fence-agents-ibmblade.sha256sum] = "73cc2ccbf1bbf292b90f69d00b7c03cb21cf1afcf4874d4abec30b9c2a74b972"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ifmib-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ifmib;unpack=0"
SRC_URI[aarch64_fence-agents-ifmib.sha256sum] = "6738b072823f27760b12ad787ecb60592e6182d0aa524e761a97a6808edf4bce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-moonshot-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ilo-moonshot;unpack=0"
SRC_URI[aarch64_fence-agents-ilo-moonshot.sha256sum] = "e27b184c69e71300e8b96bda3a56d4f2bb97c1bc596371509b0a4138359cd1a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-mp-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ilo-mp;unpack=0"
SRC_URI[aarch64_fence-agents-ilo-mp.sha256sum] = "62322eb948b5a9716f57349fb40d3116c07f08143c303e6dc4a96ac91425daad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo-ssh-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ilo-ssh;unpack=0"
SRC_URI[aarch64_fence-agents-ilo-ssh.sha256sum] = "b17714c50d380f5f035d6f9d5a65795a71f00d127f5502fbc24a2e2cf6e1f054"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ilo2-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ilo2;unpack=0"
SRC_URI[aarch64_fence-agents-ilo2.sha256sum] = "d04427012384dcd67cea7483ec73b017e8395abf3f0969919923e42f1e90f387"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-intelmodular-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-intelmodular;unpack=0"
SRC_URI[aarch64_fence-agents-intelmodular.sha256sum] = "fca8f4033e140918688851e22efc97792f50a65377de35879633a3dbdf62cb27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipdu-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ipdu;unpack=0"
SRC_URI[aarch64_fence-agents-ipdu.sha256sum] = "702048571cf783840f220a017ede4e41d01a602aa0720c12ea7f3fca52d19354"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-ipmilan-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-ipmilan;unpack=0"
SRC_URI[aarch64_fence-agents-ipmilan.sha256sum] = "4dcd1894f19e81d8f545bfeb508e0e4af0483706f7ec94cbb2d7feeba50858b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kdump-4.16.0-21.el10_2.6.aarch64.rpm;name=aarch64_fence-agents-kdump;unpack=0"
SRC_URI[aarch64_fence-agents-kdump.sha256sum] = "281a87c561210acf14680412d51bd40136d15b6975509d0680de0232c2e80cc1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-kubevirt-4.16.0-21.el10_2.6.aarch64.rpm;name=aarch64_fence-agents-kubevirt;unpack=0"
SRC_URI[aarch64_fence-agents-kubevirt.sha256sum] = "63b11e52b1e56bc3cdc63e7e8234caac08c20f3c9080a59597b761871115318c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-lpar-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-lpar;unpack=0"
SRC_URI[aarch64_fence-agents-lpar.sha256sum] = "c18247088e7dac3184a88fb70418b77f154c6cfe0a146f5f0a7201af03c3e5bf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-mpath-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-mpath;unpack=0"
SRC_URI[aarch64_fence-agents-mpath.sha256sum] = "714188e9908436a4579fe845bd7b83703aa7cc8a25062bd9c28cc1a11a08952d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-nutanix-ahv-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-nutanix-ahv;unpack=0"
SRC_URI[aarch64_fence-agents-nutanix-ahv.sha256sum] = "e395685acbfba635787de5d49a08a729b228f1f1db70cbf2a8cc255a5a8c4c00"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-redfish-4.16.0-21.el10_2.6.aarch64.rpm;name=aarch64_fence-agents-redfish;unpack=0"
SRC_URI[aarch64_fence-agents-redfish.sha256sum] = "bd5a115ca056a817a5c083d622c63e38a89097530251ea957ae0fc5fb309ab8a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rhevm-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-rhevm;unpack=0"
SRC_URI[aarch64_fence-agents-rhevm.sha256sum] = "94bc8f0c6b546b38a0c118450a63bbdc98df78225fe0dd860b218664060383a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsa-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-rsa;unpack=0"
SRC_URI[aarch64_fence-agents-rsa.sha256sum] = "ad911f4a7bbd46022a69bea14d8a0f868fbba9624d2aabd2a9e2c32c0a8df68f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-rsb-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-rsb;unpack=0"
SRC_URI[aarch64_fence-agents-rsb.sha256sum] = "225021a10ab0ebb1fcc3e7c72c164b0bc50b31f8f23604e897bc80f67d144157"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-sbd-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-sbd;unpack=0"
SRC_URI[aarch64_fence-agents-sbd.sha256sum] = "6ce8d26b113798ea10414b340f61f7574739879a7af6b0318f0ef0ddb69a8fd8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-scsi-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-scsi;unpack=0"
SRC_URI[aarch64_fence-agents-scsi.sha256sum] = "028e528044bd276feadbc052d66207240422bb9f30d1bdd3217523089a8ce175"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-virsh-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-virsh;unpack=0"
SRC_URI[aarch64_fence-agents-virsh.sha256sum] = "ee3d75ac7edbf5742fadebe52a3c2016182f6f2666456d00a41e150184eb604d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-rest-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-vmware-rest;unpack=0"
SRC_URI[aarch64_fence-agents-vmware-rest.sha256sum] = "8505b99d390723caad68a6593aeccc75f2fe9d9bbfa104fb97b5d6d5c83e444d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-vmware-soap-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-vmware-soap;unpack=0"
SRC_URI[aarch64_fence-agents-vmware-soap.sha256sum] = "5a5e641f1af0ed812d97d7899b8b79df9da864bd98d99091c097dce4156ada46"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fence-agents-wti-4.16.0-21.el10_2.6.noarch.rpm;name=aarch64_fence-agents-wti;unpack=0"
SRC_URI[aarch64_fence-agents-wti.sha256sum] = "38b7c389f8dda783541b0a2563f68a88a5ed5787a7e654b1c20c188bf1586a60"

RDEPENDS:fence-agents-aliyun = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 python3-jmespath \
 "
RDEPENDS:fence-agents-all:x86_64_v2 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
 fence-virt \
"
RDEPENDS:fence-agents-all:aarch64 = " \
 fence-agents-amt-ws \
 fence-agents-apc \
 fence-agents-apc-snmp \
 fence-agents-bladecenter \
 fence-agents-brocade \
 fence-agents-cisco-mds \
 fence-agents-cisco-ucs \
 fence-agents-drac5 \
 fence-agents-eaton-snmp \
 fence-agents-emerson \
 fence-agents-eps \
 fence-agents-heuristics-ping \
 fence-agents-hpblade \
 fence-agents-ibmblade \
 fence-agents-ifmib \
 fence-agents-ilo-moonshot \
 fence-agents-ilo-mp \
 fence-agents-ilo-ssh \
 fence-agents-ilo2 \
 fence-agents-intelmodular \
 fence-agents-ipdu \
 fence-agents-ipmilan \
 fence-agents-kdump \
 fence-agents-mpath \
 fence-agents-redfish \
 fence-agents-rhevm \
 fence-agents-rsa \
 fence-agents-rsb \
 fence-agents-sbd \
 fence-agents-scsi \
 fence-agents-vmware-rest \
 fence-agents-vmware-soap \
 fence-agents-wti \
"
RDEPENDS:fence-agents-amt-ws = " \
 fence-agents-common \
 openwsman-python3 \
 python3 \
 "
RDEPENDS:fence-agents-apc = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-apc-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-aws = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-azure-arm = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-bladecenter = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-brocade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-cisco-mds = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-cisco-ucs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-common = " \
 glibc \
 openssl-libs \
 pkgconf-pkg-config \
 python3 \
 python3-pexpect \
 python3-ptyprocess \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:fence-agents-drac5 = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-eaton-snmp = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-emerson = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-eps = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-gce = " \
 fence-agents-common \
 ha-cloud-support \
 python3 \
 "
RDEPENDS:fence-agents-heuristics-ping = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-hpblade = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ibm-powervs = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibm-vpc = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-ibmblade = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ifmib = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ilo-moonshot = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-mp = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo-ssh = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-ilo2 = " \
 fence-agents-common \
 gnutls-utils \
 python3 \
 "
RDEPENDS:fence-agents-intelmodular = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipdu = " \
 fence-agents-common \
 net-snmp-utils \
 python3 \
 "
RDEPENDS:fence-agents-ipmilan = " \
 fence-agents-common \
 ipmitool \
 python3 \
 "
RDEPENDS:fence-agents-kdump = " \
 fence-agents-common \
 glibc \
 "
RDEPENDS:fence-agents-kubevirt = " \
 fence-agents-common \
 python3 \
 python3-charset-normalizer \
 python3-dateutil \
 python3-oauthlib \
 python3-pyasn1 \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-urllib3 \
 "
RDEPENDS:fence-agents-lpar = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-mpath = " \
 device-mapper-multipath \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-nutanix-ahv = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-openstack = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-redfish = " \
 fence-agents-common \
 python3 \
 python3-requests \
 "
RDEPENDS:fence-agents-rhevm = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-rsa = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-rsb = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-sbd = " \
 fence-agents-common \
 python3 \
 sbd \
 "
RDEPENDS:fence-agents-scsi = " \
 fence-agents-common \
 python3 \
 sg3_utils \
 "
RDEPENDS:fence-agents-virsh = " \
 fence-agents-common \
 libvirt-client \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-agents-vmware-rest = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-vmware-soap = " \
 fence-agents-common \
 python3 \
 "
RDEPENDS:fence-agents-wti = " \
 fence-agents-common \
 openssh-clients \
 python3 \
 "
RDEPENDS:fence-virt = " \
 glibc \
 nss \
 systemd \
 "
RDEPENDS:fence-virtd = " \
 glibc \
 libuuid \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-cpg = " \
 corosynclib \
 fence-virtd \
 glibc \
 libqb \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-libvirt = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-multicast = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-serial = " \
 fence-virtd \
 glibc \
 libvirt \
 libvirt-libs \
 libxml2 \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:fence-virtd-tcp = " \
 fence-virtd \
 glibc \
 nspr \
 nss \
 nss-util \
 "
RDEPENDS:ha-cloud-support = " \
 awscli2 \
 glibc \
 python3-cffi \
 python3-charset-normalizer \
 python3-colorama \
 python3-cryptography \
 python3-dateutil \
 python3-docutils \
 python3-idna \
 python3-jmespath \
 python3-oauthlib \
 python3-packaging \
 python3-protobuf \
 python3-pyasn1 \
 python3-pycparser \
 python3-pyparsing \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 python3-six \
 python3-typing-extensions \
 python3-urllib3 \
 "
