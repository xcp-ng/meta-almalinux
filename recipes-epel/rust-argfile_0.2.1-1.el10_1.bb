# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argfile"
PV = "0.2.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-argfile+default-devel \
 rust-argfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argfile-0.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9928010479eaacd025290dd0c305d58b13acb1141606b37bcc638595e8d46995"

URI_x86_64_v2_rust-argfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argfile+default-devel-0.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argfile+default-devel}"
SRC_URI[x86_64_v2_rust-argfile+default-devel.sha256sum] = "cb9c148fbf78a49973c83eb7158f60d74142a86389c78c71b8aca414c74f9340"

URI_x86_64_v2_rust-argfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argfile-devel-0.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argfile-devel}"
SRC_URI[x86_64_v2_rust-argfile-devel.sha256sum] = "f0d739c69966ac51c2fbd0aced98eee94e9c56761ddf33cb6881ada3afb76c88"

URI_aarch64_rust-argfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argfile+default-devel-0.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-argfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argfile+default-devel}"
SRC_URI[aarch64_rust-argfile+default-devel.sha256sum] = "10d0f14d5a1c5a5ef2335994992e6c31db2afef7112a40614870b437628086b3"

URI_aarch64_rust-argfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argfile-devel-0.2.1-1.el10_1.noarch.rpm;name=aarch64_rust-argfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argfile-devel}"
SRC_URI[aarch64_rust-argfile-devel.sha256sum] = "1e7d5e394a1ee132d98ce86b2b5bbf1667a28568ad7e58d985556e13281aea2f"

RDEPENDS:rust-argfile+default-devel = " \
 cargo \
 rust-argfile-devel \
 "
RDEPENDS:rust-argfile-devel = " \
 cargo \
 rust \
 rust-fs-err2+default-devel \
 rust-os_str_bytes+default-devel \
 "
