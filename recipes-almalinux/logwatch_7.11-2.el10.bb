# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "logwatch"
PV = "7.11"
PR = "2.el10"
PACKAGES = " \
 logwatch \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/logwatch-7.11-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "912c1e2c4568a42ce010980194a944801501e51166537e3fe00f741e61120c0a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/logwatch-7.11-2.el10.noarch.rpm;name=x86_64_v2_logwatch;unpack=0"
SRC_URI[x86_64_v2_logwatch.sha256sum] = "0fe93d67c0b99137e2272eed09f45c323a07d7c8f91bb4d9fee97798ed0e88f9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/logwatch-7.11-2.el10.noarch.rpm;name=aarch64_logwatch;unpack=0"
SRC_URI[aarch64_logwatch.sha256sum] = "0fe93d67c0b99137e2272eed09f45c323a07d7c8f91bb4d9fee97798ed0e88f9"

RDEPENDS:logwatch = " \
 bash \
 crontabs \
 grep \
 perl-Date-Manip \
 perl-Errno \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-HTML-Parser \
 perl-POSIX \
 perl-PathTools \
 perl-Socket \
 perl-Time-Local \
 perl-URI \
 perl-diagnostics \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-subs \
 perl-vars \
 "
