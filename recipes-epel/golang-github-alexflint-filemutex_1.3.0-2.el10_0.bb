# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-alexflint-filemutex"
PV = "1.3.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-alexflint-filemutex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-alexflint-filemutex-1.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db74ef857749b9afd20a3ec5928d40bc972cc8c631e2a46997569239605f34fe"

URI_x86_64_v2_golang-github-alexflint-filemutex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-alexflint-filemutex-devel-1.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-alexflint-filemutex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-alexflint-filemutex-devel}"
SRC_URI[x86_64_v2_golang-github-alexflint-filemutex-devel.sha256sum] = "555844e3bdfdfbffe4713af25cdf462ef34315bcfcc84157db66c8560a7490cb"

URI_aarch64_golang-github-alexflint-filemutex-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-alexflint-filemutex-devel-1.3.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-alexflint-filemutex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-alexflint-filemutex-devel}"
SRC_URI[aarch64_golang-github-alexflint-filemutex-devel.sha256sum] = "925a5ca5c206c8d967c86825f1e5455490be15e6ead45b28976dd78b1db82d2f"

RDEPENDS:golang-github-alexflint-filemutex-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
