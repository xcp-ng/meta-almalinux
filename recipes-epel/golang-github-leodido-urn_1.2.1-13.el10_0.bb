# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-leodido-urn"
PV = "1.2.1"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-leodido-urn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-leodido-urn-1.2.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e478a4771e408067e7341d853a8e7dfa763732d3bad8d1a9bc5feb8f61e060a2"

URI_x86_64_v2_golang-github-leodido-urn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-leodido-urn-devel-1.2.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-leodido-urn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-leodido-urn-devel}"
SRC_URI[x86_64_v2_golang-github-leodido-urn-devel.sha256sum] = "28981998abea7da7427211e8d8f695334cd610bc09d963152b84f007caca4f71"

URI_aarch64_golang-github-leodido-urn-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-leodido-urn-devel-1.2.1-13.el10_0.noarch.rpm;name=aarch64_golang-github-leodido-urn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-leodido-urn-devel}"
SRC_URI[aarch64_golang-github-leodido-urn-devel.sha256sum] = "adea781e88d1a948e8115dd4ca9c5107e8b1725b23c7458bc562fe1eae9be243"

RDEPENDS:golang-github-leodido-urn-devel = " \
 go-filesystem \
 "
