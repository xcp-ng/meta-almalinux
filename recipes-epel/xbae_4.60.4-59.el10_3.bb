# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xbae"
PV = "4.60.4"
PR = "59.el10_3"
PACKAGES = " \
 xbae \
 xbae-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xbae-4.60.4-59.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac3c3e5f4eed40d89d95226f995c95b3e447c93a426ffc77c895dc15ad19c21e"

URI_x86_64_v2_xbae = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xbae-4.60.4-59.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xbae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xbae}"
SRC_URI[x86_64_v2_xbae.sha256sum] = "ad214481832868255ca1dc3b9ca43d767649996ec47f2f5740105dd7d9d0c36b"

URI_x86_64_v2_xbae-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xbae-devel-4.60.4-59.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xbae-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xbae-devel}"
SRC_URI[x86_64_v2_xbae-devel.sha256sum] = "8e0e258d1084c3b214ed024bd7613740a45568755aa5ef76724758c2e58c5faf"

URI_aarch64_xbae = "${EPEL_MIRROR}/aarch64/Packages/x/xbae-4.60.4-59.el10_3.aarch64.rpm;name=aarch64_xbae;unpack=0"
SRC_URI:append = " ${URI_aarch64_xbae}"
SRC_URI[aarch64_xbae.sha256sum] = "ab1ac9bd13adc272d15bb415d9523493313c287468e10ae83d5084c1be366d75"

URI_aarch64_xbae-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xbae-devel-4.60.4-59.el10_3.aarch64.rpm;name=aarch64_xbae-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xbae-devel}"
SRC_URI[aarch64_xbae-devel.sha256sum] = "39495adea9144719cbd9733c6dcae37a9f7134dce4cbe32de32cfc7259483542"

RDEPENDS:xbae = " \
 glibc \
 libX11 \
 libXext \
 libXp \
 libXpm \
 libXt \
 motif \
 "
RDEPENDS:xbae-devel = " \
 automake \
 libXpm-devel \
 motif-devel \
 xbae \
 "
