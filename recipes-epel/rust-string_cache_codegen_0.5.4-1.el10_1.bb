# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string_cache_codegen"
PV = "0.5.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-string_cache_codegen+default-devel \
 rust-string_cache_codegen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string_cache_codegen-0.5.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70268d2ea3d1e93e88d379fe67c2f9d172846eb27fd66c12d1e85856b4acc8e3"

URI_x86_64_v2_rust-string_cache_codegen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache_codegen+default-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache_codegen+default-devel}"
SRC_URI[x86_64_v2_rust-string_cache_codegen+default-devel.sha256sum] = "a3ef7b11d0c64153687ed34b324d00c8c56656bd3d447408161c070dbf9487d5"

URI_x86_64_v2_rust-string_cache_codegen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache_codegen-devel-0.5.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache_codegen-devel}"
SRC_URI[x86_64_v2_rust-string_cache_codegen-devel.sha256sum] = "99e9becd4d80f36e02e30a5510912b8e1a0fdf32aad9260871050b69283348cf"

URI_aarch64_rust-string_cache_codegen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache_codegen+default-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-string_cache_codegen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache_codegen+default-devel}"
SRC_URI[aarch64_rust-string_cache_codegen+default-devel.sha256sum] = "e2a12b8c800266911004a03b062275e56c3c51dd1aac31bb3aa427d4504d0fc9"

URI_aarch64_rust-string_cache_codegen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache_codegen-devel-0.5.4-1.el10_1.noarch.rpm;name=aarch64_rust-string_cache_codegen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache_codegen-devel}"
SRC_URI[aarch64_rust-string_cache_codegen-devel.sha256sum] = "a4402f7bdb9509c7a378c5e7a1783ed317546eb380c9f3025df503d2f3ecab71"

RDEPENDS:rust-string_cache_codegen+default-devel = " \
 cargo \
 rust-string_cache_codegen-devel \
 "
RDEPENDS:rust-string_cache_codegen-devel = " \
 cargo \
 rust-phf_generator0.11+default-devel \
 rust-phf_shared0.11+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
