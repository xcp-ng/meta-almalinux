# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-debtcollector"
PV = "3.0.0"
PR = "11.el10_2"
PACKAGES = " \
 python-debtcollector-doc \
 python3-debtcollector \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-debtcollector-3.0.0-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "805f710b83616645fa030ea93e61a7597218636ca991048088fb886b2dcfd2fb"

URI_x86_64_v2_python-debtcollector-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-debtcollector-doc-3.0.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-debtcollector-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-debtcollector-doc}"
SRC_URI[x86_64_v2_python-debtcollector-doc.sha256sum] = "e5889c295e1726c3a939740404bddcc3c1f40323277c52725a4574268914b4f4"

URI_x86_64_v2_python3-debtcollector = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-debtcollector-3.0.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-debtcollector;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debtcollector}"
SRC_URI[x86_64_v2_python3-debtcollector.sha256sum] = "0e549b6dacc2bb348dcf2e8d9246a83a62ba2d686e564eec0cf0415b6c106660"

URI_aarch64_python-debtcollector-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-debtcollector-doc-3.0.0-11.el10_2.noarch.rpm;name=aarch64_python-debtcollector-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-debtcollector-doc}"
SRC_URI[aarch64_python-debtcollector-doc.sha256sum] = "fb2fddcbbeb10a531f7cf819e53076210b0884e590176e5d4660a6b990f2c9dd"

URI_aarch64_python3-debtcollector = "${EPEL_MIRROR}/aarch64/Packages/p/python3-debtcollector-3.0.0-11.el10_2.noarch.rpm;name=aarch64_python3-debtcollector;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debtcollector}"
SRC_URI[aarch64_python3-debtcollector.sha256sum] = "abc2f464b92d989c7d4028964ea91c4f02a7caf8136637c8319e2346d01ae722"

RDEPENDS:python-debtcollector-doc = " \
 "
RDEPENDS:python3-debtcollector = " \
 python3 \
 python3-wrapt \
 "
