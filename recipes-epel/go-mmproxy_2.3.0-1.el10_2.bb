# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-mmproxy"
PV = "2.3.0"
PR = "1.el10_2"
PACKAGES = " \
 go-mmproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/go-mmproxy-2.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ec41b5f90eb0961f1ce0de89866ee7ed0c7cb166cf71c27c4ef90bc781c4e3b"

URI_x86_64_v2_go-mmproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/go-mmproxy-2.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_go-mmproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-mmproxy}"
SRC_URI[x86_64_v2_go-mmproxy.sha256sum] = "cb09c68166cdd7936eebe893ed83c114a9fe8826fdce7a0b254825f5e61da3ab"

URI_aarch64_go-mmproxy = "${EPEL_MIRROR}/aarch64/Packages/g/go-mmproxy-2.3.0-1.el10_2.aarch64.rpm;name=aarch64_go-mmproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-mmproxy}"
SRC_URI[aarch64_go-mmproxy.sha256sum] = "a94d5c58936957050f436dc69267b314815efd91707a52ba8e740fd34b9fae90"

RDEPENDS:go-mmproxy = " \
 glibc \
 "
