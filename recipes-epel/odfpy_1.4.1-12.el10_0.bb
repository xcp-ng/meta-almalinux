# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "odfpy"
PV = "1.4.1"
PR = "12.el10_0"
PACKAGES = " \
 odfpy-doc \
 python3-odfpy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/odfpy-1.4.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0149354d25937a56b15f9c8682a44f4ec117d7164ec801d13f41f12a4c6cbc01"

URI_x86_64_v2_odfpy-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/odfpy-doc-1.4.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_odfpy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_odfpy-doc}"
SRC_URI[x86_64_v2_odfpy-doc.sha256sum] = "c97c0926d9ef7f9a1fa612bdcdf557e68932c51eda4d0e1180198a139840bd3d"

URI_x86_64_v2_python3-odfpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-odfpy-1.4.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-odfpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-odfpy}"
SRC_URI[x86_64_v2_python3-odfpy.sha256sum] = "4e7027a85be7928299bd59d05c15bb89e0bef8ab5c7ec8572c9a8a5075317d8f"

URI_aarch64_odfpy-doc = "${EPEL_MIRROR}/aarch64/Packages/o/odfpy-doc-1.4.1-12.el10_0.noarch.rpm;name=aarch64_odfpy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_odfpy-doc}"
SRC_URI[aarch64_odfpy-doc.sha256sum] = "032c68442890c8f52759bf99ec85110da48ab140ae63a168a91037f9039546c2"

URI_aarch64_python3-odfpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-odfpy-1.4.1-12.el10_0.noarch.rpm;name=aarch64_python3-odfpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-odfpy}"
SRC_URI[aarch64_python3-odfpy.sha256sum] = "920a3218e1f3c2434180246b6771a1aa4a78164ccafba157a6275f96a54d0222"

RDEPENDS:odfpy-doc = " \
 "
RDEPENDS:python3-odfpy = " \
 python3 \
 python3-defusedxml \
 "
