# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-log"
PV = "0.2.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-test-log+color-devel \
 rust-test-log+default-devel \
 rust-test-log+log-devel \
 rust-test-log+trace-devel \
 rust-test-log+unstable-devel \
 rust-test-log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-log-0.2.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b73924db325deac41bda5726474d86e77044a3322ca929eba6f48b48cb43a02c"

URI_aarch64_rust-test-log+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+color-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+color-devel}"
SRC_URI[aarch64_rust-test-log+color-devel.sha256sum] = "a8adb00e8b1ad920fcb45c3ffcfd95bd097743b9a17385599325e6f927bb87ac"

URI_aarch64_rust-test-log+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+default-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+default-devel}"
SRC_URI[aarch64_rust-test-log+default-devel.sha256sum] = "e5c79fc35ecb004de087946cbcea151342ff8c7ff38b5eccb6a3dea63f35d60c"

URI_aarch64_rust-test-log+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+log-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+log-devel}"
SRC_URI[aarch64_rust-test-log+log-devel.sha256sum] = "d49b717fb36a1c89883d8eae8211a8cf9cef46b4c885f274c296b70b3b419922"

URI_aarch64_rust-test-log+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+trace-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+trace-devel}"
SRC_URI[aarch64_rust-test-log+trace-devel.sha256sum] = "65b0e4dc18d7190e9e1e5a18fc7d415c1a4236f33401eb74c2f75d4c6bc5421a"

URI_aarch64_rust-test-log+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+unstable-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+unstable-devel}"
SRC_URI[aarch64_rust-test-log+unstable-devel.sha256sum] = "028c4b163a2a7ebf8280f188e04e817bc6bdb46e539b7f39c31b7d29d0c89b1a"

URI_aarch64_rust-test-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-devel-0.2.18-1.el10_1.noarch.rpm;name=aarch64_rust-test-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-devel}"
SRC_URI[aarch64_rust-test-log-devel.sha256sum] = "c98503238084b7adbcbdc925aae02290bdac740b216c8280828b9cd56bf2b5dc"

RDEPENDS:rust-test-log+color-devel = " \
 cargo \
 rust-env_logger+auto-color-devel \
 rust-env_logger-devel \
 rust-test-log-devel \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-test-log+default-devel = " \
 cargo \
 rust-test-log+color-devel \
 rust-test-log+log-devel \
 rust-test-log-devel \
 "
RDEPENDS:rust-test-log+log-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-test-log-devel \
 rust-test-log-macros+log-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+tracing-log-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-test-log+trace-devel = " \
 cargo \
 rust-test-log-devel \
 rust-test-log-macros+trace-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-test-log+unstable-devel = " \
 cargo \
 rust-test-log-devel \
 rust-test-log-macros+unstable-devel \
 "
RDEPENDS:rust-test-log-devel = " \
 cargo \
 rust \
 rust-test-log-macros+default-devel \
 "
