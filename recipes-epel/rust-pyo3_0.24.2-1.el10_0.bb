# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3"
PV = "0.24.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3+abi3-devel \
 rust-pyo3+abi3-py310-devel \
 rust-pyo3+abi3-py311-devel \
 rust-pyo3+abi3-py312-devel \
 rust-pyo3+abi3-py313-devel \
 rust-pyo3+abi3-py37-devel \
 rust-pyo3+abi3-py38-devel \
 rust-pyo3+abi3-py39-devel \
 rust-pyo3+anyhow-devel \
 rust-pyo3+auto-initialize-devel \
 rust-pyo3+chrono-devel \
 rust-pyo3+chrono-tz-devel \
 rust-pyo3+default-devel \
 rust-pyo3+either-devel \
 rust-pyo3+experimental-async-devel \
 rust-pyo3+experimental-inspect-devel \
 rust-pyo3+extension-module-devel \
 rust-pyo3+eyre-devel \
 rust-pyo3+full-devel \
 rust-pyo3+hashbrown-devel \
 rust-pyo3+indexmap-devel \
 rust-pyo3+indoc-devel \
 rust-pyo3+inventory-devel \
 rust-pyo3+jiff-02-devel \
 rust-pyo3+macros-devel \
 rust-pyo3+multiple-pymethods-devel \
 rust-pyo3+nightly-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3+num-complex-devel \
 rust-pyo3+num-rational-devel \
 rust-pyo3+py-clone-devel \
 rust-pyo3+pyo3-macros-devel \
 rust-pyo3+rust_decimal-devel \
 rust-pyo3+serde-devel \
 rust-pyo3+smallvec-devel \
 rust-pyo3+unindent-devel \
 rust-pyo3+uuid-devel \
 rust-pyo3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-0.24.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "793c2f7602e509ad056450aa77fe37b7ed1fcda81d0096aa08a2b93b6e19f7b4"

URI_x86_64_v2_rust-pyo3+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-devel.sha256sum] = "8b75ad0bc00ab1f461285253f026eb4fde349397bfddfba96623b3336626d59a"

URI_x86_64_v2_rust-pyo3+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py310-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py310-devel.sha256sum] = "337ae8a558d5b6ac458b08439893b633c7c52296ea406090cb88228c6bc0b8f5"

URI_x86_64_v2_rust-pyo3+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py311-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py311-devel.sha256sum] = "dc0b4f95614233e2dc29e88f740e7dc739366bd9ed3194a586a90ba4fdf94f67"

URI_x86_64_v2_rust-pyo3+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py312-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py312-devel.sha256sum] = "0cd9968df0c0ad397abda8f42640247664fb3fcdeaacd5b95b518644051317ba"

URI_x86_64_v2_rust-pyo3+abi3-py313-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py313-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py313-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py313-devel.sha256sum] = "e331325346f06e385e1b840423a468cff3a29693eacba1f1daef0b4100f66a4a"

URI_x86_64_v2_rust-pyo3+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py37-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py37-devel.sha256sum] = "698ed21a4c6a4d90a8a35ab5b0ad6b87b805984ebd4c3f2f18862a0893798cda"

URI_x86_64_v2_rust-pyo3+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py38-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py38-devel.sha256sum] = "fc1af4fac550d15ef5b15c16d3e3c6e14d51cbab91f855777d89c8561b149f54"

URI_x86_64_v2_rust-pyo3+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+abi3-py39-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3+abi3-py39-devel.sha256sum] = "11c83752c846fabbfda2740f06e7876030761ea12fb21d83049f815a1a042830"

URI_x86_64_v2_rust-pyo3+anyhow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+anyhow-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+anyhow-devel}"
SRC_URI[x86_64_v2_rust-pyo3+anyhow-devel.sha256sum] = "7c6cb0dfd7530b1ec1cf81c0e7b6c0cbbb301dad0fdd880cdc6c9f39eef2a7e3"

URI_x86_64_v2_rust-pyo3+auto-initialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+auto-initialize-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+auto-initialize-devel}"
SRC_URI[x86_64_v2_rust-pyo3+auto-initialize-devel.sha256sum] = "95e44a190677c917466265c59b026219d04d0e4c617dd4d425cdc2100e78cf99"

URI_x86_64_v2_rust-pyo3+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-devel.sha256sum] = "4253aa242089a6b30173fceff4e38c4bf983e4211f9a0db572de385ba081f62d"

URI_x86_64_v2_rust-pyo3+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+chrono-tz-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-pyo3+chrono-tz-devel.sha256sum] = "3bfc68a4f640e097399a2b98e3f4d7c6827e1fe42bde3e950a15a0f5863d7519"

URI_x86_64_v2_rust-pyo3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+default-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3+default-devel.sha256sum] = "a7ed09723c2f583d5717325ddfb6b7ba0e25b32be5553f4bc9db0bebb40abcf7"

URI_x86_64_v2_rust-pyo3+either-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+either-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+either-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+either-devel}"
SRC_URI[x86_64_v2_rust-pyo3+either-devel.sha256sum] = "0252fbc40a0e8681bad93a40227c67e67e9a1e8150371ac6a387cdd7c2f2f588"

URI_x86_64_v2_rust-pyo3+experimental-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+experimental-async-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+experimental-async-devel}"
SRC_URI[x86_64_v2_rust-pyo3+experimental-async-devel.sha256sum] = "f991996454bdd38df1fdcc22a62b2a39c1600abe550083977994d69698c0b1d6"

URI_x86_64_v2_rust-pyo3+experimental-inspect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+experimental-inspect-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+experimental-inspect-devel}"
SRC_URI[x86_64_v2_rust-pyo3+experimental-inspect-devel.sha256sum] = "60e5d4a7fa46359f33abe54980072d17e447b6d5e2e637a1b5f4062166bdea14"

URI_x86_64_v2_rust-pyo3+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+extension-module-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3+extension-module-devel.sha256sum] = "c48a1042155155764a4754c7a8e20d162f325ddc308dfd18669ae44b211c877e"

URI_x86_64_v2_rust-pyo3+eyre-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+eyre-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+eyre-devel}"
SRC_URI[x86_64_v2_rust-pyo3+eyre-devel.sha256sum] = "0b509e632d092e5b9c5c4f0ce5ee4eac1295bdeff73099a65ca2661f43c34643"

URI_x86_64_v2_rust-pyo3+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+full-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+full-devel}"
SRC_URI[x86_64_v2_rust-pyo3+full-devel.sha256sum] = "23c2344785ee00b0aff295f87322a3b38974aa809782980b88184e237a856507"

URI_x86_64_v2_rust-pyo3+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+hashbrown-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-pyo3+hashbrown-devel.sha256sum] = "acba6c8b2567abe3f50f87c4c7ea1e6f3b88a2c127e2d1d15a5a7efc4da5b433"

URI_x86_64_v2_rust-pyo3+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+indexmap-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+indexmap-devel}"
SRC_URI[x86_64_v2_rust-pyo3+indexmap-devel.sha256sum] = "98ffaead12e95c6c825aee911ddf7345110541b0de58d63e064e94322108b93c"

URI_x86_64_v2_rust-pyo3+indoc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+indoc-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+indoc-devel}"
SRC_URI[x86_64_v2_rust-pyo3+indoc-devel.sha256sum] = "192638c348d07e2b501ec6fab45e91319683f8d7f3612cd1c9b4af0d8d1b6ce8"

URI_x86_64_v2_rust-pyo3+inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+inventory-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+inventory-devel}"
SRC_URI[x86_64_v2_rust-pyo3+inventory-devel.sha256sum] = "36815354c8ade41caa8e324cbe4464441070e1b974cf1bda86bcc42257b8e251"

URI_x86_64_v2_rust-pyo3+jiff-02-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+jiff-02-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+jiff-02-devel}"
SRC_URI[x86_64_v2_rust-pyo3+jiff-02-devel.sha256sum] = "5c66e7ad264274354f913dfc92a84e44ea177b935a9ad01563c06b6506ab1087"

URI_x86_64_v2_rust-pyo3+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+macros-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3+macros-devel.sha256sum] = "443205286d0a04daa5bc9a359f0ec97eb1eb55514bb3cf384f1253f991ce3fe5"

URI_x86_64_v2_rust-pyo3+multiple-pymethods-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+multiple-pymethods-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+multiple-pymethods-devel}"
SRC_URI[x86_64_v2_rust-pyo3+multiple-pymethods-devel.sha256sum] = "90f832b0bd655571f6dd58772a3b55f781099b45dbff3975a2038f4254d6e4c2"

URI_x86_64_v2_rust-pyo3+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+nightly-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+nightly-devel}"
SRC_URI[x86_64_v2_rust-pyo3+nightly-devel.sha256sum] = "ec61f5411040f059e2e8622258ddc62104e61b7b1f961ea77d3078a0ed0da69c"

URI_x86_64_v2_rust-pyo3+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-bigint-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-bigint-devel.sha256sum] = "57da2a4fd67b7d92bb5b2cd7fb36c8447328630439483ad3094856fba1876978"

URI_x86_64_v2_rust-pyo3+num-complex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-complex-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-complex-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-complex-devel.sha256sum] = "8cba07a809f598b512ddf5f5f6162365244f65d2be1cc7363a9d82cdb71771c6"

URI_x86_64_v2_rust-pyo3+num-rational-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+num-rational-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+num-rational-devel}"
SRC_URI[x86_64_v2_rust-pyo3+num-rational-devel.sha256sum] = "0d8b4c0ae27b8b634b62afa4a6fbd0301c7cbcf8b6160bc223f0d79b4fc524ac"

URI_x86_64_v2_rust-pyo3+py-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+py-clone-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+py-clone-devel}"
SRC_URI[x86_64_v2_rust-pyo3+py-clone-devel.sha256sum] = "8b22931d1eb29234762c22fc372626a7c7380bb36630a69bcf976b89a6c935bf"

URI_x86_64_v2_rust-pyo3+pyo3-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+pyo3-macros-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+pyo3-macros-devel}"
SRC_URI[x86_64_v2_rust-pyo3+pyo3-macros-devel.sha256sum] = "c0f861ecb084903f7f39795ab8f9e73f7f3c7425dce6bfce8d4634327ace3074"

URI_x86_64_v2_rust-pyo3+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+rust_decimal-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-pyo3+rust_decimal-devel.sha256sum] = "1cf661d4c827e096ccd5dde2eabed823eda08f53d005b9a3f20d0d951860f306"

URI_x86_64_v2_rust-pyo3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+serde-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+serde-devel}"
SRC_URI[x86_64_v2_rust-pyo3+serde-devel.sha256sum] = "5be47a4b762d6bd1229d574589824c3526a7076a39c41971352f3cbbb2bb6a12"

URI_x86_64_v2_rust-pyo3+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+smallvec-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+smallvec-devel}"
SRC_URI[x86_64_v2_rust-pyo3+smallvec-devel.sha256sum] = "05eaf2f1753ed4075e4a3684823abb39211b7c404573a7d42e62506739931204"

URI_x86_64_v2_rust-pyo3+unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+unindent-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+unindent-devel}"
SRC_URI[x86_64_v2_rust-pyo3+unindent-devel.sha256sum] = "03b207d68be3dad31e82373213ffcdab720da9e689a8f7db0c0159206d6d7d48"

URI_x86_64_v2_rust-pyo3+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3+uuid-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3+uuid-devel}"
SRC_URI[x86_64_v2_rust-pyo3+uuid-devel.sha256sum] = "323d5b3577a2fbaa324315a4547898db0f3b62be0206106afa7243cc09c5303a"

URI_x86_64_v2_rust-pyo3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-devel-0.24.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-devel.sha256sum] = "96ccc0820d218b1c0cb7a7db26e917ff564760b38c1a8cc583897dd2570a849d"

URI_aarch64_rust-pyo3+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-devel.sha256sum] = "51f974fde1bb9bde12b5197c6c5159d65b3f45adfbd0374b4727b6b293c1e1a0"

URI_aarch64_rust-pyo3+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py310-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py310-devel.sha256sum] = "7c1eb4f7b81d6a51a887e21c62527c336530d7eeb15fbbf391ee23175db8ac0b"

URI_aarch64_rust-pyo3+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py311-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py311-devel.sha256sum] = "3534934e09099b5d24feb007a693bd116dcc778cd0a7bc64907ca911bb90985f"

URI_aarch64_rust-pyo3+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py312-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py312-devel.sha256sum] = "4e36e353cc99b43b4a8f80a5f23923e99cfe6da150b205a21c0b7e58d13f58e5"

URI_aarch64_rust-pyo3+abi3-py313-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py313-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+abi3-py313-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py313-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py313-devel.sha256sum] = "4d999266eb22ccf7e8b5d4df8b89ab4d2f16ea102ec0dfa4ec3458088326e680"

URI_aarch64_rust-pyo3+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py37-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py37-devel.sha256sum] = "9bbd127de4a22500db18d0af7ddad3dcf93cf881bc7821703623f870e5a093f7"

URI_aarch64_rust-pyo3+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py38-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py38-devel.sha256sum] = "513bef9f4f564a56cb88a669ea2202fd3d0da1c5eaf5c9e20e007aa75c32e420"

URI_aarch64_rust-pyo3+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+abi3-py39-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3+abi3-py39-devel.sha256sum] = "5f3e9d7e86d2c96af75389454267d22ae4367bcb4d89e7f41aed2694daddcacf"

URI_aarch64_rust-pyo3+anyhow-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+anyhow-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+anyhow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+anyhow-devel}"
SRC_URI[aarch64_rust-pyo3+anyhow-devel.sha256sum] = "adba8f2398a363125b9e57be3697479dd5ef61a2c5300138530dbb7e7ee8a734"

URI_aarch64_rust-pyo3+auto-initialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+auto-initialize-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+auto-initialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+auto-initialize-devel}"
SRC_URI[aarch64_rust-pyo3+auto-initialize-devel.sha256sum] = "4d4c39e98846abd3d8b352b316283f0252a9f88e1197c2dde4edf5fe85680e94"

URI_aarch64_rust-pyo3+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-devel.sha256sum] = "86d5f9a4a644a25f64b965a1dd7521a85c678eabd273de47937c818e3e8ea4db"

URI_aarch64_rust-pyo3+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+chrono-tz-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+chrono-tz-devel}"
SRC_URI[aarch64_rust-pyo3+chrono-tz-devel.sha256sum] = "1a3e348816363d0041ba2b7b2d927c6e07530a09247fcebcf3310423344bc996"

URI_aarch64_rust-pyo3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+default-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+default-devel}"
SRC_URI[aarch64_rust-pyo3+default-devel.sha256sum] = "2e7ce0d7490b5299eabc24e70d9360fad25412e21c9607125b91d1ba863606e2"

URI_aarch64_rust-pyo3+either-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+either-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+either-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+either-devel}"
SRC_URI[aarch64_rust-pyo3+either-devel.sha256sum] = "ee1b8df5bc217895276d61998432bb7f614c46ffeaf5d79530ea51e7a679c25f"

URI_aarch64_rust-pyo3+experimental-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+experimental-async-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+experimental-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+experimental-async-devel}"
SRC_URI[aarch64_rust-pyo3+experimental-async-devel.sha256sum] = "9d46b47cea7b7c7c7868cec786c124631140e04052a6c0fc0e4ec009322335ff"

URI_aarch64_rust-pyo3+experimental-inspect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+experimental-inspect-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+experimental-inspect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+experimental-inspect-devel}"
SRC_URI[aarch64_rust-pyo3+experimental-inspect-devel.sha256sum] = "354ca2d41759b4a26af53f89e4599e61b65db8cb5fa2be0509f453f30f9db1f6"

URI_aarch64_rust-pyo3+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+extension-module-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3+extension-module-devel.sha256sum] = "6e611ad713deaf70650d4264a2b91aeab070a87b128e30b6eab893b0422c9524"

URI_aarch64_rust-pyo3+eyre-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+eyre-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+eyre-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+eyre-devel}"
SRC_URI[aarch64_rust-pyo3+eyre-devel.sha256sum] = "cc5cb6f5f5b2ecfa0077e8324df907c1ae148c249cc9def019609f2482333fb4"

URI_aarch64_rust-pyo3+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+full-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+full-devel}"
SRC_URI[aarch64_rust-pyo3+full-devel.sha256sum] = "669ba8db788ee01781425303328940d26ae86ddf81a212c4d9fc53b0188679af"

URI_aarch64_rust-pyo3+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+hashbrown-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+hashbrown-devel}"
SRC_URI[aarch64_rust-pyo3+hashbrown-devel.sha256sum] = "0928d05aeb865bebfd94b2b08f1b26ef74a0e52ffe51f03b3b6ab193f90fd6a6"

URI_aarch64_rust-pyo3+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+indexmap-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+indexmap-devel}"
SRC_URI[aarch64_rust-pyo3+indexmap-devel.sha256sum] = "85644088b0b3f06fbcf9804937af49382a520bc00c1e5544b767a04c5e9434b4"

URI_aarch64_rust-pyo3+indoc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+indoc-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+indoc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+indoc-devel}"
SRC_URI[aarch64_rust-pyo3+indoc-devel.sha256sum] = "e0d832747e608ad0820e467eddda9fb229bdfc8b83c4576ffc36cbf0fe0b4899"

URI_aarch64_rust-pyo3+inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+inventory-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+inventory-devel}"
SRC_URI[aarch64_rust-pyo3+inventory-devel.sha256sum] = "e0a97bb1ef14b8bfca0e021ccf2a548597b313781d5ddb278645c041459485b6"

URI_aarch64_rust-pyo3+jiff-02-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+jiff-02-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+jiff-02-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+jiff-02-devel}"
SRC_URI[aarch64_rust-pyo3+jiff-02-devel.sha256sum] = "9e906d2d017078bb587f056ec3c4e1b6bfcad5fe416b64a1bfa78d87f2db915b"

URI_aarch64_rust-pyo3+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+macros-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+macros-devel}"
SRC_URI[aarch64_rust-pyo3+macros-devel.sha256sum] = "7dffb2cc19be413a8118d4c5bdc3cf8418b86541ed85c0ce1582d9f80f4e0cbe"

URI_aarch64_rust-pyo3+multiple-pymethods-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+multiple-pymethods-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+multiple-pymethods-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+multiple-pymethods-devel}"
SRC_URI[aarch64_rust-pyo3+multiple-pymethods-devel.sha256sum] = "75f0944204d6fd0fd8bdb63c762f977f2fff2c9924b32f3b805ec8f22e7e8027"

URI_aarch64_rust-pyo3+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+nightly-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+nightly-devel}"
SRC_URI[aarch64_rust-pyo3+nightly-devel.sha256sum] = "01a2c43d1db377d9e6ea707203a7ac566f40e767bd4a29817db360c6136efba8"

URI_aarch64_rust-pyo3+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-bigint-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-bigint-devel}"
SRC_URI[aarch64_rust-pyo3+num-bigint-devel.sha256sum] = "baa41faef06756a10a2b0e169fbc17b6250444bbce438234bcb64158f3fd4ec3"

URI_aarch64_rust-pyo3+num-complex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-complex-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+num-complex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-complex-devel}"
SRC_URI[aarch64_rust-pyo3+num-complex-devel.sha256sum] = "eb2e33c3767a6f1f3703ad923232fbce5589dfeeffd8ac478659d0f9a7ad1927"

URI_aarch64_rust-pyo3+num-rational-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+num-rational-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+num-rational-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+num-rational-devel}"
SRC_URI[aarch64_rust-pyo3+num-rational-devel.sha256sum] = "f0152883e9eb2d50357b4e81c3b8da3ed274391c9d76d1f9c7067a96e398496c"

URI_aarch64_rust-pyo3+py-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+py-clone-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+py-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+py-clone-devel}"
SRC_URI[aarch64_rust-pyo3+py-clone-devel.sha256sum] = "e5cc834170323c0259d764c0214e9dda2626dd408e44d2bcfd839598b66a7fca"

URI_aarch64_rust-pyo3+pyo3-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+pyo3-macros-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+pyo3-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+pyo3-macros-devel}"
SRC_URI[aarch64_rust-pyo3+pyo3-macros-devel.sha256sum] = "dada632616895316632705b797625edc59d5b0865f7bfb6623d21f61338bf65e"

URI_aarch64_rust-pyo3+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+rust_decimal-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+rust_decimal-devel}"
SRC_URI[aarch64_rust-pyo3+rust_decimal-devel.sha256sum] = "4477e8e9d49cf4a5b64db1a90bd031bc2387f166c3b7b24dbd1195b50c6f3360"

URI_aarch64_rust-pyo3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+serde-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+serde-devel}"
SRC_URI[aarch64_rust-pyo3+serde-devel.sha256sum] = "f879bbeb74095a1e0e39afc837045eb1a2c8357e821f287745ffdd22d43fb4f3"

URI_aarch64_rust-pyo3+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+smallvec-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+smallvec-devel}"
SRC_URI[aarch64_rust-pyo3+smallvec-devel.sha256sum] = "12e34339f23cb5dd8acd93054b68d75479b2bab944c1765424896a43a9dce30c"

URI_aarch64_rust-pyo3+unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+unindent-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+unindent-devel}"
SRC_URI[aarch64_rust-pyo3+unindent-devel.sha256sum] = "7d131a1a57b41c559b6ae0f009dad14dd00299369bbd17f13dabfa265aa5a72a"

URI_aarch64_rust-pyo3+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3+uuid-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3+uuid-devel}"
SRC_URI[aarch64_rust-pyo3+uuid-devel.sha256sum] = "d46e42c3462abd02928c54ae38c2ca8e6022029fbca8eac05e94271df63f71d6"

URI_aarch64_rust-pyo3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-devel-0.24.2-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-devel}"
SRC_URI[aarch64_rust-pyo3-devel.sha256sum] = "cca91e404fe637cbb54860029cff736cd559f228fc9323e4f9f6e52d3354f88a"

RDEPENDS:rust-pyo3+abi3-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-devel \
 "
RDEPENDS:rust-pyo3+abi3-py310-devel = " \
 cargo \
 rust-pyo3+abi3-py311-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py310-devel \
 "
RDEPENDS:rust-pyo3+abi3-py311-devel = " \
 cargo \
 rust-pyo3+abi3-py312-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py311-devel \
 "
RDEPENDS:rust-pyo3+abi3-py312-devel = " \
 cargo \
 rust-pyo3+abi3-py313-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py312-devel \
 "
RDEPENDS:rust-pyo3+abi3-py313-devel = " \
 cargo \
 rust-pyo3+abi3-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py313-devel \
 "
RDEPENDS:rust-pyo3+abi3-py37-devel = " \
 cargo \
 rust-pyo3+abi3-py38-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py37-devel \
 "
RDEPENDS:rust-pyo3+abi3-py38-devel = " \
 cargo \
 rust-pyo3+abi3-py39-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py38-devel \
 "
RDEPENDS:rust-pyo3+abi3-py39-devel = " \
 cargo \
 rust-pyo3+abi3-py310-devel \
 rust-pyo3-devel \
 rust-pyo3-ffi+abi3-py39-devel \
 "
RDEPENDS:rust-pyo3+anyhow-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+auto-initialize-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+default-devel = " \
 cargo \
 rust-pyo3+macros-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+either-devel = " \
 cargo \
 rust-either+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+experimental-async-devel = " \
 cargo \
 rust-pyo3+macros-devel \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+experimental-async-devel \
 "
RDEPENDS:rust-pyo3+experimental-inspect-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+extension-module-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-ffi+extension-module-devel \
 "
RDEPENDS:rust-pyo3+eyre-devel = " \
 cargo \
 rust-eyre+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+full-devel = " \
 cargo \
 rust-pyo3+anyhow-devel \
 rust-pyo3+chrono-devel \
 rust-pyo3+chrono-tz-devel \
 rust-pyo3+either-devel \
 rust-pyo3+experimental-async-devel \
 rust-pyo3+experimental-inspect-devel \
 rust-pyo3+eyre-devel \
 rust-pyo3+hashbrown-devel \
 rust-pyo3+indexmap-devel \
 rust-pyo3+macros-devel \
 rust-pyo3+num-bigint-devel \
 rust-pyo3+num-complex-devel \
 rust-pyo3+num-rational-devel \
 rust-pyo3+py-clone-devel \
 rust-pyo3+rust_decimal-devel \
 rust-pyo3+serde-devel \
 rust-pyo3+smallvec-devel \
 rust-pyo3+uuid-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+hashbrown-devel = " \
 cargo \
 rust-pyo3-devel \
 virtual/crate_hashbrown/default__ge_0.14.5_with_crate_hashbrown/default__lt_0.16.0~ \
 "
RDEPENDS:rust-pyo3+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+indoc-devel = " \
 cargo \
 rust-indoc+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+inventory-devel = " \
 cargo \
 rust-inventory+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+jiff-02-devel = " \
 cargo \
 rust-jiff+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+macros-devel = " \
 cargo \
 rust-pyo3+indoc-devel \
 rust-pyo3+pyo3-macros-devel \
 rust-pyo3+unindent-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+multiple-pymethods-devel = " \
 cargo \
 rust-pyo3+inventory-devel \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 rust-pyo3-macros+multiple-pymethods-devel \
 "
RDEPENDS:rust-pyo3+nightly-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-bigint-devel = " \
 cargo \
 rust-num-bigint+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-complex-devel = " \
 cargo \
 rust-num-complex+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+num-rational-devel = " \
 cargo \
 rust-num-rational+default-devel \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+py-clone-devel = " \
 cargo \
 rust-pyo3-devel \
 "
RDEPENDS:rust-pyo3+pyo3-macros-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-pyo3-macros+default-devel \
 "
RDEPENDS:rust-pyo3+rust_decimal-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-rust_decimal-devel \
 "
RDEPENDS:rust-pyo3+serde-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-pyo3+smallvec-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-pyo3+unindent-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-unindent+default-devel \
 "
RDEPENDS:rust-pyo3+uuid-devel = " \
 cargo \
 rust-pyo3-devel \
 rust-uuid+default-devel \
 "
RDEPENDS:rust-pyo3-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-memoffset+default-devel \
 rust-once_cell+default-devel \
 rust-pyo3-build-config+default-devel \
 rust-pyo3-build-config+resolve-config-devel \
 rust-pyo3-ffi+default-devel \
 "
