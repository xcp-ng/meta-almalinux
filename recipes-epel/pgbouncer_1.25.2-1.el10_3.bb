# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pgbouncer"
PV = "1.25.2"
PR = "1.el10_3"
PACKAGES = " \
 pgbouncer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pgbouncer-1.25.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4d157c72afa39e65b52b321bc6fd1d16f4d253dcb1a8b93e7fda7388bcd3219"

URI_x86_64_v2_pgbouncer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pgbouncer-1.25.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pgbouncer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pgbouncer}"
SRC_URI[x86_64_v2_pgbouncer.sha256sum] = "d1fe83d35e2a9ae6686c4119bf2e9b9757444537606c2d1523ce487f887f13f4"

URI_aarch64_pgbouncer = "${EPEL_MIRROR}/aarch64/Packages/p/pgbouncer-1.25.2-1.el10_3.aarch64.rpm;name=aarch64_pgbouncer;unpack=0"
SRC_URI:append = " ${URI_aarch64_pgbouncer}"
SRC_URI[aarch64_pgbouncer.sha256sum] = "7a165bfa6872a826c7dcd5e97dc5cd41944f2963677756d38f0da46eab0d3a24"

RDEPENDS:pgbouncer = " \
 bash \
 c-ares \
 glibc \
 libevent \
 logrotate \
 openldap \
 openssl-libs \
 pam-libs \
 python3 \
 python3-psycopg2 \
 shadow-utils \
 systemd \
 systemd-libs \
 "
