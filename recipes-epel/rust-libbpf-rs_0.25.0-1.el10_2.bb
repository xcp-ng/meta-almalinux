# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbpf-rs"
PV = "0.25.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-libbpf-rs+default-devel \
 rust-libbpf-rs+dont-generate-test-files-devel \
 rust-libbpf-rs+generate-test-files-devel \
 rust-libbpf-rs+libbpf-sys-devel \
 rust-libbpf-rs+static-devel \
 rust-libbpf-rs+vendored-devel \
 rust-libbpf-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbpf-rs-0.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "997c8a7216933404feb6eb377490cf363a657ad99c7426bdd24924a640a693d8"

URI_x86_64_v2_rust-libbpf-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+default-devel-0.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+default-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+default-devel.sha256sum] = "0ef310bd52e323f0f467da8109fc3d49d4097b2e84d08a44c0d5fc82f8a8dfcd"

URI_x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+dont-generate-test-files-devel-0.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+dont-generate-test-files-devel.sha256sum] = "00af5581cb3335ffdc0213561f0016fe66df84d25b95a7fdcdffb85f61880282"

URI_x86_64_v2_rust-libbpf-rs+generate-test-files-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+generate-test-files-devel-0.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+generate-test-files-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+generate-test-files-devel.sha256sum] = "951a6ba9f25fe3f1d86f92d38558650f68201c65b9aade8f22d14c5ca53b79a6"

URI_x86_64_v2_rust-libbpf-rs+libbpf-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+libbpf-sys-devel-0.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+libbpf-sys-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+libbpf-sys-devel.sha256sum] = "08a3be46b39be382de04128b35730ae5388f1cdd2d83fe30d1be59e5cb909d6b"

URI_x86_64_v2_rust-libbpf-rs+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+static-devel-0.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+static-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+static-devel.sha256sum] = "2cdd8cec9ec92acc7d9e3dc348ce60cbfe3921a35007dd6ff138c8c09535279c"

URI_x86_64_v2_rust-libbpf-rs+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs+vendored-devel-0.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs+vendored-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs+vendored-devel.sha256sum] = "c844ab5ec44dab60fd6614ffaf7feb13e02aad2e78c0271d8ec39a30147a1058"

URI_x86_64_v2_rust-libbpf-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbpf-rs-devel-0.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbpf-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbpf-rs-devel}"
SRC_URI[x86_64_v2_rust-libbpf-rs-devel.sha256sum] = "16ae34a362a8eca04439c458e19e9e0954838ebd6dd37d69b073e2e3f86e08bc"

URI_aarch64_rust-libbpf-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+default-devel-0.25.0-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+default-devel}"
SRC_URI[aarch64_rust-libbpf-rs+default-devel.sha256sum] = "9b7dd7cc8824d0638bc537eb3414f4b6c640f0df29f3abe8bb8bfc3912cbe752"

URI_aarch64_rust-libbpf-rs+dont-generate-test-files-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+dont-generate-test-files-devel-0.25.0-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs+dont-generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+dont-generate-test-files-devel}"
SRC_URI[aarch64_rust-libbpf-rs+dont-generate-test-files-devel.sha256sum] = "d90636f6ac5116cb9b28cd9329946fa5ea9c62835e5df8c59bec351f55df137e"

URI_aarch64_rust-libbpf-rs+generate-test-files-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+generate-test-files-devel-0.25.0-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs+generate-test-files-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+generate-test-files-devel}"
SRC_URI[aarch64_rust-libbpf-rs+generate-test-files-devel.sha256sum] = "e88405bff7106a3b9bc6dd1ac2bdb4c29f7e71e770156a6cb02777d924abeeca"

URI_aarch64_rust-libbpf-rs+libbpf-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+libbpf-sys-devel-0.25.0-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs+libbpf-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+libbpf-sys-devel}"
SRC_URI[aarch64_rust-libbpf-rs+libbpf-sys-devel.sha256sum] = "67e8ef1b8f6597c47277a4dfdd68a31410bd4bb7bcd41ea8020c0c2bbed20e99"

URI_aarch64_rust-libbpf-rs+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+static-devel-0.25.0-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+static-devel}"
SRC_URI[aarch64_rust-libbpf-rs+static-devel.sha256sum] = "75f0b2b92c8444f8639882ac26d371d0788a244bdf7b753a468816d13be8c531"

URI_aarch64_rust-libbpf-rs+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs+vendored-devel-0.25.0-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs+vendored-devel}"
SRC_URI[aarch64_rust-libbpf-rs+vendored-devel.sha256sum] = "422dc3c45b7d76f49fe9fdebf41b5a0154fe7d1ec6c12ae8d616d354d85ce07b"

URI_aarch64_rust-libbpf-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbpf-rs-devel-0.25.0-1.el10_2.noarch.rpm;name=aarch64_rust-libbpf-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbpf-rs-devel}"
SRC_URI[aarch64_rust-libbpf-rs-devel.sha256sum] = "f731d8d8e684708575eee9f93bed40808ff1981a524fb1fdb767870bdfb6daea"

RDEPENDS:rust-libbpf-rs+default-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs+dont-generate-test-files-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 "
RDEPENDS:rust-libbpf-rs+generate-test-files-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+vendored-libbpf-devel \
 rust-libbpf-sys-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-libbpf-rs+libbpf-sys-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs+static-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+static-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs+vendored-devel = " \
 cargo \
 rust-libbpf-rs-devel \
 rust-libbpf-sys+vendored-devel \
 rust-libbpf-sys-devel \
 "
RDEPENDS:rust-libbpf-rs-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-libbpf-sys-devel \
 rust-libc+default-devel \
 rust-vsprintf+default-devel \
 "
