# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-process_executer"
PV = "4.0.0"
PR = "2.el10_0"
PACKAGES = " \
 rubygem-process_executer \
 rubygem-process_executer-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-process_executer-4.0.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb807087524098721fc4af6e32b91565a41b2787857584c65eeb0aa3f20ab2f4"

URI_x86_64_v2_rubygem-process_executer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-process_executer-4.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-process_executer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-process_executer}"
SRC_URI[x86_64_v2_rubygem-process_executer.sha256sum] = "1fe6527abd84a7feefb8a09cabe110737d149baa03a574e62a6b46ef033900ee"

URI_x86_64_v2_rubygem-process_executer-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-process_executer-doc-4.0.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-process_executer-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-process_executer-doc}"
SRC_URI[x86_64_v2_rubygem-process_executer-doc.sha256sum] = "22634df7aca6148e27f60b45b939c4c6e64c1f52039a41a46c275eeb9b53ffc5"

URI_aarch64_rubygem-process_executer = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-process_executer-4.0.0-2.el10_0.noarch.rpm;name=aarch64_rubygem-process_executer;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-process_executer}"
SRC_URI[aarch64_rubygem-process_executer.sha256sum] = "236d808ef0951d99d32a3cf6f94e2cd52dadd9ddf1ff9e00c585fd3170c93613"

URI_aarch64_rubygem-process_executer-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-process_executer-doc-4.0.0-2.el10_0.noarch.rpm;name=aarch64_rubygem-process_executer-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-process_executer-doc}"
SRC_URI[aarch64_rubygem-process_executer-doc.sha256sum] = "3452c2b596239b09eeff64a4f5aaf4e9414ca739a8f4b5313af3850fc1d71f5f"

RDEPENDS:rubygem-process_executer = " \
 rubygem-track_open_instances \
 rubygems \
 "
RDEPENDS:rubygem-process_executer-doc = " \
 rubygem-process_executer \
 "
