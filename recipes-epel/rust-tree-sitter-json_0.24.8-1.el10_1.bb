# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-json"
PV = "0.24.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-json+default-devel \
 rust-tree-sitter-json-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-json-0.24.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8955fa571ae8f5e229d80e8cb22330e97f09b6a9e7f19c24b43978e30129376"

URI_x86_64_v2_rust-tree-sitter-json+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-json+default-devel-0.24.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-json+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-json+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-json+default-devel.sha256sum] = "0c96709b17c80ac7950a6a783974c73a40cb2e8de785b8cbc7ea7654ad53f9e3"

URI_x86_64_v2_rust-tree-sitter-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-json-devel-0.24.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-json-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-json-devel.sha256sum] = "85df6622bc9aaacb08cb1171f537cc39a5c10a7e994b0f1baca5bb868a9555eb"

URI_aarch64_rust-tree-sitter-json+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-json+default-devel-0.24.8-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-json+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-json+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-json+default-devel.sha256sum] = "93045e6bc61d2a8521201de60cc6fca73d10c75a90fa0b680241b0f257bb50c2"

URI_aarch64_rust-tree-sitter-json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-json-devel-0.24.8-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-json-devel}"
SRC_URI[aarch64_rust-tree-sitter-json-devel.sha256sum] = "0d0b9a2400eebc70af92fbd9bd83d981a684d4a375bd4a3aa534366a9c8167f8"

RDEPENDS:rust-tree-sitter-json+default-devel = " \
 cargo \
 rust-tree-sitter-json-devel \
 "
RDEPENDS:rust-tree-sitter-json-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
