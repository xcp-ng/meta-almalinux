# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-version-ranges"
PV = "0.1.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-version-ranges+default-devel \
 rust-version-ranges+proptest-devel \
 rust-version-ranges+semver-devel \
 rust-version-ranges+serde-devel \
 rust-version-ranges-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-version-ranges-0.1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25f4216a7c24614bf07d463f7f7ffe61e10295aa22ccae1d699cf1fa281f7592"

URI_x86_64_v2_rust-version-ranges+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+default-devel-0.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+default-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+default-devel.sha256sum] = "2bc302edc9d2b7a4bbcfad8857d8f7df350b0266b8282e382d9f7a4dbf21a144"

URI_x86_64_v2_rust-version-ranges+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+proptest-devel-0.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+proptest-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+proptest-devel.sha256sum] = "a98d4dd55f46b411deae29fe95b30f75b8e5711e5c74c8ec3369f62e5ad2451d"

URI_x86_64_v2_rust-version-ranges+semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+semver-devel-0.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+semver-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+semver-devel.sha256sum] = "626522bfc9b6b7d273a9a38e61dccb0ab16b9329aeb2907fc756b6fd2c3e1cd4"

URI_x86_64_v2_rust-version-ranges+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+serde-devel-0.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+serde-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+serde-devel.sha256sum] = "1180f358ab28140c5c77621764b8d22dc1a1a23bc1035e4f758aee2be22c3419"

URI_x86_64_v2_rust-version-ranges-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges-devel-0.1.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges-devel}"
SRC_URI[x86_64_v2_rust-version-ranges-devel.sha256sum] = "e31c5be7fc99e9cd3518374395d2aab2ffbf208cc6269772777f7487fb578d64"

URI_aarch64_rust-version-ranges+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+default-devel-0.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+default-devel}"
SRC_URI[aarch64_rust-version-ranges+default-devel.sha256sum] = "65ac50479ea5e346b5f4c83637e71e7d3ed717f7c8058e21ee53d840338dc514"

URI_aarch64_rust-version-ranges+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+proptest-devel-0.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+proptest-devel}"
SRC_URI[aarch64_rust-version-ranges+proptest-devel.sha256sum] = "aaf84667a94542c01494b1c0cd1ea1dbfb998cde0d1733802291c7df16bfb6f2"

URI_aarch64_rust-version-ranges+semver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+semver-devel-0.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-version-ranges+semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+semver-devel}"
SRC_URI[aarch64_rust-version-ranges+semver-devel.sha256sum] = "89b90e8c1f6fffa0915a568150bb3c9899843c84d1e796fd3f388f1aa0bf20c4"

URI_aarch64_rust-version-ranges+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+serde-devel-0.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+serde-devel}"
SRC_URI[aarch64_rust-version-ranges+serde-devel.sha256sum] = "c207f982f08605af0e3432befba8ce7a675a3f6718f673abc8449c52eefb7881"

URI_aarch64_rust-version-ranges-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges-devel-0.1.3-1.el10_3.noarch.rpm;name=aarch64_rust-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges-devel}"
SRC_URI[aarch64_rust-version-ranges-devel.sha256sum] = "2c15032d576eaf998292a8362c55e58c5be3d55e01c7f0c19b85577239dc2114"

RDEPENDS:rust-version-ranges+default-devel = " \
 cargo \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+proptest-devel = " \
 cargo \
 rust-proptest+default-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+semver-devel = " \
 cargo \
 rust-semver+default-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-smallvec+serde-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
