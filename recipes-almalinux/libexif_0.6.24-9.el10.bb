# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libexif"
PV = "0.6.24"
PR = "9.el10"
PACKAGES = " \
 libexif \
 libexif-devel \
 libexif-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libexif-0.6.24-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dc5f0386308d477580fa43b77e4835ebe76b21acc7f3cf2a0a5400a54474f7c"

URI_x86_64_v2_libexif = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libexif-0.6.24-9.el10.x86_64_v2.rpm;name=x86_64_v2_libexif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libexif}"
SRC_URI[x86_64_v2_libexif.sha256sum] = "433ee71fac7b984f6044f364ca8def4d2b547eedcccbd7d299ba427d49c35fad"

URI_x86_64_v2_libexif-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libexif-devel-0.6.24-9.el10.x86_64_v2.rpm;name=x86_64_v2_libexif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libexif-devel}"
SRC_URI[x86_64_v2_libexif-devel.sha256sum] = "c65fcf83d520977043c6459fafdd62bee9c98be7a3b2867fe78d4ba77c841e26"

URI_x86_64_v2_libexif-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libexif-doc-0.6.24-9.el10.x86_64_v2.rpm;name=x86_64_v2_libexif-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libexif-doc}"
SRC_URI[x86_64_v2_libexif-doc.sha256sum] = "7031ff0e32f17bfb87dfbeb009575ed672ea7233b2f8ca40cdac2f1983c75e28"

URI_aarch64_libexif = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libexif-0.6.24-9.el10.aarch64.rpm;name=aarch64_libexif;unpack=0"
SRC_URI:append = " ${URI_aarch64_libexif}"
SRC_URI[aarch64_libexif.sha256sum] = "d3beb9b5a30dbe6d219866cbd8400221f0cca84a173e2753e16c4160a099722d"

URI_aarch64_libexif-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libexif-devel-0.6.24-9.el10.aarch64.rpm;name=aarch64_libexif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libexif-devel}"
SRC_URI[aarch64_libexif-devel.sha256sum] = "d56363147f68bc65e086b7e98eeeaf6479c714e03d1040b1716539e7f44f08c7"

URI_aarch64_libexif-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libexif-doc-0.6.24-9.el10.aarch64.rpm;name=aarch64_libexif-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libexif-doc}"
SRC_URI[aarch64_libexif-doc.sha256sum] = "4b32081a7ee8266c023c1071daa52503b8180104db03f97b1c9a8a9e4a8e0b41"

RDEPENDS:libexif = " \
 glibc \
 "
RDEPENDS:libexif-devel = " \
 libexif \
 pkgconf-pkg-config \
 "
RDEPENDS:libexif-doc = " \
 libexif \
 "
