# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-googleapis-enterprise-certificate-proxy"
PV = "0.3.2"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-googleapis-enterprise-certificate-proxy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-googleapis-enterprise-certificate-proxy-0.3.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d86a8e9faec3eb83025b1c7ef3ba486d459e4edc934eb8b693656bc7cd5ac2c2"

URI_x86_64_v2_golang-github-googleapis-enterprise-certificate-proxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-googleapis-enterprise-certificate-proxy-devel-0.3.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-googleapis-enterprise-certificate-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-googleapis-enterprise-certificate-proxy-devel}"
SRC_URI[x86_64_v2_golang-github-googleapis-enterprise-certificate-proxy-devel.sha256sum] = "f9afdc05f375209be6df88f2d84850018f65a082bcfec2bd5d759ce8a2bdea65"

URI_aarch64_golang-github-googleapis-enterprise-certificate-proxy-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-googleapis-enterprise-certificate-proxy-devel-0.3.2-2.el10_0.noarch.rpm;name=aarch64_golang-github-googleapis-enterprise-certificate-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-googleapis-enterprise-certificate-proxy-devel}"
SRC_URI[aarch64_golang-github-googleapis-enterprise-certificate-proxy-devel.sha256sum] = "a3a4c14d1a260b0098a63f78a8f3941571cd96cd3e6d2e89bfc7db1fd3d8986e"

RDEPENDS:golang-github-googleapis-enterprise-certificate-proxy-devel = " \
 go-filesystem \
 "
