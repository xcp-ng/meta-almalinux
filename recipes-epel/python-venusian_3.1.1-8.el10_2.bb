# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-venusian"
PV = "3.1.1"
PR = "8.el10_2"
PACKAGES = " \
 python3-venusian \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-venusian-3.1.1-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8b302d03a6e3f0553acf36393a66177cd3b8bcd36ac8aaa57036571c65152a1"

URI_x86_64_v2_python3-venusian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-venusian-3.1.1-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-venusian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-venusian}"
SRC_URI[x86_64_v2_python3-venusian.sha256sum] = "b8ad5df4526909216829b995577b61858e1b186de4a8050277bde37c24c63b40"

URI_aarch64_python3-venusian = "${EPEL_MIRROR}/aarch64/Packages/p/python3-venusian-3.1.1-8.el10_2.noarch.rpm;name=aarch64_python3-venusian;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-venusian}"
SRC_URI[aarch64_python3-venusian.sha256sum] = "20a87dcb4c9070b5057e3af3569ac3e3743f5f786493f55b3f005e183c63fb86"

RDEPENDS:python3-venusian = " \
 python3 \
 "
