# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-BibTeX"
PV = "0.91"
PR = "6.el10_1"
PACKAGES = " \
 perl-Text-BibTeX \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-BibTeX-0.91-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2412d3dc42cdb132eea0aab295aa9f9133dc0386347d62fe890a79ea2e7e96c4"

URI_x86_64_v2_perl-Text-BibTeX = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-BibTeX-0.91-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Text-BibTeX;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-BibTeX}"
SRC_URI[x86_64_v2_perl-Text-BibTeX.sha256sum] = "cfd6fc9d5417a38310f50efc9626c372ec4a8713ab358a3e7043ef36915685bc"

URI_aarch64_perl-Text-BibTeX = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-BibTeX-0.91-6.el10_1.aarch64.rpm;name=aarch64_perl-Text-BibTeX;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-BibTeX}"
SRC_URI[aarch64_perl-Text-BibTeX.sha256sum] = "e7a762103d7eee6161dd958ac5b02da1375268b4971917ba3d7236ae5ea15c2b"

RDEPENDS:perl-Text-BibTeX = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Tabular \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-Text-BibTeX \
 perl-Unicode-Normalize \
 perl-libs \
 perl-vars \
 "
