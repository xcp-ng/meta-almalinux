# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colordiff"
PV = "1.0.22"
PR = "1.el10_2"
PACKAGES = " \
 colordiff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/colordiff-1.0.22-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "743dbcb909ccfac60d4bfc5c552f742caf660db0b2fd07a73f69843ba3553191"

URI_x86_64_v2_colordiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/colordiff-1.0.22-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_colordiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colordiff}"
SRC_URI[x86_64_v2_colordiff.sha256sum] = "50133c71175f6a4a97a65922f22f9e46966863b4bd87668289fe165ad6f4d85a"

URI_aarch64_colordiff = "${EPEL_MIRROR}/aarch64/Packages/c/colordiff-1.0.22-1.el10_2.noarch.rpm;name=aarch64_colordiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_colordiff}"
SRC_URI[aarch64_colordiff.sha256sum] = "341505a5828d411c8ed1da8915f4f4bfa46a87dab42c469c02372684d1c20375"

RDEPENDS:colordiff = " \
 bash \
 diffutils \
 less \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
