# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-siphasher"
PV = "1.0.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-siphasher+default-devel \
 rust-siphasher+serde-devel \
 rust-siphasher+serde_json-devel \
 rust-siphasher+serde_no_std-devel \
 rust-siphasher+serde_std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-siphasher-1.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "055c942fce49d13a8bae08eb1f3d2f17a59e22bba3a42c5b42c281b5fe77e0bb"

URI_x86_64_v2_rust-siphasher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+default-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+default-devel}"
SRC_URI[x86_64_v2_rust-siphasher+default-devel.sha256sum] = "b1428f1213a8baa9cd919ef98c388e7a59bf20dc4ae798aa8f4f6000abe43c0f"

URI_x86_64_v2_rust-siphasher+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde-devel.sha256sum] = "c4d14588f8068913a371f23d62f37ea56d3127ebdff02e0a801476a177c42746"

URI_x86_64_v2_rust-siphasher+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_json-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde_json-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde_json-devel.sha256sum] = "a69bbb1de79c0102611edb93b167ca9ab0563ad71d8f26a9fdb7d2dd82b73fd3"

URI_x86_64_v2_rust-siphasher+serde_no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_no_std-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde_no_std-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde_no_std-devel.sha256sum] = "1232a6239907bde60c90fb4babdd2cccb481d9f2e22c13bd153eca4a1e679953"

URI_x86_64_v2_rust-siphasher+serde_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_std-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde_std-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde_std-devel.sha256sum] = "ea71483b0c9b90b736450c421b234838282197772d5f7dd3e85428d6debff9a6"

URI_x86_64_v2_rust-siphasher+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+std-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+std-devel}"
SRC_URI[x86_64_v2_rust-siphasher+std-devel.sha256sum] = "c2947c878b9ad47fbe66c0faf06403099f6db0153ab85f210b0c0f6e94fa618d"

URI_x86_64_v2_rust-siphasher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher-devel-1.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher-devel}"
SRC_URI[x86_64_v2_rust-siphasher-devel.sha256sum] = "8e3b2dffdd77cbc02c1627e78b1443fa54d804456cfa9d74541e776d1d302bd3"

URI_aarch64_rust-siphasher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+default-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+default-devel}"
SRC_URI[aarch64_rust-siphasher+default-devel.sha256sum] = "51536aa05ecf28d332a8efbee56228a3cb46978610044756e8bb1dde8a289719"

URI_aarch64_rust-siphasher+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde-devel}"
SRC_URI[aarch64_rust-siphasher+serde-devel.sha256sum] = "749f19bd6f982f5738fd0415449bbfaf00747938f9e177ffbdb3010a9fab0606"

URI_aarch64_rust-siphasher+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_json-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde_json-devel}"
SRC_URI[aarch64_rust-siphasher+serde_json-devel.sha256sum] = "a9dde327dc50135247ef4e7e0ab27fd8b7a9689ad1091e5bda1831e01e793072"

URI_aarch64_rust-siphasher+serde_no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_no_std-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde_no_std-devel}"
SRC_URI[aarch64_rust-siphasher+serde_no_std-devel.sha256sum] = "9e6e6604a46b0218f20cf67d70a120bd80861316dc6718d30b365bc97b5d1dbb"

URI_aarch64_rust-siphasher+serde_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_std-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde_std-devel}"
SRC_URI[aarch64_rust-siphasher+serde_std-devel.sha256sum] = "b1bd6033e75a235238a0fd524ba0172f52177a79e81781b7b0b588e236dccdf3"

URI_aarch64_rust-siphasher+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+std-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+std-devel}"
SRC_URI[aarch64_rust-siphasher+std-devel.sha256sum] = "8bb962268e2a3544f76296ada3f9b02aebd9ce6ac914fda6f6bfd0822b9ee6fc"

URI_aarch64_rust-siphasher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher-devel-1.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-siphasher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher-devel}"
SRC_URI[aarch64_rust-siphasher-devel.sha256sum] = "df0a46a6964db371cc79647d58490bb8a7562e56f4a0b262dabcaf202611bb8f"

RDEPENDS:rust-siphasher+default-devel = " \
 cargo \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_no_std-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_std-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+std-devel = " \
 cargo \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher-devel = " \
 cargo \
 "
