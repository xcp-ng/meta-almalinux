# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-throttler"
PV = "1.2.3"
PR = "25.el10_2"
PACKAGES = " \
 python3-throttler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-throttler-1.2.3-25.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1c0a36b63f1dc885c26da8b99185ba732186ba13a2a18e4f127b61beb1db59f"

URI_x86_64_v2_python3-throttler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-throttler-1.2.3-25.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-throttler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-throttler}"
SRC_URI[x86_64_v2_python3-throttler.sha256sum] = "60ba2854b8828695bed25f4c058d0bdfb886755343cbb462a0708d815f3f7aa3"

URI_aarch64_python3-throttler = "${EPEL_MIRROR}/aarch64/Packages/p/python3-throttler-1.2.3-25.el10_2.noarch.rpm;name=aarch64_python3-throttler;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-throttler}"
SRC_URI[aarch64_python3-throttler.sha256sum] = "38f6828bfd4c8feee507ed893fb7ae680e3ab9fab1fdf7c0e24bc6361223f633"

RDEPENDS:python3-throttler = " \
 python3 \
 "
