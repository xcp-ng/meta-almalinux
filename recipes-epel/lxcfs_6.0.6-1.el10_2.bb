# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lxcfs"
PV = "6.0.6"
PR = "1.el10_2"
PACKAGES = " \
 lxcfs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lxcfs-6.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f83a5e3c98fbc3aa6fe01bae33564324235fcc9ff4d2ffb84f95ba868d63b44c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lxcfs-6.0.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lxcfs;unpack=0"
SRC_URI[x86_64_v2_lxcfs.sha256sum] = "f142b80fb99837d157c3cd36bd9367f20a3f32b632e00061906dec4011713aca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lxcfs-6.0.6-1.el10_2.aarch64.rpm;name=aarch64_lxcfs;unpack=0"
SRC_URI[aarch64_lxcfs.sha256sum] = "182d8389c890fe6fe72424936a7e0b56bcc21a2eaa5396c50c62bc08b75a0b8d"

RDEPENDS:lxcfs = " \
 bash \
 fuse3-libs \
 glibc \
 libgcc \
 lxc-templates \
 systemd \
 "
