# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typed-builder"
PV = "0.18.2"
PR = "5.el10_3"
PACKAGES = " \
 rust-typed-builder+default-devel \
 rust-typed-builder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typed-builder-0.18.2-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81a1c0feecd4f85435751b2154b47efb2f7a1637abd7b84d14ddd6ad6686a9d9"

URI_x86_64_v2_rust-typed-builder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-builder+default-devel-0.18.2-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-builder+default-devel}"
SRC_URI[x86_64_v2_rust-typed-builder+default-devel.sha256sum] = "117c410688a4b292f3ab7ee55f6224956f60d55148d173bc31f7a7abcfaba996"

URI_x86_64_v2_rust-typed-builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-builder-devel-0.18.2-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-builder-devel}"
SRC_URI[x86_64_v2_rust-typed-builder-devel.sha256sum] = "3f343bccf119ed02147c93fc2f5592e4f3c8c2df8b5ea12a100ca01cba5abf00"

URI_aarch64_rust-typed-builder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-builder+default-devel-0.18.2-5.el10_3.noarch.rpm;name=aarch64_rust-typed-builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-builder+default-devel}"
SRC_URI[aarch64_rust-typed-builder+default-devel.sha256sum] = "d9272edcafc3748bd1fe530c80721f4501ff6bb12aa3a4c6314d716104bc05de"

URI_aarch64_rust-typed-builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-builder-devel-0.18.2-5.el10_3.noarch.rpm;name=aarch64_rust-typed-builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-builder-devel}"
SRC_URI[aarch64_rust-typed-builder-devel.sha256sum] = "f54e53a9292052a525cf141ce4c3d5c972f088f1845d6135e02148a7383a2f53"

RDEPENDS:rust-typed-builder+default-devel = " \
 cargo \
 rust-typed-builder-devel \
 "
RDEPENDS:rust-typed-builder-devel = " \
 cargo \
 rust-typed-builder-macro+default-devel \
 "
