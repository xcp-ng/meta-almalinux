# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral_async_http_range_reader"
PV = "0.11.0"
PR = "6.el10_3"
PACKAGES = " \
 rust-astral_async_http_range_reader+default-devel \
 rust-astral_async_http_range_reader-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral_async_http_range_reader-0.11.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71e7620b248cd8e17c25a6a7a63c6a83b23041a12cef3c5975c5d9086b602646"

URI_x86_64_v2_rust-astral_async_http_range_reader+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_http_range_reader+default-devel-0.11.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_http_range_reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_http_range_reader+default-devel}"
SRC_URI[x86_64_v2_rust-astral_async_http_range_reader+default-devel.sha256sum] = "03393b54bdf6a1149df9beccb5ff8d0ad2500d7dc1182cb07e5cf35d94aef3f7"

URI_x86_64_v2_rust-astral_async_http_range_reader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral_async_http_range_reader-devel-0.11.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral_async_http_range_reader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral_async_http_range_reader-devel}"
SRC_URI[x86_64_v2_rust-astral_async_http_range_reader-devel.sha256sum] = "9c0165a992ae052bafeea12434285de26b90b3a070ae3e02723d448f6ba54cc1"

URI_aarch64_rust-astral_async_http_range_reader+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_http_range_reader+default-devel-0.11.0-6.el10_3.noarch.rpm;name=aarch64_rust-astral_async_http_range_reader+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_http_range_reader+default-devel}"
SRC_URI[aarch64_rust-astral_async_http_range_reader+default-devel.sha256sum] = "9aed68da5cf3a122e1236d460a9ec0b816b9fedb91bf5ec42fe69e471be7f7aa"

URI_aarch64_rust-astral_async_http_range_reader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral_async_http_range_reader-devel-0.11.0-6.el10_3.noarch.rpm;name=aarch64_rust-astral_async_http_range_reader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral_async_http_range_reader-devel}"
SRC_URI[aarch64_rust-astral_async_http_range_reader-devel.sha256sum] = "373dd234a6735d0139b0e018e5efe3cb972d8ec04c1f6f811c66fc0182e40d2e"

RDEPENDS:rust-astral_async_http_range_reader+default-devel = " \
 cargo \
 rust-astral_async_http_range_reader-devel \
 "
RDEPENDS:rust-astral_async_http_range_reader-devel = " \
 cargo \
 rust \
 rust-astral-reqwest-middleware+default-devel \
 rust-futures+default-devel \
 rust-http-content-range+default-devel \
 rust-itertools0.14+default-devel \
 rust-memmap2+default-devel \
 rust-reqwest+stream-devel \
 rust-reqwest-devel \
 rust-thiserror+default-devel \
 rust-tokio-devel \
 rust-tokio-stream+default-devel \
 rust-tokio-stream+sync-devel \
 rust-tokio-util+default-devel \
 rust-tracing+default-devel \
 "
