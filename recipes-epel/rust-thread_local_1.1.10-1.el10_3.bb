# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thread_local"
PV = "1.1.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-thread_local+default-devel \
 rust-thread_local+nightly-devel \
 rust-thread_local-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thread_local-1.1.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e14084d7f341f367b3460f51c7d7f1fffe4f044a0987e7a78f57bc37d898be88"

URI_x86_64_v2_rust-thread_local+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local+default-devel-1.1.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local+default-devel}"
SRC_URI[x86_64_v2_rust-thread_local+default-devel.sha256sum] = "a698a499efa64e116feb683b0d4fdda4c519afd9247040fd4b9e858239a10199"

URI_x86_64_v2_rust-thread_local+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local+nightly-devel-1.1.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local+nightly-devel}"
SRC_URI[x86_64_v2_rust-thread_local+nightly-devel.sha256sum] = "cb8cf139325f4a533736ff182c229077cf951a0f93b5879843b77dbaf0cdb299"

URI_x86_64_v2_rust-thread_local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local-devel-1.1.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local-devel}"
SRC_URI[x86_64_v2_rust-thread_local-devel.sha256sum] = "ec7aece2598228e7f1acc18830006b9b946354fd030b3eca454bb2df852de73b"

URI_aarch64_rust-thread_local+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local+default-devel-1.1.10-1.el10_3.noarch.rpm;name=aarch64_rust-thread_local+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local+default-devel}"
SRC_URI[aarch64_rust-thread_local+default-devel.sha256sum] = "e70e31eb0b8d14e01ebbd6fc9f1d245a0194856ef57f44a150bbb5dcdfb0c9c9"

URI_aarch64_rust-thread_local+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local+nightly-devel-1.1.10-1.el10_3.noarch.rpm;name=aarch64_rust-thread_local+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local+nightly-devel}"
SRC_URI[aarch64_rust-thread_local+nightly-devel.sha256sum] = "5c27eb5d9a4595a6907543e6d47787255c3087e48ffe67faa0ca0b2372e877ba"

URI_aarch64_rust-thread_local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local-devel-1.1.10-1.el10_3.noarch.rpm;name=aarch64_rust-thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local-devel}"
SRC_URI[aarch64_rust-thread_local-devel.sha256sum] = "dbaa8db173f06595f63663a58a859cedc1bb30715ea1507a2e67b79264d35abc"

RDEPENDS:rust-thread_local+default-devel = " \
 cargo \
 rust-thread_local-devel \
 "
RDEPENDS:rust-thread_local+nightly-devel = " \
 cargo \
 rust-thread_local-devel \
 "
RDEPENDS:rust-thread_local-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
