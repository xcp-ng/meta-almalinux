# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2-breeze-theme"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 grub2-breeze-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grub2-breeze-theme-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc0fd0a049e1b3566f5bb2cb61cc7465be3fc6940a0e3c9c491c1ac352059529"

URI_x86_64_v2_grub2-breeze-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grub2-breeze-theme-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grub2-breeze-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grub2-breeze-theme}"
SRC_URI[x86_64_v2_grub2-breeze-theme.sha256sum] = "1cc6da9c870eb405183fb186160180e89a2c42c65574c955eac1f9324054b3a1"

URI_aarch64_grub2-breeze-theme = "${EPEL_MIRROR}/aarch64/Packages/g/grub2-breeze-theme-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_grub2-breeze-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_grub2-breeze-theme}"
SRC_URI[aarch64_grub2-breeze-theme.sha256sum] = "86f4c459c4f80ed9977a7d5e21fec43a27b6586e99cf0d58bcdeb589bf238ac1"

RDEPENDS:grub2-breeze-theme:x86_64_v2 = " \
 grub2-pc \
"
RDEPENDS:grub2-breeze-theme:aarch64 = " \
 grub2-efi-aa64 \
"
