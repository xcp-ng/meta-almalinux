# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "picmi"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 picmi \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/picmi-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f80faea47d5af9f0eb49711aab533828dfd29fb1a0ed2ef7d9f31686b7f8a33"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/picmi-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_picmi;unpack=0"
SRC_URI[x86_64_v2_picmi.sha256sum] = "87dea0e07d9d078c1ab5871d159e5f821d18d59ebd707ac8b644c7466b6bb4e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/picmi-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_picmi;unpack=0"
SRC_URI[aarch64_picmi.sha256sum] = "95368883b7f2649d7bb96fab1abb08acdf28bc9a9a0cfc91abb6fcd3a044d70b"

RDEPENDS:picmi = " \
 glibc \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
