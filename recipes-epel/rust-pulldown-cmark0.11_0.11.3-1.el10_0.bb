# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pulldown-cmark0.11"
PV = "0.11.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-pulldown-cmark0.11+default-devel \
 rust-pulldown-cmark0.11+gen-tests-devel \
 rust-pulldown-cmark0.11+getopts-devel \
 rust-pulldown-cmark0.11+html-devel \
 rust-pulldown-cmark0.11+pulldown-cmark-escape-devel \
 rust-pulldown-cmark0.11+serde-devel \
 rust-pulldown-cmark0.11+simd-devel \
 rust-pulldown-cmark0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pulldown-cmark0.11-0.11.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "600bc4edb8617634fa8d75502babcb92fe479a4ce1d904a8fe3aa682cb6cbc13"

URI_x86_64_v2_rust-pulldown-cmark0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark0.11+default-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark0.11+default-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark0.11+default-devel.sha256sum] = "26a42629121a6d2cf3fbdd9502b5f780e0fcd079899a19528166549af320f356"

URI_x86_64_v2_rust-pulldown-cmark0.11+gen-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark0.11+gen-tests-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark0.11+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark0.11+gen-tests-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark0.11+gen-tests-devel.sha256sum] = "5062ffbbc74d4d7840a0a83fa0857cce828275525cd8457ba24893fcc50059f3"

URI_x86_64_v2_rust-pulldown-cmark0.11+getopts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark0.11+getopts-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark0.11+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark0.11+getopts-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark0.11+getopts-devel.sha256sum] = "12e3a72e9ff58c76f1d717e551159d45cdb75094909d91e35bf61069c0b1c1e1"

URI_x86_64_v2_rust-pulldown-cmark0.11+html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark0.11+html-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark0.11+html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark0.11+html-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark0.11+html-devel.sha256sum] = "7a192cdac4cea9d576824871e3722c39e6ada52735c79f0ec8d4901c2d96b55d"

URI_x86_64_v2_rust-pulldown-cmark0.11+pulldown-cmark-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark0.11+pulldown-cmark-escape-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark0.11+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark0.11+pulldown-cmark-escape-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark0.11+pulldown-cmark-escape-devel.sha256sum] = "ce758af99ad406b0b1e1f13de4a7e3f1174abce368af14f4a9258db5dfd6c7af"

URI_x86_64_v2_rust-pulldown-cmark0.11+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark0.11+serde-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark0.11+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark0.11+serde-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark0.11+serde-devel.sha256sum] = "4ddfd97b6161b6a9034e8614286964551c3bfc1a72fda5fe0e249477e1898b08"

URI_x86_64_v2_rust-pulldown-cmark0.11+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark0.11+simd-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark0.11+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark0.11+simd-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark0.11+simd-devel.sha256sum] = "ed014d75cfb214e31144447623c9b74d67ace34a55a25e712fbe2ccab9d3a9ee"

URI_x86_64_v2_rust-pulldown-cmark0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark0.11-devel-0.11.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark0.11-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark0.11-devel.sha256sum] = "28a11d4c332545a64a2aeeafdf20bada3320c3cb6a13fa7f771dba9e5f69f4ab"

URI_aarch64_rust-pulldown-cmark0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark0.11+default-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark0.11+default-devel}"
SRC_URI[aarch64_rust-pulldown-cmark0.11+default-devel.sha256sum] = "e4576df650444fc9e7a5a60c9f77eadfe38bb2e3e6ebc35a840aa06b265666a6"

URI_aarch64_rust-pulldown-cmark0.11+gen-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark0.11+gen-tests-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark0.11+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark0.11+gen-tests-devel}"
SRC_URI[aarch64_rust-pulldown-cmark0.11+gen-tests-devel.sha256sum] = "f6ae2a335a45e665e6ae16b19fe16ea9bfb3f9660f1b05220527baa660b6bd67"

URI_aarch64_rust-pulldown-cmark0.11+getopts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark0.11+getopts-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark0.11+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark0.11+getopts-devel}"
SRC_URI[aarch64_rust-pulldown-cmark0.11+getopts-devel.sha256sum] = "1d2b2b158fd693b69afd7b2fec21336e7e2e7d65d971b9a8713e7ad6036e2367"

URI_aarch64_rust-pulldown-cmark0.11+html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark0.11+html-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark0.11+html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark0.11+html-devel}"
SRC_URI[aarch64_rust-pulldown-cmark0.11+html-devel.sha256sum] = "80e09f5385249c8a403d707b24a52a802d6fee4cf3df6c79e1352f8b3e615320"

URI_aarch64_rust-pulldown-cmark0.11+pulldown-cmark-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark0.11+pulldown-cmark-escape-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark0.11+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark0.11+pulldown-cmark-escape-devel}"
SRC_URI[aarch64_rust-pulldown-cmark0.11+pulldown-cmark-escape-devel.sha256sum] = "e117ed8f6693a41985a812bf1f1a451f882e4011781c8d8775e8c6bd802e062d"

URI_aarch64_rust-pulldown-cmark0.11+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark0.11+serde-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark0.11+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark0.11+serde-devel}"
SRC_URI[aarch64_rust-pulldown-cmark0.11+serde-devel.sha256sum] = "edf2f1f798b20b37e5590079ba71e32b1f974b7f96fad67f4ed15f86ef33d636"

URI_aarch64_rust-pulldown-cmark0.11+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark0.11+simd-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark0.11+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark0.11+simd-devel}"
SRC_URI[aarch64_rust-pulldown-cmark0.11+simd-devel.sha256sum] = "50c4935b53eb227e7edf1efa17781d0f6fcb10ddca0b1bb0dd25ed88e96a96db"

URI_aarch64_rust-pulldown-cmark0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark0.11-devel-0.11.3-1.el10_0.noarch.rpm;name=aarch64_rust-pulldown-cmark0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark0.11-devel}"
SRC_URI[aarch64_rust-pulldown-cmark0.11-devel.sha256sum] = "71ae98050bba6a4f825206dcc5ee7681c24ac0dd61bf970c1f3d1d2f5bd84f2e"

RDEPENDS:rust-pulldown-cmark0.11+default-devel = " \
 cargo \
 rust-pulldown-cmark0.11+getopts-devel \
 rust-pulldown-cmark0.11+html-devel \
 rust-pulldown-cmark0.11-devel \
 "
RDEPENDS:rust-pulldown-cmark0.11+gen-tests-devel = " \
 cargo \
 rust-pulldown-cmark0.11-devel \
 "
RDEPENDS:rust-pulldown-cmark0.11+getopts-devel = " \
 cargo \
 rust-getopts+default-devel \
 rust-pulldown-cmark0.11-devel \
 "
RDEPENDS:rust-pulldown-cmark0.11+html-devel = " \
 cargo \
 rust-pulldown-cmark0.11+pulldown-cmark-escape-devel \
 rust-pulldown-cmark0.11-devel \
 "
RDEPENDS:rust-pulldown-cmark0.11+pulldown-cmark-escape-devel = " \
 cargo \
 rust-pulldown-cmark-escape+default-devel \
 rust-pulldown-cmark0.11-devel \
 "
RDEPENDS:rust-pulldown-cmark0.11+serde-devel = " \
 cargo \
 rust-pulldown-cmark0.11-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-pulldown-cmark0.11+simd-devel = " \
 cargo \
 rust-pulldown-cmark-escape+default-devel \
 rust-pulldown-cmark-escape+simd-devel \
 rust-pulldown-cmark0.11-devel \
 "
RDEPENDS:rust-pulldown-cmark0.11-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-memchr+default-devel \
 rust-unicase+default-devel \
 "
