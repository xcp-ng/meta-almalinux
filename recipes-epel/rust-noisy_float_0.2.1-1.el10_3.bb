# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-noisy_float"
PV = "0.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-noisy_float+approx-devel \
 rust-noisy_float+default-devel \
 rust-noisy_float+serde-devel \
 rust-noisy_float-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-noisy_float-0.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1022539f4a64c14a93cfa79a669aaffb88bba7a93bcf8621ff9fd738859ce0b5"

URI_x86_64_v2_rust-noisy_float+approx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-noisy_float+approx-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-noisy_float+approx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-noisy_float+approx-devel}"
SRC_URI[x86_64_v2_rust-noisy_float+approx-devel.sha256sum] = "87e78e2375da9d78d41cfe6cedc8ecdad2355fcc2ed481519cec4f12ad4adcda"

URI_x86_64_v2_rust-noisy_float+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-noisy_float+default-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-noisy_float+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-noisy_float+default-devel}"
SRC_URI[x86_64_v2_rust-noisy_float+default-devel.sha256sum] = "0d6c571d849a17bfe42babbf26eb52a49743f790738f89299bd6796acc04803c"

URI_x86_64_v2_rust-noisy_float+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-noisy_float+serde-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-noisy_float+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-noisy_float+serde-devel}"
SRC_URI[x86_64_v2_rust-noisy_float+serde-devel.sha256sum] = "fadda6416f336aafcba24f464f8e50110bb03acee1ef17763daaae962c21f8f6"

URI_x86_64_v2_rust-noisy_float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-noisy_float-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-noisy_float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-noisy_float-devel}"
SRC_URI[x86_64_v2_rust-noisy_float-devel.sha256sum] = "70df2132e68594144ef5805c6b959286711d3bedae80aba3c4c274d906d2600d"

URI_aarch64_rust-noisy_float+approx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-noisy_float+approx-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-noisy_float+approx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-noisy_float+approx-devel}"
SRC_URI[aarch64_rust-noisy_float+approx-devel.sha256sum] = "0ae4fab1801507b0ee94309905178a9fea6a2386018957d298593436bd9a2283"

URI_aarch64_rust-noisy_float+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-noisy_float+default-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-noisy_float+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-noisy_float+default-devel}"
SRC_URI[aarch64_rust-noisy_float+default-devel.sha256sum] = "e13c56aad7505e29070367e333aeda1aec36faa1afcb9a37009a3a4d1aa44f44"

URI_aarch64_rust-noisy_float+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-noisy_float+serde-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-noisy_float+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-noisy_float+serde-devel}"
SRC_URI[aarch64_rust-noisy_float+serde-devel.sha256sum] = "f38a1174c72ffef02b53244752dc8d8a4a4e4a5a7f84049ffe640d47935dd87d"

URI_aarch64_rust-noisy_float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-noisy_float-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-noisy_float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-noisy_float-devel}"
SRC_URI[aarch64_rust-noisy_float-devel.sha256sum] = "2373a5676910759eb3fb411cad981284ee9169bb73d58c9922f2c3cfa41c3a6e"

RDEPENDS:rust-noisy_float+approx-devel = " \
 cargo \
 rust-approx+default-devel \
 rust-noisy_float-devel \
 "
RDEPENDS:rust-noisy_float+default-devel = " \
 cargo \
 rust-noisy_float-devel \
 "
RDEPENDS:rust-noisy_float+serde-devel = " \
 cargo \
 rust-noisy_float-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-noisy_float-devel = " \
 cargo \
 rust-num-traits+default-devel \
 "
