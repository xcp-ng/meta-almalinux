# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-css"
PV = "0.25.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-css+default-devel \
 rust-tree-sitter-css-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-css-0.25.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d2792908ffef17ba9b315c0b1cbfbc52b28c9a6adc284380f2b94b049b660aa2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-css+default-devel-0.25.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-css+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-css+default-devel.sha256sum] = "5f480567b34fa9f0d68e7bad70922e4347ac6c69bcf52dfd38a56dc941fa870e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-css-devel-0.25.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-css-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tree-sitter-css-devel.sha256sum] = "31dfe3d41ccf4b71b71ba1df944e5d370b785e5d36b54262949de11550d648dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-css+default-devel-0.25.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-css+default-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-css+default-devel.sha256sum] = "1073e5e5257cd903eb4079777c6f6191056f7d4a43b768efb46268f4d97b0ebe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-css-devel-0.25.0-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-css-devel;unpack=0"
SRC_URI[aarch64_rust-tree-sitter-css-devel.sha256sum] = "4bdf76e94c09677e3c9f7925dc8552701f1ce6c8648831ff50eaa78c33a524e9"

RDEPENDS:rust-tree-sitter-css+default-devel = " \
 cargo \
 rust-tree-sitter-css-devel \
 "
RDEPENDS:rust-tree-sitter-css-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
