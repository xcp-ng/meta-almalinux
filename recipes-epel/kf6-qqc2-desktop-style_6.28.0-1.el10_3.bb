# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-qqc2-desktop-style"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-qqc2-desktop-style \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-qqc2-desktop-style-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b6eb78df0ac6a852f9c280971ecb09b69e3ba7e2391defd92fc53d3878e7f76"

URI_x86_64_v2_kf6-qqc2-desktop-style = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-qqc2-desktop-style-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-qqc2-desktop-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-qqc2-desktop-style}"
SRC_URI[x86_64_v2_kf6-qqc2-desktop-style.sha256sum] = "f2f83928122bf47a5f164a4f438ee0e9efc5410c53bc560be25feebb635dcb61"

URI_aarch64_kf6-qqc2-desktop-style = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-qqc2-desktop-style-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-qqc2-desktop-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-qqc2-desktop-style}"
SRC_URI[aarch64_kf6-qqc2-desktop-style.sha256sum] = "368d0a8d17de0f9020515657a341c141d484a54d3ad719bdb5a85a73857413a9"

RDEPENDS:kf6-qqc2-desktop-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
