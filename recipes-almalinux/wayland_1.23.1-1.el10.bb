# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wayland"
PV = "1.23.1"
PR = "1.el10"
PACKAGES = " \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 wayland-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wayland-1.23.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0d214b367cac6147387c739bc5aa7c75b36dc30e46e2ff7cc86b4783a4763c4"

URI_x86_64_v2_libwayland-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-client-1.23.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-client}"
SRC_URI[x86_64_v2_libwayland-client.sha256sum] = "d1afc3d38420ec46d19fb7471e51b04fd9ff5788adcbd61b20dcd99bdeef587f"

URI_x86_64_v2_libwayland-cursor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-cursor-1.23.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-cursor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-cursor}"
SRC_URI[x86_64_v2_libwayland-cursor.sha256sum] = "a364cfe2bd27e28f2acb38545f3a65ef6304341b295b8a80f38cd910d1b6a818"

URI_x86_64_v2_libwayland-egl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-egl-1.23.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-egl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-egl}"
SRC_URI[x86_64_v2_libwayland-egl.sha256sum] = "e83a7e5e17b6f640ecb78c05437248a0a890c3c3dd574d9987ae8433a611fccd"

URI_x86_64_v2_libwayland-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-server-1.23.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-server}"
SRC_URI[x86_64_v2_libwayland-server.sha256sum] = "1008d48b8baa6901a899f1dbf590e308f14ca3cbabc4f64740a51dd34e362642"

URI_x86_64_v2_wayland-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wayland-devel-1.23.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_wayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wayland-devel}"
SRC_URI[x86_64_v2_wayland-devel.sha256sum] = "4bef587ea412f1b790d938827f726e5006a2f7ba072dcb4dc311f6ed553ae9db"

URI_aarch64_libwayland-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-client-1.23.1-1.el10.aarch64.rpm;name=aarch64_libwayland-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-client}"
SRC_URI[aarch64_libwayland-client.sha256sum] = "b0f0edaa88b3b9f90bf7d7578990794d8a6a0caedec9ef3ac30f2e51f7160151"

URI_aarch64_libwayland-cursor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-cursor-1.23.1-1.el10.aarch64.rpm;name=aarch64_libwayland-cursor;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-cursor}"
SRC_URI[aarch64_libwayland-cursor.sha256sum] = "0978649f38e7fabb9d7fbf925e87242cc284c1d4ab4a5a48e1dca5b220ad7d05"

URI_aarch64_libwayland-egl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-egl-1.23.1-1.el10.aarch64.rpm;name=aarch64_libwayland-egl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-egl}"
SRC_URI[aarch64_libwayland-egl.sha256sum] = "1621ae2c403869301b13d74d51af74a39b2d9c91af6c0750cf83504ddbcdc381"

URI_aarch64_libwayland-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-server-1.23.1-1.el10.aarch64.rpm;name=aarch64_libwayland-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-server}"
SRC_URI[aarch64_libwayland-server.sha256sum] = "078b6481d1d20b996f6e12455fd54b8526d4f35f501a44b8d52c555e7db06894"

URI_aarch64_wayland-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wayland-devel-1.23.1-1.el10.aarch64.rpm;name=aarch64_wayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wayland-devel}"
SRC_URI[aarch64_wayland-devel.sha256sum] = "7053bb24bc076e81e9f66b2136130917f5b8666c6346b999ae21193f5aed9958"

RDEPENDS:libwayland-client = " \
 glibc \
 libffi \
 "
RDEPENDS:libwayland-cursor = " \
 glibc \
 libwayland-client \
 "
RDEPENDS:libwayland-egl = " \
 glibc \
 "
RDEPENDS:libwayland-server = " \
 glibc \
 libffi \
 "
RDEPENDS:wayland-devel = " \
 expat \
 glibc \
 libffi-devel \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libxml2 \
 pkgconf-pkg-config \
 wayland-devel \
 "
