# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awf-gtk2"
PV = "4.2.0"
PR = "1.el10_2"
PACKAGES = " \
 awf-gtk2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awf-gtk2-4.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be80c495b78629d379b06dc848625a9ff0539328291d1ecc9a0954e1448e67ac"

URI_x86_64_v2_awf-gtk2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awf-gtk2-4.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_awf-gtk2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awf-gtk2}"
SRC_URI[x86_64_v2_awf-gtk2.sha256sum] = "596ecf4f174c8764a488c305d14be4ed85087480571b52295526b968cf586b7c"

URI_aarch64_awf-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/a/awf-gtk2-4.2.0-1.el10_2.aarch64.rpm;name=aarch64_awf-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_awf-gtk2}"
SRC_URI[aarch64_awf-gtk2.sha256sum] = "1e1cb9f139c7326fd80c4977bf5592975e7f3d5fad11d1f2c8cb957af514d7a6"

RDEPENDS:awf-gtk2 = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 hicolor-icon-theme \
 libnotify \
 pango \
 "
