# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "msoffcrypto-tool"
PV = "5.4.2"
PR = "1.el10_1"
PACKAGES = " \
 msoffcrypto-tool \
 python3-msoffcrypto \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/msoffcrypto-tool-5.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef6c5b8e7038dad093c43188c19ac83fc6bccbf03e633298a6129959da5e8775"

URI_x86_64_v2_msoffcrypto-tool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/msoffcrypto-tool-5.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_msoffcrypto-tool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msoffcrypto-tool}"
SRC_URI[x86_64_v2_msoffcrypto-tool.sha256sum] = "1d2e5686b7a78d2e625d9e49611514c64a2f5dbad91703cb8c00e5526b10be17"

URI_x86_64_v2_python3-msoffcrypto = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-msoffcrypto-5.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-msoffcrypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-msoffcrypto}"
SRC_URI[x86_64_v2_python3-msoffcrypto.sha256sum] = "4eb79ee2e42f9c67c33c6f673852d261a35f46933cd9c1ef39b331b7b00d02ae"

URI_aarch64_msoffcrypto-tool = "${EPEL_MIRROR}/aarch64/Packages/m/msoffcrypto-tool-5.4.2-1.el10_1.noarch.rpm;name=aarch64_msoffcrypto-tool;unpack=0"
SRC_URI:append = " ${URI_aarch64_msoffcrypto-tool}"
SRC_URI[aarch64_msoffcrypto-tool.sha256sum] = "030aac1d39956a94f49e59da9cb711c4abe379ae7e7c27eef5ea11df8b0861a7"

URI_aarch64_python3-msoffcrypto = "${EPEL_MIRROR}/aarch64/Packages/p/python3-msoffcrypto-5.4.2-1.el10_1.noarch.rpm;name=aarch64_python3-msoffcrypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-msoffcrypto}"
SRC_URI[aarch64_python3-msoffcrypto.sha256sum] = "38188dd9319b115a72e645a918599e3bb047c8c7ce494728dc98b4cd1c1f99ac"

RDEPENDS:msoffcrypto-tool = " \
 python3 \
 python3-msoffcrypto \
 "
RDEPENDS:python3-msoffcrypto = " \
 python3 \
 python3-cryptography \
 python3-olefile \
 "
