# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-el"
PE = "1"
PV = "0.9"
PR = "18.el10"
PACKAGES = " \
 hunspell-el \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-el-0.9-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8114a48e35cf52e84c5064c111eede9ce0a0f5a5f8fc2f6f17fd577a7fef8dde"

URI_x86_64_v2_hunspell-el = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-el-0.9-18.el10.noarch.rpm;name=x86_64_v2_hunspell-el;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-el}"
SRC_URI[x86_64_v2_hunspell-el.sha256sum] = "8c57bba837ef173665238c03c2701cc06ef0616045af160041196e2f1cd75628"

URI_aarch64_hunspell-el = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-el-0.9-18.el10.noarch.rpm;name=aarch64_hunspell-el;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-el}"
SRC_URI[aarch64_hunspell-el.sha256sum] = "8c57bba837ef173665238c03c2701cc06ef0616045af160041196e2f1cd75628"

RDEPENDS:hunspell-el = " \
 hunspell-filesystem \
 "
