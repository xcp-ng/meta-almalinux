# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-core"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-core+alloc-devel \
 rust-futures-core+cfg-target-has-atomic-devel \
 rust-futures-core+default-devel \
 rust-futures-core+portable-atomic-devel \
 rust-futures-core+std-devel \
 rust-futures-core+unstable-devel \
 rust-futures-core-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-futures-core-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "289d787df4443ab9c60f09d3e5ac35611da89e57a57c1cad2e28828e21f5b940"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+alloc-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-core+alloc-devel.sha256sum] = "b8dfd0c508c4e9b33170e146fffc8a8aca18287bccc4c04bf4d7554687413745"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+cfg-target-has-atomic-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-core+cfg-target-has-atomic-devel.sha256sum] = "b0d3982686d9ea5ab01fffac8af4e2f3141c2f7f45328035b387a5822fd4421b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-core+default-devel.sha256sum] = "985158989f0e2ae450653887f7270713aea1fdbbee1e280445483309a62336a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+portable-atomic-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+portable-atomic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-core+portable-atomic-devel.sha256sum] = "043ae89283620c8118299f6bd5902bc4d4613ecedda7abca99e84a7b5dd22238"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+std-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-core+std-devel.sha256sum] = "e4071c2e855f65da6e99850e318b1bcfe7e1a67b1dcc7de6c4aef6abfd9a18af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core+unstable-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core+unstable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-core+unstable-devel.sha256sum] = "a29ac3d0f72cb6cc5a497c6bac1d121da27d0dea2a69224d376e5de79391212f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-core-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-futures-core-devel.sha256sum] = "dedbe7ea447c71e665a18c218134bb30e823a0d7889abfa69db30edbaaa38a05"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+alloc-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-futures-core+alloc-devel.sha256sum] = "ca4a58c2a3675757fea44a23ca4263ee9fe733f7405485d24a77d46cd6a975fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+cfg-target-has-atomic-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+cfg-target-has-atomic-devel;unpack=0"
SRC_URI[aarch64_rust-futures-core+cfg-target-has-atomic-devel.sha256sum] = "3cf67737e5bfc03a2284e3ca094a324582a46ee6db7d8ae17ee03f8888bb7cdc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+default-devel;unpack=0"
SRC_URI[aarch64_rust-futures-core+default-devel.sha256sum] = "9992639881d821cd596801eab3bcb0e291757cebf0255f97364548cf5804e11e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+portable-atomic-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+portable-atomic-devel;unpack=0"
SRC_URI[aarch64_rust-futures-core+portable-atomic-devel.sha256sum] = "c8fd36a76f1e46e0af5be78d2ee04eca5a32f3c2e583da1d808b7d646f231fa7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+std-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+std-devel;unpack=0"
SRC_URI[aarch64_rust-futures-core+std-devel.sha256sum] = "3e824b9f2cbe531370690c6a735125f74973e723451c897d94538f6eac888491"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core+unstable-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core+unstable-devel;unpack=0"
SRC_URI[aarch64_rust-futures-core+unstable-devel.sha256sum] = "c59d01f1a417949f657bb1ffcc7b4449536e2a4a197e2c6e2e8b564e1066f005"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-core-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-futures-core-devel;unpack=0"
SRC_URI[aarch64_rust-futures-core-devel.sha256sum] = "40eda73a6d8699d4a32dba222ec42a93eb2ddda21fbfeb4f86adb0e5c954237d"

RDEPENDS:rust-futures-core+alloc-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+default-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+portable-atomic-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-futures-core+std-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core+unstable-devel = " \
 cargo \
 rust-futures-core-devel \
 "
RDEPENDS:rust-futures-core-devel = " \
 cargo \
 rust \
 "
