# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-ftp-client"
PV = "9.9"
PR = "1.el10_2"
PACKAGES = " \
 globus-ftp-client \
 globus-ftp-client-devel \
 globus-ftp-client-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-ftp-client-9.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58d97f9865f5e6b91bef459b81f8ddda37335cb1d7f48a2edd2c06199d2c3025"

URI_x86_64_v2_globus-ftp-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-client-9.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-ftp-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-client}"
SRC_URI[x86_64_v2_globus-ftp-client.sha256sum] = "39ce5351b953f39e3725048ff1c63622e3791f70c5132aa628450178a1320d9a"

URI_x86_64_v2_globus-ftp-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-client-devel-9.9-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-ftp-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-client-devel}"
SRC_URI[x86_64_v2_globus-ftp-client-devel.sha256sum] = "dfc21c05887517aedaca392212d7ab7cbe642ee468e6c624f28d5cb77955f755"

URI_x86_64_v2_globus-ftp-client-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-ftp-client-doc-9.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-ftp-client-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-ftp-client-doc}"
SRC_URI[x86_64_v2_globus-ftp-client-doc.sha256sum] = "4e061bce09c301e4bfa4f4e7cfe1cf7e172eba63ebe4ef2b6845ba230837c740"

URI_aarch64_globus-ftp-client = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-client-9.9-1.el10_2.aarch64.rpm;name=aarch64_globus-ftp-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-client}"
SRC_URI[aarch64_globus-ftp-client.sha256sum] = "e7f29dae73c35e8ecc08aabbc17599940dcca77afb539f7783b100af8636d9d9"

URI_aarch64_globus-ftp-client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-client-devel-9.9-1.el10_2.aarch64.rpm;name=aarch64_globus-ftp-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-client-devel}"
SRC_URI[aarch64_globus-ftp-client-devel.sha256sum] = "2ed6ce181342cd56a045255f4c2e14f75f7e1c21c1ea42b14e656fcb2c765149"

URI_aarch64_globus-ftp-client-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-ftp-client-doc-9.9-1.el10_2.noarch.rpm;name=aarch64_globus-ftp-client-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-ftp-client-doc}"
SRC_URI[aarch64_globus-ftp-client-doc.sha256sum] = "51b1b9a445f7b046d870933bed4af32c85cf7c2fc00ddbbf80c2be9946c098e3"

RDEPENDS:globus-ftp-client = " \
 bash \
 glibc \
 globus-common \
 globus-ftp-control \
 globus-gsi-callback \
 globus-gsi-credential \
 globus-gsi-sysconfig \
 globus-gssapi-gsi \
 globus-xio \
 globus-xio-popen-driver \
 openssl-libs \
 "
RDEPENDS:globus-ftp-client-devel = " \
 globus-common-devel \
 globus-ftp-client \
 globus-ftp-control-devel \
 globus-gsi-callback-devel \
 globus-gsi-credential-devel \
 globus-gsi-sysconfig-devel \
 globus-gssapi-gsi-devel \
 globus-xio-devel \
 globus-xio-popen-driver-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-ftp-client-doc = " \
 "
