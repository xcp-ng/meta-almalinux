# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-evalidate"
PV = "2.0.5"
PR = "1.el10_1"
PACKAGES = " \
 python3-evalidate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-evalidate-2.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c9b79b757e3d96278bd846bd3ae3896f48d18ef2c92d5f85e4b68438659e5d"

URI_x86_64_v2_python3-evalidate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-evalidate-2.0.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-evalidate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-evalidate}"
SRC_URI[x86_64_v2_python3-evalidate.sha256sum] = "e65b173f1070c33e9feb33f14adb191d7d14cff674a357791133995d6f54d6b1"

URI_aarch64_python3-evalidate = "${EPEL_MIRROR}/aarch64/Packages/p/python3-evalidate-2.0.5-1.el10_1.noarch.rpm;name=aarch64_python3-evalidate;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-evalidate}"
SRC_URI[aarch64_python3-evalidate.sha256sum] = "d561fbeaa6b7c64cc8967a5328bf1ce770123d602dfda1c64584f64d89fd3122"

RDEPENDS:python3-evalidate = " \
 python3 \
 "
