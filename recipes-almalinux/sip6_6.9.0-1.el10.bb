# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sip6"
PV = "6.9.0"
PR = "1.el10"
PACKAGES = " \
 sip6 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sip6-6.9.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "770cb20cbe4c143d82230cfc43fefd9b35c0799748b2dc69e730a5c2403d595d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sip6-6.9.0-1.el10.noarch.rpm;name=x86_64_v2_sip6;unpack=0"
SRC_URI[x86_64_v2_sip6.sha256sum] = "7698bee06f89fe02583730f3b73e493b5acdace8bf3c2ec6257f54bd0578ed6c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sip6-6.9.0-1.el10.noarch.rpm;name=aarch64_sip6;unpack=0"
SRC_URI[aarch64_sip6.sha256sum] = "7698bee06f89fe02583730f3b73e493b5acdace8bf3c2ec6257f54bd0578ed6c"

RDEPENDS:sip6 = " \
 python3 \
 python3-packaging \
 python3-setuptools \
 "
