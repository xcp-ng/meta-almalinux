# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-antihax-optional"
PV = "1.0.0"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-antihax-optional-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-antihax-optional-1.0.0-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d517db644f2af8cb5914dbdc0571e6827b0c06bd9fc46cca752a6bafa06bf8dc"

URI_x86_64_v2_golang-github-antihax-optional-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-antihax-optional-devel-1.0.0-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-antihax-optional-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-antihax-optional-devel}"
SRC_URI[x86_64_v2_golang-github-antihax-optional-devel.sha256sum] = "94dbefb3d5d56fe6ffd1c1075d9e74077a53503e5a23faef34113e6b5d099e81"

URI_aarch64_golang-github-antihax-optional-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-antihax-optional-devel-1.0.0-14.el10_0.noarch.rpm;name=aarch64_golang-github-antihax-optional-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-antihax-optional-devel}"
SRC_URI[aarch64_golang-github-antihax-optional-devel.sha256sum] = "0ec46d43a74c43e5db112dbc9560aec2c436648b6af1da2961babd921d4a25ac"

RDEPENDS:golang-github-antihax-optional-devel = " \
 go-filesystem \
 "
