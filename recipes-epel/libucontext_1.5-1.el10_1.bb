# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libucontext"
PV = "1.5"
PR = "1.el10_1"
PACKAGES = " \
 libucontext \
 libucontext-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libucontext-1.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ef84d32a39723ea5be573b653c9b4ba106f4c73a4ab49d124040a1e3afa2ad8"

URI_x86_64_v2_libucontext = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libucontext-1.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libucontext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libucontext}"
SRC_URI[x86_64_v2_libucontext.sha256sum] = "1eef830355a6fca87f6d176b841b1fca280613ab4a2da489cd08424797b6918a"

URI_x86_64_v2_libucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libucontext-devel-1.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libucontext-devel}"
SRC_URI[x86_64_v2_libucontext-devel.sha256sum] = "598187327d1d65e005ddb2a1f8ec4126b1895aeded94795e2074123856a52fee"

URI_aarch64_libucontext = "${EPEL_MIRROR}/aarch64/Packages/l/libucontext-1.5-1.el10_1.aarch64.rpm;name=aarch64_libucontext;unpack=0"
SRC_URI:append = " ${URI_aarch64_libucontext}"
SRC_URI[aarch64_libucontext.sha256sum] = "f5ffe2041f848310aef9c272a3151473790a86c7e4119e8c34b2ed0540b69d86"

URI_aarch64_libucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libucontext-devel-1.5-1.el10_1.aarch64.rpm;name=aarch64_libucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libucontext-devel}"
SRC_URI[aarch64_libucontext-devel.sha256sum] = "c5f0a786fc016fa8b65cec8356d1ad63fe140940c7ebf65b73a9c447803879fd"

RDEPENDS:libucontext = " \
 glibc \
 "
RDEPENDS:libucontext-devel = " \
 libucontext \
 pkgconf-pkg-config \
 "
