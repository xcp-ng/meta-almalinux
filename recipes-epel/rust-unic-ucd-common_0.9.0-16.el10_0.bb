# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-ucd-common"
PV = "0.9.0"
PR = "16.el10_0"
PACKAGES = " \
 rust-unic-ucd-common+default-devel \
 rust-unic-ucd-common-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-ucd-common-0.9.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ddaa98ccbe2cc0b55419722112a80edb5d39823caadad9be9cc05f9271cf257"

URI_x86_64_v2_rust-unic-ucd-common+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-common+default-devel-0.9.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-common+default-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-common+default-devel.sha256sum] = "6dc9741a98fd7f9aa6a64583d46293d43ea238a0139f1465c83b0be2f64b4d22"

URI_x86_64_v2_rust-unic-ucd-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-ucd-common-devel-0.9.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-ucd-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-ucd-common-devel}"
SRC_URI[x86_64_v2_rust-unic-ucd-common-devel.sha256sum] = "cc37003bb2af505ddfb50379ae67d00e034d4c2abba274d1d72c63cde8a3537e"

URI_aarch64_rust-unic-ucd-common+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-common+default-devel-0.9.0-16.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-common+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-common+default-devel}"
SRC_URI[aarch64_rust-unic-ucd-common+default-devel.sha256sum] = "a0f7c20c9e084b4c7d519ffcb9d852bee920252997e2622085b45aec8bf4ec40"

URI_aarch64_rust-unic-ucd-common-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-ucd-common-devel-0.9.0-16.el10_0.noarch.rpm;name=aarch64_rust-unic-ucd-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-ucd-common-devel}"
SRC_URI[aarch64_rust-unic-ucd-common-devel.sha256sum] = "df3884799a4baf96d3ffb1408363809152f74c3e524b9dbf8ba1897185594454"

RDEPENDS:rust-unic-ucd-common+default-devel = " \
 cargo \
 rust-unic-ucd-common-devel \
 "
RDEPENDS:rust-unic-ucd-common-devel = " \
 cargo \
 rust-unic-char-property+default-devel \
 rust-unic-char-range+default-devel \
 rust-unic-ucd-version+default-devel \
 "
