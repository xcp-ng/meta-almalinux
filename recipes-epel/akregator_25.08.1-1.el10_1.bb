# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akregator"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 akregator \
 akregator-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akregator-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6710a8e01bc112f96a0d6d96b4881019f086919bfb7b1fed664795cd6e10c66c"

URI_x86_64_v2_akregator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akregator}"
SRC_URI[x86_64_v2_akregator.sha256sum] = "1f09f510c08214fe19a68e03fbdef10f327e873768febcc7024984900ac2dc66"

URI_x86_64_v2_akregator-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-libs-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akregator-libs}"
SRC_URI[x86_64_v2_akregator-libs.sha256sum] = "be3fb4d1d0fd5ae553de692bb4aca9ba673aa9cabc9aabfe77b87b467efe57d9"

URI_aarch64_akregator = "${EPEL_MIRROR}/aarch64/Packages/a/akregator-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akregator;unpack=0"
SRC_URI:append = " ${URI_aarch64_akregator}"
SRC_URI[aarch64_akregator.sha256sum] = "b6362e3fd10ec437a6d3f9467e4936b92d5d9a8226d3abaf5f505eba176e661a"

URI_aarch64_akregator-libs = "${EPEL_MIRROR}/aarch64/Packages/a/akregator-libs-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akregator-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_akregator-libs}"
SRC_URI[aarch64_akregator-libs.sha256sum] = "bfaada97ff1c20de43ef9e97a0e10053cd684546b5b3700dd394b7ddccb0ab2d"

RDEPENDS:akregator = " \
 akregator-libs \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akregator-libs = " \
 akregator \
 glibc \
 grantleetheme \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktexttemplate \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
