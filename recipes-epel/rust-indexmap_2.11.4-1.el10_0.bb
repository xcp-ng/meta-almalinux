# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indexmap"
PV = "2.11.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-indexmap+arbitrary-devel \
 rust-indexmap+default-devel \
 rust-indexmap+quickcheck-devel \
 rust-indexmap+rayon-devel \
 rust-indexmap+serde-devel \
 rust-indexmap+std-devel \
 rust-indexmap+test_debug-devel \
 rust-indexmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indexmap-2.11.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "79a55e4f0d4c66a74188007ba1b15d33def52b921211885f381928ad1efd121f"

URI_x86_64_v2_rust-indexmap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+arbitrary-devel-2.11.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-indexmap+arbitrary-devel.sha256sum] = "daf4f63b3d16fc54f051443f9f132fe7cb2ab0da4af35eea4c0820fac358ef54"

URI_x86_64_v2_rust-indexmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+default-devel-2.11.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+default-devel}"
SRC_URI[x86_64_v2_rust-indexmap+default-devel.sha256sum] = "30e954d8defae3fdd147509cdb1e0fc076b7821a365ea6d23f66cf71c3e88da5"
RPROVIDES:rust-indexmap+default-devel:x86_64_v2 = "virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_x86_64_v2_rust-indexmap+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+quickcheck-devel-2.11.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-indexmap+quickcheck-devel.sha256sum] = "0f276a202b60e6b8ba5d9960112edd666184a73a61a58113c0a46b3812b67c7b"

URI_x86_64_v2_rust-indexmap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+rayon-devel-2.11.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+rayon-devel}"
SRC_URI[x86_64_v2_rust-indexmap+rayon-devel.sha256sum] = "eb91963f059b14fdd6e28fdeadd27a9d4f1cc4f466a60c34703fee15b2b63d35"

URI_x86_64_v2_rust-indexmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+serde-devel-2.11.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+serde-devel}"
SRC_URI[x86_64_v2_rust-indexmap+serde-devel.sha256sum] = "e8d047653faa727684a68283dade8b56f246d0cb760c19d7ebf4a2fc90d72ff4"

URI_x86_64_v2_rust-indexmap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+std-devel-2.11.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+std-devel}"
SRC_URI[x86_64_v2_rust-indexmap+std-devel.sha256sum] = "13cb00578891b17b0e96746d6f1d4926d00a78e466f53cef4bef78a0b38188c1"

URI_x86_64_v2_rust-indexmap+test_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+test_debug-devel-2.11.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+test_debug-devel}"
SRC_URI[x86_64_v2_rust-indexmap+test_debug-devel.sha256sum] = "a9b70368aa69f220c3a54cf3111ec9667739a2ef4b4922a743289ffa27721d41"

URI_x86_64_v2_rust-indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap-devel-2.11.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap-devel}"
SRC_URI[x86_64_v2_rust-indexmap-devel.sha256sum] = "17873bd6b24c8281b7895e05ed6f4c23e39b94a76415d5321056ec821a0c8f78"

URI_aarch64_rust-indexmap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+arbitrary-devel-2.11.4-1.el10_0.noarch.rpm;name=aarch64_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+arbitrary-devel}"
SRC_URI[aarch64_rust-indexmap+arbitrary-devel.sha256sum] = "45f728cb22d1a43577a9b965c7e4dd1f28d839dbf9743d98d2d391d9ea1e24b6"

URI_aarch64_rust-indexmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+default-devel-2.11.4-1.el10_0.noarch.rpm;name=aarch64_rust-indexmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+default-devel}"
SRC_URI[aarch64_rust-indexmap+default-devel.sha256sum] = "986c7b495ae8454ae0f73512c081a3c8d28cb4771d302bd6c0a4421c14ef8fd3"
RPROVIDES:rust-indexmap+default-devel:aarch64 = "virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_aarch64_rust-indexmap+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+quickcheck-devel-2.11.4-1.el10_0.noarch.rpm;name=aarch64_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+quickcheck-devel}"
SRC_URI[aarch64_rust-indexmap+quickcheck-devel.sha256sum] = "243c772558aee9f13a44b7c09772dd11e603a9ef89ffc8f1d51e23a77ace4d15"

URI_aarch64_rust-indexmap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+rayon-devel-2.11.4-1.el10_0.noarch.rpm;name=aarch64_rust-indexmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+rayon-devel}"
SRC_URI[aarch64_rust-indexmap+rayon-devel.sha256sum] = "727833c9fdd1122da70f432f67f06acc1c434cc8af2e5b5bdc9506cd30cfff3c"

URI_aarch64_rust-indexmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+serde-devel-2.11.4-1.el10_0.noarch.rpm;name=aarch64_rust-indexmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+serde-devel}"
SRC_URI[aarch64_rust-indexmap+serde-devel.sha256sum] = "883922ead1af6e144401fc9dbfc28cff8a4ad5733ca6a865b8f0a653339cecd0"

URI_aarch64_rust-indexmap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+std-devel-2.11.4-1.el10_0.noarch.rpm;name=aarch64_rust-indexmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+std-devel}"
SRC_URI[aarch64_rust-indexmap+std-devel.sha256sum] = "ac518b627cb41059b298cf07aebf1030cb79e260bb90bf14a67c70b822bad370"

URI_aarch64_rust-indexmap+test_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+test_debug-devel-2.11.4-1.el10_0.noarch.rpm;name=aarch64_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+test_debug-devel}"
SRC_URI[aarch64_rust-indexmap+test_debug-devel.sha256sum] = "b5295e6e1f196652b7c06d38a5f4ec25dd1f32f7af99ec17bd4a532c123e1dca"

URI_aarch64_rust-indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap-devel-2.11.4-1.el10_0.noarch.rpm;name=aarch64_rust-indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap-devel}"
SRC_URI[aarch64_rust-indexmap-devel.sha256sum] = "d00bba01e678f5187a523f7ddd7d67873651d1a0a921f29d424beccc79374fd7"

RDEPENDS:rust-indexmap+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+default-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+quickcheck-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-indexmap+rayon-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indexmap+serde-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-indexmap+std-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+test_debug-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap-devel = " \
 cargo \
 rust \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"
