# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_cmd"
PV = "2.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-assert_cmd+color-auto-devel \
 rust-assert_cmd+color-devel \
 rust-assert_cmd+default-devel \
 rust-assert_cmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_cmd-2.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c31cf44d2b113c092b6d2da53ff277365dfe36a968cfc5c9744bf2679d13dba2"

URI_x86_64_v2_rust-assert_cmd+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+color-auto-devel-2.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+color-auto-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+color-auto-devel.sha256sum] = "c320e882ef24b8d3c6bf869d9212960ed8a77355459f25411526ef9841b46238"

URI_x86_64_v2_rust-assert_cmd+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+color-devel-2.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+color-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+color-devel.sha256sum] = "38d22bb90b241cef602d556fef9b8a3cd1435d512d5125b64cf7cdb6b38c1735"

URI_x86_64_v2_rust-assert_cmd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd+default-devel-2.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd+default-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd+default-devel.sha256sum] = "612ef973ff2cd56141811b6be0eafd423b77e29fc1b05161f124493cf2518a91"

URI_x86_64_v2_rust-assert_cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_cmd-devel-2.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_cmd-devel}"
SRC_URI[x86_64_v2_rust-assert_cmd-devel.sha256sum] = "652f49977ea6b7556a2063510bcf078cf78f88d8f505f6193c503ec839fe5e2d"

URI_aarch64_rust-assert_cmd+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+color-auto-devel-2.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-assert_cmd+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+color-auto-devel}"
SRC_URI[aarch64_rust-assert_cmd+color-auto-devel.sha256sum] = "d13d53e7989d9699ab159e45bf832657bd5139a123bc774dcb5b2ec66be55f63"

URI_aarch64_rust-assert_cmd+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+color-devel-2.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-assert_cmd+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+color-devel}"
SRC_URI[aarch64_rust-assert_cmd+color-devel.sha256sum] = "655781e4f22e5fe113c61a57c4387afa2f765c5dc43640012f5ee5c779d49e8c"

URI_aarch64_rust-assert_cmd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd+default-devel-2.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-assert_cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd+default-devel}"
SRC_URI[aarch64_rust-assert_cmd+default-devel.sha256sum] = "9225800aeb2c464e34be7f5300887b9f71079eb5e554a30e8f0b946ccea630e9"

URI_aarch64_rust-assert_cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_cmd-devel-2.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-assert_cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_cmd-devel}"
SRC_URI[aarch64_rust-assert_cmd-devel.sha256sum] = "2ea25812314e69493b3082d867cae1ddf62245e0f8df314411f93972e00a026e"

RDEPENDS:rust-assert_cmd+color-auto-devel = " \
 cargo \
 rust-assert_cmd+color-devel \
 rust-assert_cmd-devel \
 "
RDEPENDS:rust-assert_cmd+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-assert_cmd-devel \
 rust-predicates+color-devel \
 "
RDEPENDS:rust-assert_cmd+default-devel = " \
 cargo \
 rust-assert_cmd-devel \
 "
RDEPENDS:rust-assert_cmd-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-bstr+default-devel \
 rust-libc+default-devel \
 rust-predicates+diff-devel \
 rust-predicates-core+default-devel \
 rust-predicates-devel \
 rust-predicates-tree+default-devel \
 rust-wait-timeout+default-devel \
 "
