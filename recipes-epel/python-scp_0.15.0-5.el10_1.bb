# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-scp"
PV = "0.15.0"
PR = "5.el10_1"
PACKAGES = " \
 python3-scp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-scp-0.15.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a2788ace06bb5bc7740aa2cac2353fe750ab4a99b9cff6087e3044ffe499ac8"

URI_x86_64_v2_python3-scp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-scp-0.15.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-scp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-scp}"
SRC_URI[x86_64_v2_python3-scp.sha256sum] = "597bfe5d18b69ba85f39345257bfde8713d2247331fe5afe21603333bce03522"

URI_aarch64_python3-scp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-scp-0.15.0-5.el10_1.noarch.rpm;name=aarch64_python3-scp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-scp}"
SRC_URI[aarch64_python3-scp.sha256sum] = "15e3952114d417b879f75f9ab36161051b9c355a9db9926775120a0456a93392"

RDEPENDS:python3-scp = " \
 python3 \
 python3-paramiko \
 "
