# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "artikulate"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 artikulate \
 artikulate-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/artikulate-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77931da037996d801dff1c88ad5d8c92a9aa766688b872d53e18a0a59f3f098f"

URI_x86_64_v2_artikulate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artikulate-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_artikulate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artikulate}"
SRC_URI[x86_64_v2_artikulate.sha256sum] = "6e6d1ec2e592bdbd2ba3a672a270a92115f989c9179794bdd98913208f6d836f"

URI_x86_64_v2_artikulate-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artikulate-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_artikulate-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artikulate-libs}"
SRC_URI[x86_64_v2_artikulate-libs.sha256sum] = "6ab14777a046bd290d861438d9e5dcab3480718fb9a3cec004d9e2b04b980266"

URI_aarch64_artikulate = "${EPEL_MIRROR}/aarch64/Packages/a/artikulate-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_artikulate;unpack=0"
SRC_URI:append = " ${URI_aarch64_artikulate}"
SRC_URI[aarch64_artikulate.sha256sum] = "9033afab6d04e8694af8a57f02125d6132cd4b2462e6746366067dc9a4a2fdb4"

URI_aarch64_artikulate-libs = "${EPEL_MIRROR}/aarch64/Packages/a/artikulate-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_artikulate-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_artikulate-libs}"
SRC_URI[aarch64_artikulate-libs.sha256sum] = "500118592677b28cf14a82f64ea3ac86fddaedfb144a4063ba309e256ce34c30"

RDEPENDS:artikulate = " \
 artikulate-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemmodels \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:artikulate-libs = " \
 artikulate \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-ki18n \
 libstdc++ \
 libxml2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
