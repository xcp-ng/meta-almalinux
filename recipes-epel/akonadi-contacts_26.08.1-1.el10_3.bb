# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-contacts"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-contacts \
 akonadi-contacts-devel \
 akonadi-contacts-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akonadi-contacts-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9e196ebe256dce1ae7a1fa6913794b97c59c88e4133b5ffa1cb540478b86e6e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts;unpack=0"
SRC_URI[x86_64_v2_akonadi-contacts.sha256sum] = "cbfb8d08f00c18b7ab07048ca578c1a7127cd5cda3751cde7e948a840395ab80"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts-devel;unpack=0"
SRC_URI[x86_64_v2_akonadi-contacts-devel.sha256sum] = "3b900be7fd910a90d768868ae8fe31db393c8d374e5f0d990d9452b1f3cbef85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-contacts-doc;unpack=0"
SRC_URI[x86_64_v2_akonadi-contacts-doc.sha256sum] = "8baccc313d26618bd137371539029d61e494a5028be0f6ac85419b2721ea95d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadi-contacts;unpack=0"
SRC_URI[aarch64_akonadi-contacts.sha256sum] = "999fd70a3271127c911af4441a6d21eb1e493e25d63f9e58f71dba99d3e97194"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akonadi-contacts-devel;unpack=0"
SRC_URI[aarch64_akonadi-contacts-devel.sha256sum] = "a6b4f40d32b5a5986380a63ece96abf5b3487063bfe781672ec11ed93f14276f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_akonadi-contacts-doc;unpack=0"
SRC_URI[aarch64_akonadi-contacts-doc.sha256sum] = "4f72f7fcf4d45408a0dd338978606e94da5251578e2e3eec001b28b2a0ad09c0"

RDEPENDS:akonadi-contacts = " \
 akonadi-server \
 glibc \
 grantleetheme \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kmime \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-prison \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-contacts-devel = " \
 akonadi-contacts \
 akonadi-server-devel \
 cmake-filesystem \
 grantleetheme-devel \
 kf6-kcontacts-devel \
 "
RDEPENDS:akonadi-contacts-doc = " \
 "
