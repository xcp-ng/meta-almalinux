# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kplotting"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kplotting \
 kf6-kplotting-devel \
 kf6-kplotting-doc \
 kf6-kplotting-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kplotting-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6424378d54e4f3d9a6679b46de45038d6d78c55f289bc467aff158ea2e2c98c7"

URI_x86_64_v2_kf6-kplotting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting}"
SRC_URI[x86_64_v2_kf6-kplotting.sha256sum] = "a53b97c2c96df1c81a34f63bf7666c99b3932e783f08a1617d978f45d19fd4de"

URI_x86_64_v2_kf6-kplotting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kplotting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-devel}"
SRC_URI[x86_64_v2_kf6-kplotting-devel.sha256sum] = "bb6e3c6dd20f1175200a00b035b7f941d0473bb787c454191d9bf0556050ae5c"

URI_x86_64_v2_kf6-kplotting-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kplotting-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-doc}"
SRC_URI[x86_64_v2_kf6-kplotting-doc.sha256sum] = "a18afe3a43ea1c39b7b7b1dc45b5941e92e2815523d4c375743f67ccca93fa9a"

URI_x86_64_v2_kf6-kplotting-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kplotting-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kplotting-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kplotting-html}"
SRC_URI[x86_64_v2_kf6-kplotting-html.sha256sum] = "f734117b54211533fcfce36fd5a4db4b68bed50322e946955ce8acfd34186567"

URI_aarch64_kf6-kplotting = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kplotting;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting}"
SRC_URI[aarch64_kf6-kplotting.sha256sum] = "1cf1ce77227df353789a913e77ae2c4d6f11a0153602b22de8e249dc3ce5f8dd"

URI_aarch64_kf6-kplotting-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kplotting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-devel}"
SRC_URI[aarch64_kf6-kplotting-devel.sha256sum] = "d3e8189189a29db7effe0ac9591333032c44882a734898bdc72464441a4cb232"

URI_aarch64_kf6-kplotting-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kplotting-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-doc}"
SRC_URI[aarch64_kf6-kplotting-doc.sha256sum] = "3464a6cb3efa17820249a1b1b779d44d94c22448cf57346f165a2eb07c761a23"

URI_aarch64_kf6-kplotting-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kplotting-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kplotting-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kplotting-html}"
SRC_URI[aarch64_kf6-kplotting-html.sha256sum] = "63b6d225238d3677c7285e57b144193c7384f81e57f3074fff21b02153ff7b42"

RDEPENDS:kf6-kplotting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kplotting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kplotting-doc = " \
 "
RDEPENDS:kf6-kplotting-html = " \
 "
