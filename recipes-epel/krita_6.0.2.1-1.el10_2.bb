# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krita"
PV = "6.0.2.1"
PR = "1.el10_2"
PACKAGES = " \
 krita \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/krita-6.0.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b31b3b0b9bdba55089617d618f205f2d762a8b3e5bd614ffad1e9b2315aed74"

URI_x86_64_v2_krita = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/krita-6.0.2.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_krita;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krita}"
SRC_URI[x86_64_v2_krita.sha256sum] = "7e24f62d7e616fcd4ceb70bc3a0fff81b7114c3f3b2892fe94b401027dab490d"

URI_aarch64_krita = "${EPEL_MIRROR}/aarch64/Packages/k/krita-6.0.2.1-1.el10_2.aarch64.rpm;name=aarch64_krita;unpack=0"
SRC_URI:append = " ${URI_aarch64_krita}"
SRC_URI[aarch64_krita.sha256sum] = "2ba31836282dc79f8a1678365a74f87cf09ebf72350ccb1aa87a0c054862e58f"

RDEPENDS:krita = " \
 OpenColorIO \
 exiv2-libs \
 fftw-libs-double \
 fontconfig \
 freetype \
 fribidi \
 giflib \
 glibc \
 gsl \
 harfbuzz \
 hicolor-icon-theme \
 imath \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kseexpr \
 lcms2 \
 libX11 \
 libgcc \
 libgomp \
 libheif \
 libjpeg-turbo \
 libjxl \
 libkdcraw \
 libmypaint \
 libpng \
 libstdc++ \
 libtiff \
 libunibreak \
 libwayland-client \
 libwebp \
 libxkbcommon \
 mlt \
 openexr-libs \
 openjpeg2 \
 poppler-qt6 \
 python3-libs \
 python3-pyqt6-base \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 quazip-qt6 \
 turbojpeg \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
