# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signon-ui"
PV = "0.15^20240205.eef943f"
PR = "2.el10_0"
PACKAGES = " \
 signon-ui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signon-ui-0.15^20240205.eef943f-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56ccd8544143c603019ce33519a382a01a20955c6a4faae7e8c98a0a2bbb9bb2"

URI_x86_64_v2_signon-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-ui-0.15^20240205.eef943f-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-ui}"
SRC_URI[x86_64_v2_signon-ui.sha256sum] = "7d0d0b5f1675322e545710ca7c65352c025bb544dcd661694ee0a202d2e522fc"

URI_aarch64_signon-ui = "${EPEL_MIRROR}/aarch64/Packages/s/signon-ui-0.15^20240205.eef943f-2.el10_0.aarch64.rpm;name=aarch64_signon-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-ui}"
SRC_URI[aarch64_signon-ui.sha256sum] = "964e02769a98a046c4a2cbb6bb63ae06d7be768a33918baf8f2673b2d47108b0"

RDEPENDS:signon-ui = " \
 dbus \
 glib2 \
 glibc \
 libaccounts-qt6 \
 libgcc \
 libnotify \
 libproxy \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 signon-qt6 \
 "
