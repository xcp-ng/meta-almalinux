# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-difftastic"
PV = "0.63.0"
PR = "4.el10_1"
PACKAGES = " \
 difftastic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-difftastic-0.63.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8be065dd29ca353df63217afd9a53648d9c56a9f52312e8d3266dffa85cea7e7"

URI_x86_64_v2_difftastic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/difftastic-0.63.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_difftastic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_difftastic}"
SRC_URI[x86_64_v2_difftastic.sha256sum] = "60244b5c0fd1d192b77da71820a296a9116ce3a2050ab29e786dc0ffa7778229"

URI_aarch64_difftastic = "${EPEL_MIRROR}/aarch64/Packages/d/difftastic-0.63.0-4.el10_1.aarch64.rpm;name=aarch64_difftastic;unpack=0"
SRC_URI:append = " ${URI_aarch64_difftastic}"
SRC_URI[aarch64_difftastic.sha256sum] = "d78064ea8492b591e07ffc503d85309b6411681f72013ff88f21df02a27727ee"

RDEPENDS:difftastic = " \
 glibc \
 libgcc \
 libstdc++ \
 "
