# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "trace-cmd"
PV = "3.3.1"
PR = "2.el10"
PACKAGES = " \
 trace-cmd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/trace-cmd-3.3.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cb239cc7368bbdc7138b6dcdfd6a9beacb85498ac17d2d0bcb09835717802c4"

URI_x86_64_v2_trace-cmd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/trace-cmd-3.3.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_trace-cmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_trace-cmd}"
SRC_URI[x86_64_v2_trace-cmd.sha256sum] = "66dca80b1edccb4d895e555d684f5baf2b30baf023292ea843da47525ed31db6"

URI_aarch64_trace-cmd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/trace-cmd-3.3.1-2.el10.aarch64.rpm;name=aarch64_trace-cmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_trace-cmd}"
SRC_URI[aarch64_trace-cmd.sha256sum] = "08a20d5fb4d71f0bc0273ea5fb12c808d138c4766e7e1fabf9e92fb3934c28de"

RDEPENDS:trace-cmd = " \
 audit-libs \
 bash \
 glibc \
 libtraceevent \
 libtracefs \
 libzstd \
 "
