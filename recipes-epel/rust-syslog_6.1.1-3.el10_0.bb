# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syslog"
PV = "6.1.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-syslog+default-devel \
 rust-syslog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syslog-6.1.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e58ba0519981c346ab21b6caa7f21b3b3f09558cc9c13f92afaa61f728736124"

URI_x86_64_v2_rust-syslog+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syslog+default-devel-6.1.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syslog+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syslog+default-devel}"
SRC_URI[x86_64_v2_rust-syslog+default-devel.sha256sum] = "ddb83042f3cac67105a862ae9ab3a40596cc3bec1d63e613e193bf8368b30b25"

URI_x86_64_v2_rust-syslog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syslog-devel-6.1.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syslog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syslog-devel}"
SRC_URI[x86_64_v2_rust-syslog-devel.sha256sum] = "c0a21069e7dda0f2855fd6125675e0df2488ddabf2a33c055d3c268da1a18f60"

URI_aarch64_rust-syslog+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syslog+default-devel-6.1.1-3.el10_0.noarch.rpm;name=aarch64_rust-syslog+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syslog+default-devel}"
SRC_URI[aarch64_rust-syslog+default-devel.sha256sum] = "1055383ddbc4f25ae4416bc49fdd1d6b2d8a70b27d247f99867b91e4753b23ae"

URI_aarch64_rust-syslog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syslog-devel-6.1.1-3.el10_0.noarch.rpm;name=aarch64_rust-syslog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syslog-devel}"
SRC_URI[aarch64_rust-syslog-devel.sha256sum] = "d8a46d43f618ed87da58c49002ded69f0a1b8b82fa52725b3327a7a03e247c55"

RDEPENDS:rust-syslog+default-devel = " \
 cargo \
 rust-syslog-devel \
 "
RDEPENDS:rust-syslog-devel = " \
 cargo \
 rust-error-chain-devel \
 rust-hostname+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 "
