# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duktape"
PV = "2.7.0"
PR = "10.el10"
PACKAGES = " \
 duktape \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/duktape-2.7.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f3071b657c96a4f7a26a74c567c534cf2f8e7049312e980324bacd5a2809016d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/duktape-2.7.0-10.el10.x86_64_v2.rpm;name=x86_64_v2_duktape;unpack=0"
SRC_URI[x86_64_v2_duktape.sha256sum] = "da3353ab0298b8758da0e7bf30a53243a79e203f5df9168cc51abfde7d6b5ee8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/duktape-2.7.0-10.el10.aarch64.rpm;name=aarch64_duktape;unpack=0"
SRC_URI[aarch64_duktape.sha256sum] = "e46a7493b1e37c24bc8f7ef7fecbcb28396e741997b838ee99da5eb701902db8"

RDEPENDS:duktape = " \
 glibc \
 "
