# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdp-tools"
PV = "1.5.5"
PR = "1.el10_0"
PACKAGES = " \
 libxdp \
 libxdp-devel \
 libxdp-static \
 xdp-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdp-tools-1.5.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4824270a0cfa93ea635cd7aeafb32600b19fa6dd4d8cd915ac292f91a39d8691"

URI_x86_64_v2_libxdp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxdp-1.5.5-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libxdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdp}"
SRC_URI[x86_64_v2_libxdp.sha256sum] = "16dc74dbf2dd954359042137a6ba55cbf8bffd708ed1df4b8d676eaadbf3ddc9"

URI_x86_64_v2_libxdp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxdp-devel-1.5.5-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libxdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdp-devel}"
SRC_URI[x86_64_v2_libxdp-devel.sha256sum] = "eb834bff460fcc507acf647edfa5a9c84f829711096d61cae2c4b93fa5a66165"

URI_x86_64_v2_libxdp-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxdp-static-1.5.5-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_libxdp-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdp-static}"
SRC_URI[x86_64_v2_libxdp-static.sha256sum] = "fee057f38938cb22f3181c7d80d888aa29a2d38ad456fd58c96f313773741239"

URI_x86_64_v2_xdp-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdp-tools-1.5.5-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_xdp-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdp-tools}"
SRC_URI[x86_64_v2_xdp-tools.sha256sum] = "9476de1ec42dc6c3ca62ceb2c41565bb522ffd3fbbfe28154c96a14c64652115"

URI_aarch64_libxdp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxdp-1.5.5-1.el10_0.aarch64.rpm;name=aarch64_libxdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdp}"
SRC_URI[aarch64_libxdp.sha256sum] = "a1dd25cefce94c004e7838588071d848707002b399d32ea94a7f5df0ba21827b"

URI_aarch64_libxdp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxdp-devel-1.5.5-1.el10_0.aarch64.rpm;name=aarch64_libxdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdp-devel}"
SRC_URI[aarch64_libxdp-devel.sha256sum] = "f179d4c81ba677d93eb5845b0db782ff52af86e0701395c15cc7be7e06d50bd7"

URI_aarch64_libxdp-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxdp-static-1.5.5-1.el10_0.aarch64.rpm;name=aarch64_libxdp-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdp-static}"
SRC_URI[aarch64_libxdp-static.sha256sum] = "0f75a46b72f78624e2805f519910f31f8c0a81bbbed69ab2334d1b712d819f35"

URI_aarch64_xdp-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdp-tools-1.5.5-1.el10_0.aarch64.rpm;name=aarch64_xdp-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdp-tools}"
SRC_URI[aarch64_xdp-tools.sha256sum] = "cc1d35a2db7f67c9f6b6db98a6e7f7e617b94288cf8f3d1aa583042e534ca220"

RDEPENDS:libxdp = " \
 glibc \
 libbpf \
 "
RDEPENDS:libxdp-devel = " \
 kernel-headers \
 libbpf-devel \
 libxdp \
 pkgconf-pkg-config \
 "
RDEPENDS:libxdp-static = " \
 libxdp-devel \
 "
RDEPENDS:xdp-tools = " \
 bash \
 glibc \
 libbpf \
 libpcap \
 libxdp \
 "
