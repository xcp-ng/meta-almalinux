# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dunce"
PV = "1.0.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-dunce+default-devel \
 rust-dunce-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dunce-1.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ba109222d34a298f799ab49f0f218ef64dce48e915760e8c11286df07cc7025"

URI_x86_64_v2_rust-dunce+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dunce+default-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dunce+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dunce+default-devel}"
SRC_URI[x86_64_v2_rust-dunce+default-devel.sha256sum] = "1cd036b399baa276b3773d9b71a6fe43873875439cfa781d1d4c6df054e72134"

URI_x86_64_v2_rust-dunce-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dunce-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dunce-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dunce-devel}"
SRC_URI[x86_64_v2_rust-dunce-devel.sha256sum] = "6989d63152fe16adc68a0dfe3da1df49f33850c0d21b1657e940518976317d48"

URI_aarch64_rust-dunce+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dunce+default-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-dunce+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dunce+default-devel}"
SRC_URI[aarch64_rust-dunce+default-devel.sha256sum] = "0eb310a906ab24ff59f3156361292c5ff235175ee340a925947220afba9e0001"

URI_aarch64_rust-dunce-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dunce-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-dunce-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dunce-devel}"
SRC_URI[aarch64_rust-dunce-devel.sha256sum] = "10b81b108ddfe8f30fd1257c9b2ab7313c4c57c9316826ac747337408e12a8be"

RDEPENDS:rust-dunce+default-devel = " \
 cargo \
 rust-dunce-devel \
 "
RDEPENDS:rust-dunce-devel = " \
 cargo \
 "
