# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "docbook-style-dsssl"
PV = "1.79"
PR = "43.el10_0"
PACKAGES = " \
 docbook-style-dsssl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/docbook-style-dsssl-1.79-43.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7b7b1d1dc57628b85f50c839de19ad0346588e62d71298b79247ce99bcb233c"

URI_x86_64_v2_docbook-style-dsssl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/docbook-style-dsssl-1.79-43.el10_0.noarch.rpm;name=x86_64_v2_docbook-style-dsssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_docbook-style-dsssl}"
SRC_URI[x86_64_v2_docbook-style-dsssl.sha256sum] = "34062788b9aae30b9346ca38cd40a80fcf353361620fe98c1eb6facef463bf6f"

URI_aarch64_docbook-style-dsssl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/docbook-style-dsssl-1.79-43.el10_0.noarch.rpm;name=aarch64_docbook-style-dsssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_docbook-style-dsssl}"
SRC_URI[aarch64_docbook-style-dsssl.sha256sum] = "34062788b9aae30b9346ca38cd40a80fcf353361620fe98c1eb6facef463bf6f"

RDEPENDS:docbook-style-dsssl = " \
 bash \
 docbook-dtds \
 openjade \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-interpreter \
 sgml-common \
 "
