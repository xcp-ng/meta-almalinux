# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gatekeeper"
PV = "11.4"
PR = "10.el10_1"
PACKAGES = " \
 globus-gatekeeper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gatekeeper-11.4-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef61afb15837d587a565fab23c7079072e2119bd3ddc42e27df790528122037c"

URI_x86_64_v2_globus-gatekeeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gatekeeper-11.4-10.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gatekeeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gatekeeper}"
SRC_URI[x86_64_v2_globus-gatekeeper.sha256sum] = "d15f08343a3b2e9c623163c42d83af549755e61eccdfa71c0c4e1bbdb69fd04b"

URI_aarch64_globus-gatekeeper = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gatekeeper-11.4-10.el10_1.aarch64.rpm;name=aarch64_globus-gatekeeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gatekeeper}"
SRC_URI[aarch64_globus-gatekeeper.sha256sum] = "1e9dc5fb3d0732a50dc9bbbcfd1c8b0545a4ec9ac142436e6a66330d6c82cab7"

RDEPENDS:globus-gatekeeper = " \
 bash \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 logrotate \
 openssl-libs \
 systemd \
 "
