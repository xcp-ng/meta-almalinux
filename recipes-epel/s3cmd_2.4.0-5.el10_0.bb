# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s3cmd"
PV = "2.4.0"
PR = "5.el10_0"
PACKAGES = " \
 s3cmd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/s3cmd-2.4.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a8d443af68aa1b63d040c4786795080909aeb87b5352a0366f5a82bea876e11"

URI_x86_64_v2_s3cmd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/s3cmd-2.4.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_s3cmd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s3cmd}"
SRC_URI[x86_64_v2_s3cmd.sha256sum] = "5b261969be3db7c938080c340435da961413bb4e352c6b99a4e7ebe0b55524ac"

URI_aarch64_s3cmd = "${EPEL_MIRROR}/aarch64/Packages/s/s3cmd-2.4.0-5.el10_0.noarch.rpm;name=aarch64_s3cmd;unpack=0"
SRC_URI:append = " ${URI_aarch64_s3cmd}"
SRC_URI[aarch64_s3cmd.sha256sum] = "fc63d74b114dc482fbf61627f60c8b1fc1cc5ec379de48c98423b5e23f73f72a"

RDEPENDS:s3cmd = " \
 python3 \
 python3-dateutil \
 python3-file-magic \
 "
