# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SNMP_Session"
PV = "1.16"
PR = "6.el10"
PACKAGES = " \
 perl-SNMP_Session \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-SNMP_Session-1.16-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5d24511e3baa6001b2a0c83c2501e2b0556497a71f49387f8f78f3da465f9ae"

URI_x86_64_v2_perl-SNMP_Session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-SNMP_Session-1.16-6.el10.noarch.rpm;name=x86_64_v2_perl-SNMP_Session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SNMP_Session}"
SRC_URI[x86_64_v2_perl-SNMP_Session.sha256sum] = "47082bb7f4995770d54da704185450c880a111ce6b70228bc7848bea1ecdfd18"

URI_aarch64_perl-SNMP_Session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-SNMP_Session-1.16-6.el10.noarch.rpm;name=aarch64_perl-SNMP_Session;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SNMP_Session}"
SRC_URI[aarch64_perl-SNMP_Session.sha256sum] = "47082bb7f4995770d54da704185450c880a111ce6b70228bc7848bea1ecdfd18"

RDEPENDS:perl-SNMP_Session = " \
 perl-Carp \
 perl-Exporter \
 perl-IO \
 perl-IO-Socket-INET6 \
 perl-Net-SNMP \
 perl-SNMP_Session \
 perl-Socket \
 perl-Socket6 \
 perl-libs \
 perl-vars \
 "
