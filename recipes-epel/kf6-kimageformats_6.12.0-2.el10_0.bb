# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kimageformats"
PV = "6.12.0"
PR = "2.el10_0"
PACKAGES = " \
 kf6-kimageformats \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kimageformats-6.12.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d8cfe94ff16570171dfa5116c6755aa5a18b26527ad6ef966f122912dbdd72c"

URI_x86_64_v2_kf6-kimageformats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kimageformats-6.12.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kimageformats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kimageformats}"
SRC_URI[x86_64_v2_kf6-kimageformats.sha256sum] = "c9e6f33020379277a9f46ccc9977d009103f1aeb40352d0e8183c9a2f90405af"

URI_aarch64_kf6-kimageformats = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kimageformats-6.12.0-2.el10_0.aarch64.rpm;name=aarch64_kf6-kimageformats;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kimageformats}"
SRC_URI[aarch64_kf6-kimageformats.sha256sum] = "5437083fc13b7fe2790e42e9d17caa7d56302878a36564283dd07bc8c28e9bb5"

RDEPENDS:kf6-kimageformats = " \
 LibRaw \
 glibc \
 imath \
 kf6-filesystem \
 kf6-karchive \
 libavif \
 libgcc \
 libheif \
 libjxl \
 libstdc++ \
 openexr-libs \
 openjpeg2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
