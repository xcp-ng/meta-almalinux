# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree_magic_db"
PV = "3.0.1"
PR = "2.el10_1"
PACKAGES = " \
 rust-tree_magic_db+default-devel \
 rust-tree_magic_db-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree_magic_db-3.0.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07623c9f87647b906a5a3cdefbd9af48e2fe9d26c8606ad17c728939560f692c"

URI_x86_64_v2_rust-tree_magic_db+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_db+default-devel-3.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_db+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_db+default-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_db+default-devel.sha256sum] = "76f871cd59441dc7f3dcb4cc4403356c6ba206536ef9889271ef905cedcbcf67"

URI_x86_64_v2_rust-tree_magic_db-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree_magic_db-devel-3.0.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree_magic_db-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree_magic_db-devel}"
SRC_URI[x86_64_v2_rust-tree_magic_db-devel.sha256sum] = "699a1cca009ce03a60bbafcbb7bd43ad2a76fd28a018447c5b50ab75d5adb708"

URI_aarch64_rust-tree_magic_db+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_db+default-devel-3.0.1-2.el10_1.noarch.rpm;name=aarch64_rust-tree_magic_db+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_db+default-devel}"
SRC_URI[aarch64_rust-tree_magic_db+default-devel.sha256sum] = "929e7b1cf3e5279abe74205a1a28bb4a9c24e8db8511615d84ba251568d00dad"

URI_aarch64_rust-tree_magic_db-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree_magic_db-devel-3.0.1-2.el10_1.noarch.rpm;name=aarch64_rust-tree_magic_db-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree_magic_db-devel}"
SRC_URI[aarch64_rust-tree_magic_db-devel.sha256sum] = "eec41f6fb1aaec6c67fdade1a5e9e36de2199ca0aa541d76f28e90348a52c0f2"

RDEPENDS:rust-tree_magic_db+default-devel = " \
 cargo \
 rust-tree_magic_db-devel \
 "
RDEPENDS:rust-tree_magic_db-devel = " \
 cargo \
 "
