# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-path"
PV = "0.10.22"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-path+default-devel \
 rust-gix-path-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-path-0.10.22-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9e533d2a21e0e27a6ead427aff79535ce4f59f02319fbe9051b1e9418c2ab54"

URI_x86_64_v2_rust-gix-path+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-path+default-devel-0.10.22-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-path+default-devel}"
SRC_URI[x86_64_v2_rust-gix-path+default-devel.sha256sum] = "d1ccc6da540c9a9cf02e7630c958b2558ceeeab18ad67545674a0c9d67cf6df1"

URI_x86_64_v2_rust-gix-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-path-devel-0.10.22-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-path-devel}"
SRC_URI[x86_64_v2_rust-gix-path-devel.sha256sum] = "19f48b2cd1b577a9fd4ac1394e6849efc5dd70428384f82b7da8f35964215db7"

URI_aarch64_rust-gix-path+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-path+default-devel-0.10.22-1.el10_2.noarch.rpm;name=aarch64_rust-gix-path+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-path+default-devel}"
SRC_URI[aarch64_rust-gix-path+default-devel.sha256sum] = "4573edc4a7e79b11b33ee7f7ee1c0cb3872d4e3250f3248c3af1aa14a07af8fc"

URI_aarch64_rust-gix-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-path-devel-0.10.22-1.el10_2.noarch.rpm;name=aarch64_rust-gix-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-path-devel}"
SRC_URI[aarch64_rust-gix-path-devel.sha256sum] = "60e408c73a0fac89279d17d78a7e1c830ef3210337d38913f55d22a95d1bd796"

RDEPENDS:rust-gix-path+default-devel = " \
 cargo \
 rust-gix-path-devel \
 "
RDEPENDS:rust-gix-path-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-trace+default-devel \
 rust-gix-validate+default-devel \
 rust-thiserror+default-devel \
 "
