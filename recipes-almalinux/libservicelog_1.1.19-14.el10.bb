# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libservicelog"
PV = "1.1.19"
PR = "14.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libservicelog-1.1.19-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74373f3cbb29caf77aedf6707956198f38bea7cf0e692ba8f4c0e5d05f1f580e"

