# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-markdown"
PV = "3.5.1"
PR = "6.el10"
PACKAGES = " \
 python3-markdown \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-markdown-3.5.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "693d2321a90bf33304065105594f5391e0e63c700f9d764c2f791338d9434ac2"

URI_x86_64_v2_python3-markdown = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-markdown-3.5.1-6.el10.noarch.rpm;name=x86_64_v2_python3-markdown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-markdown}"
SRC_URI[x86_64_v2_python3-markdown.sha256sum] = "c11bf8e04ca40c9daeb16c19d85781cceaf53a3a387058c1eafd4ffa59728914"

URI_aarch64_python3-markdown = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-markdown-3.5.1-6.el10.noarch.rpm;name=aarch64_python3-markdown;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-markdown}"
SRC_URI[aarch64_python3-markdown.sha256sum] = "c11bf8e04ca40c9daeb16c19d85781cceaf53a3a387058c1eafd4ffa59728914"

RDEPENDS:python3-markdown = " \
 python3 \
 "
