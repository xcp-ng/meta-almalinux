# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdb"
PV = "16.3"
PR = "3.1.el10_2"
PACKAGES = " \
 gdb \
 gdb-doc \
 gdb-gdbserver \
 gdb-headless \
 gdb-minimal \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdb-16.3-3.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "27e8639d3523f40884b0e1872846989a7125c224d58824ec960261c3ae84b82b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-16.3-3.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdb;unpack=0"
SRC_URI[x86_64_v2_gdb.sha256sum] = "b9afcc430e043ec05a43a9541cb34a483c305edd39cc19fc47f4ae1dfc8ab20f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-doc-16.3-3.1.el10_2.noarch.rpm;name=x86_64_v2_gdb-doc;unpack=0"
SRC_URI[x86_64_v2_gdb-doc.sha256sum] = "39dce27fc5099ec9272403ef4efccf67f2543fb0057041caf17d6dd68cc06eb9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-gdbserver-16.3-3.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdb-gdbserver;unpack=0"
SRC_URI[x86_64_v2_gdb-gdbserver.sha256sum] = "480079455cfd3c9acb8b76331477e5de758461bb4050450b352e3aaf61e4309f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-headless-16.3-3.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdb-headless;unpack=0"
SRC_URI[x86_64_v2_gdb-headless.sha256sum] = "a650f52d660550bd04871d58e131aab20df0badbc418e7617335f2c0a3c86ce3"
RPROVIDES:gdb-headless:append:x86_64_v2 = " virtual//usr/bin/gdb-add-index"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdb-minimal-16.3-3.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_gdb-minimal;unpack=0"
SRC_URI[x86_64_v2_gdb-minimal.sha256sum] = "01e91c39ea94c3c1fa44c0d28189d774e84497412bdddfdf69b268d31db0147b"
RPROVIDES:gdb-minimal:append:x86_64_v2 = " virtual//usr/bin/gdb-add-index"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-16.3-3.1.el10_2.aarch64.rpm;name=aarch64_gdb;unpack=0"
SRC_URI[aarch64_gdb.sha256sum] = "fe6c9988e781a8319d71984219edc4b8bf0ad7ed3bff0aaf50f74885e3d6620f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-doc-16.3-3.1.el10_2.noarch.rpm;name=aarch64_gdb-doc;unpack=0"
SRC_URI[aarch64_gdb-doc.sha256sum] = "39dce27fc5099ec9272403ef4efccf67f2543fb0057041caf17d6dd68cc06eb9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-gdbserver-16.3-3.1.el10_2.aarch64.rpm;name=aarch64_gdb-gdbserver;unpack=0"
SRC_URI[aarch64_gdb-gdbserver.sha256sum] = "2ff1818e6c08740f4459d3d8bf9ff562e0a4866fe2951c4f90af9ef9b298c975"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-headless-16.3-3.1.el10_2.aarch64.rpm;name=aarch64_gdb-headless;unpack=0"
SRC_URI[aarch64_gdb-headless.sha256sum] = "57ac37f4f6c731c08aa08b056c095be1f9587c792efc881138383d8ea1eacc61"
RPROVIDES:gdb-headless:append:aarch64 = " virtual//usr/bin/gdb-add-index"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdb-minimal-16.3-3.1.el10_2.aarch64.rpm;name=aarch64_gdb-minimal;unpack=0"
SRC_URI[aarch64_gdb-minimal.sha256sum] = "5600dd85b3dd8f61914c16fa432eedb126da37f75b794429e337030676a1e502"
RPROVIDES:gdb-minimal:append:aarch64 = " virtual//usr/bin/gdb-add-index"

RDEPENDS:gdb = " \
 bash \
 gdb-headless \
 "
RDEPENDS:gdb-doc = " \
 "
RDEPENDS:gdb-gdbserver = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gdb-headless:x86_64_v2 = " \
 bash \
 binutils \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libipt \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-headless:aarch64 = " \
 bash \
 binutils \
 elfutils-debuginfod-client \
 expat \
 glibc \
 gmp \
 libbabeltrace \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 python3-libs \
 readline \
 source-highlight \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:gdb-minimal = " \
 bash \
 elfutils-debuginfod-client \
 glibc \
 gmp \
 libgcc \
 libstdc++ \
 mpfr \
 ncurses-libs \
 readline \
 xz-libs \
 zlib-ng-compat \
 "
