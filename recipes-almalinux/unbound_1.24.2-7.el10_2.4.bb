# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unbound"
PV = "1.24.2"
PR = "7.el10_2.4"
PACKAGES = " \
 python3-unbound \
 unbound \
 unbound-anchor \
 unbound-devel \
 unbound-dracut \
 unbound-libs \
 unbound-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/unbound-1.24.2-7.el10_2.4.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a20d11fb2cb30ae9b120a05532cf850fc46831199f3da9e070a21f3842ac6fca"

URI_x86_64_v2_python3-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-unbound-1.24.2-7.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_python3-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-unbound}"
SRC_URI[x86_64_v2_python3-unbound.sha256sum] = "59985b1e0ee9b0642e0476cd5eb444f76c53ae724ff072adad49aac63c852333"

URI_x86_64_v2_unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-1.24.2-7.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound}"
SRC_URI[x86_64_v2_unbound.sha256sum] = "0a16752fe035528e3c0b640744b3fc76aed794608d2b5ac26eb41899af9382a8"

URI_x86_64_v2_unbound-anchor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-anchor-1.24.2-7.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_unbound-anchor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-anchor}"
SRC_URI[x86_64_v2_unbound-anchor.sha256sum] = "4dfac69f2fa754147922a61031b7e4b336f5633f19d56d07bb66ebb6aec0f69f"

URI_x86_64_v2_unbound-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/unbound-devel-1.24.2-7.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_unbound-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-devel}"
SRC_URI[x86_64_v2_unbound-devel.sha256sum] = "ea4d86bdff67150af33517b3d6bd8b62ce465639e3c2a8583b932a693a6bfc78"

URI_x86_64_v2_unbound-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-dracut-1.24.2-7.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_unbound-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-dracut}"
SRC_URI[x86_64_v2_unbound-dracut.sha256sum] = "3ae839ae75c8ed9306134db0947b4655d5b7aabd90622a426052f32db72d3a58"

URI_x86_64_v2_unbound-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-libs-1.24.2-7.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_unbound-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-libs}"
SRC_URI[x86_64_v2_unbound-libs.sha256sum] = "c2a3977c6eebb3582c8dfb5ca109bfbddcfeec8e51aa5b8a87fbc779ef50b610"

URI_x86_64_v2_unbound-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unbound-utils-1.24.2-7.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_unbound-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_unbound-utils}"
SRC_URI[x86_64_v2_unbound-utils.sha256sum] = "956b387af2b8af319589c1b616a14f8dfac6dd8f11dd02391e65054da126c65c"

URI_aarch64_python3-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-unbound-1.24.2-7.el10_2.4.aarch64.rpm;name=aarch64_python3-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-unbound}"
SRC_URI[aarch64_python3-unbound.sha256sum] = "aed736edcfdc8d553698bed0f174b9753d09f7a8a5406707168eb09afd05f56f"

URI_aarch64_unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-1.24.2-7.el10_2.4.aarch64.rpm;name=aarch64_unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound}"
SRC_URI[aarch64_unbound.sha256sum] = "c62c1676cec0a00cfe95fe94f0fc7c80a9314c32325034a9184e4c7a039220fe"

URI_aarch64_unbound-anchor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-anchor-1.24.2-7.el10_2.4.aarch64.rpm;name=aarch64_unbound-anchor;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-anchor}"
SRC_URI[aarch64_unbound-anchor.sha256sum] = "97c6980a6a7fac3d6822686b40b863d1c607a3cb1e19fdabdc9ff028b4384337"

URI_aarch64_unbound-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/unbound-devel-1.24.2-7.el10_2.4.aarch64.rpm;name=aarch64_unbound-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-devel}"
SRC_URI[aarch64_unbound-devel.sha256sum] = "b7dd73ac4616d4e0620efbc18d3e6659208e55532a70e0d9825531a8ca8047c2"

URI_aarch64_unbound-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-dracut-1.24.2-7.el10_2.4.aarch64.rpm;name=aarch64_unbound-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-dracut}"
SRC_URI[aarch64_unbound-dracut.sha256sum] = "c2351f47822d8467851df22738d3477f947ef37d416e838c06c5958ffdba59b6"

URI_aarch64_unbound-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-libs-1.24.2-7.el10_2.4.aarch64.rpm;name=aarch64_unbound-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-libs}"
SRC_URI[aarch64_unbound-libs.sha256sum] = "c490d4c3522a2179ad5d94eef7103f69750b1acc2d0f5b5ff8e045c0f89a4608"

URI_aarch64_unbound-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unbound-utils-1.24.2-7.el10_2.4.aarch64.rpm;name=aarch64_unbound-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_unbound-utils}"
SRC_URI[aarch64_unbound-utils.sha256sum] = "2d2cad288615eac319ba5b1acd1868894afcfca93518df101a45117daa186215"

RDEPENDS:python3-unbound = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3 \
 python3-libs \
 systemd-libs \
 unbound-libs \
 "
RDEPENDS:unbound = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl \
 openssl-libs \
 protobuf-c \
 python3-libs \
 systemd-libs \
 unbound-anchor \
 unbound-libs \
 "
RDEPENDS:unbound-anchor = " \
 bash \
 expat \
 glibc \
 openssl-libs \
 unbound-libs \
 "
RDEPENDS:unbound-devel = " \
 libevent-devel \
 openssl-devel \
 pkgconf-pkg-config \
 python3-devel \
 unbound-libs \
 "
RDEPENDS:unbound-dracut = " \
 bash \
 dracut \
 unbound \
 "
RDEPENDS:unbound-libs = " \
 bash \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 protobuf-c \
 python3-libs \
 shadow-utils \
 systemd-libs \
 "
RDEPENDS:unbound-utils = " \
 glibc \
 libevent \
 libnghttp2 \
 openssl-libs \
 python3-libs \
 unbound-libs \
 "
