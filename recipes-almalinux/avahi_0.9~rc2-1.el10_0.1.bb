# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "avahi"
PV = "0.9~rc2"
PR = "1.el10_0.1"
PACKAGES = " \
 avahi \
 avahi-compat-howl \
 avahi-compat-howl-devel \
 avahi-compat-libdns_sd \
 avahi-compat-libdns_sd-devel \
 avahi-devel \
 avahi-glib \
 avahi-glib-devel \
 avahi-gobject \
 avahi-libs \
 avahi-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/avahi-0.9~rc2-1.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "013a456256ec5cf20ab90ec6462e61685795910f7d45fab56650ca634ec3a731"

URI_x86_64_v2_avahi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/avahi-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi}"
SRC_URI[x86_64_v2_avahi.sha256sum] = "eb3cdaec6e7370b9f8a56f127e694fd03370b1262734cc59c3c17fbf9e90fc1e"

URI_x86_64_v2_avahi-compat-howl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-howl-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-howl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-howl}"
SRC_URI[x86_64_v2_avahi-compat-howl.sha256sum] = "10fce60c0b6ae288657261fe925e74aae45061e3ff61ed8ad5d09e8f7573bdf1"

URI_x86_64_v2_avahi-compat-howl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-howl-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-howl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-howl-devel}"
SRC_URI[x86_64_v2_avahi-compat-howl-devel.sha256sum] = "61baa291d218458eb9e3ba5e04c6b539d58ccebeb45270e3cef6608a7888ea43"

URI_x86_64_v2_avahi-compat-libdns_sd = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-libdns_sd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-libdns_sd}"
SRC_URI[x86_64_v2_avahi-compat-libdns_sd.sha256sum] = "16881fdbc8a2037bc2ae4cbfe73ecffe6aa6502167093770b7a440e98dd35f4a"

URI_x86_64_v2_avahi-compat-libdns_sd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-libdns_sd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-libdns_sd-devel}"
SRC_URI[x86_64_v2_avahi-compat-libdns_sd-devel.sha256sum] = "2a66518400b1310d598c7e3e0230da33b88c668f7e51d7cfb6759e1dfa024deb"

URI_x86_64_v2_avahi-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-devel}"
SRC_URI[x86_64_v2_avahi-devel.sha256sum] = "c6fec4a0b2574e9d841b77ad42fa71913d930419d836bdef503d3e8039d7509a"

URI_x86_64_v2_avahi-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-glib-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-glib}"
SRC_URI[x86_64_v2_avahi-glib.sha256sum] = "d9b22fb865c0eabb171bb4bb5c8617d4b78bad29541ab89e56097afe0fa3016f"

URI_x86_64_v2_avahi-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-glib-devel-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-glib-devel}"
SRC_URI[x86_64_v2_avahi-glib-devel.sha256sum] = "233842aec68fb2b494c0ea2bf7f79755956a04847137cdbc2a33cbba6050adc2"

URI_x86_64_v2_avahi-gobject = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-gobject-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-gobject;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-gobject}"
SRC_URI[x86_64_v2_avahi-gobject.sha256sum] = "a87c9396a21b2a8462e2421e5d488a7a25a3a103603a9e925736260d3f60b536"

URI_x86_64_v2_avahi-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/avahi-libs-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-libs}"
SRC_URI[x86_64_v2_avahi-libs.sha256sum] = "a4ffd2ecdadc429a95c986d82a14bfbca6334de6ddf976b3abe51ef0d7312423"

URI_x86_64_v2_avahi-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-tools-0.9~rc2-1.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_avahi-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-tools}"
SRC_URI[x86_64_v2_avahi-tools.sha256sum] = "067b4448bb97871c165045c43fabd72e4d14378eb180fecba949e246527d4611"

URI_aarch64_avahi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/avahi-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi}"
SRC_URI[aarch64_avahi.sha256sum] = "fe74e54935172a324f01371ee3a50c3de78b3a3319e1078f5158653701a81410"

URI_aarch64_avahi-compat-howl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-howl-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-compat-howl;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-howl}"
SRC_URI[aarch64_avahi-compat-howl.sha256sum] = "bbd60073d23717df6ffe69defe1a80bdb87f4549de064d51666acb081a3634f6"

URI_aarch64_avahi-compat-howl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-howl-devel-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-compat-howl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-howl-devel}"
SRC_URI[aarch64_avahi-compat-howl-devel.sha256sum] = "d3ecaa61b4c80938ef68965da5db054690bd31a7c8503424232720d628093191"

URI_aarch64_avahi-compat-libdns_sd = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-libdns_sd-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-compat-libdns_sd;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-libdns_sd}"
SRC_URI[aarch64_avahi-compat-libdns_sd.sha256sum] = "e020e3df85ffa95b6fb3be5154eae11f6ca1fea7373ec079c9bf3328ebe37f06"

URI_aarch64_avahi-compat-libdns_sd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-libdns_sd-devel-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-compat-libdns_sd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-libdns_sd-devel}"
SRC_URI[aarch64_avahi-compat-libdns_sd-devel.sha256sum] = "7343d19e92bb639ef174ff089b292c538e6cced27119f19b803c183d05052186"

URI_aarch64_avahi-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-devel-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-devel}"
SRC_URI[aarch64_avahi-devel.sha256sum] = "53aaf605c1f3a314ce8e87590d945b1557d6010444539d2937ebd9b880492532"

URI_aarch64_avahi-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-glib-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-glib}"
SRC_URI[aarch64_avahi-glib.sha256sum] = "da04b82c47c73edded3c8c4e32dbcb982cca0d3d4e34645824c99b080fa48042"

URI_aarch64_avahi-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-glib-devel-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-glib-devel}"
SRC_URI[aarch64_avahi-glib-devel.sha256sum] = "7302184753c2b71cf6ceda020c4c335a868bcc3a237a3fef5534293f8565eb4f"

URI_aarch64_avahi-gobject = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-gobject-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-gobject;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-gobject}"
SRC_URI[aarch64_avahi-gobject.sha256sum] = "3a87dec3aaa383d340b5ab0126e778d870991b5792abb486f9f8fc88a3096f24"

URI_aarch64_avahi-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/avahi-libs-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-libs}"
SRC_URI[aarch64_avahi-libs.sha256sum] = "069f442e194e69d3250ce8234641bc6fa1665490ee9908d95f3539914ce1a117"

URI_aarch64_avahi-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-tools-0.9~rc2-1.el10_0.1.aarch64.rpm;name=aarch64_avahi-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-tools}"
SRC_URI[aarch64_avahi-tools.sha256sum] = "68f594d98e88d44de9ad613332a3bdbb246210c511d4156806e4cff49df01248"

RDEPENDS:avahi = " \
 avahi-libs \
 bash \
 dbus \
 dbus-libs \
 expat \
 glibc \
 libcap \
 libdaemon \
 shadow-utils \
 systemd-libs \
 virtual/coreutils \
 "
RDEPENDS:avahi-compat-howl = " \
 avahi-libs \
 dbus-libs \
 glibc \
 "
RDEPENDS:avahi-compat-howl-devel = " \
 avahi-compat-howl \
 avahi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-compat-libdns_sd = " \
 avahi-libs \
 dbus-libs \
 glibc \
 "
RDEPENDS:avahi-compat-libdns_sd-devel = " \
 avahi-compat-libdns_sd \
 avahi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-devel = " \
 avahi \
 avahi-libs \
 dbus-devel \
 libevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-glib = " \
 avahi-libs \
 glib2 \
 glibc \
 "
RDEPENDS:avahi-glib-devel = " \
 avahi-devel \
 avahi-glib \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-gobject = " \
 avahi-glib \
 avahi-libs \
 dbus-libs \
 glib2 \
 glibc \
 "
RDEPENDS:avahi-libs = " \
 dbus-libs \
 glibc \
 libevent \
 "
RDEPENDS:avahi-tools = " \
 avahi \
 avahi-libs \
 gdbm-libs \
 glibc \
 "
