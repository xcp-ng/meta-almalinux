# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tempfile"
PV = "3.27.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tempfile+default-devel \
 rust-tempfile+getrandom-devel \
 rust-tempfile+nightly-devel \
 rust-tempfile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tempfile-3.27.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74bcd497b9c7ad82633cf4d46b4c628c0ab38bc4425bc42b074271fe0273d242"

URI_x86_64_v2_rust-tempfile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+default-devel-3.27.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+default-devel}"
SRC_URI[x86_64_v2_rust-tempfile+default-devel.sha256sum] = "34ec3537547d0c80f4370cf8d8dbf1637c6197152059e7fdf68c211bf7664bf3"

URI_x86_64_v2_rust-tempfile+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+getrandom-devel-3.27.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+getrandom-devel}"
SRC_URI[x86_64_v2_rust-tempfile+getrandom-devel.sha256sum] = "20d976c8283d1b29057e2ae0c2a34a60514a1baf3494b33ee2080843c9c659c3"

URI_x86_64_v2_rust-tempfile+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile+nightly-devel-3.27.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile+nightly-devel}"
SRC_URI[x86_64_v2_rust-tempfile+nightly-devel.sha256sum] = "3a686a8c0d0d6fb54a231c20be20f2246aecb5bfc93909a73bb79fba3782e841"

URI_x86_64_v2_rust-tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tempfile-devel-3.27.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tempfile-devel}"
SRC_URI[x86_64_v2_rust-tempfile-devel.sha256sum] = "9b478fcddbe14bb92224eefb2e7b18a171eeea60891f6311de61d22f45584e61"

URI_aarch64_rust-tempfile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+default-devel-3.27.0-1.el10_2.noarch.rpm;name=aarch64_rust-tempfile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+default-devel}"
SRC_URI[aarch64_rust-tempfile+default-devel.sha256sum] = "95102a66f72b86b3ccb47ec4619d7a44d321dcf531d7b273ddad56dda8bfbdb5"

URI_aarch64_rust-tempfile+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+getrandom-devel-3.27.0-1.el10_2.noarch.rpm;name=aarch64_rust-tempfile+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+getrandom-devel}"
SRC_URI[aarch64_rust-tempfile+getrandom-devel.sha256sum] = "bdfcf4a914a8f048d715a194393b9010524779b33ddfdf6179dab8dd5883264e"

URI_aarch64_rust-tempfile+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile+nightly-devel-3.27.0-1.el10_2.noarch.rpm;name=aarch64_rust-tempfile+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile+nightly-devel}"
SRC_URI[aarch64_rust-tempfile+nightly-devel.sha256sum] = "9f6cd705eaba8119a12f300b7cb7f521c17cd767b3645b4483b00848d466c796"

URI_aarch64_rust-tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tempfile-devel-3.27.0-1.el10_2.noarch.rpm;name=aarch64_rust-tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tempfile-devel}"
SRC_URI[aarch64_rust-tempfile-devel.sha256sum] = "a05d9ce8cd6e7ec343faabfe98faaef0b71d9454f6325b72fdde6f05fed40238"

RDEPENDS:rust-tempfile+default-devel = " \
 cargo \
 rust-tempfile+getrandom-devel \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile+getrandom-devel = " \
 cargo \
 rust-tempfile-devel \
 virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~ \
 "
RDEPENDS:rust-tempfile+nightly-devel = " \
 cargo \
 rust-tempfile-devel \
 "
RDEPENDS:rust-tempfile-devel = " \
 cargo \
 rust \
 rust-fastrand+default-devel \
 rust-once_cell+std-devel \
 rust-once_cell-devel \
 rust-rustix+default-devel \
 rust-rustix+fs-devel \
 "
