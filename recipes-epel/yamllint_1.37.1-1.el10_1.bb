# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yamllint"
PV = "1.37.1"
PR = "1.el10_1"
PACKAGES = " \
 yamllint \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/y/yamllint-1.37.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "71b6d7f0ed2675049c6a1be36e62c37e59855ddf720bfd1ddb1abbbf8a19b472"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yamllint-1.37.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_yamllint;unpack=0"
SRC_URI[x86_64_v2_yamllint.sha256sum] = "f4a2715d7c79507610c92839e1de0aff41dc93808010e7e218afc446b6867dcc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yamllint-1.37.1-1.el10_1.noarch.rpm;name=aarch64_yamllint;unpack=0"
SRC_URI[aarch64_yamllint.sha256sum] = "ae59bdd6af05e547fd64d0816360bbab1c49eda79ec336399ef8399e3a4e237f"

RDEPENDS:yamllint = " \
 python3 \
 python3-pathspec \
 python3-pyyaml \
 "
