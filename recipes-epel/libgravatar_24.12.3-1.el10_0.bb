# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgravatar"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libgravatar \
 libgravatar-devel \
 libgravatar-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgravatar-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4135a5fecb58534748fc645ba418053cf3fb1b603508a4837629216d880d67be"

URI_x86_64_v2_libgravatar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar}"
SRC_URI[x86_64_v2_libgravatar.sha256sum] = "cb4df55e3cd4fe6aa5ee17eff017f316c8527cfaa7ec945012413dbbba547679"

URI_x86_64_v2_libgravatar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgravatar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar-devel}"
SRC_URI[x86_64_v2_libgravatar-devel.sha256sum] = "138306edc4d8b85880cadcca1717014dc5637905458e7e707afefb7d1faa1bf4"

URI_x86_64_v2_libgravatar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgravatar-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libgravatar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgravatar-doc}"
SRC_URI[x86_64_v2_libgravatar-doc.sha256sum] = "c2c46259732000f76e3a67d1cf9ae984ce2657ab86f351fbffac79942c58b1fa"

URI_aarch64_libgravatar = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libgravatar;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar}"
SRC_URI[aarch64_libgravatar.sha256sum] = "de5e3812a21047b376f30866b073406fae9d39cb7e19b3c8a23686d05ed3ca7b"

URI_aarch64_libgravatar-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libgravatar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar-devel}"
SRC_URI[aarch64_libgravatar-devel.sha256sum] = "428993d8602f79f05f3f16abea331737b4277635bf8073113a1b9b3b4ccfc64c"

URI_aarch64_libgravatar-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libgravatar-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_libgravatar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgravatar-doc}"
SRC_URI[aarch64_libgravatar-doc.sha256sum] = "a7df205f4217788968db7c6ae34b8f77d949fc1f46c5a26f95bed2013ca08225"

RDEPENDS:libgravatar = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libgravatar-devel = " \
 cmake-filesystem \
 libgravatar \
 "
RDEPENDS:libgravatar-doc = " \
 "
