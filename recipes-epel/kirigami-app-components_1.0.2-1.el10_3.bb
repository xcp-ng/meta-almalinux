# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kirigami-app-components"
PV = "1.0.2"
PR = "1.el10_3"
PACKAGES = " \
 kirigami-app-components \
 kirigami-app-components-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kirigami-app-components-1.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f596706338723085fcff8d538bfaa8f23766479cbed284d4c5fb9716d9d243f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kirigami-app-components-1.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kirigami-app-components;unpack=0"
SRC_URI[x86_64_v2_kirigami-app-components.sha256sum] = "911913356632064b2335c87f9d67addc9ed23ae43e18fc0a14ae91417c71c38e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kirigami-app-components-devel-1.0.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kirigami-app-components-devel;unpack=0"
SRC_URI[x86_64_v2_kirigami-app-components-devel.sha256sum] = "8722671512a485fa193b7a586837c1fb3e93ad5f91e83904f76963c5120bb925"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kirigami-app-components-1.0.2-1.el10_3.aarch64.rpm;name=aarch64_kirigami-app-components;unpack=0"
SRC_URI[aarch64_kirigami-app-components.sha256sum] = "1924c4f180d9b116591a96e5aac9c8d82dc22d3a30a0fdfdf50a21fba3509cf4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kirigami-app-components-devel-1.0.2-1.el10_3.aarch64.rpm;name=aarch64_kirigami-app-components-devel;unpack=0"
SRC_URI[aarch64_kirigami-app-components-devel.sha256sum] = "69ae0b340c6e48370aca32ef2a398206735f9fdc2548a576b5e52eb533100534"

RDEPENDS:kirigami-app-components = " \
 glibc \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kirigami-app-components-devel = " \
 cmake-filesystem \
 kirigami-app-components \
 "
