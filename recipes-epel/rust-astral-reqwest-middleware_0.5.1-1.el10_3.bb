# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-reqwest-middleware"
PV = "0.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-astral-reqwest-middleware+charset-devel \
 rust-astral-reqwest-middleware+default-devel \
 rust-astral-reqwest-middleware+form-devel \
 rust-astral-reqwest-middleware+http2-devel \
 rust-astral-reqwest-middleware+json-devel \
 rust-astral-reqwest-middleware+multipart-devel \
 rust-astral-reqwest-middleware+query-devel \
 rust-astral-reqwest-middleware+rustls-devel \
 rust-astral-reqwest-middleware-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral-reqwest-middleware-0.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b9245f3c616c4c5de2bb0536c8bcf5a16890caffe54c12b588f3e80bbd7dacc"

URI_x86_64_v2_rust-astral-reqwest-middleware+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+charset-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+charset-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+charset-devel.sha256sum] = "f93509cbe1a2cd3846098a03e1df72c23d00c9a253669e11654fa5432ba3e26f"

URI_x86_64_v2_rust-astral-reqwest-middleware+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+default-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+default-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+default-devel.sha256sum] = "ea21e77d1946c520c29d2ad5994d7dc125aee65fef7e022e26c4b7ff8fdf1d34"

URI_x86_64_v2_rust-astral-reqwest-middleware+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+form-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+form-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+form-devel.sha256sum] = "fe3fd49326742a08085025295c9c96265e6ca446820d2d60baaf73ca450c9853"

URI_x86_64_v2_rust-astral-reqwest-middleware+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+http2-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+http2-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+http2-devel.sha256sum] = "69603a7576bfd0ac7baa3601b31e8e2aea7eab0217501e8627fab96d6e0775be"

URI_x86_64_v2_rust-astral-reqwest-middleware+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+json-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+json-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+json-devel.sha256sum] = "e1de56d78cbbee485986a1991f153b2af599724e331997dc30f3bfa59469e692"

URI_x86_64_v2_rust-astral-reqwest-middleware+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+multipart-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+multipart-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+multipart-devel.sha256sum] = "9d1e5fb39863d0a42c179ceb9633f348c5b28ae158eec23b461ce1fe33668585"

URI_x86_64_v2_rust-astral-reqwest-middleware+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+query-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+query-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+query-devel.sha256sum] = "4a74197255901e6ab77dfee5c91fd14f7e5befdf5bf00ea189af15576d19757c"

URI_x86_64_v2_rust-astral-reqwest-middleware+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware+rustls-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware+rustls-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware+rustls-devel.sha256sum] = "1c590ac9d45f4561cbf38f2292215cf7d28931a6cd67b40fe0d244c2607abb78"

URI_x86_64_v2_rust-astral-reqwest-middleware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-reqwest-middleware-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-reqwest-middleware-devel}"
SRC_URI[x86_64_v2_rust-astral-reqwest-middleware-devel.sha256sum] = "90cc7d3c9a43fc399e7c11fa1dc1370bfa8e8ebf604a2bfe9752325f290c99e4"

URI_aarch64_rust-astral-reqwest-middleware+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+charset-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+charset-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+charset-devel.sha256sum] = "206b2731e7fb13d508a19947f0b76f5e4273cf0cad24534af824b7133c61aff8"

URI_aarch64_rust-astral-reqwest-middleware+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+default-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+default-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+default-devel.sha256sum] = "c1d79bdf049b89fb2730f5c159a7035b750440494b4b05a1713a9df97460ec11"

URI_aarch64_rust-astral-reqwest-middleware+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+form-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+form-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+form-devel.sha256sum] = "87a287bd146d18bf71615c065370499ffdd099bd857d42b78ac9c0abe39e929f"

URI_aarch64_rust-astral-reqwest-middleware+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+http2-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+http2-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+http2-devel.sha256sum] = "507dbd7155426a8089f7104367ac4e2c4d0ad0c3cfb9013d4888a73731e11995"

URI_aarch64_rust-astral-reqwest-middleware+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+json-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+json-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+json-devel.sha256sum] = "6bb0ea216167a80f4d5e4fb6f798e602f372a7444c3726c702ce4f7c586f837c"

URI_aarch64_rust-astral-reqwest-middleware+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+multipart-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+multipart-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+multipart-devel.sha256sum] = "bd6306fdb4bce1a476b2ba9ece6ba87effe3433eca6a0464e3f5a61245368240"

URI_aarch64_rust-astral-reqwest-middleware+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+query-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+query-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+query-devel.sha256sum] = "944f874b4f27192e3ecacf2a681cfb875dcf282caff8992aa9f8ee1eb98dc532"

URI_aarch64_rust-astral-reqwest-middleware+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware+rustls-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware+rustls-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware+rustls-devel.sha256sum] = "9da7429390db0624ee7de978e124d1257028f050e1ddaa9eb1621e55688c4a40"

URI_aarch64_rust-astral-reqwest-middleware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-reqwest-middleware-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-astral-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-reqwest-middleware-devel}"
SRC_URI[aarch64_rust-astral-reqwest-middleware-devel.sha256sum] = "b768772a4c1da5e1154dbb548520657ce5bf0672619d4ebfb373ebcfda54fe0d"

RDEPENDS:rust-astral-reqwest-middleware+charset-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest+charset-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+default-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+form-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest+form-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+http2-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest+http2-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+json-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest+json-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+multipart-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest+multipart-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+query-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest+query-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware+rustls-devel = " \
 cargo \
 rust-astral-reqwest-middleware-devel \
 rust-reqwest+rustls-devel \
 "
RDEPENDS:rust-astral-reqwest-middleware-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-reqwest-devel \
 rust-thiserror+default-devel \
 rust-tower-service+default-devel \
 "
