# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gengetopt"
PV = "2.23"
PR = "14.el10_0"
PACKAGES = " \
 gengetopt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gengetopt-2.23-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d34de3c7c84c83d60de146e9d2e862cec7570ba44a12e3e8c80a383e363b2888"

URI_x86_64_v2_gengetopt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gengetopt-2.23-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gengetopt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gengetopt}"
SRC_URI[x86_64_v2_gengetopt.sha256sum] = "68e9085b3722e4f336bbc01b5a0ca19fd66243d5031900fe2518590db49ed722"

URI_aarch64_gengetopt = "${EPEL_MIRROR}/aarch64/Packages/g/gengetopt-2.23-14.el10_0.aarch64.rpm;name=aarch64_gengetopt;unpack=0"
SRC_URI:append = " ${URI_aarch64_gengetopt}"
SRC_URI[aarch64_gengetopt.sha256sum] = "ce5c4258ef1acbc6a81a1409079aa95f9034be95eea90a3b87fd80895b361cba"

RDEPENDS:gengetopt = " \
 glibc \
 libgcc \
 libstdc++ \
 "
