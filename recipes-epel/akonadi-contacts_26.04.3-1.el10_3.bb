# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-contacts"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-contacts \
 akonadi-contacts-devel \
 akonadi-contacts-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-contacts-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "521998bc9d0dc7d3932382ed06322ad236fe04894bc98b8c856257b2704178bd"

URI_x86_64_v2_akonadi-contacts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts}"
SRC_URI[x86_64_v2_akonadi-contacts.sha256sum] = "d292a28c188bd0cc65655e8a2768a48d406eb07ac6e05fd38bb3662cd70b6d4c"

URI_x86_64_v2_akonadi-contacts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts-devel}"
SRC_URI[x86_64_v2_akonadi-contacts-devel.sha256sum] = "518efa07a32fba80855b37b67cd84cdc8ccffa11101ddb68fdab2d1e185007ae"

URI_x86_64_v2_akonadi-contacts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-contacts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts-doc}"
SRC_URI[x86_64_v2_akonadi-contacts-doc.sha256sum] = "773a9f0da845bde5c6c045a49c6320677e81ecd5449185e7a04bd560ea2c0e9b"

URI_aarch64_akonadi-contacts = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-contacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts}"
SRC_URI[aarch64_akonadi-contacts.sha256sum] = "ba03823ff1e0fcdd1426c326343f3980b91ac91d200663d3863d9dc75944334f"

URI_aarch64_akonadi-contacts-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-contacts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts-devel}"
SRC_URI[aarch64_akonadi-contacts-devel.sha256sum] = "2b020261153d9c60624afa16138ef4470a2939495e0cbdb50d0f702f551f4037"

URI_aarch64_akonadi-contacts-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_akonadi-contacts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts-doc}"
SRC_URI[aarch64_akonadi-contacts-doc.sha256sum] = "957295ef85f39fcdd749fec1cccf7a71a3bb18cec3679bba01cf4799e910588a"

RDEPENDS:akonadi-contacts = " \
 akonadi-server \
 glibc \
 grantleetheme \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-prison \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-contacts-devel = " \
 akonadi-contacts \
 akonadi-server-devel \
 cmake-filesystem \
 grantleetheme-devel \
 kf6-kcontacts-devel \
 "
RDEPENDS:akonadi-contacts-doc = " \
 "
