# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-vcs2l"
PV = "1.1.7"
PR = "1.el10_2"
PACKAGES = " \
 python3-vcs2l \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-vcs2l-1.1.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f27277d2f9619fc4551c3b0e4db47778fa7fff28feedd8fa6c70fddfb0fbefb"

URI_x86_64_v2_python3-vcs2l = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vcs2l-1.1.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-vcs2l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vcs2l}"
SRC_URI[x86_64_v2_python3-vcs2l.sha256sum] = "9989a0a44abbe63d46206b7dc0c9e69df9ee08cd549233b23e91be39d074d7bc"

URI_aarch64_python3-vcs2l = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vcs2l-1.1.7-1.el10_2.noarch.rpm;name=aarch64_python3-vcs2l;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vcs2l}"
SRC_URI[aarch64_python3-vcs2l.sha256sum] = "7bc158e1a86940cb53a76981d84784397f3a8678540173cee833c54f3b487890"

RDEPENDS:python3-vcs2l = " \
 python3 \
 python3-pyyaml \
 "
