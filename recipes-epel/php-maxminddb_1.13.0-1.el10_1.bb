# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-maxminddb"
PV = "1.13.0"
PR = "1.el10_1"
PACKAGES = " \
 php-maxmind-db-reader \
 php-maxminddb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-maxminddb-1.13.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d61e7ac9f9d63517a8d66a420ca19a9e94e13e12937b4ea521ab6607d9750ef"

URI_x86_64_v2_php-maxmind-db-reader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-maxmind-db-reader-1.13.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_php-maxmind-db-reader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-maxmind-db-reader}"
SRC_URI[x86_64_v2_php-maxmind-db-reader.sha256sum] = "49cececce4f6957c04fe17ec305f3a3c7d837485855d23bd699072160ebfa572"

URI_x86_64_v2_php-maxminddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-maxminddb-1.13.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-maxminddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-maxminddb}"
SRC_URI[x86_64_v2_php-maxminddb.sha256sum] = "09748730a2f60b05accb6026b1aa34f5a59d53a852b0b005f908b6c1536c0b10"

URI_aarch64_php-maxmind-db-reader = "${EPEL_MIRROR}/aarch64/Packages/p/php-maxmind-db-reader-1.13.0-1.el10_1.noarch.rpm;name=aarch64_php-maxmind-db-reader;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-maxmind-db-reader}"
SRC_URI[aarch64_php-maxmind-db-reader.sha256sum] = "6f4b9279871cced6d6699fd3e3a1fc08d0d85b44590d1329e801b108a1e94dcb"

URI_aarch64_php-maxminddb = "${EPEL_MIRROR}/aarch64/Packages/p/php-maxminddb-1.13.0-1.el10_1.aarch64.rpm;name=aarch64_php-maxminddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-maxminddb}"
SRC_URI[aarch64_php-maxminddb.sha256sum] = "5e6d66dbda528cf9d752ba6507b9d889f0b4036e2eb2140450e2f206f17746be"

RDEPENDS:php-maxmind-db-reader = " \
 php-common \
 php-fedora-autoloader \
 "
RDEPENDS:php-maxminddb = " \
 glibc \
 libmaxminddb \
 php-common \
 "
