# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baloo-widgets"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 baloo-widgets \
 baloo-widgets-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/baloo-widgets-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f31ad9fa7ef55c2fb626ae4ac1125221638932e054b00943d2a1e1b3e9674333"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baloo-widgets-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baloo-widgets;unpack=0"
SRC_URI[x86_64_v2_baloo-widgets.sha256sum] = "beebaea0dcdd8a4b5a1ad91ebb862fbf1eab2e06aab6dee902a439e3e5960dae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baloo-widgets-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baloo-widgets-devel;unpack=0"
SRC_URI[x86_64_v2_baloo-widgets-devel.sha256sum] = "c6917d43531f1fbda80bdf2a611220c75f90b9bbb7465770ea95d3d830cf0106"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baloo-widgets-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_baloo-widgets;unpack=0"
SRC_URI[aarch64_baloo-widgets.sha256sum] = "bffc7f56c188347de299002fda5e29ae34d4a4bdf6d6e691527e4a5fe295059b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/baloo-widgets-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_baloo-widgets-devel;unpack=0"
SRC_URI[aarch64_baloo-widgets-devel.sha256sum] = "445d82f717b493929671d3ed86132e15d4edeae33a9924e44a8f817d91cd2211"

RDEPENDS:baloo-widgets = " \
 glibc \
 kf6-baloo-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:baloo-widgets-devel = " \
 baloo-widgets \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kio-devel \
 qt6-qtbase-devel \
 "
