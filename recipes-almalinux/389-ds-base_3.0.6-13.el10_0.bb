# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "389-ds-base"
PV = "3.0.6"
PR = "13.el10_0"
PACKAGES = " \
 389-ds-base \
 389-ds-base-bdb \
 389-ds-base-devel \
 389-ds-base-libs \
 389-ds-base-snmp \
 python3-lib389 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/389-ds-base-3.0.6-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bf665bb84316f30e9c8fe5f78e08f42dedd735f04c9efca253f1578ff56d068"

URI_x86_64_v2_389-ds-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-3.0.6-13.el10_0.x86_64_v2.rpm;name=x86_64_v2_389-ds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base}"
SRC_URI[x86_64_v2_389-ds-base.sha256sum] = "f953b39d658fb56aaa84dbe147bbaa78aea1a5a07a25efb7ed8bea7b3b12d658"

URI_x86_64_v2_389-ds-base-bdb = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-bdb-3.0.6-13.el10_0.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-bdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-bdb}"
SRC_URI[x86_64_v2_389-ds-base-bdb.sha256sum] = "b28746622b9b76dc69352f7a721aabd7bb74975d3b3abf30408ee544d2ed4751"

URI_x86_64_v2_389-ds-base-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-devel-3.0.6-13.el10_0.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-devel}"
SRC_URI[x86_64_v2_389-ds-base-devel.sha256sum] = "0bb95dc97ad911610e19a4e8213be1dd97978cb7a73b713e240375f0dc19c717"

URI_x86_64_v2_389-ds-base-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-libs-3.0.6-13.el10_0.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-libs}"
SRC_URI[x86_64_v2_389-ds-base-libs.sha256sum] = "a9bff5c6a3c22a978d0c015b00e8033067535ee7c4adcc93226e26d10b1f031f"

URI_x86_64_v2_389-ds-base-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-snmp-3.0.6-13.el10_0.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-snmp}"
SRC_URI[x86_64_v2_389-ds-base-snmp.sha256sum] = "c4dd3b166d941d34c2348d3d3b6450b48223606a9b0692cfd4d83e58405c5055"

URI_x86_64_v2_python3-lib389 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lib389-3.0.6-13.el10_0.noarch.rpm;name=x86_64_v2_python3-lib389;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lib389}"
SRC_URI[x86_64_v2_python3-lib389.sha256sum] = "11ebf5d56fec6cba8957c0c79fb018a7576e5a7e876dd8c175ba94a4678f938b"

URI_aarch64_389-ds-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-3.0.6-13.el10_0.aarch64.rpm;name=aarch64_389-ds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base}"
SRC_URI[aarch64_389-ds-base.sha256sum] = "f5f430f8486c897e55dae89608156b55ccc2157da28a144c99a70608c8a5c2a6"

URI_aarch64_389-ds-base-bdb = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-bdb-3.0.6-13.el10_0.aarch64.rpm;name=aarch64_389-ds-base-bdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-bdb}"
SRC_URI[aarch64_389-ds-base-bdb.sha256sum] = "8094161120c5f8eb63bda0160dda69ff6de27c9bee3a496cc615f2aafefaba8a"

URI_aarch64_389-ds-base-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-devel-3.0.6-13.el10_0.aarch64.rpm;name=aarch64_389-ds-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-devel}"
SRC_URI[aarch64_389-ds-base-devel.sha256sum] = "348e6dc682f75555d020157c63429f1a3c5290242ab92ff854d9706feaa8a437"

URI_aarch64_389-ds-base-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-libs-3.0.6-13.el10_0.aarch64.rpm;name=aarch64_389-ds-base-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-libs}"
SRC_URI[aarch64_389-ds-base-libs.sha256sum] = "f49842f3e2d188568a9d4ac3103d952eabe751988e83ffb7afc251f95dee7223"

URI_aarch64_389-ds-base-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-snmp-3.0.6-13.el10_0.aarch64.rpm;name=aarch64_389-ds-base-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-snmp}"
SRC_URI[aarch64_389-ds-base-snmp.sha256sum] = "f4a98aecd4b13adfd4038b4f239c6e0ef916e3dd74b6e0977c1f90a8fff1625d"

URI_aarch64_python3-lib389 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lib389-3.0.6-13.el10_0.noarch.rpm;name=aarch64_python3-lib389;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lib389}"
SRC_URI[aarch64_python3-lib389.sha256sum] = "11ebf5d56fec6cba8957c0c79fb018a7576e5a7e876dd8c175ba94a4678f938b"

RDEPENDS:389-ds-base = " \
 389-ds-base-libs \
 acl \
 bash \
 cracklib \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 cyrus-sasl-md5 \
 cyrus-sasl-plain \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libstdc++ \
 libxcrypt \
 lmdb-libs \
 nspr \
 nss \
 nss-tools \
 nss-util \
 openldap \
 openldap-clients \
 openssl-libs \
 pam-libs \
 pcre2 \
 perl-Archive-Tar \
 perl-debugger \
 perl-interpreter \
 perl-sigtrap \
 policycoreutils-python-utils \
 python3 \
 python3-file-magic \
 python3-lib389 \
 python3-libsemanage \
 shadow-utils \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:389-ds-base-bdb = " \
 389-ds-base \
 389-ds-base-libs \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 lmdb-libs \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-devel = " \
 389-ds-base-libs \
 nspr-devel \
 nss-devel \
 openldap-devel \
 pkgconf-pkg-config \
 systemd-libs \
 "
RDEPENDS:389-ds-base-libs = " \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-snmp = " \
 389-ds-base \
 bash \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 nspr \
 openldap \
 "
RDEPENDS:python3-lib389 = " \
 389-ds-base \
 iproute \
 openssl \
 openssl-perl \
 python3 \
 python3-argcomplete \
 python3-cryptography \
 python3-dateutil \
 python3-distro \
 python3-ldap \
 python3-libselinux \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-setuptools \
 "
