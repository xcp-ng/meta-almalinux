# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-apprise"
PV = "1.12.0"
PR = "1.el10_3"
PACKAGES = " \
 apprise \
 python3-apprise \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-apprise-1.12.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb61c8853d10d91494667a2f5f5e4fc1012cf81e9a72810e2af8de7adf0bc267"

URI_x86_64_v2_apprise = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apprise-1.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_apprise;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apprise}"
SRC_URI[x86_64_v2_apprise.sha256sum] = "2eae9c8fcf29b80155057f8bacb925aea1f290afaac908f3059231c75b270b03"

URI_x86_64_v2_python3-apprise = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-apprise-1.12.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-apprise;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-apprise}"
SRC_URI[x86_64_v2_python3-apprise.sha256sum] = "234f4634b7eeb1b97b69e8a289b2be2fca9c1c75e69113d9b37bca730f592b25"

URI_aarch64_apprise = "${EPEL_MIRROR}/aarch64/Packages/a/apprise-1.12.0-1.el10_3.noarch.rpm;name=aarch64_apprise;unpack=0"
SRC_URI:append = " ${URI_aarch64_apprise}"
SRC_URI[aarch64_apprise.sha256sum] = "1af8dd8926a5b29aefc4a21e5935a5c27f1d7691e32dd16d8dd64e6103e7e036"

URI_aarch64_python3-apprise = "${EPEL_MIRROR}/aarch64/Packages/p/python3-apprise-1.12.0-1.el10_3.noarch.rpm;name=aarch64_python3-apprise;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-apprise}"
SRC_URI[aarch64_python3-apprise.sha256sum] = "8a96afee6ddc71ce26fa1823cd4939513e696e1607028956702904862b1d3724"

RDEPENDS:apprise = " \
 python3 \
 python3-apprise \
 python3-click \
 "
RDEPENDS:python3-apprise = " \
 python3 \
 python3-certifi \
 python3-click \
 python3-cryptography \
 python3-markdown \
 python3-pyyaml \
 python3-requests \
 python3-requests-oauthlib \
 "
