# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-xml"
PV = "0.37.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-quick-xml+arbitrary-devel \
 rust-quick-xml+async-tokio-devel \
 rust-quick-xml+default-devel \
 rust-quick-xml+document-features-devel \
 rust-quick-xml+encoding-devel \
 rust-quick-xml+encoding_rs-devel \
 rust-quick-xml+escape-html-devel \
 rust-quick-xml+overlapped-lists-devel \
 rust-quick-xml+serde-devel \
 rust-quick-xml+serde-types-devel \
 rust-quick-xml+serialize-devel \
 rust-quick-xml+tokio-devel \
 rust-quick-xml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-xml-0.37.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f4748a6ab2572e4adfcaa578adad04604991fa709cce0f142ab517b467b17f6"

URI_x86_64_v2_rust-quick-xml+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+arbitrary-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+arbitrary-devel.sha256sum] = "b7cbd375b29d1f0d27a2b95c9756aa299df6d00ced9e554043ac3ec00fc4a66d"

URI_x86_64_v2_rust-quick-xml+async-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+async-tokio-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+async-tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+async-tokio-devel.sha256sum] = "df9bb014b536205216dd902063e6b2fd7d9bc71755d4abbb75a2d5669cc36a73"

URI_x86_64_v2_rust-quick-xml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+default-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+default-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+default-devel.sha256sum] = "a6fa995601bb9b0cce1d696427f0fc98dd39480a5569a5e47d9026edf0d31f12"

URI_x86_64_v2_rust-quick-xml+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+document-features-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+document-features-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+document-features-devel.sha256sum] = "e5fa7cc7618332cdf49f6d884911bc2112b43f9d6229a5ff85e023f6885c995d"

URI_x86_64_v2_rust-quick-xml+encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+encoding-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+encoding-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+encoding-devel.sha256sum] = "1b451e16cd92bf3c55ae6d5b3446344a46539e3cda01d5199df04d1103d489eb"

URI_x86_64_v2_rust-quick-xml+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+encoding_rs-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+encoding_rs-devel.sha256sum] = "d928b2805f12ae01ed1fea4a7323f0ff133c5c846b060c09954d6e61cf79d30d"

URI_x86_64_v2_rust-quick-xml+escape-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+escape-html-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+escape-html-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+escape-html-devel.sha256sum] = "37378b7ec1ee941c9b5dfec5547fe940963ed48f62b550656bcfbbf0ae78a8f6"

URI_x86_64_v2_rust-quick-xml+overlapped-lists-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+overlapped-lists-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+overlapped-lists-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+overlapped-lists-devel.sha256sum] = "fe491e2387cb01b2b8fcb186fb0e65a4eb72971a44a52d188d48c29b79bbc876"

URI_x86_64_v2_rust-quick-xml+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serde-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+serde-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+serde-devel.sha256sum] = "0876b37a9b9ea23e5759249c426bce05871819371816553d849c69d98e0c53bb"

URI_x86_64_v2_rust-quick-xml+serde-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serde-types-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+serde-types-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+serde-types-devel.sha256sum] = "0bb8d9302b14c3b79c62d60f41e98ec4fbb08dcc7f7c3cfb4687fd9115a58e45"

URI_x86_64_v2_rust-quick-xml+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serialize-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+serialize-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+serialize-devel.sha256sum] = "602589d2ada8715e2943a4a951c06db86932676f6e1a309e94d7b6e15ae56098"

URI_x86_64_v2_rust-quick-xml+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+tokio-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+tokio-devel.sha256sum] = "0a96b8d0eb359048791e0556593e303cb10f32cf71e594e0de230b93bd0e3cf3"

URI_x86_64_v2_rust-quick-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml-devel-0.37.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml-devel}"
SRC_URI[x86_64_v2_rust-quick-xml-devel.sha256sum] = "12fefebc3f79802f5b3a0c865b01977f51374946ec78364ff79ae9549929b9d5"

URI_aarch64_rust-quick-xml+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+arbitrary-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+arbitrary-devel}"
SRC_URI[aarch64_rust-quick-xml+arbitrary-devel.sha256sum] = "cb33aba384894d4fd4c17650c887a6200ac483f12183dff674b10852fbcd4a3f"

URI_aarch64_rust-quick-xml+async-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+async-tokio-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+async-tokio-devel}"
SRC_URI[aarch64_rust-quick-xml+async-tokio-devel.sha256sum] = "81e75268b3ac5e8e1435694f2a5f8b2af71542094d19bbc35719dc32f51414f8"

URI_aarch64_rust-quick-xml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+default-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+default-devel}"
SRC_URI[aarch64_rust-quick-xml+default-devel.sha256sum] = "163b3e67bf7ac9579e8bb3ae995481846e9de0fac3967b6520ecfd3f59e5cda9"

URI_aarch64_rust-quick-xml+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+document-features-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+document-features-devel}"
SRC_URI[aarch64_rust-quick-xml+document-features-devel.sha256sum] = "48636733802962afc922015ea0d25321b74c4fbb9fa2a8fe3171cacd6a065b11"

URI_aarch64_rust-quick-xml+encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+encoding-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+encoding-devel}"
SRC_URI[aarch64_rust-quick-xml+encoding-devel.sha256sum] = "55f6a10540be8ecb01cca09253fc7c7555b4d74bb37cae8f1b8c000f1af88ca5"

URI_aarch64_rust-quick-xml+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+encoding_rs-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+encoding_rs-devel}"
SRC_URI[aarch64_rust-quick-xml+encoding_rs-devel.sha256sum] = "431c2b83eff474e51d641edd5f2ea410aa4dde65aab47e3589b793ebd64214f1"

URI_aarch64_rust-quick-xml+escape-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+escape-html-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+escape-html-devel}"
SRC_URI[aarch64_rust-quick-xml+escape-html-devel.sha256sum] = "3bf06a125073194e7433ded3076c6d7614548de677172b5eb10aa72abdb1dca3"

URI_aarch64_rust-quick-xml+overlapped-lists-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+overlapped-lists-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+overlapped-lists-devel}"
SRC_URI[aarch64_rust-quick-xml+overlapped-lists-devel.sha256sum] = "1af832f9135d33bcb14819e5d3ae30c6669c9547539e691526cabba301f759f9"

URI_aarch64_rust-quick-xml+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serde-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+serde-devel}"
SRC_URI[aarch64_rust-quick-xml+serde-devel.sha256sum] = "af013a8fed7223d74f5309630860d460135d425346f670abad5e96c77a2b8f91"

URI_aarch64_rust-quick-xml+serde-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serde-types-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+serde-types-devel}"
SRC_URI[aarch64_rust-quick-xml+serde-types-devel.sha256sum] = "e22944935cd0cda4ffc01240362aeb0c8f2d3c1c6d060476cd9d69fbdbd45ad7"

URI_aarch64_rust-quick-xml+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serialize-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+serialize-devel}"
SRC_URI[aarch64_rust-quick-xml+serialize-devel.sha256sum] = "ba6f1c811c7894756e2b7d03a25a9122b0387ac4df3c9458549e6a87c6cfa9ea"

URI_aarch64_rust-quick-xml+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+tokio-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+tokio-devel}"
SRC_URI[aarch64_rust-quick-xml+tokio-devel.sha256sum] = "f76fb72b5aa25f56612775655dfd604ce6897ee28ce985b9f750a42b1886a000"

URI_aarch64_rust-quick-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml-devel-0.37.5-1.el10_0.noarch.rpm;name=aarch64_rust-quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml-devel}"
SRC_URI[aarch64_rust-quick-xml-devel.sha256sum] = "24042030f8ba9389d0356f74cd2e3a7fe382bfbf7d20b912b206933a2d3b0c57"

RDEPENDS:rust-quick-xml+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+async-tokio-devel = " \
 cargo \
 rust-quick-xml+tokio-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+default-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+encoding-devel = " \
 cargo \
 rust-quick-xml+encoding_rs-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+escape-html-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+overlapped-lists-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+serde-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-quick-xml+serde-types-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-quick-xml+serialize-devel = " \
 cargo \
 rust-quick-xml+serde-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+tokio-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-quick-xml-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 "
