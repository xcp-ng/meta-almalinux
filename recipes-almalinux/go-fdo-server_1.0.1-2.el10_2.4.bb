# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-fdo-server"
PV = "1.0.1"
PR = "2.el10_2.4"
PACKAGES = " \
 go-fdo-server \
 go-fdo-server-manufacturer \
 go-fdo-server-owner \
 go-fdo-server-rendezvous \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-fdo-server-1.0.1-2.el10_2.4.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aed9985519ba86cb80fb937c7b1bdc634dd1329b0c947eadfb024368203eff14"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-1.0.1-2.el10_2.4.x86_64_v2.rpm;name=x86_64_v2_go-fdo-server;unpack=0"
SRC_URI[x86_64_v2_go-fdo-server.sha256sum] = "129618859d7e7e51555f1114292207f6bbb9f12aee014d76dedc91de3ddea775"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-manufacturer-1.0.1-2.el10_2.4.noarch.rpm;name=x86_64_v2_go-fdo-server-manufacturer;unpack=0"
SRC_URI[x86_64_v2_go-fdo-server-manufacturer.sha256sum] = "84881985faeb5b98d8a5aa9bcdf5c151015a891734684a6dfae3071d412b6e96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-owner-1.0.1-2.el10_2.4.noarch.rpm;name=x86_64_v2_go-fdo-server-owner;unpack=0"
SRC_URI[x86_64_v2_go-fdo-server-owner.sha256sum] = "df71d99ab263c33a04002cecffd3691380cb99ec2d02cac000f9c35a6af35a83"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-server-rendezvous-1.0.1-2.el10_2.4.noarch.rpm;name=x86_64_v2_go-fdo-server-rendezvous;unpack=0"
SRC_URI[x86_64_v2_go-fdo-server-rendezvous.sha256sum] = "0211aa299091abf4cfdbbe76f87520827c571e8db4a3770fdd0349a146e1d8c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-1.0.1-2.el10_2.4.aarch64.rpm;name=aarch64_go-fdo-server;unpack=0"
SRC_URI[aarch64_go-fdo-server.sha256sum] = "3fd37c6ce57f687d65f8c5afbf821e09b7239db12c17992ffb04dc3ab7ec8621"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-manufacturer-1.0.1-2.el10_2.4.noarch.rpm;name=aarch64_go-fdo-server-manufacturer;unpack=0"
SRC_URI[aarch64_go-fdo-server-manufacturer.sha256sum] = "84881985faeb5b98d8a5aa9bcdf5c151015a891734684a6dfae3071d412b6e96"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-owner-1.0.1-2.el10_2.4.noarch.rpm;name=aarch64_go-fdo-server-owner;unpack=0"
SRC_URI[aarch64_go-fdo-server-owner.sha256sum] = "df71d99ab263c33a04002cecffd3691380cb99ec2d02cac000f9c35a6af35a83"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-server-rendezvous-1.0.1-2.el10_2.4.noarch.rpm;name=aarch64_go-fdo-server-rendezvous;unpack=0"
SRC_URI[aarch64_go-fdo-server-rendezvous.sha256sum] = "0211aa299091abf4cfdbbe76f87520827c571e8db4a3770fdd0349a146e1d8c0"

RDEPENDS:go-fdo-server = " \
 bash \
 glibc \
 shadow-utils \
 "
RDEPENDS:go-fdo-server-manufacturer = " \
 bash \
 go-fdo-server \
 openssl \
 "
RDEPENDS:go-fdo-server-owner = " \
 bash \
 go-fdo-server \
 "
RDEPENDS:go-fdo-server-rendezvous = " \
 bash \
 go-fdo-server \
 "
