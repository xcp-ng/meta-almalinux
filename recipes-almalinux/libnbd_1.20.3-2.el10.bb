# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnbd"
PV = "1.20.3"
PR = "2.el10"
PACKAGES = " \
 libnbd \
 libnbd-bash-completion \
 libnbd-devel \
 nbdfuse \
 ocaml-libnbd \
 ocaml-libnbd-devel \
 python3-libnbd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnbd-1.20.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8472b53202a355217d5e55b3de818cd665b2b2e99c9ad579fe984540fe62e3a"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

URI_x86_64_v2_libnbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-1.20.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd}"
SRC_URI[x86_64_v2_libnbd.sha256sum] = "8e80186cefdfd5df85e02400832d959f051fc7f07ee9f712267dd9131c4850c4"

URI_x86_64_v2_libnbd-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-bash-completion-1.20.3-2.el10.noarch.rpm;name=x86_64_v2_libnbd-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd-bash-completion}"
SRC_URI[x86_64_v2_libnbd-bash-completion.sha256sum] = "a68eb8b35ea215ff80b0549156d3638b6e93149ec62fc31835f443a3966bd250"

URI_x86_64_v2_libnbd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnbd-devel-1.20.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnbd-devel}"
SRC_URI[x86_64_v2_libnbd-devel.sha256sum] = "68fe006d51f60f1faac99fc0bc5faa817852c359a3173ae43ade31988d7468fb"

URI_x86_64_v2_nbdfuse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdfuse-1.20.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_nbdfuse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbdfuse}"
SRC_URI[x86_64_v2_nbdfuse.sha256sum] = "f4f1954369b2eac4615f8aa006dc3e720425aed50b13ea7f382858f8a5bd0f74"

URI_x86_64_v2_ocaml-libnbd = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-1.20.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libnbd}"
SRC_URI[x86_64_v2_ocaml-libnbd.sha256sum] = "238ab01e1d2cd8bd272c4a19151141561718e156e136b732a2ece6424884241f"

URI_x86_64_v2_ocaml-libnbd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-devel-1.20.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libnbd-devel}"
SRC_URI[x86_64_v2_ocaml-libnbd-devel.sha256sum] = "30b463ae32918e7f169b9c9075f0b09436096ead360819191b82e2c374d47c5f"

URI_x86_64_v2_python3-libnbd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnbd-1.20.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnbd}"
SRC_URI[x86_64_v2_python3-libnbd.sha256sum] = "a20a8cf4f0c72769a653b2013ab2f1357dffa28330572782ebe94d12bb4ec71e"

URI_aarch64_libnbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-1.20.3-2.el10.aarch64.rpm;name=aarch64_libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd}"
SRC_URI[aarch64_libnbd.sha256sum] = "2a3913f50d8b0506e5b7d83acc4ed85457642ddc2a26dc48f2a3092fc4dbf6f2"

URI_aarch64_libnbd-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-bash-completion-1.20.3-2.el10.noarch.rpm;name=aarch64_libnbd-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd-bash-completion}"
SRC_URI[aarch64_libnbd-bash-completion.sha256sum] = "a68eb8b35ea215ff80b0549156d3638b6e93149ec62fc31835f443a3966bd250"

URI_aarch64_libnbd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnbd-devel-1.20.3-2.el10.aarch64.rpm;name=aarch64_libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnbd-devel}"
SRC_URI[aarch64_libnbd-devel.sha256sum] = "ca4e6e4769be2ee2cad26defd3c079decd66702fbb6dc5da510b4ab5757ad7f0"

URI_aarch64_nbdfuse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdfuse-1.20.3-2.el10.aarch64.rpm;name=aarch64_nbdfuse;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbdfuse}"
SRC_URI[aarch64_nbdfuse.sha256sum] = "43430fa959e2701366c75ad97f178736d3c4d9fbc94f83146144d52f0bf71367"

URI_aarch64_ocaml-libnbd = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-1.20.3-2.el10.aarch64.rpm;name=aarch64_ocaml-libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libnbd}"
SRC_URI[aarch64_ocaml-libnbd.sha256sum] = "5af5f254c9abcbc4ab4819fa2a798da1d135e25828e69ddbe3106ffcc69f5081"

URI_aarch64_ocaml-libnbd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-devel-1.20.3-2.el10.aarch64.rpm;name=aarch64_ocaml-libnbd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libnbd-devel}"
SRC_URI[aarch64_ocaml-libnbd-devel.sha256sum] = "4cf6db9c9445a8d68158ac82953eb353cbe7cee71b8559e693be7553e54224a9"

URI_aarch64_python3-libnbd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnbd-1.20.3-2.el10.aarch64.rpm;name=aarch64_python3-libnbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnbd}"
SRC_URI[aarch64_python3-libnbd.sha256sum] = "c39aceadff502f41b9b54243fa042db8d16839788db41719c7ae401e8f771d3c"

RDEPENDS:libnbd = " \
 glibc \
 gnutls \
 libxml2 \
 "
RDEPENDS:libnbd-bash-completion = " \
 bash-completion \
 libnbd \
 "
RDEPENDS:libnbd-devel = " \
 libnbd \
 pkgconf-pkg-config \
 "
RDEPENDS:nbdfuse = " \
 fuse3-libs \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd = " \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd-devel = " \
 ocaml-libnbd \
 "
RDEPENDS:python3-libnbd = " \
 bash \
 glibc \
 gnutls \
 libnbd \
 libxml2 \
 python3 \
 "
