# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBIx-ContextualFetch"
PV = "1.03"
PR = "56.el10_2"
PACKAGES = " \
 perl-DBIx-ContextualFetch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-DBIx-ContextualFetch-1.03-56.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b3b6ba316ffce55f4139d4c978ee83b319bbfef68236121dca23fc0b0d24a27c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DBIx-ContextualFetch-1.03-56.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DBIx-ContextualFetch;unpack=0"
SRC_URI[x86_64_v2_perl-DBIx-ContextualFetch.sha256sum] = "e56c968ecf9d123d51d6d01137c6559a7115498cad5ec9a32ec8adc547064a4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DBIx-ContextualFetch-1.03-56.el10_2.noarch.rpm;name=aarch64_perl-DBIx-ContextualFetch;unpack=0"
SRC_URI[aarch64_perl-DBIx-ContextualFetch.sha256sum] = "9ee98de2d95cef25f9f644d5c18f82dd4046bd3005f97f014b241472e3e61f7b"

RDEPENDS:perl-DBIx-ContextualFetch = " \
 perl-DBI \
 perl-base \
 perl-libs \
 "
