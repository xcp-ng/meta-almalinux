# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rapidyaml"
PV = "0.7.2"
PR = "3.el10_0"
PACKAGES = " \
 python3-rapidyaml \
 rapidyaml \
 rapidyaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rapidyaml-0.7.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8856729ab42da337007476d0cdc539ca8e53bea5997830f1ae133c9ecd0ebdc"

URI_x86_64_v2_python3-rapidyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rapidyaml-0.7.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rapidyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rapidyaml}"
SRC_URI[x86_64_v2_python3-rapidyaml.sha256sum] = "ec4b1d000fd059cc2e760cc0126c32257f909462b083d76c3143087adb5041b8"

URI_x86_64_v2_rapidyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidyaml-0.7.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rapidyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidyaml}"
SRC_URI[x86_64_v2_rapidyaml.sha256sum] = "ec9f52458bcc83998a0aec18faf0203e7026e6989283ce2ef6dd188c4f4ff4d1"

URI_x86_64_v2_rapidyaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rapidyaml-devel-0.7.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rapidyaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rapidyaml-devel}"
SRC_URI[x86_64_v2_rapidyaml-devel.sha256sum] = "76c6cfc720bbad1cc08a928dd8b5b11ae74398f7988e10476fba4abb7ed0d726"

URI_aarch64_python3-rapidyaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rapidyaml-0.7.2-3.el10_0.aarch64.rpm;name=aarch64_python3-rapidyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rapidyaml}"
SRC_URI[aarch64_python3-rapidyaml.sha256sum] = "a17055343d7560c428949939a6103782a6d7e2251c399b21dcf91a02ae61f8b3"

URI_aarch64_rapidyaml = "${EPEL_MIRROR}/aarch64/Packages/r/rapidyaml-0.7.2-3.el10_0.aarch64.rpm;name=aarch64_rapidyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidyaml}"
SRC_URI[aarch64_rapidyaml.sha256sum] = "7d5cf11701060b3d75937e54ea13bb20d57c58d452840de161cd118c381f987c"

URI_aarch64_rapidyaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rapidyaml-devel-0.7.2-3.el10_0.aarch64.rpm;name=aarch64_rapidyaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rapidyaml-devel}"
SRC_URI[aarch64_rapidyaml-devel.sha256sum] = "82aacd5638cea9637954413754ba673bdefa48a87e020096ffc170e3192ea969"

RDEPENDS:python3-rapidyaml = " \
 c4core \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-deprecation \
 "
RDEPENDS:rapidyaml = " \
 c4core \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:rapidyaml-devel = " \
 c4core-devel \
 cmake-filesystem \
 rapidyaml \
 "
