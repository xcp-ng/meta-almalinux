# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MouseX-Types"
PV = "0.06"
PR = "34.el10_0"
PACKAGES = " \
 perl-MouseX-Types \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MouseX-Types-0.06-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ee8c69510d5928711f08c96e1c381d92e6687950c1168b6fc517563981612b1"

URI_x86_64_v2_perl-MouseX-Types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MouseX-Types-0.06-34.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MouseX-Types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MouseX-Types}"
SRC_URI[x86_64_v2_perl-MouseX-Types.sha256sum] = "9ddf751746b094d597f7ddecdc1d573403d37412d171642931c7efec627a2d85"

URI_aarch64_perl-MouseX-Types = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MouseX-Types-0.06-34.el10_0.noarch.rpm;name=aarch64_perl-MouseX-Types;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MouseX-Types}"
SRC_URI[aarch64_perl-MouseX-Types.sha256sum] = "330df80d09a1ddeae067888e33f3f06160157edd72ffc6b5cd85e2791c948dfd"

RDEPENDS:perl-MouseX-Types = " \
 perl-Carp \
 perl-Mouse \
 perl-MouseX-Types \
 perl-constant \
 perl-libs \
 "
