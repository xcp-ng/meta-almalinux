# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "btop"
PV = "1.4.7"
PR = "1.el10_2"
PACKAGES = " \
 btop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/btop-1.4.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71f49fa456d566fab6253644f3f903966a77419c2384439a12cf4fcc1cc2ec05"

URI_x86_64_v2_btop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/btop-1.4.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_btop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_btop}"
SRC_URI[x86_64_v2_btop.sha256sum] = "1e4bbcdae7787119f5d5b1cda8474822cd98b76d4b6086f59ed81fb549b53cb7"

URI_aarch64_btop = "${EPEL_MIRROR}/aarch64/Packages/b/btop-1.4.7-1.el10_2.aarch64.rpm;name=aarch64_btop;unpack=0"
SRC_URI:append = " ${URI_aarch64_btop}"
SRC_URI[aarch64_btop.sha256sum] = "56928f09e7b8bdd4320c1a67b8562269376540548a3bc8a70d538f9744c936f4"

RDEPENDS:btop = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 "
