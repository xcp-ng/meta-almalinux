# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs26"
PE = "1"
PV = "26.8.2"
PR = "1.el10"
PACKAGES = " \
 nodejs26 \
 nodejs26-devel \
 nodejs26-docs \
 nodejs26-full-i18n \
 nodejs26-libs \
 nodejs26-npm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs26-26.8.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e0b3e517fa01f95ef92326a54652ad382c3684804e8faf48138a45bc37bcc9d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs26-26.8.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs26;unpack=0"
SRC_URI[x86_64_v2_nodejs26.sha256sum] = "42fa5613fa44bd06f5f2672634b683b20f6168f1df00ade8d46e6769c5bc0715"
RPROVIDES:nodejs26:append:x86_64_v2 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs26-devel-26.8.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs26-devel;unpack=0"
SRC_URI[x86_64_v2_nodejs26-devel.sha256sum] = "fad8f5b4c679424dac92e4a81c08c0aaba270e36bd1b48639eee1b474883c457"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs26-docs-26.8.2-1.el10.noarch.rpm;name=x86_64_v2_nodejs26-docs;unpack=0"
SRC_URI[x86_64_v2_nodejs26-docs.sha256sum] = "374b874b1c31e787f9b526f3348c1f4e5d6639295369a2a48c5b941e61e6d102"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs26-full-i18n-26.8.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs26-full-i18n;unpack=0"
SRC_URI[x86_64_v2_nodejs26-full-i18n.sha256sum] = "9d3c6f5b02031f4ae621fea78a1a9fc0fc00934488da479a52185d49c92e70a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs26-libs-26.8.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_nodejs26-libs;unpack=0"
SRC_URI[x86_64_v2_nodejs26-libs.sha256sum] = "68a708653f0675fd363906d94a9b59860f64738b82cb48fadf5ce199535c3776"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs26-npm-11.19.1-1.26.8.2.1.el10.noarch.rpm;name=x86_64_v2_nodejs26-npm;unpack=0"
SRC_URI[x86_64_v2_nodejs26-npm.sha256sum] = "210d3173190c6b8b2341108ece4046d41ffe34fc8f3cb009ca6515933b862801"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs26-26.8.2-1.el10.aarch64.rpm;name=aarch64_nodejs26;unpack=0"
SRC_URI[aarch64_nodejs26.sha256sum] = "a17043b9a173e65ff793c8771cfb8541d6d9bd3456d96297f904a24b30e922c0"
RPROVIDES:nodejs26:append:aarch64 = " virtual/nodejs_engine_ virtual/nodejs_engine__ge_0.8.0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs26-devel-26.8.2-1.el10.aarch64.rpm;name=aarch64_nodejs26-devel;unpack=0"
SRC_URI[aarch64_nodejs26-devel.sha256sum] = "31bd3ff2857a01cd4568e22284b770b1301b491904cdb9318ef1dad6146eda95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs26-docs-26.8.2-1.el10.noarch.rpm;name=aarch64_nodejs26-docs;unpack=0"
SRC_URI[aarch64_nodejs26-docs.sha256sum] = "374b874b1c31e787f9b526f3348c1f4e5d6639295369a2a48c5b941e61e6d102"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs26-full-i18n-26.8.2-1.el10.aarch64.rpm;name=aarch64_nodejs26-full-i18n;unpack=0"
SRC_URI[aarch64_nodejs26-full-i18n.sha256sum] = "dea73a3af9f70ca2b32bed2dc6dd3da9c309ff2d4ae7698b2973f636ed24d00b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs26-libs-26.8.2-1.el10.aarch64.rpm;name=aarch64_nodejs26-libs;unpack=0"
SRC_URI[aarch64_nodejs26-libs.sha256sum] = "bf6982883fa0fc529baa027a4201a324572d6bb5fe38b61db8c392d8941c15dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs26-npm-11.19.1-1.26.8.2.1.el10.noarch.rpm;name=aarch64_nodejs26-npm;unpack=0"
SRC_URI[aarch64_nodejs26-npm.sha256sum] = "210d3173190c6b8b2341108ece4046d41ffe34fc8f3cb009ca6515933b862801"

RDEPENDS:nodejs26 = " \
 ca-certificates \
 glibc \
 nodejs26-libs \
 "
RDEPENDS:nodejs26-devel = " \
 brotli-devel \
 nodejs-packaging \
 nodejs26 \
 nodejs26-libs \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs26-docs = " \
 nodejs26 \
 "
RDEPENDS:nodejs26-full-i18n = " \
 nodejs26 \
 "
RDEPENDS:nodejs26-libs = " \
 c-ares \
 glibc \
 libatomic \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs26-npm = " \
 bash \
 nodejs26 \
 "
