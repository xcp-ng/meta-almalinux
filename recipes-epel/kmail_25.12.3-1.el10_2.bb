# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmail"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kmail \
 kmail-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmail-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86ec1ef4ff40dc7e7c37bbe4063b01cff467795c6fbf580ea6774e63e72df7f9"

URI_x86_64_v2_kmail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail}"
SRC_URI[x86_64_v2_kmail.sha256sum] = "b9a7caa3e5677bd761ded99cb5ac2decf92bd4c051d7990f18498ddda0d2f7e1"

URI_x86_64_v2_kmail-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmail-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmail-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmail-libs}"
SRC_URI[x86_64_v2_kmail-libs.sha256sum] = "d3c4de878cef9398d723107b4a560c089de578bf0be6bd7c199db2f95412acc2"

URI_aarch64_kmail = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail}"
SRC_URI[aarch64_kmail.sha256sum] = "101fffee9296cdb366a6cf9cd8558f43fb8c718335dfa753649bc478bc39bada"

URI_aarch64_kmail-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kmail-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kmail-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmail-libs}"
SRC_URI[aarch64_kmail-libs.sha256sum] = "a2a3851485b0e56f6b02d24b59aa005f13668350ed5d2b706352cff00c0c5ce3"

RDEPENDS:kmail = " \
 akonadi-import-wizard \
 akonadi-mime \
 akonadi-server \
 glibc \
 grantlee-editor \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmail-account-wizard \
 kmail-libs \
 kmailtransport \
 kmime \
 kontactinterface \
 ktnef \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib \
 pim-data-exporter \
 pim-sieve-editor \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:kmail-libs = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgmepp \
 kcalutils \
 kf6-kbookmarks \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 kidentitymanagement \
 kldap \
 kmail \
 kmailtransport \
 kmime \
 kontactinterface \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgpg-error \
 libgravatar \
 libkdepim \
 libkleo \
 libksieve \
 libstdc++ \
 mailcommon \
 messagelib \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qtkeychain-qt6 \
 "
