# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "roundcubemail"
PV = "1.6.18"
PR = "1.el10_2"
PACKAGES = " \
 roundcubemail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/roundcubemail-1.6.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9dea3ae24227d1fb96f204f636a55c55641dee3ba7ae245881d385877df6040"

URI_x86_64_v2_roundcubemail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/roundcubemail-1.6.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_roundcubemail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_roundcubemail}"
SRC_URI[x86_64_v2_roundcubemail.sha256sum] = "3c7d236527925708c25c643904bc70b9c2935b579644e09113c7ed6f64cf5a9b"

URI_aarch64_roundcubemail = "${EPEL_MIRROR}/aarch64/Packages/r/roundcubemail-1.6.18-1.el10_2.noarch.rpm;name=aarch64_roundcubemail;unpack=0"
SRC_URI:append = " ${URI_aarch64_roundcubemail}"
SRC_URI[aarch64_roundcubemail.sha256sum] = "13d180d921e9381197b4a1ca714303bb152d9c5aa8c926b8de9810fe1cb74004"

RDEPENDS:roundcubemail = " \
 bash \
 httpd-filesystem \
 mailcap \
 nginx-filesystem \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-date \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-hash \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-libxml \
 virtual/php-mbstring \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-posix \
 virtual/php-reflection \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-sockets \
 virtual/php-spl \
 virtual/php-tokenizer \
 virtual/php-zip \
 virtual/php_httpd_ \
 virtual/php_language__ge_7.3 \
 virtual/webserver \
 "
