# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-rpm-macros"
PV = "1.3.7"
PR = "1.el10_1"
PACKAGES = " \
 R-rpm-macros \
 R-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-rpm-macros-1.3.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0fb800ba50666a936eb08061e73c82cfe4581e83f1ad24ed95cb39770b92290"

URI_x86_64_v2_R-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-rpm-macros-1.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_R-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-rpm-macros}"
SRC_URI[x86_64_v2_R-rpm-macros.sha256sum] = "2d0cbebde4bec2cd6cbb6e47d3719c330c942045dc78880b6e56c562208d1011"

URI_x86_64_v2_R-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-srpm-macros-1.3.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_R-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-srpm-macros}"
SRC_URI[x86_64_v2_R-srpm-macros.sha256sum] = "e2998029ca9312b8489228e4663e6967238028c0bd43607ed749a3f1bf8ab5ca"

URI_aarch64_R-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/r/R-rpm-macros-1.3.7-1.el10_1.noarch.rpm;name=aarch64_R-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-rpm-macros}"
SRC_URI[aarch64_R-rpm-macros.sha256sum] = "217a6296c16c8809494dd263f0631090b4b734c354dd85d16a9416fda13e2bcf"

URI_aarch64_R-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/r/R-srpm-macros-1.3.7-1.el10_1.noarch.rpm;name=aarch64_R-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-srpm-macros}"
SRC_URI[aarch64_R-srpm-macros.sha256sum] = "d5fb07078c4119c006cb37d13159fdd3910e06fb42d3fbd58ce007892cbba262"

RDEPENDS:R-rpm-macros = " \
 R-core \
 R-srpm-macros \
 rpm \
 "
RDEPENDS:R-srpm-macros = " \
 redhat-rpm-config \
 "
