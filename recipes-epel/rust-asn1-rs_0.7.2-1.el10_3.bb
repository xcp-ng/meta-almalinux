# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1-rs"
PV = "0.7.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-asn1-rs+bigint-devel \
 rust-asn1-rs+bits-devel \
 rust-asn1-rs+bitvec-devel \
 rust-asn1-rs+colored-devel \
 rust-asn1-rs+cookie-factory-devel \
 rust-asn1-rs+datetime-devel \
 rust-asn1-rs+debug-devel \
 rust-asn1-rs+default-devel \
 rust-asn1-rs+num-bigint-devel \
 rust-asn1-rs+serialize-devel \
 rust-asn1-rs+std-devel \
 rust-asn1-rs+time-devel \
 rust-asn1-rs+trace-devel \
 rust-asn1-rs-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-rs-0.7.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e167d78e1b955c5efa866c9df5bcdcfed2aa637ab8cb37293f45387a7ee849cf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bigint-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bigint-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+bigint-devel.sha256sum] = "8cc0de23e0f7362430862697d04686d1f201ad1fc2dea3a551021a74928bcc19"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bits-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bits-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+bits-devel.sha256sum] = "8f71c218f45dc9e76baa0c3c6b94f8e6af6a58b7215abcbf243a55be1a22a05a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+bitvec-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+bitvec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+bitvec-devel.sha256sum] = "548a1162a64ad6322213f3ad8c3e8fe508d15072ff7fd4c22e5b512ec1601ad7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+colored-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+colored-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+colored-devel.sha256sum] = "1289908dc70c7cc481f68c299284a9391afa4cfd4223adbcc98b7050e3c650cb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+cookie-factory-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+cookie-factory-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+cookie-factory-devel.sha256sum] = "ad20fdd6f9dd8ef2ac17b566f8f759e5ba48cb9dc35145d1f92684d0a76ec9be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+datetime-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+datetime-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+datetime-devel.sha256sum] = "78c38cabe7f13a0d628fa121a7ffdd58ab2e2c378f8a001c4d5e6005abdd51ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+debug-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+debug-devel.sha256sum] = "4246c24b7262c61fb7eb0b192cfe416798760383c1f6be521c2f0abf7caf6a78"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+default-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+default-devel.sha256sum] = "ac65c2a5ce210f655af70af9421b2515424c15f47a063a066e1da7c0e92cce50"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+num-bigint-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+num-bigint-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+num-bigint-devel.sha256sum] = "e5af4876a63c9ec573622906947a222472cca49513a9d14fe4b85c00d85068e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+serialize-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+serialize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+serialize-devel.sha256sum] = "ffaadb3c41a75018fdc16406f6e8a767e974999b9df5a6cc6e2654bd629bc844"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+std-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+std-devel.sha256sum] = "eb3c4453f722bc76e187472099a5db70ede235810812a6eda24a596913862c30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+time-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+time-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+time-devel.sha256sum] = "809a5ecb35c32f6d2c0ab2ca706dea0cd3649ada91a6f19ae53c32a5a17294f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs+trace-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs+trace-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs+trace-devel.sha256sum] = "251e2aca4f27b72f69f5c532329b08798042e19a3874bc588ac0a5f3e3d87803"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-rs-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-rs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-asn1-rs-devel.sha256sum] = "72d1c37a4254b0a06861350d2c12238599ee7fa50970875d200706a44a2b7bcd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bigint-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+bigint-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+bigint-devel.sha256sum] = "84e159a9c62d9ed40aa55f0cfa7db8c529185d2055507b54086ac17fac35a508"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bits-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+bits-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+bits-devel.sha256sum] = "72d8e212f5323c59f4eb7586369e78b4ff815f458777db0c23bc7c296cc297dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+bitvec-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+bitvec-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+bitvec-devel.sha256sum] = "db68c25c4382ca5c1a45356ffde41dea41c005778620931994439af6ad9f3d83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+colored-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+colored-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+colored-devel.sha256sum] = "770310a8041fb8ef48c3033233010b836776c9bf718d4fd0e1b0cef4dd3ee2a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+cookie-factory-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+cookie-factory-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+cookie-factory-devel.sha256sum] = "1367d9a0ad0abb37d64d7ea5a15a21b8fc9d71162975029485e0d724080149e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+datetime-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+datetime-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+datetime-devel.sha256sum] = "880131aaa3d8dfc4feee5b968aa5e9c215d189d43ab4899cd13f5a2312928ebc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+debug-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+debug-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+debug-devel.sha256sum] = "e14b6dced70cb78ffb6882ec16c8860ead3e2f786e1c465b3f6d1c5380046ff9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+default-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+default-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+default-devel.sha256sum] = "13443196543379a7eb72d1730eac2d49fc7893e45fd7b8847bf3225da92ca31d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+num-bigint-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+num-bigint-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+num-bigint-devel.sha256sum] = "9d6811e6ea0977d6ee979d14e24de60fa7884aae36faec9ae0ffe1022f987445"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+serialize-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+serialize-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+serialize-devel.sha256sum] = "546c06d81966bd994f80f9606ed085e987930f68f8afa8a763bd317027a78840"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+std-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+std-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+std-devel.sha256sum] = "a51d043223e699d2431b60ed8bafc5d512eebdeeafa22661af331d10a78cb789"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+time-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+time-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+time-devel.sha256sum] = "df42154b9e79181e5e7d0818e7685151746bd21c240f4a1e312ecdd486938917"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs+trace-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs+trace-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs+trace-devel.sha256sum] = "1fa2eee0e062b8403665045c8869d8f1c1388bf2fa18f7ebf562aac11dbd2f92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-rs-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-asn1-rs-devel;unpack=0"
SRC_URI[aarch64_rust-asn1-rs-devel.sha256sum] = "550532c47355436e8f4fc130feabae48f1cf34de3a8ae41752da916baae28328"

RDEPENDS:rust-asn1-rs+bigint-devel = " \
 cargo \
 rust-asn1-rs+num-bigint-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+bits-devel = " \
 cargo \
 rust-asn1-rs+bitvec-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+bitvec-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-bitvec+default-devel \
 "
RDEPENDS:rust-asn1-rs+colored-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-colored+default-devel \
 "
RDEPENDS:rust-asn1-rs+cookie-factory-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-cookie-factory+default-devel \
 "
RDEPENDS:rust-asn1-rs+datetime-devel = " \
 cargo \
 rust-asn1-rs+time-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+debug-devel = " \
 cargo \
 rust-asn1-rs+colored-devel \
 rust-asn1-rs+std-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+default-devel = " \
 cargo \
 rust-asn1-rs+std-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+num-bigint-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-num-bigint+default-devel \
 "
RDEPENDS:rust-asn1-rs+serialize-devel = " \
 cargo \
 rust-asn1-rs+cookie-factory-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+std-devel = " \
 cargo \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs+time-devel = " \
 cargo \
 rust-asn1-rs-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 "
RDEPENDS:rust-asn1-rs+trace-devel = " \
 cargo \
 rust-asn1-rs+debug-devel \
 rust-asn1-rs-devel \
 "
RDEPENDS:rust-asn1-rs-devel = " \
 cargo \
 rust \
 rust-asn1-rs-derive+default-devel \
 rust-asn1-rs-impl+default-devel \
 rust-displaydoc+default-devel \
 rust-nom7+std-devel \
 rust-nom7-devel \
 rust-num-traits+default-devel \
 rust-rusticata-macros+default-devel \
 rust-thiserror+default-devel \
 "
