# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgeography"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kgeography \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgeography-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b165ed59dcdf3fc07e22f2bb94431ba060fff1d5f64b8849739f42e63b59655"

URI_x86_64_v2_kgeography = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgeography-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgeography;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgeography}"
SRC_URI[x86_64_v2_kgeography.sha256sum] = "30066836b41843cb19eb395f77547c4f045b84e929bcaabe093e06fa1d0b9d87"

URI_aarch64_kgeography = "${EPEL_MIRROR}/aarch64/Packages/k/kgeography-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kgeography;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgeography}"
SRC_URI[aarch64_kgeography.sha256sum] = "cfdce9ea9865724a662ad9e94817cc8dab8d9dd3171bd2fbbdc0fb78188ee25b"

RDEPENDS:kgeography = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
