# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plexus-languages"
PV = "1.2.0"
PR = "7.el10"
PACKAGES = " \
 plexus-languages \
 plexus-languages-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/plexus-languages-1.2.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c974da31c8f9c095eaf69cce92e06087ce094dc917d62ecb8ffb85f4a48de9da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-languages-1.2.0-7.el10.noarch.rpm;name=x86_64_v2_plexus-languages;unpack=0"
SRC_URI[x86_64_v2_plexus-languages.sha256sum] = "8d1d4bae56bd942203aa0bfd2c44a6be5a661b62525f137f6b3ad582b47b68cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plexus-languages-javadoc-1.2.0-7.el10.noarch.rpm;name=x86_64_v2_plexus-languages-javadoc;unpack=0"
SRC_URI[x86_64_v2_plexus-languages-javadoc.sha256sum] = "0ec1cbcfe6278ca6fbb6d5632afa971f3e1a9026288daca080f7e9cc6053c07b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-languages-1.2.0-7.el10.noarch.rpm;name=aarch64_plexus-languages;unpack=0"
SRC_URI[aarch64_plexus-languages.sha256sum] = "8d1d4bae56bd942203aa0bfd2c44a6be5a661b62525f137f6b3ad582b47b68cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plexus-languages-javadoc-1.2.0-7.el10.noarch.rpm;name=aarch64_plexus-languages-javadoc;unpack=0"
SRC_URI[aarch64_plexus-languages-javadoc.sha256sum] = "0ec1cbcfe6278ca6fbb6d5632afa971f3e1a9026288daca080f7e9cc6053c07b"

RDEPENDS:plexus-languages = " \
 javapackages-filesystem \
 objectweb-asm \
 qdox \
 "
RDEPENDS:plexus-languages-javadoc = " \
 javapackages-filesystem \
 "
