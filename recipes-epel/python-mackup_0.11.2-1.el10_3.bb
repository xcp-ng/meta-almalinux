# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mackup"
PV = "0.11.2"
PR = "1.el10_3"
PACKAGES = " \
 mackup \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-mackup-0.11.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b664955d83dce5cec354c6e1ed4f65c600faef27d4ad7daf1b37250a5a521aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mackup-0.11.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mackup;unpack=0"
SRC_URI[x86_64_v2_mackup.sha256sum] = "3df93c6b506a84a62ebe7c2ce7ebe7d36055792c5d493a34f22e64597ca68378"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mackup-0.11.2-1.el10_3.noarch.rpm;name=aarch64_mackup;unpack=0"
SRC_URI[aarch64_mackup.sha256sum] = "e6c01c23104afd1b821df008b80d143c16672dcd94c367f56509918c0023f361"

RDEPENDS:mackup = " \
 procps-ng \
 python3 \
 python3-docopt-ng \
 "
