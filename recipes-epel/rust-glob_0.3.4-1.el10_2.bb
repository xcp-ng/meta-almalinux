# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-glob"
PV = "0.3.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-glob+default-devel \
 rust-glob-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-glob-0.3.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10d096ddc7b309a8bdeec0617814810760c0067d0e91411b1c7df1505dfe90d7"

URI_x86_64_v2_rust-glob+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-glob+default-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-glob+default-devel}"
SRC_URI[x86_64_v2_rust-glob+default-devel.sha256sum] = "ab874ca9288604ffe5847ecbd55649ad57215f07310bdd1f769d9893010b8a67"

URI_x86_64_v2_rust-glob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-glob-devel-0.3.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-glob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-glob-devel}"
SRC_URI[x86_64_v2_rust-glob-devel.sha256sum] = "49ccbaa024e2777dfc54579fbb8bd9b1c2f4d438c5a8cfceb7dee4d8051b14f7"

URI_aarch64_rust-glob+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-glob+default-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-glob+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-glob+default-devel}"
SRC_URI[aarch64_rust-glob+default-devel.sha256sum] = "615c24956a0fe7639a7b8ca00593de35ecee56e429e5fbf529b8b5999ec54cbc"

URI_aarch64_rust-glob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-glob-devel-0.3.4-1.el10_2.noarch.rpm;name=aarch64_rust-glob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-glob-devel}"
SRC_URI[aarch64_rust-glob-devel.sha256sum] = "9478d69f4321286d5de970c66106c0e69f7a8c035317b6ad6105651e89b91fba"

RDEPENDS:rust-glob+default-devel = " \
 cargo \
 rust-glob-devel \
 "
RDEPENDS:rust-glob-devel = " \
 cargo \
 rust \
 "
