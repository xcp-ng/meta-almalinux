# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedpkg"
PV = "1.47"
PR = "5.el10_2"
PACKAGES = " \
 fedpkg \
 fedpkg-completion \
 fedpkg-stage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedpkg-1.47-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e936b0366c746f16c961a18f6d7c133c7e1db7b66de2571126af4a4549b83f8a"

URI_x86_64_v2_fedpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-1.47-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedpkg}"
SRC_URI[x86_64_v2_fedpkg.sha256sum] = "c1553af29058974e20ac5628bafaf8d4591b6d4b10f4dfe805a2efff36b14c40"

URI_x86_64_v2_fedpkg-completion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-completion-1.47-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedpkg-completion}"
SRC_URI[x86_64_v2_fedpkg-completion.sha256sum] = "904e15061d69cccae9d53340cb9a1085c12a67f3495a0dee67c0d4bc935f46ad"

URI_x86_64_v2_fedpkg-stage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-stage-1.47-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg-stage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedpkg-stage}"
SRC_URI[x86_64_v2_fedpkg-stage.sha256sum] = "32588fc3d99ad84ba8c116004cf429b27086a8cea9c9cde26eb5963cb9123097"

URI_aarch64_fedpkg = "${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-1.47-5.el10_2.noarch.rpm;name=aarch64_fedpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedpkg}"
SRC_URI[aarch64_fedpkg.sha256sum] = "c939fb6a49a15e437630fe8f1ba0540da6b8544fd1cdf763865876502d0cb15e"

URI_aarch64_fedpkg-completion = "${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-completion-1.47-5.el10_2.noarch.rpm;name=aarch64_fedpkg-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedpkg-completion}"
SRC_URI[aarch64_fedpkg-completion.sha256sum] = "5c770b0977008497724d4182b05085f01aa279a1341c25049ce7c82d64f0e1a6"

URI_aarch64_fedpkg-stage = "${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-stage-1.47-5.el10_2.noarch.rpm;name=aarch64_fedpkg-stage;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedpkg-stage}"
SRC_URI[aarch64_fedpkg-stage.sha256sum] = "ab5a50ce732b6d1c2e40b8a03afbbfe07d7d99ca24a30040ad759b4a18971457"

RDEPENDS:fedpkg = " \
 bodhi-client \
 koji \
 python3 \
 python3-argcomplete \
 python3-bugzilla \
 python3-distro \
 python3-openidc-client \
 python3-rpkg \
 redhat-rpm-config \
 "
RDEPENDS:fedpkg-completion = " \
 fedpkg \
 "
RDEPENDS:fedpkg-stage = " \
 fedpkg \
 python3 \
 "
