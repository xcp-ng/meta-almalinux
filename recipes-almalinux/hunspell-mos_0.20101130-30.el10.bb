# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-mos"
PV = "0.20101130"
PR = "30.el10"
PACKAGES = " \
 hunspell-mos \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-mos-0.20101130-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de49fbaa2c9742d370c224e70fb6014dd1e25e6dd2688b4f3c937fdbd965c9b0"

URI_x86_64_v2_hunspell-mos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-mos-0.20101130-30.el10.noarch.rpm;name=x86_64_v2_hunspell-mos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-mos}"
SRC_URI[x86_64_v2_hunspell-mos.sha256sum] = "77644b02e928a25c8a474980dfef23c1859b9266dd336b71ec311db93121b458"

URI_aarch64_hunspell-mos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-mos-0.20101130-30.el10.noarch.rpm;name=aarch64_hunspell-mos;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-mos}"
SRC_URI[aarch64_hunspell-mos.sha256sum] = "77644b02e928a25c8a474980dfef23c1859b9266dd336b71ec311db93121b458"

RDEPENDS:hunspell-mos = " \
 hunspell-filesystem \
 "
