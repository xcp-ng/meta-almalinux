# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_datetime0.7"
PV = "0.7.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-toml_datetime0.7+alloc-devel \
 rust-toml_datetime0.7+default-devel \
 rust-toml_datetime0.7+serde-devel \
 rust-toml_datetime0.7+std-devel \
 rust-toml_datetime0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_datetime0.7-0.7.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d7d284bfc6ad557975479ced7bbfda1f8820ea269d79835f5849a674c571fb0"

URI_x86_64_v2_rust-toml_datetime0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime0.7+alloc-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime0.7+alloc-devel.sha256sum] = "44c0f83a297020471989562e9794afde4ddaf6c2fcbd094fe6daacd5d7d6bfc5"

URI_x86_64_v2_rust-toml_datetime0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime0.7+default-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime0.7+default-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime0.7+default-devel.sha256sum] = "b18e9fa4cfc138f446ed27c718aa6187e45abaf30a506ac8049f43e21f0a5243"

URI_x86_64_v2_rust-toml_datetime0.7+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime0.7+serde-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime0.7+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime0.7+serde-devel.sha256sum] = "3fe96773bc3ca6ba53b202fba58dba36d57c849eb7d79a9ad308980d12c4f404"

URI_x86_64_v2_rust-toml_datetime0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime0.7+std-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime0.7+std-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime0.7+std-devel.sha256sum] = "a241382e36ea9a5c0bfbc160d7127404f4c53e67754c9451f4116932601e7d7a"

URI_x86_64_v2_rust-toml_datetime0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_datetime0.7-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_datetime0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_datetime0.7-devel}"
SRC_URI[x86_64_v2_rust-toml_datetime0.7-devel.sha256sum] = "922bf2ca637ea61a2ea932a1f7136f8568924ae05c0913739a158a8e7b254abb"

URI_aarch64_rust-toml_datetime0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime0.7+alloc-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime0.7+alloc-devel}"
SRC_URI[aarch64_rust-toml_datetime0.7+alloc-devel.sha256sum] = "7aab13ca206d1de101b04a23a71bb5b7ba17706ae34eb1beb370d073af287f92"

URI_aarch64_rust-toml_datetime0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime0.7+default-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime0.7+default-devel}"
SRC_URI[aarch64_rust-toml_datetime0.7+default-devel.sha256sum] = "75c5bdd5f3efe195072336a7bc6e486c50d90d83d378548e02a58d5bdb78d811"

URI_aarch64_rust-toml_datetime0.7+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime0.7+serde-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime0.7+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime0.7+serde-devel}"
SRC_URI[aarch64_rust-toml_datetime0.7+serde-devel.sha256sum] = "bc4c90814bd334a663e3bc53de5d9f7b79ddfbf44437a0f1205df0b0d37dec2b"

URI_aarch64_rust-toml_datetime0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime0.7+std-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime0.7+std-devel}"
SRC_URI[aarch64_rust-toml_datetime0.7+std-devel.sha256sum] = "4e55c3550910f62bb0d631c5ccc4b6552fd2264b7d6c39ae7a9d57dd1eee246f"

URI_aarch64_rust-toml_datetime0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_datetime0.7-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-toml_datetime0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_datetime0.7-devel}"
SRC_URI[aarch64_rust-toml_datetime0.7-devel.sha256sum] = "6510b7e1b6dcfacc1b2d21e1349ebf511f39b344efb0ee57b2f5054eef4e374f"

RDEPENDS:rust-toml_datetime0.7+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-toml_datetime0.7-devel \
 "
RDEPENDS:rust-toml_datetime0.7+default-devel = " \
 cargo \
 rust-toml_datetime0.7+std-devel \
 rust-toml_datetime0.7-devel \
 "
RDEPENDS:rust-toml_datetime0.7+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-toml_datetime0.7-devel \
 "
RDEPENDS:rust-toml_datetime0.7+std-devel = " \
 cargo \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-toml_datetime0.7+alloc-devel \
 rust-toml_datetime0.7-devel \
 "
RDEPENDS:rust-toml_datetime0.7-devel = " \
 cargo \
 rust \
 "
