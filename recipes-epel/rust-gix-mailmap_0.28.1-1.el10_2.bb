# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-mailmap"
PV = "0.28.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-mailmap+default-devel \
 rust-gix-mailmap+document-features-devel \
 rust-gix-mailmap+serde-devel \
 rust-gix-mailmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-mailmap-0.28.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "752e1ab6648a1539751ca79abac26a9936d5f51514d4d070ff119be7748a3872"

URI_x86_64_v2_rust-gix-mailmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+default-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+default-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+default-devel.sha256sum] = "565ffcb59b4bebbd548968da7b8b97f162b3ca65e35d5401cec865c7807c7c5c"

URI_x86_64_v2_rust-gix-mailmap+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+document-features-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+document-features-devel.sha256sum] = "197e55244002edd8c23c873f0b9bb61cdfcbb05d8b4599f865f13e2d53d26aac"

URI_x86_64_v2_rust-gix-mailmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+serde-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+serde-devel.sha256sum] = "635b4c05d6c1699de90d03be427af65f8247832f82e150618aac50bc16a8c2b3"

URI_x86_64_v2_rust-gix-mailmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap-devel-0.28.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap-devel.sha256sum] = "090fa71fe591e0b46c50e999b90b061b300768135196645f40b8ad347398aca7"

URI_aarch64_rust-gix-mailmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+default-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-mailmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+default-devel}"
SRC_URI[aarch64_rust-gix-mailmap+default-devel.sha256sum] = "27c376fd233435c63896f56302464778481fb0c6e2d21f42bdd93a22731c4f8d"

URI_aarch64_rust-gix-mailmap+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+document-features-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-mailmap+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+document-features-devel}"
SRC_URI[aarch64_rust-gix-mailmap+document-features-devel.sha256sum] = "b44577c007db2c22d5f9d3f4078ca6b7bfdd6bc7e4fe1da92a972eb4b137d33f"

URI_aarch64_rust-gix-mailmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+serde-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-mailmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+serde-devel}"
SRC_URI[aarch64_rust-gix-mailmap+serde-devel.sha256sum] = "cadbff0eb6bd7c74767e8e40572485815dc0c24c31e2d1d0019778c11b675920"

URI_aarch64_rust-gix-mailmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap-devel-0.28.1-1.el10_2.noarch.rpm;name=aarch64_rust-gix-mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap-devel}"
SRC_URI[aarch64_rust-gix-mailmap-devel.sha256sum] = "c8ab07f4baaa2844ec240534c584906d7e2cde32702f10f1237d1e61be58aa65"

RDEPENDS:rust-gix-mailmap+default-devel = " \
 cargo \
 rust-gix-mailmap-devel \
 "
RDEPENDS:rust-gix-mailmap+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-mailmap-devel \
 "
RDEPENDS:rust-gix-mailmap+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor+serde-devel \
 rust-gix-mailmap-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-mailmap-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-actor+default-devel \
 rust-gix-date+default-devel \
 rust-thiserror+default-devel \
 "
