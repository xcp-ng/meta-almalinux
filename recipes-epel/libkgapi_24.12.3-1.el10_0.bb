# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkgapi"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkgapi \
 libkgapi-devel \
 libkgapi-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkgapi-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fab9311328b9bcbe499647728f927ef0db47bc8eb03bbbf1c245bda58e61a52"

URI_x86_64_v2_libkgapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi}"
SRC_URI[x86_64_v2_libkgapi.sha256sum] = "6c8cb1c953762243a760f2853a228669b6be2cc3c9b217f82fa278a8076199fe"

URI_x86_64_v2_libkgapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi-devel}"
SRC_URI[x86_64_v2_libkgapi-devel.sha256sum] = "17270ca75ac9e092564bf78882c316e3464b242d9c6412743d3795a44b492c4c"

URI_x86_64_v2_libkgapi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libkgapi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi-doc}"
SRC_URI[x86_64_v2_libkgapi-doc.sha256sum] = "d45e49ee793470604c5ab315dc551f2c684300b6ff107428d58da7c4dc5a2288"

URI_aarch64_libkgapi = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkgapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi}"
SRC_URI[aarch64_libkgapi.sha256sum] = "3922aa2dda85ee33420944065e91d6bbb40bbf1f92c944f1be2f4f2c746eb34e"

URI_aarch64_libkgapi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkgapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi-devel}"
SRC_URI[aarch64_libkgapi-devel.sha256sum] = "fa36a43d66e91f3c0ab211926cacd199fdef6577b18b16106198bcba810f365b"

URI_aarch64_libkgapi-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_libkgapi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi-doc}"
SRC_URI[aarch64_libkgapi-doc.sha256sum] = "df317662cc874677bec62e74f253ce16a19f69a261fcce1f7d5cbc44093540ed"

RDEPENDS:libkgapi = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kwallet-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkgapi-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 libkgapi \
 "
RDEPENDS:libkgapi-doc = " \
 "
