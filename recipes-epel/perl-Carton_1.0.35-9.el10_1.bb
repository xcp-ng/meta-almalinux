# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Carton"
PV = "1.0.35"
PR = "9.el10_1"
PACKAGES = " \
 perl-Carton \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Carton-1.0.35-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9bc298a462075068fcaa30e1f6cd22c7f4af4de36741c77cc85cc455283eed1"

URI_x86_64_v2_perl-Carton = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Carton-1.0.35-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Carton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Carton}"
SRC_URI[x86_64_v2_perl-Carton.sha256sum] = "7e298b80984251d57b23743093ba809c79b4a9abae0faaabf708eec3543a023c"

URI_aarch64_perl-Carton = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Carton-1.0.35-9.el10_1.noarch.rpm;name=aarch64_perl-Carton;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Carton}"
SRC_URI[aarch64_perl-Carton.sha256sum] = "b809dcc5775ef463d2ad0121f39a3a484f605b58fe96410d12bd1ca07486ac61"

RDEPENDS:perl-Carton = " \
 perl-App-FatPacker \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Carp \
 perl-Carton \
 perl-Class-Tiny \
 perl-File-Find \
 perl-File-pushd \
 perl-Getopt-Long \
 perl-JSON-PP \
 perl-Menlo-Legacy \
 perl-Module-CPANfile \
 perl-Module-CoreList \
 perl-Path-Tiny \
 perl-Scalar-List-Utils \
 perl-Try-Tiny \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-parent \
 perl-subs \
 perl-version \
 "
