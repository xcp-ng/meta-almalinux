# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dcw-gmt"
PV = "2.2.0"
PR = "2.el10_0"
PACKAGES = " \
 dcw-gmt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dcw-gmt-2.2.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76ae12121dab1a22a1d5aab515d728dbdd28a1195891bd6c9d50dd70d3bd9d83"

URI_x86_64_v2_dcw-gmt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dcw-gmt-2.2.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dcw-gmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dcw-gmt}"
SRC_URI[x86_64_v2_dcw-gmt.sha256sum] = "ea7975e3caa404ad89e87b1a30057e651c453a426164ac5f901855d2fc3adc00"

URI_aarch64_dcw-gmt = "${EPEL_MIRROR}/aarch64/Packages/d/dcw-gmt-2.2.0-2.el10_0.noarch.rpm;name=aarch64_dcw-gmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_dcw-gmt}"
SRC_URI[aarch64_dcw-gmt.sha256sum] = "c77afaba6cff3e9e3c836826f93de4bd10aeaa4d8fbd08b610a8b2b8df6d0da3"

RDEPENDS:dcw-gmt = " \
 "
