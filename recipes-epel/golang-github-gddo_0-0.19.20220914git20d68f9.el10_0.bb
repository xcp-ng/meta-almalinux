# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gddo"
PV = "0"
PR = "0.19.20220914git20d68f9.el10_0"
PACKAGES = " \
 golang-github-gddo-httputil-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gddo-0-0.19.20220914git20d68f9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c98b604777f21cfede0927022e1c2cc55f89a94f8689271a7d583d1fd944f194"

URI_aarch64_golang-github-gddo-httputil-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gddo-httputil-devel-0-0.19.20220914git20d68f9.el10_0.noarch.rpm;name=aarch64_golang-github-gddo-httputil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gddo-httputil-devel}"
SRC_URI[aarch64_golang-github-gddo-httputil-devel.sha256sum] = "4223735a96b738d7a90e72291fc21d304a3c0f1448bfc1c191e58865c69c7b9f"

RDEPENDS:golang-github-gddo-httputil-devel = " \
 go-filesystem \
 "
