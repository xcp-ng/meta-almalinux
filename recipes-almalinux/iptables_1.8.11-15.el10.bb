# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iptables"
PV = "1.8.11"
PR = "15.el10"
PACKAGES = " \
 iptables-devel \
 iptables-libs \
 iptables-nft \
 iptables-nft-services \
 iptables-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iptables-1.8.11-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e21792fb4cbcd6c34cb116d770e22fc1b8a0c13d3b53e337f2023ccf237244b6"

URI_x86_64_v2_iptables-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-devel-1.8.11-15.el10.x86_64_v2.rpm;name=x86_64_v2_iptables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-devel}"
SRC_URI[x86_64_v2_iptables-devel.sha256sum] = "b8af49f67ddf6039f281a296a630aed77e7c2376391915f34bcea917271f5013"

URI_x86_64_v2_iptables-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iptables-libs-1.8.11-15.el10.x86_64_v2.rpm;name=x86_64_v2_iptables-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-libs}"
SRC_URI[x86_64_v2_iptables-libs.sha256sum] = "9064b54c9eeeadd895505363c862c79fa7009c17556f26dac8de924f7747a894"

URI_x86_64_v2_iptables-nft = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-1.8.11-15.el10.x86_64_v2.rpm;name=x86_64_v2_iptables-nft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-nft}"
SRC_URI[x86_64_v2_iptables-nft.sha256sum] = "c977288357e2e899b0f36d5236a121aa540a8ca9f319d5d5d07603c58b3fa4bc"

URI_x86_64_v2_iptables-nft-services = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-services-1.8.11-15.el10.noarch.rpm;name=x86_64_v2_iptables-nft-services;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-nft-services}"
SRC_URI[x86_64_v2_iptables-nft-services.sha256sum] = "08cbebda99fc912769170f87bc6ff01c7f57633cd278ef773c1f7af5a7b1afb9"

URI_x86_64_v2_iptables-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-utils-1.8.11-15.el10.x86_64_v2.rpm;name=x86_64_v2_iptables-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-utils}"
SRC_URI[x86_64_v2_iptables-utils.sha256sum] = "c939e525935d4703177d6b651c279f6bfcb4abb6e7886f270940c0b37369a112"

URI_aarch64_iptables-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-devel-1.8.11-15.el10.aarch64.rpm;name=aarch64_iptables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-devel}"
SRC_URI[aarch64_iptables-devel.sha256sum] = "b7bf36f492cbd8007c8d0a8c703c0988599f388f6b302f1645674fdab8a05159"

URI_aarch64_iptables-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iptables-libs-1.8.11-15.el10.aarch64.rpm;name=aarch64_iptables-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-libs}"
SRC_URI[aarch64_iptables-libs.sha256sum] = "6e0e80c8e28cf7bcc5571d20d93fa9927d51668f92bd3ea58ad1b3ddea8d4b00"

URI_aarch64_iptables-nft = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-1.8.11-15.el10.aarch64.rpm;name=aarch64_iptables-nft;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-nft}"
SRC_URI[aarch64_iptables-nft.sha256sum] = "b25cd62f632511f6f5f3e160bea2710dd5cdae98756e50847d12dd431d936362"

URI_aarch64_iptables-nft-services = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-services-1.8.11-15.el10.noarch.rpm;name=aarch64_iptables-nft-services;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-nft-services}"
SRC_URI[aarch64_iptables-nft-services.sha256sum] = "08cbebda99fc912769170f87bc6ff01c7f57633cd278ef773c1f7af5a7b1afb9"

URI_aarch64_iptables-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-utils-1.8.11-15.el10.aarch64.rpm;name=aarch64_iptables-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-utils}"
SRC_URI[aarch64_iptables-utils.sha256sum] = "46c29e23311b07deb4ed6cea0e8e69a0df3be3a15a6ba41341c0e95b08bfa802"

RDEPENDS:iptables-devel = " \
 iptables-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:iptables-libs = " \
 glibc \
 libnetfilter_conntrack \
 "
RDEPENDS:iptables-nft = " \
 alternatives \
 bash \
 glibc \
 iptables-libs \
 libmnl \
 libnftnl \
 virtual//usr/bin/readlink \
 "
RDEPENDS:iptables-nft-services = " \
 bash \
 iptables-nft \
 "
RDEPENDS:iptables-utils = " \
 bash \
 glibc \
 iptables-nft \
 libnfnetlink \
 libpcap \
 "
