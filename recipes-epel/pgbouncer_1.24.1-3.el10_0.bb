# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pgbouncer"
PV = "1.24.1"
PR = "3.el10_0"
PACKAGES = " \
 pgbouncer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pgbouncer-1.24.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38e218a74e65d2488b63728462a412770171b92f779b52e4057043996080ef7a"

URI_x86_64_v2_pgbouncer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pgbouncer-1.24.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pgbouncer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pgbouncer}"
SRC_URI[x86_64_v2_pgbouncer.sha256sum] = "3db6641ea9aeef400c898ac783407cc73a7c1ea46529cf87d5295b2cf405c721"

URI_aarch64_pgbouncer = "${EPEL_MIRROR}/aarch64/Packages/p/pgbouncer-1.24.1-3.el10_0.aarch64.rpm;name=aarch64_pgbouncer;unpack=0"
SRC_URI:append = " ${URI_aarch64_pgbouncer}"
SRC_URI[aarch64_pgbouncer.sha256sum] = "ff5b965855a9a89b5ea1a2a32c95613f4aebaa1df5b541680ac146d2782435c7"

RDEPENDS:pgbouncer = " \
 bash \
 c-ares \
 glibc \
 libevent \
 logrotate \
 openssl-libs \
 pam-libs \
 python3 \
 python3-psycopg2 \
 shadow-utils \
 systemd \
 systemd-libs \
 "
