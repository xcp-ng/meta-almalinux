# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "geolite2"
PV = "20191217"
PR = "14.el10"
PACKAGES = " \
 geolite2-city \
 geolite2-country \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/geolite2-20191217-14.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "98e6b1eab8218c180f5e69d6f3388cbff21f556ff9a5cf4422ebf24d92e76eae"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/geolite2-city-20191217-14.el10.noarch.rpm;name=x86_64_v2_geolite2-city;unpack=0"
SRC_URI[x86_64_v2_geolite2-city.sha256sum] = "769f7806429d7ef18c5a5bd97fd93c9ccd3c2512cb154f6529a26016d5a66b67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/geolite2-country-20191217-14.el10.noarch.rpm;name=x86_64_v2_geolite2-country;unpack=0"
SRC_URI[x86_64_v2_geolite2-country.sha256sum] = "a19503a6bf26b243aa926c7648d670654b3e3e0f6d4d9930c9fe208a5d9a6d99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/geolite2-city-20191217-14.el10.noarch.rpm;name=aarch64_geolite2-city;unpack=0"
SRC_URI[aarch64_geolite2-city.sha256sum] = "769f7806429d7ef18c5a5bd97fd93c9ccd3c2512cb154f6529a26016d5a66b67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/geolite2-country-20191217-14.el10.noarch.rpm;name=aarch64_geolite2-country;unpack=0"
SRC_URI[aarch64_geolite2-country.sha256sum] = "a19503a6bf26b243aa926c7648d670654b3e3e0f6d4d9930c9fe208a5d9a6d99"

RDEPENDS:geolite2-city = " \
 "
RDEPENDS:geolite2-country = " \
 "
