# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mccabe"
PV = "0.7.0"
PR = "11.el10_0"
PACKAGES = " \
 python3-mccabe \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mccabe-0.7.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c55a60c941a0300beb18dc16dfb300298de8bbc6606692a36257a5bf2180196"

URI_x86_64_v2_python3-mccabe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mccabe-0.7.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mccabe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mccabe}"
SRC_URI[x86_64_v2_python3-mccabe.sha256sum] = "db6e4088f8b4325a8e7a00a2909acc4b6f2f7ca5f9f5dcbdbae07024c6761acf"

URI_aarch64_python3-mccabe = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mccabe-0.7.0-11.el10_0.noarch.rpm;name=aarch64_python3-mccabe;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mccabe}"
SRC_URI[aarch64_python3-mccabe.sha256sum] = "897825d0ab7b5140d90496e5c4377a0dde1c4a0b4bcc89d893a59773a7e23a11"

RDEPENDS:python3-mccabe = " \
 python3 \
 "
