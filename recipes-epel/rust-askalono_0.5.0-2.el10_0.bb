# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-askalono"
PV = "0.5.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-askalono+default-devel \
 rust-askalono+flate2-devel \
 rust-askalono+gzip-devel \
 rust-askalono+serde_json-devel \
 rust-askalono+spdx-devel \
 rust-askalono-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-askalono-0.5.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca21e8aecd622fe5850db476125036d8e91eb505a831a2011cf6c7c261b7f370"

URI_x86_64_v2_rust-askalono+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-askalono+default-devel-0.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-askalono+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-askalono+default-devel}"
SRC_URI[x86_64_v2_rust-askalono+default-devel.sha256sum] = "8c09978ea86bc34ee89d800ae452004128826119ab70d7b47f65aa1021903420"

URI_x86_64_v2_rust-askalono+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-askalono+flate2-devel-0.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-askalono+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-askalono+flate2-devel}"
SRC_URI[x86_64_v2_rust-askalono+flate2-devel.sha256sum] = "92fb8d8bdc4933ad90e2e99910a114fa5c369be0771147a4e229144e3e7e146a"

URI_x86_64_v2_rust-askalono+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-askalono+gzip-devel-0.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-askalono+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-askalono+gzip-devel}"
SRC_URI[x86_64_v2_rust-askalono+gzip-devel.sha256sum] = "bd362ecf0670696dc8a582fac9c1030d192db696322f8ffe642fd4533f56df94"

URI_x86_64_v2_rust-askalono+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-askalono+serde_json-devel-0.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-askalono+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-askalono+serde_json-devel}"
SRC_URI[x86_64_v2_rust-askalono+serde_json-devel.sha256sum] = "960cfdb1be15738eee94202126d14abea9960291da4af2830ae426878e37a009"

URI_x86_64_v2_rust-askalono+spdx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-askalono+spdx-devel-0.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-askalono+spdx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-askalono+spdx-devel}"
SRC_URI[x86_64_v2_rust-askalono+spdx-devel.sha256sum] = "ad520924c47f528ac8e9c29a7778fc4ffde6b2f281bb9ec663f9a5a01b9acecc"

URI_x86_64_v2_rust-askalono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-askalono-devel-0.5.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-askalono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-askalono-devel}"
SRC_URI[x86_64_v2_rust-askalono-devel.sha256sum] = "fce83ded24d947019fd09ba1bd339a44e02f82540b6362de74b810a56780a2e2"

URI_aarch64_rust-askalono+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-askalono+default-devel-0.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-askalono+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-askalono+default-devel}"
SRC_URI[aarch64_rust-askalono+default-devel.sha256sum] = "9e8bd50c852894fb409bfd53bf242b206f2ecdd72651e4cdc6594f67a17efb97"

URI_aarch64_rust-askalono+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-askalono+flate2-devel-0.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-askalono+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-askalono+flate2-devel}"
SRC_URI[aarch64_rust-askalono+flate2-devel.sha256sum] = "4e04e3b5af881b060b8bb537f81dd80204d421f6176dcc71ab66c77740cb5eee"

URI_aarch64_rust-askalono+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-askalono+gzip-devel-0.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-askalono+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-askalono+gzip-devel}"
SRC_URI[aarch64_rust-askalono+gzip-devel.sha256sum] = "54c30546376fe9c283d515bf11357fa8cc843620ece4c396758ec984c6fcfe5a"

URI_aarch64_rust-askalono+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-askalono+serde_json-devel-0.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-askalono+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-askalono+serde_json-devel}"
SRC_URI[aarch64_rust-askalono+serde_json-devel.sha256sum] = "a30cffc0e65bd1fb36a6b8ac94ae107e2efaaa5aa58e7e62c2c2cb4474942ede"

URI_aarch64_rust-askalono+spdx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-askalono+spdx-devel-0.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-askalono+spdx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-askalono+spdx-devel}"
SRC_URI[aarch64_rust-askalono+spdx-devel.sha256sum] = "42633c35dbec2a763dca64f8b4f9cf536d275d0674cf8304af0c5fccdd847fc8"

URI_aarch64_rust-askalono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-askalono-devel-0.5.0-2.el10_0.noarch.rpm;name=aarch64_rust-askalono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-askalono-devel}"
SRC_URI[aarch64_rust-askalono-devel.sha256sum] = "1a51265ff55a18f1c2ca2074bc3a18e3f7f5322856f44734005efbeab390d915"

RDEPENDS:rust-askalono+default-devel = " \
 cargo \
 rust-askalono+spdx-devel \
 rust-askalono-devel \
 "
RDEPENDS:rust-askalono+flate2-devel = " \
 cargo \
 rust-askalono-devel \
 rust-flate2+default-devel \
 "
RDEPENDS:rust-askalono+gzip-devel = " \
 cargo \
 rust-askalono+flate2-devel \
 rust-askalono-devel \
 "
RDEPENDS:rust-askalono+serde_json-devel = " \
 cargo \
 rust-askalono-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-askalono+spdx-devel = " \
 cargo \
 rust-askalono+serde_json-devel \
 rust-askalono-devel \
 "
RDEPENDS:rust-askalono-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-lazy_static+default-devel \
 rust-log+default-devel \
 rust-rayon+default-devel \
 rust-regex+default-devel \
 rust-rmp-serde+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-unicode-normalization+default-devel \
 rust-zstd+default-devel \
 "
