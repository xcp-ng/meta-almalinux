# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miniz_oxide"
PV = "0.8.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-miniz_oxide+block-boundary-devel \
 rust-miniz_oxide+default-devel \
 rust-miniz_oxide+serde-devel \
 rust-miniz_oxide+simd-adler32-devel \
 rust-miniz_oxide+simd-devel \
 rust-miniz_oxide+std-devel \
 rust-miniz_oxide+with-alloc-devel \
 rust-miniz_oxide-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-miniz_oxide-0.8.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "464c2db2d4a8f1057da15b27a56a03e2944f5bece40cdb83049458b606a65d02"

URI_x86_64_v2_rust-miniz_oxide+block-boundary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+block-boundary-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+block-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+block-boundary-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+block-boundary-devel.sha256sum] = "dba72504f56d1e1e49e9462afb6970cab2c2778647df044520bd283fd31676fd"

URI_x86_64_v2_rust-miniz_oxide+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+default-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+default-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+default-devel.sha256sum] = "9cf1ce061d615d2869ce37724ee8585e50c5016589ae94d2e8592bea6e42894e"

URI_x86_64_v2_rust-miniz_oxide+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+serde-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+serde-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+serde-devel.sha256sum] = "1734cf362bcace78bb3d44142eb01260479fea41e6c5851d0c7b424f4395960e"

URI_x86_64_v2_rust-miniz_oxide+simd-adler32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+simd-adler32-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+simd-adler32-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+simd-adler32-devel.sha256sum] = "64dcf37762a0217725f22c7908a2352397876fd3a79074eefb9986a711d82bfa"

URI_x86_64_v2_rust-miniz_oxide+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+simd-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+simd-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+simd-devel.sha256sum] = "73155c8a5477fe603254363cda824eacd92171e9bbe170bb846b8861f01aff49"

URI_x86_64_v2_rust-miniz_oxide+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+std-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+std-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+std-devel.sha256sum] = "9e6ee3577ede5489f4ea5affe493c1211bef66b6d06f3fd60ac2df94ab9706a5"

URI_x86_64_v2_rust-miniz_oxide+with-alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+with-alloc-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+with-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+with-alloc-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+with-alloc-devel.sha256sum] = "e69884466370e78273d0292eff5869c117d4a33755c7cf57289dd495654d5a60"

URI_x86_64_v2_rust-miniz_oxide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide-devel.sha256sum] = "830db248b2d541d5d8e8bf959cf0c942e75dacf8253cd91a29b88cddf2a21700"

URI_aarch64_rust-miniz_oxide+block-boundary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+block-boundary-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide+block-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+block-boundary-devel}"
SRC_URI[aarch64_rust-miniz_oxide+block-boundary-devel.sha256sum] = "0a7d210c828aa0e71f4ae1a7b9067f4200e945140198db16bbd3aa8cf5a560ad"

URI_aarch64_rust-miniz_oxide+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+default-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+default-devel}"
SRC_URI[aarch64_rust-miniz_oxide+default-devel.sha256sum] = "09dcfe8ea6c7e508d2abdcd3889ed50e1c033390e61ed734cca096d9096e28e9"

URI_aarch64_rust-miniz_oxide+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+serde-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+serde-devel}"
SRC_URI[aarch64_rust-miniz_oxide+serde-devel.sha256sum] = "633e1aa5f3e04ee89beac2197c12df0e575021c96e0ebe5aff7801f043569d80"

URI_aarch64_rust-miniz_oxide+simd-adler32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+simd-adler32-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+simd-adler32-devel}"
SRC_URI[aarch64_rust-miniz_oxide+simd-adler32-devel.sha256sum] = "abef29c18a3b0b1f457282daa4f4f1a088f924d5cd52279fb09d867d23c10da4"

URI_aarch64_rust-miniz_oxide+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+simd-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+simd-devel}"
SRC_URI[aarch64_rust-miniz_oxide+simd-devel.sha256sum] = "694421320d00b82a4be51eac94ee39d462c4798c075dcbdfdc9278e002ce3b50"

URI_aarch64_rust-miniz_oxide+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+std-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+std-devel}"
SRC_URI[aarch64_rust-miniz_oxide+std-devel.sha256sum] = "37240a72c80e9f51cd1ccea6e69fd8ef48a6a8c0513a3da380eefc8a79eb8b9c"

URI_aarch64_rust-miniz_oxide+with-alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+with-alloc-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide+with-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+with-alloc-devel}"
SRC_URI[aarch64_rust-miniz_oxide+with-alloc-devel.sha256sum] = "5c13d2e95d55b6d1ac63d481b499f8d3f47dbee8d3b5e290f7113859f16626eb"

URI_aarch64_rust-miniz_oxide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide-devel}"
SRC_URI[aarch64_rust-miniz_oxide-devel.sha256sum] = "0797ef4fb86ec7347b18df37c75b74e05d53f54b39cd294a110ee3053671ca69"

RDEPENDS:rust-miniz_oxide+block-boundary-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+default-devel = " \
 cargo \
 rust-miniz_oxide+with-alloc-devel \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+serde-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-miniz_oxide+simd-adler32-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-miniz_oxide+simd-devel = " \
 cargo \
 rust-miniz_oxide+simd-adler32-devel \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+std-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+with-alloc-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide-devel = " \
 cargo \
 rust-adler2-devel \
 "
