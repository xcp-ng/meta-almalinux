# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-native-tls"
PV = "0.2.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-native-tls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-native-tls-0.2.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "873074889f9415fe3a88215e6312dfea25b8986e1e930bab8fe61c3ae4b3d1c7"

URI_x86_64_v2_rust-native-tls+alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls+alpn-devel-0.2.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls+alpn-devel}"
SRC_URI[x86_64_v2_rust-native-tls+alpn-devel.sha256sum] = "fb26d9f39f59a3ff326c24847af2617629597edf1a1ad860fdff270f8e6f4ba9"

URI_x86_64_v2_rust-native-tls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls+default-devel-0.2.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls+default-devel}"
SRC_URI[x86_64_v2_rust-native-tls+default-devel.sha256sum] = "d72c29e99b4ad003e8f5dc443e3f4a7d9313e3ded12a40ddc88f1033fb519dbb"

URI_x86_64_v2_rust-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls-devel-0.2.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls-devel}"
SRC_URI[x86_64_v2_rust-native-tls-devel.sha256sum] = "7afb7851b1a027c813b120a20ea7d39df75dd1aabf6fe3bb3c0d1f2b42baebd5"

URI_aarch64_rust-native-tls+alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls+alpn-devel-0.2.14-1.el10_0.noarch.rpm;name=aarch64_rust-native-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls+alpn-devel}"
SRC_URI[aarch64_rust-native-tls+alpn-devel.sha256sum] = "14ac2eb883b30a3eda883025f265dd23bcea0c3e35d08b46ae3cc9fb7c26e74e"

URI_aarch64_rust-native-tls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls+default-devel-0.2.14-1.el10_0.noarch.rpm;name=aarch64_rust-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls+default-devel}"
SRC_URI[aarch64_rust-native-tls+default-devel.sha256sum] = "7362ae96ffa64e9b38bac28bed818ba456edb2f89e956562aca11f92a94f16d8"

URI_aarch64_rust-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls-devel-0.2.14-1.el10_0.noarch.rpm;name=aarch64_rust-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls-devel}"
SRC_URI[aarch64_rust-native-tls-devel.sha256sum] = "8d547b5a472e1544e53fa72c93a040aac8abc7fae16357b0e0811ec3926e7a35"

RDEPENDS:rust-native-tls+alpn-devel = " \
 cargo \
 rust-native-tls-devel \
 "
RDEPENDS:rust-native-tls+default-devel = " \
 cargo \
 rust-native-tls-devel \
 "
RDEPENDS:rust-native-tls-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-openssl+default-devel \
 rust-openssl-probe+default-devel \
 rust-openssl-sys+default-devel \
 "
