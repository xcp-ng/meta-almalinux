# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-dev-scripts"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kde-dev-scripts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-dev-scripts-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aff37c9101cef1b96281612dd5af7f297df35d0a1ab30d0e266043b6f4ab596d"

URI_x86_64_v2_kde-dev-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-scripts-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kde-dev-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-scripts}"
SRC_URI[x86_64_v2_kde-dev-scripts.sha256sum] = "d2a2dc68c98245edb84061bb19549e695bfec859cbe0b5d3c7fc8fd8154f2179"

URI_aarch64_kde-dev-scripts = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-scripts-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kde-dev-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-scripts}"
SRC_URI[aarch64_kde-dev-scripts.sha256sum] = "c2594c7f1a34fb07ee4bdee9fcf2b4da4aca06629c9ef73a414bdfe0c808f966"

RDEPENDS:kde-dev-scripts = " \
 advancecomp \
 bash \
 optipng \
 perl-Data-Dumper \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Term-ANSIColor \
 perl-Time-Local \
 perl-XML-DOM \
 perl-constant \
 perl-interpreter \
 perl-libs \
 python3 \
 "
