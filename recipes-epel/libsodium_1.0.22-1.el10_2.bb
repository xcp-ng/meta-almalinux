# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsodium"
PV = "1.0.22"
PR = "1.el10_2"
PACKAGES = " \
 libsodium \
 libsodium-devel \
 libsodium-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libsodium-1.0.22-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c9d42c9db9ab8fbe076749b857ddf0abc06191be42674de1eca60dfb2a1da21"

URI_x86_64_v2_libsodium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-1.0.22-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsodium}"
SRC_URI[x86_64_v2_libsodium.sha256sum] = "4b8095772d5fda5c9b80119fa8eb0408629c7f428b7cf66ccbf5fc8c665797db"

URI_x86_64_v2_libsodium-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-devel-1.0.22-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsodium-devel}"
SRC_URI[x86_64_v2_libsodium-devel.sha256sum] = "abbc5b0054bb6d9997ed190cafe2f723f4f7af2def43846a0dc56994005d390b"

URI_x86_64_v2_libsodium-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-static-1.0.22-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsodium-static}"
SRC_URI[x86_64_v2_libsodium-static.sha256sum] = "a9868001414ac43d2d4b6454b00b9e0ee81ff23a9de849715efd9ec309a34c90"

URI_aarch64_libsodium = "${EPEL_MIRROR}/aarch64/Packages/l/libsodium-1.0.22-1.el10_2.aarch64.rpm;name=aarch64_libsodium;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsodium}"
SRC_URI[aarch64_libsodium.sha256sum] = "e4ade03ef108a8cd75cad9dd5ded4f76a14c66475b7cd55b8570e88cb5286c91"

URI_aarch64_libsodium-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsodium-devel-1.0.22-1.el10_2.aarch64.rpm;name=aarch64_libsodium-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsodium-devel}"
SRC_URI[aarch64_libsodium-devel.sha256sum] = "80c24229adb8396e025e9f5f32d8a17ccf07a0626e0c336112ff3e834ab243ac"

URI_aarch64_libsodium-static = "${EPEL_MIRROR}/aarch64/Packages/l/libsodium-static-1.0.22-1.el10_2.aarch64.rpm;name=aarch64_libsodium-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsodium-static}"
SRC_URI[aarch64_libsodium-static.sha256sum] = "d90d091a7164089a760af46a1e057386f3f0684c63632f294ff2137d3e620f47"

RDEPENDS:libsodium = " \
 glibc \
 "
RDEPENDS:libsodium-devel = " \
 libsodium \
 pkgconf-pkg-config \
 "
RDEPENDS:libsodium-static = " \
 libsodium-devel \
 "
