# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "testssl"
PV = "3.2.3"
PR = "1.el10_1"
PACKAGES = " \
 testssl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/testssl-3.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68fa9d495f00c0179ffb750d1a5b926e3bd862ef491b37ac3cee739fa16bb2e0"

URI_x86_64_v2_testssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/testssl-3.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_testssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_testssl}"
SRC_URI[x86_64_v2_testssl.sha256sum] = "66f264621baecdd43d7fabf7b929d2a4cd871a9bd050681c7e502169cd0f9a83"

URI_aarch64_testssl = "${EPEL_MIRROR}/aarch64/Packages/t/testssl-3.2.3-1.el10_1.noarch.rpm;name=aarch64_testssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_testssl}"
SRC_URI[aarch64_testssl.sha256sum] = "11fa6c7dafe5c171e1576f188589b16f652eeda3f8311cf81691d8b77849cdeb"

RDEPENDS:testssl = " \
 bash \
 bind-utils \
 ca-certificates \
 gawk \
 glibc-common \
 grep \
 hostname \
 ncurses \
 openssl \
 procps-ng \
 sed \
 util-linux \
 virtual/coreutils \
 "
