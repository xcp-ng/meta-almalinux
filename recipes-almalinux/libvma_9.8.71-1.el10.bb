# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvma"
PV = "9.8.71"
PR = "1.el10"
PACKAGES = " \
 libvma \
 libvma-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvma-9.8.71-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "108d1308f807d985d24a00412ab866ad637f0d87be23bbba6b758a779f7477b3"

URI_x86_64_v2_libvma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvma-9.8.71-1.el10.x86_64_v2.rpm;name=x86_64_v2_libvma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvma}"
SRC_URI[x86_64_v2_libvma.sha256sum] = "4daca9452d7caac86d51dd4950566adbf1077a73b653abe714db4fd8ad060a53"

URI_x86_64_v2_libvma-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvma-utils-9.8.71-1.el10.x86_64_v2.rpm;name=x86_64_v2_libvma-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvma-utils}"
SRC_URI[x86_64_v2_libvma-utils.sha256sum] = "4d1da48512913c4c5c4f62cde36360e6fb8afa9914cf403dbceff586ee32f460"

URI_aarch64_libvma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvma-9.8.71-1.el10.aarch64.rpm;name=aarch64_libvma;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvma}"
SRC_URI[aarch64_libvma.sha256sum] = "beb30ec1c482a85741bb2053e74fe9471b2cc76e11ebafa592a92a17c9af3d3d"

URI_aarch64_libvma-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvma-utils-9.8.71-1.el10.aarch64.rpm;name=aarch64_libvma-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvma-utils}"
SRC_URI[aarch64_libvma-utils.sha256sum] = "3d706019f01dced624e72e9705cdd81f8492ad451a60038e4d0f7f46ba645438"

RDEPENDS:libvma = " \
 bash \
 glibc \
 libgcc \
 libibverbs \
 libnl3 \
 librdmacm \
 libstdc++ \
 "
RDEPENDS:libvma-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 libvma \
 "
