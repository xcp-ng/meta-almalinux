# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-alloc-no-stdlib"
PV = "2.0.4"
PR = "4.el10_0"
PACKAGES = " \
 rust-alloc-no-stdlib+default-devel \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-alloc-no-stdlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-alloc-no-stdlib-2.0.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27a60989b488e486b419bdd0a1675c5de1d38ea87ce03d68375086c353b84ede"

URI_x86_64_v2_rust-alloc-no-stdlib+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-no-stdlib+default-devel-2.0.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-no-stdlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alloc-no-stdlib+default-devel}"
SRC_URI[x86_64_v2_rust-alloc-no-stdlib+default-devel.sha256sum] = "2ad08cbb60e8c62d647a66c33a86c413f256593ec220ca6e730b51e6f93f2715"

URI_x86_64_v2_rust-alloc-no-stdlib+unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-no-stdlib+unsafe-devel-2.0.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-no-stdlib+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alloc-no-stdlib+unsafe-devel}"
SRC_URI[x86_64_v2_rust-alloc-no-stdlib+unsafe-devel.sha256sum] = "83b3750c71ca5d54992ab6f8665664a80d7119bd540035bb827878dcb21d13e3"

URI_x86_64_v2_rust-alloc-no-stdlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-no-stdlib-devel-2.0.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-no-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alloc-no-stdlib-devel}"
SRC_URI[x86_64_v2_rust-alloc-no-stdlib-devel.sha256sum] = "0f4b3435eb426d09d57f197b7adbed9812937da3d636b415ce7fd066c78efd3f"

URI_aarch64_rust-alloc-no-stdlib+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-no-stdlib+default-devel-2.0.4-4.el10_0.noarch.rpm;name=aarch64_rust-alloc-no-stdlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alloc-no-stdlib+default-devel}"
SRC_URI[aarch64_rust-alloc-no-stdlib+default-devel.sha256sum] = "999a42233681f72777928cb21e21bf654ea1b8d28a63948305ddb5cf57601d61"

URI_aarch64_rust-alloc-no-stdlib+unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-no-stdlib+unsafe-devel-2.0.4-4.el10_0.noarch.rpm;name=aarch64_rust-alloc-no-stdlib+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alloc-no-stdlib+unsafe-devel}"
SRC_URI[aarch64_rust-alloc-no-stdlib+unsafe-devel.sha256sum] = "c0088d04f2bcd1bc6f996eeccc3b3f7fcd0ec9b7771dcc118e49022ad7c060c7"

URI_aarch64_rust-alloc-no-stdlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-no-stdlib-devel-2.0.4-4.el10_0.noarch.rpm;name=aarch64_rust-alloc-no-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alloc-no-stdlib-devel}"
SRC_URI[aarch64_rust-alloc-no-stdlib-devel.sha256sum] = "bbf36fc39c91bd24dab384a0db819db06a2a255c784139002789801107944a5e"

RDEPENDS:rust-alloc-no-stdlib+default-devel = " \
 cargo \
 rust-alloc-no-stdlib-devel \
 "
RDEPENDS:rust-alloc-no-stdlib+unsafe-devel = " \
 cargo \
 rust-alloc-no-stdlib-devel \
 "
RDEPENDS:rust-alloc-no-stdlib-devel = " \
 cargo \
 "
