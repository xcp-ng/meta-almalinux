# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-File-ShareDir"
PV = "1.001002"
PR = "23.el10_0"
PACKAGES = " \
 perl-Test-File-ShareDir \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-File-ShareDir-1.001002-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "476e0366abb6c2cd6b3ebea44b9a356e5aee7d6365f4c187c616ae880ae3d6e3"

URI_x86_64_v2_perl-Test-File-ShareDir = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-File-ShareDir-1.001002-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-File-ShareDir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-File-ShareDir}"
SRC_URI[x86_64_v2_perl-Test-File-ShareDir.sha256sum] = "7afffccd5c6fa89a513ea23aff101bddf7895e04e538684176a8d37d3d8cf152"

URI_aarch64_perl-Test-File-ShareDir = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-File-ShareDir-1.001002-23.el10_0.noarch.rpm;name=aarch64_perl-Test-File-ShareDir;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-File-ShareDir}"
SRC_URI[aarch64_perl-Test-File-ShareDir.sha256sum] = "775939231852d1bc61f8a201d3e3a70e232aeb3036b769fc73e6929380373732"

RDEPENDS:perl-Test-File-ShareDir = " \
 perl-Carp \
 perl-Class-Tiny \
 perl-Exporter \
 perl-File-Copy-Recursive \
 perl-File-ShareDir \
 perl-Path-Tiny \
 perl-Scope-Guard \
 perl-Test-File-ShareDir \
 perl-libs \
 perl-parent \
 "
