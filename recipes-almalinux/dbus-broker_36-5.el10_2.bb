# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus-broker"
PV = "36"
PR = "5.el10_2"
PACKAGES = " \
 dbus-broker \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dbus-broker-36-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c1c6107be7d9e40ea697bd21fee34a9d857626c97660082114f585906420a64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-broker-36-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_dbus-broker;unpack=0"
SRC_URI[x86_64_v2_dbus-broker.sha256sum] = "ca4c4f50a0b7bdcfd554135474fea98369c780e0b7328c94935247d36c173267"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-broker-36-5.el10_2.aarch64.rpm;name=aarch64_dbus-broker;unpack=0"
SRC_URI[aarch64_dbus-broker.sha256sum] = "869133a12538b9ce4725486d6dd0cb6e15401e6630fb3081a3974c9c6aee5866"

RDEPENDS:dbus-broker = " \
 audit-libs \
 bash \
 dbus-common \
 expat \
 glibc \
 libcap-ng \
 libgcc \
 libselinux \
 systemd-libs \
 "
