# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-partd"
PV = "1.4.2"
PR = "3.el10_0"
PACKAGES = " \
 python3-partd \
 python3-partd+complete \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-partd-1.4.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16cf6c57e2ed15e31c583541a1998d7edf0cbadbc1ce69eed35b3ad6569e33ea"

URI_x86_64_v2_python3-partd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-partd-1.4.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-partd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-partd}"
SRC_URI[x86_64_v2_python3-partd.sha256sum] = "a5fed6f7dc9650cab1401a4a5a0774f9f96f7b0be2607cec613f9d793c81c8b0"

URI_x86_64_v2_python3-partd+complete = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-partd+complete-1.4.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-partd+complete;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-partd+complete}"
SRC_URI[x86_64_v2_python3-partd+complete.sha256sum] = "600b06c2b9a8c410f0d1644f6d0283b1ecf32c46ccd5defc2c19ff7185ddacbb"

URI_aarch64_python3-partd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-partd-1.4.2-3.el10_0.noarch.rpm;name=aarch64_python3-partd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-partd}"
SRC_URI[aarch64_python3-partd.sha256sum] = "d299e41dcd19022a9f1d6149616b91f7cd553351af4e5bbb53ca152515ba34c7"

URI_aarch64_python3-partd+complete = "${EPEL_MIRROR}/aarch64/Packages/p/python3-partd+complete-1.4.2-3.el10_0.noarch.rpm;name=aarch64_python3-partd+complete;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-partd+complete}"
SRC_URI[aarch64_python3-partd+complete.sha256sum] = "cc49b889dae7cdbee4a840c8c7786ceabdc15f3f32ab60b3c392ffea52cb32cb"

RDEPENDS:python3-partd = " \
 python3 \
 python3-locket \
 python3-toolz \
 "
RDEPENDS:python3-partd+complete = " \
 python3 \
 python3-blosc \
 python3-numpy \
 python3-pandas \
 python3-partd \
 python3-pyzmq \
 "
