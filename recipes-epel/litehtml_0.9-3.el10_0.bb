# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "litehtml"
PV = "0.9"
PR = "3.el10_0"
PACKAGES = " \
 litehtml \
 litehtml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/litehtml-0.9-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07cd47edc4f58949e5f4a7252c8083fb35c727b42d69da7a7f834911227017ec"

URI_x86_64_v2_litehtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/litehtml-0.9-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_litehtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_litehtml}"
SRC_URI[x86_64_v2_litehtml.sha256sum] = "87a9fd98a96315a6323fdb3ed9eb9ffda258fb4ab69f74699ec487e9b7e786e2"

URI_x86_64_v2_litehtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/litehtml-devel-0.9-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_litehtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_litehtml-devel}"
SRC_URI[x86_64_v2_litehtml-devel.sha256sum] = "ade429e44221c92472699c52bc5e14d44d73062bf414de858a4e63ef6ec22bae"

URI_aarch64_litehtml = "${EPEL_MIRROR}/aarch64/Packages/l/litehtml-0.9-3.el10_0.aarch64.rpm;name=aarch64_litehtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_litehtml}"
SRC_URI[aarch64_litehtml.sha256sum] = "ea2d329af4def6ad2017120b84090cab867e5f79e8b0a0e787b1499043cc7747"

URI_aarch64_litehtml-devel = "${EPEL_MIRROR}/aarch64/Packages/l/litehtml-devel-0.9-3.el10_0.aarch64.rpm;name=aarch64_litehtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_litehtml-devel}"
SRC_URI[aarch64_litehtml-devel.sha256sum] = "5660bfc1ef13f946e64744f3f818ba18a86536e05c0397cbb3f8e738e4b7f034"

RDEPENDS:litehtml = " \
 glibc \
 gumbo-parser \
 libgcc \
 libstdc++ \
 "
RDEPENDS:litehtml-devel = " \
 cmake-filesystem \
 gumbo-parser-devel \
 litehtml \
 "
