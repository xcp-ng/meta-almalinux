# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mistifyio-zfs"
PV = "2.1.1"
PR = "18.20220917gitc6a6a34.el10_0"
PACKAGES = " \
 golang-github-mistifyio-zfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mistifyio-zfs-2.1.1-18.20220917gitc6a6a34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19a35ea235149f6bd0179927b1d6260ddcfe3d5cd4913251cf6bb44a54baa6d7"

URI_aarch64_golang-github-mistifyio-zfs-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mistifyio-zfs-devel-2.1.1-18.20220917gitc6a6a34.el10_0.noarch.rpm;name=aarch64_golang-github-mistifyio-zfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mistifyio-zfs-devel}"
SRC_URI[aarch64_golang-github-mistifyio-zfs-devel.sha256sum] = "028c55b0d9ac6109721eee2a98e92d7a4d99d57105db03941f190e3181af2497"

RDEPENDS:golang-github-mistifyio-zfs-devel = " \
 go-filesystem \
 golang-github-google-uuid-devel \
 "
