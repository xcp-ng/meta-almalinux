# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clifm"
PV = "1.26.3"
PR = "1.el10_0"
PACKAGES = " \
 clifm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/clifm-1.26.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "86ba6dd9e0c6189572bbade13e354cf105c720eee95a2c94652f7933db01d85c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clifm-1.26.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clifm;unpack=0"
SRC_URI[x86_64_v2_clifm.sha256sum] = "49af2a9d22ef0343276ec57bd3cc4cf4434bd1e0373e39dcb8532d59f4634dd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/clifm-1.26.3-1.el10_0.aarch64.rpm;name=aarch64_clifm;unpack=0"
SRC_URI[aarch64_clifm.sha256sum] = "13cafa8f399f5280f47d5904c3b396355243e2624d9ff077ad94606e023f99d0"

RDEPENDS:clifm = " \
 bash \
 file-libs \
 glibc \
 hicolor-icon-theme \
 libacl \
 libcap \
 python3 \
 readline \
 "
