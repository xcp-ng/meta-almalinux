# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsmasq"
PV = "2.90"
PR = "7.el10_2.1"
PACKAGES = " \
 dnsmasq \
 dnsmasq-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dnsmasq-2.90-7.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "15e38cc24e02baaa048fb13d71d29b0dbb3998ac603612c873d27a06a776e5e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-2.90-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_dnsmasq;unpack=0"
SRC_URI[x86_64_v2_dnsmasq.sha256sum] = "e32eeca0ab3a3d4bbb668bba1e22dbfcabceca64feb1e6288c4b098ce0d2bfc8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-utils-2.90-7.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_dnsmasq-utils;unpack=0"
SRC_URI[x86_64_v2_dnsmasq-utils.sha256sum] = "e9b6436b2d8897b8a05a04c24bf506299591c2e68a5ee645133a1856ae1a20c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-2.90-7.el10_2.1.aarch64.rpm;name=aarch64_dnsmasq;unpack=0"
SRC_URI[aarch64_dnsmasq.sha256sum] = "2fe4d37787f17c3079023fa88f3d46736e3bc74cea18ab38ac4ab5165db69865"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-utils-2.90-7.el10_2.1.aarch64.rpm;name=aarch64_dnsmasq-utils;unpack=0"
SRC_URI[aarch64_dnsmasq-utils.sha256sum] = "b8e20c85ae210d80ff1c89d0eef47a4805cf545429ed61a6f3081a903ec96f3a"

RDEPENDS:dnsmasq = " \
 bash \
 dbus-libs \
 glibc \
 gmp \
 libidn2 \
 libnetfilter_conntrack \
 nettle \
 "
RDEPENDS:dnsmasq-utils = " \
 glibc \
 "
