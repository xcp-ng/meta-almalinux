# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fixedbitset0.4"
PV = "0.4.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-fixedbitset0.4+default-devel \
 rust-fixedbitset0.4+serde-devel \
 rust-fixedbitset0.4+std-devel \
 rust-fixedbitset0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fixedbitset0.4-0.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea02ae25fe7cd73c6fdd6a25580264b11cb60c2675cfbeab074cd877988d2dfd"

URI_x86_64_v2_rust-fixedbitset0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixedbitset0.4+default-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixedbitset0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixedbitset0.4+default-devel}"
SRC_URI[x86_64_v2_rust-fixedbitset0.4+default-devel.sha256sum] = "9fa98e33c8201ba60efecad40af4b0c29a71b5b8109236c354e5960369a7d1a5"

URI_x86_64_v2_rust-fixedbitset0.4+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixedbitset0.4+serde-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixedbitset0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixedbitset0.4+serde-devel}"
SRC_URI[x86_64_v2_rust-fixedbitset0.4+serde-devel.sha256sum] = "f0bca88f2672d88d2940b8c37a015b2c9492b380fc78b72690c74d97c71e2810"

URI_x86_64_v2_rust-fixedbitset0.4+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixedbitset0.4+std-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixedbitset0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixedbitset0.4+std-devel}"
SRC_URI[x86_64_v2_rust-fixedbitset0.4+std-devel.sha256sum] = "bad5fa9b4b51ddfbf53c437e46ab89964ee67bdc137a6d1f71e48bbe00186da8"

URI_x86_64_v2_rust-fixedbitset0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fixedbitset0.4-devel-0.4.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fixedbitset0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fixedbitset0.4-devel}"
SRC_URI[x86_64_v2_rust-fixedbitset0.4-devel.sha256sum] = "07e5954730c798169b11d524c6c3cd65f95cc80b153ad24e6f4e26e62ac1d3e9"

URI_aarch64_rust-fixedbitset0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixedbitset0.4+default-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-fixedbitset0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixedbitset0.4+default-devel}"
SRC_URI[aarch64_rust-fixedbitset0.4+default-devel.sha256sum] = "bfc74c13bd825b590c4aa83f04720eedace1542fb8baaafbd5f58f939108e658"

URI_aarch64_rust-fixedbitset0.4+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixedbitset0.4+serde-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-fixedbitset0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixedbitset0.4+serde-devel}"
SRC_URI[aarch64_rust-fixedbitset0.4+serde-devel.sha256sum] = "aea39c02729c56b7543c4f92bb6bdced395e8d69cd60050e157fd1b008c7d0ff"

URI_aarch64_rust-fixedbitset0.4+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixedbitset0.4+std-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-fixedbitset0.4+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixedbitset0.4+std-devel}"
SRC_URI[aarch64_rust-fixedbitset0.4+std-devel.sha256sum] = "f3eee71b5031ae559f0a7a64132e023b5790357bf6ffcd3b6845faef38c619c3"

URI_aarch64_rust-fixedbitset0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fixedbitset0.4-devel-0.4.2-1.el10_0.noarch.rpm;name=aarch64_rust-fixedbitset0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fixedbitset0.4-devel}"
SRC_URI[aarch64_rust-fixedbitset0.4-devel.sha256sum] = "3c248442b41923d176d18967a04089ebb7fcb4d965ec46c593098ffeecf75fcd"

RDEPENDS:rust-fixedbitset0.4+default-devel = " \
 cargo \
 rust-fixedbitset0.4+std-devel \
 rust-fixedbitset0.4-devel \
 "
RDEPENDS:rust-fixedbitset0.4+serde-devel = " \
 cargo \
 rust-fixedbitset0.4-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-fixedbitset0.4+std-devel = " \
 cargo \
 rust-fixedbitset0.4-devel \
 "
RDEPENDS:rust-fixedbitset0.4-devel = " \
 cargo \
 "
