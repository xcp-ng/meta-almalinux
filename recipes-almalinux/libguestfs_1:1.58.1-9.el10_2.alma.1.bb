# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libguestfs"
PE = "1"
PV = "1.58.1"
PR = "9.el10_2.alma.1"
PACKAGES = " \
 libguestfs \
 libguestfs-appliance \
 libguestfs-bash-completion \
 libguestfs-devel \
 libguestfs-inspect-icons \
 libguestfs-man-pages-ja \
 libguestfs-man-pages-uk \
 libguestfs-rescue \
 libguestfs-rsync \
 libguestfs-xfs \
 ocaml-libguestfs \
 ocaml-libguestfs-devel \
 perl-Sys-Guestfs \
 python3-libguestfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libguestfs-1.58.1-9.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e5d8db7c4e9432ac05856c2e706ab2b8293cab94856f1ffec853dfa1ebb8db2"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - libguestfs-appliance: augeas-libs
# - libguestfs: augeas-libs(x86-64) >= 1.7.0
# - ocaml-libguestfs-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs-devel: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libguestfs-devel: ocamlx(CamlinternalOO) = 3bb5173e1a86ae74d96d5b3bc80f14a3
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libguestfs: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - libguestfs-appliance: augeas-libs
# - libguestfs: augeas-libs(aarch-64) >= 1.7.0
# - ocaml-libguestfs-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs-devel: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libguestfs-devel: ocamlx(CamlinternalOO) = 3bb5173e1a86ae74d96d5b3bc80f14a3
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libguestfs: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827

URI_x86_64_v2_libguestfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs}"
SRC_URI[x86_64_v2_libguestfs.sha256sum] = "2117fb9aa3ace13dbf9d1650ea76e72c049ea6fa4c4cd08707135275303a32c9"

URI_x86_64_v2_libguestfs-appliance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-appliance-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-appliance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-appliance}"
SRC_URI[x86_64_v2_libguestfs-appliance.sha256sum] = "20b00fcbba7f871884c080bca7f23e923968d5e644b76c73e4c01ccc8ab394fc"

URI_x86_64_v2_libguestfs-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-bash-completion-1.58.1-9.el10_2.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-bash-completion}"
SRC_URI[x86_64_v2_libguestfs-bash-completion.sha256sum] = "510c509fba7953bc988f60c38c1fb10511553b4cd35909d1dfb36bc39dc6f397"

URI_x86_64_v2_libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-devel-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-devel}"
SRC_URI[x86_64_v2_libguestfs-devel.sha256sum] = "cfa577ec45e0d972fa008988eb177d3aae1a99a59d4f83ebbef081223f8248af"

URI_x86_64_v2_libguestfs-inspect-icons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-inspect-icons-1.58.1-9.el10_2.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-inspect-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-inspect-icons}"
SRC_URI[x86_64_v2_libguestfs-inspect-icons.sha256sum] = "8c8085cede7e072f5039a74f03231c1394fcf1f22db3e37f76afcb3793a6f2d1"

URI_x86_64_v2_libguestfs-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-ja-1.58.1-9.el10_2.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-man-pages-ja}"
SRC_URI[x86_64_v2_libguestfs-man-pages-ja.sha256sum] = "ee9c86e24100c457e19f3eb97812a6021d13a39d07304e410a5e4cba1573ce1b"

URI_x86_64_v2_libguestfs-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-uk-1.58.1-9.el10_2.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-man-pages-uk}"
SRC_URI[x86_64_v2_libguestfs-man-pages-uk.sha256sum] = "0779deea14e6e231b3ae89b245a1ba99bfbc8101d2466c3f92fcd4669cdbb3e1"

URI_x86_64_v2_libguestfs-rescue = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-rescue-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-rescue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-rescue}"
SRC_URI[x86_64_v2_libguestfs-rescue.sha256sum] = "b82b7ea9d1b32c3e5aefefbc702a120aee89c54ebdb7806cb500811448383bfa"

URI_x86_64_v2_libguestfs-rsync = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-rsync-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-rsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-rsync}"
SRC_URI[x86_64_v2_libguestfs-rsync.sha256sum] = "2a2b084e2af87ed666c38f4faf4bf0073436fcdee6a620753ef7c3be3ac60263"

URI_x86_64_v2_libguestfs-xfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-xfs-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-xfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-xfs}"
SRC_URI[x86_64_v2_libguestfs-xfs.sha256sum] = "74ce8713dbf68b0f03dfa9eca80169e9b3b3af7a83f0e63f887371a96fdcd40a"

URI_x86_64_v2_ocaml-libguestfs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libguestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libguestfs}"
SRC_URI[x86_64_v2_ocaml-libguestfs.sha256sum] = "002f13bc3c38c742368ffd376b68f1af91d4a8ea37bb2885a090150ba78a7d26"

URI_x86_64_v2_ocaml-libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-devel-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libguestfs-devel}"
SRC_URI[x86_64_v2_ocaml-libguestfs-devel.sha256sum] = "26734ab2eda1a05d930983058cf984c035ce5694e8c9be5760be130c79c38daf"

URI_x86_64_v2_perl-Sys-Guestfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sys-Guestfs-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Guestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Guestfs}"
SRC_URI[x86_64_v2_perl-Sys-Guestfs.sha256sum] = "6f146e2403e30aebd705140a95f3cc4b8eb0180f2ec285efeebb9487e59d307a"

URI_x86_64_v2_python3-libguestfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libguestfs-1.58.1-9.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-libguestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libguestfs}"
SRC_URI[x86_64_v2_python3-libguestfs.sha256sum] = "eb286489f38ecc16e438d2d79385cc85836f57fbc8dd3ba1e414dc0bd04de2de"

URI_aarch64_libguestfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_libguestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs}"
SRC_URI[aarch64_libguestfs.sha256sum] = "229072c8e9cf7badd86f2aa9aff82b3390370e22383a9d14268fbf7137bb9e4f"

URI_aarch64_libguestfs-appliance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-appliance-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_libguestfs-appliance;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-appliance}"
SRC_URI[aarch64_libguestfs-appliance.sha256sum] = "85aa913a2e2127b65a318d48f1a91b715e1febcf8afa591452217294330874d5"

URI_aarch64_libguestfs-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-bash-completion-1.58.1-9.el10_2.alma.1.noarch.rpm;name=aarch64_libguestfs-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-bash-completion}"
SRC_URI[aarch64_libguestfs-bash-completion.sha256sum] = "510c509fba7953bc988f60c38c1fb10511553b4cd35909d1dfb36bc39dc6f397"

URI_aarch64_libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-devel-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-devel}"
SRC_URI[aarch64_libguestfs-devel.sha256sum] = "562667919d81332029c8e6d3ff9b2ab3b02c1007f949d39702b176d1f24f9067"

URI_aarch64_libguestfs-inspect-icons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-inspect-icons-1.58.1-9.el10_2.alma.1.noarch.rpm;name=aarch64_libguestfs-inspect-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-inspect-icons}"
SRC_URI[aarch64_libguestfs-inspect-icons.sha256sum] = "8c8085cede7e072f5039a74f03231c1394fcf1f22db3e37f76afcb3793a6f2d1"

URI_aarch64_libguestfs-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-man-pages-ja-1.58.1-9.el10_2.alma.1.noarch.rpm;name=aarch64_libguestfs-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-man-pages-ja}"
SRC_URI[aarch64_libguestfs-man-pages-ja.sha256sum] = "ee9c86e24100c457e19f3eb97812a6021d13a39d07304e410a5e4cba1573ce1b"

URI_aarch64_libguestfs-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-man-pages-uk-1.58.1-9.el10_2.alma.1.noarch.rpm;name=aarch64_libguestfs-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-man-pages-uk}"
SRC_URI[aarch64_libguestfs-man-pages-uk.sha256sum] = "0779deea14e6e231b3ae89b245a1ba99bfbc8101d2466c3f92fcd4669cdbb3e1"

URI_aarch64_libguestfs-rescue = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-rescue-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_libguestfs-rescue;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-rescue}"
SRC_URI[aarch64_libguestfs-rescue.sha256sum] = "faee171ab6fa1d1a9b5d5233441dea016e6cf3599090b5d6edcd1bbb00f03a37"

URI_aarch64_libguestfs-rsync = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-rsync-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_libguestfs-rsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-rsync}"
SRC_URI[aarch64_libguestfs-rsync.sha256sum] = "75eb1566d8d5a5728fb51057e7b53232c2441a3303c052b8a7d8080eb3eefcee"

URI_aarch64_libguestfs-xfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-xfs-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_libguestfs-xfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-xfs}"
SRC_URI[aarch64_libguestfs-xfs.sha256sum] = "bd17e9038b1498ae3fa93f746d3296f99f7f08865d3ca1bd5e1ceb6e365a5640"

URI_aarch64_ocaml-libguestfs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libguestfs-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_ocaml-libguestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libguestfs}"
SRC_URI[aarch64_ocaml-libguestfs.sha256sum] = "f4664ed10095f50eb4508063af4a75e2afbe8e4e00db74720215474e50cd010b"

URI_aarch64_ocaml-libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libguestfs-devel-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_ocaml-libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libguestfs-devel}"
SRC_URI[aarch64_ocaml-libguestfs-devel.sha256sum] = "79ad4b3660ef99838814008cba2fefff152cb3c67b22b6875df0c1f5f1a8049b"

URI_aarch64_perl-Sys-Guestfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sys-Guestfs-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_perl-Sys-Guestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Guestfs}"
SRC_URI[aarch64_perl-Sys-Guestfs.sha256sum] = "66250f703a57a164fbc0d336978cc793bf1c1bd47a96d109a9bcf9696984b903"

URI_aarch64_python3-libguestfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libguestfs-1.58.1-9.el10_2.alma.1.aarch64.rpm;name=aarch64_python3-libguestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libguestfs}"
SRC_URI[aarch64_python3-libguestfs.sha256sum] = "e991e03f76d2a927cbdb248a82cd6564d1cf0ef01d89ee7253c6d1ea0288a5d8"

RDEPENDS:libguestfs:x86_64_v2 = " \
 bash \
 fuse \
 fuse-libs \
 glibc \
 grep \
 hexedit \
 hivex-libs \
 json-c \
 less \
 libacl \
 libcap \
 libconfig \
 libgcc \
 libguestfs-appliance \
 libselinux \
 libtirpc \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 libxml2 \
 ncurses-libs \
 passt \
 pcre2 \
 qemu-img \
 qemu-kvm-core \
 readline \
 rpm-libs \
 selinux-policy \
 systemd-libs \
 tar \
 vim-minimal \
 virtual//usr/bin/man \
 virtual/coreutils \
 xz \
"
RDEPENDS:libguestfs:aarch64 = " \
 bash \
 edk2-aarch64 \
 fuse \
 fuse-libs \
 glibc \
 grep \
 hexedit \
 hivex-libs \
 json-c \
 less \
 libacl \
 libcap \
 libconfig \
 libgcc \
 libguestfs-appliance \
 libselinux \
 libtirpc \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 libxml2 \
 ncurses-libs \
 passt \
 pcre2 \
 qemu-img \
 qemu-kvm-core \
 readline \
 rpm-libs \
 selinux-policy \
 systemd-libs \
 tar \
 vim-minimal \
 virtual//usr/bin/man \
 virtual/coreutils \
 xz \
"
RDEPENDS:libguestfs-appliance = " \
 acl \
 attr \
 bash \
 binutils \
 bzip2 \
 clevis-luks \
 cpio \
 cryptsetup \
 dhcpcd \
 diffutils \
 dosfstools \
 e2fsprogs \
 file \
 findutils \
 gawk \
 glibc \
 glibc-gconv-extra \
 grep \
 gzip \
 hivex-libs \
 iproute \
 json-c \
 kmod \
 less \
 libacl \
 libcap \
 libgcc \
 libselinux \
 libtirpc \
 libxml2 \
 lsscsi \
 lvm2 \
 lzop \
 mdadm \
 parted \
 pcre2 \
 policycoreutils \
 procps-ng \
 psmisc \
 rpm-libs \
 scrub \
 sed \
 supermin \
 systemd \
 systemd-libs \
 systemd-udev \
 tar \
 util-linux \
 virtual/coreutils \
 virtual/kernel \
 xz \
 zstd \
 "
RDEPENDS:libguestfs-bash-completion = " \
 bash-completion \
 "
RDEPENDS:libguestfs-devel = " \
 libguestfs \
 pkgconf-pkg-config \
 "
RDEPENDS:libguestfs-inspect-icons = " \
 icoutils \
 libguestfs \
 netpbm-progs \
 "
RDEPENDS:libguestfs-man-pages-ja = " \
 libguestfs \
 "
RDEPENDS:libguestfs-man-pages-uk = " \
 libguestfs \
 "
RDEPENDS:libguestfs-rescue = " \
 glibc \
 iputils \
 libconfig \
 libgcc \
 libguestfs \
 libxml2 \
 lsof \
 openssh-clients \
 pciutils \
 strace \
 vim-minimal \
 "
RDEPENDS:libguestfs-rsync = " \
 libguestfs \
 rsync \
 "
RDEPENDS:libguestfs-xfs = " \
 libguestfs \
 xfsprogs \
 "
RDEPENDS:ocaml-libguestfs = " \
 glibc \
 libguestfs \
 "
RDEPENDS:ocaml-libguestfs-devel = " \
 ocaml-libguestfs \
 "
RDEPENDS:perl-Sys-Guestfs = " \
 glibc \
 libguestfs \
 perl-libs \
 perl-vars \
 "
RDEPENDS:python3-libguestfs = " \
 glibc \
 libguestfs \
 python3 \
 "
