# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-version-ranges"
PV = "0.1.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-version-ranges+default-devel \
 rust-version-ranges+proptest-devel \
 rust-version-ranges+serde-devel \
 rust-version-ranges-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-version-ranges-0.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f457b7627e15a40ab2ff601d382092d72b96ca8b357f62224388b40506f78eb"

URI_x86_64_v2_rust-version-ranges+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+default-devel-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+default-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+default-devel.sha256sum] = "57b37d4e9c7fef5cca228e62ee5240916ddc3e3dd0e4510e64431c048f1ce661"

URI_x86_64_v2_rust-version-ranges+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+proptest-devel-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+proptest-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+proptest-devel.sha256sum] = "887d54d2452555c8644ad2b95236f1d401a487276bed88e406ccfd340b9306a3"

URI_x86_64_v2_rust-version-ranges+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges+serde-devel-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges+serde-devel}"
SRC_URI[x86_64_v2_rust-version-ranges+serde-devel.sha256sum] = "628d7be4d3cca70eff41f31ecbcf408edcd70d62e257efe1e90e5fefc1ef843e"

URI_x86_64_v2_rust-version-ranges-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-version-ranges-devel-0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-version-ranges-devel}"
SRC_URI[x86_64_v2_rust-version-ranges-devel.sha256sum] = "c1dc814cb31a6a9db3eed68197ada79481b28e0c8b88348a3b04eee786e7bc8e"

URI_aarch64_rust-version-ranges+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+default-devel-0.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-version-ranges+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+default-devel}"
SRC_URI[aarch64_rust-version-ranges+default-devel.sha256sum] = "c71fdb90e7089b4f412834c19152b69e19f97a08b35b75004d175adb3e791785"

URI_aarch64_rust-version-ranges+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+proptest-devel-0.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-version-ranges+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+proptest-devel}"
SRC_URI[aarch64_rust-version-ranges+proptest-devel.sha256sum] = "61d19ffd80dc7b32f2111faa1f982272cef2724d2e481c96bd88e3caf58bf1c8"

URI_aarch64_rust-version-ranges+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges+serde-devel-0.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-version-ranges+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges+serde-devel}"
SRC_URI[aarch64_rust-version-ranges+serde-devel.sha256sum] = "d6147112c4ec25148da190c222c604141d4d92eca805fc54f1000a8224fb2ea4"

URI_aarch64_rust-version-ranges-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-version-ranges-devel-0.1.1-1.el10_0.noarch.rpm;name=aarch64_rust-version-ranges-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-version-ranges-devel}"
SRC_URI[aarch64_rust-version-ranges-devel.sha256sum] = "c8287550d90c172fff3224607ce3b20b9d2314121157d6c825be45724510ad2a"

RDEPENDS:rust-version-ranges+default-devel = " \
 cargo \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+proptest-devel = " \
 cargo \
 rust-proptest+default-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-smallvec+serde-devel \
 rust-version-ranges-devel \
 "
RDEPENDS:rust-version-ranges-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 "
