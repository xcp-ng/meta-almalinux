# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgraphviewer"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kgraphviewer \
 kgraphviewer-devel \
 kgraphviewer-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kgraphviewer-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d97f15cafa0a4be474aab3e12e38f205a009a31319338fc41c31f79d842e2b60"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - kgraphviewer-libs: libcgraph.so.6()(64bit)
# - kgraphviewer-libs: libgvc.so.6()(64bit)
# - kgraphviewer: graphviz

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer;unpack=0"
SRC_URI[x86_64_v2_kgraphviewer.sha256sum] = "0f9901fda3269c48fe2fe6af7f07d34323e749fb83a1f01afc8bbc228738cc36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer-devel;unpack=0"
SRC_URI[x86_64_v2_kgraphviewer-devel.sha256sum] = "a9490dd98728a2b10876d759ff4e535c555a0ffcdbac59a5f8f2fd3b6939183f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgraphviewer-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgraphviewer-libs;unpack=0"
SRC_URI[x86_64_v2_kgraphviewer-libs.sha256sum] = "08b202ff764d992cffcddd259a1b1210cf620475ffbcc590823cca23fad9622b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kgraphviewer;unpack=0"
SRC_URI[aarch64_kgraphviewer.sha256sum] = "97e089ecbbbbc8b404221453eed51f8e08f091989e0619b3cc6299a492cce16c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kgraphviewer-devel;unpack=0"
SRC_URI[aarch64_kgraphviewer-devel.sha256sum] = "d55d5d5cc2203080c1e7db8688dd08a1e46bfcf3fc5163df3e1685d63c551b22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kgraphviewer-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kgraphviewer-libs;unpack=0"
SRC_URI[aarch64_kgraphviewer-libs.sha256sum] = "067a750ee7c86327c05f5168cfb2feb9b6844ad37ceea0821febf2a25ee6964c"

RDEPENDS:kgraphviewer:x86_64_v2 = " \
 glibc \
 graphviz \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kgraphviewer-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
"
RDEPENDS:kgraphviewer:aarch64 = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kgraphviewer-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
"
RDEPENDS:kgraphviewer-devel = " \
 cmake \
 cmake-filesystem \
 kgraphviewer-libs \
 "
RDEPENDS:kgraphviewer-libs:x86_64_v2 = " \
 glibc \
 graphviz \
 kde-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
RDEPENDS:kgraphviewer-libs:aarch64 = " \
 glibc \
 kde-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
"
