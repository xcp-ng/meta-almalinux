# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Trigger"
PV = "0.15"
PR = "10.el10_3"
PACKAGES = " \
 perl-Class-Trigger \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Trigger-0.15-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "20417bcfa5b0ef2c72caa5d3522502d9d7f5f2a3f3c758ab03a096564d74accd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Trigger-0.15-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Trigger;unpack=0"
SRC_URI[x86_64_v2_perl-Class-Trigger.sha256sum] = "bd9589e101b1fca6d3720fc164f0d261a1174f735b65d2249c298105910d01b2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Trigger-0.15-10.el10_3.noarch.rpm;name=aarch64_perl-Class-Trigger;unpack=0"
SRC_URI[aarch64_perl-Class-Trigger.sha256sum] = "529db9213d948e2f24f6d05fcbc760010442860161f3377a3ef17556bf6584fd"

RDEPENDS:perl-Class-Trigger = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
