# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "7zip"
PV = "26.02"
PR = "1.el10_3"
PACKAGES = " \
 7zip \
 7zip-reduced \
 7zip-standalone \
 7zip-standalone-all \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/7/7zip-26.02-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed0a87ec246ad6d5b84e8819c3c408e385d0385829ad4a2b9616eb583f37467f"

URI_x86_64_v2_7zip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-26.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip}"
SRC_URI[x86_64_v2_7zip.sha256sum] = "8c447e1842e615e779e865d396f9678a208aaf210039b98c1aa1b5e227abde64"

URI_x86_64_v2_7zip-reduced = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-reduced-26.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-reduced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-reduced}"
SRC_URI[x86_64_v2_7zip-reduced.sha256sum] = "16ec295d73de2331331b0ffc554283440b09c4389ad94b20e8085851c36b2d10"

URI_x86_64_v2_7zip-standalone = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-26.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-standalone}"
SRC_URI[x86_64_v2_7zip-standalone.sha256sum] = "73488a3d842ecd9daa31fa23f4c299c2b4fe161a02b12ffe6dcb6ce6891598f5"

URI_x86_64_v2_7zip-standalone-all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/7zip-standalone-all-26.02-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_7zip-standalone-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_7zip-standalone-all}"
SRC_URI[x86_64_v2_7zip-standalone-all.sha256sum] = "487232b3fd2380d5a64b91f6c021c71754158f1e9247b33dd7893c61b6a1e77f"

URI_aarch64_7zip = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-26.02-1.el10_3.aarch64.rpm;name=aarch64_7zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip}"
SRC_URI[aarch64_7zip.sha256sum] = "6165dd6f7cb1c67a2ebb34d078852b8e3134499f109a1027f25a824a3f95e7ab"

URI_aarch64_7zip-reduced = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-reduced-26.02-1.el10_3.aarch64.rpm;name=aarch64_7zip-reduced;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-reduced}"
SRC_URI[aarch64_7zip-reduced.sha256sum] = "bd751361a14222bacccaa62f4dd91d404d8c9792e567ced73114e4573aaaa8b3"

URI_aarch64_7zip-standalone = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-26.02-1.el10_3.aarch64.rpm;name=aarch64_7zip-standalone;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-standalone}"
SRC_URI[aarch64_7zip-standalone.sha256sum] = "093cff67b720f3be75d34718ad9ac447b257983e3efc5b1e2f38600773a5045d"

URI_aarch64_7zip-standalone-all = "${EPEL_MIRROR}/aarch64/Packages/7/7zip-standalone-all-26.02-1.el10_3.aarch64.rpm;name=aarch64_7zip-standalone-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_7zip-standalone-all}"
SRC_URI[aarch64_7zip-standalone-all.sha256sum] = "8bfaf5e50de1e0cc16335102f796d03ee58be75ffb4e559c495e3baf2fdaf4e6"

RDEPENDS:7zip = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-reduced = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:7zip-standalone-all = " \
 glibc \
 libgcc \
 libstdc++ \
 "
