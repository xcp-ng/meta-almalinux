# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-avif-parse"
PV = "1.4.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-avif-parse+default-devel \
 rust-avif-parse+mp4parse_fallible-devel \
 rust-avif-parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-avif-parse-1.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b5a57e0d6c9a03cb3ff00f9473dd72194921c681cfd0033677ad9a61768a0cc"

URI_x86_64_v2_rust-avif-parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-parse+default-devel-1.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-parse+default-devel}"
SRC_URI[x86_64_v2_rust-avif-parse+default-devel.sha256sum] = "863bfbf42f7fc3b19921bc5e6cd0e0a744ece74125f61528a57456ee7172cd4e"

URI_x86_64_v2_rust-avif-parse+mp4parse_fallible-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-parse+mp4parse_fallible-devel-1.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-parse+mp4parse_fallible-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-parse+mp4parse_fallible-devel}"
SRC_URI[x86_64_v2_rust-avif-parse+mp4parse_fallible-devel.sha256sum] = "9b7b200d75301f0692440834fb8ebc2e53cf7157c2e99c235261b8ae0654951c"

URI_x86_64_v2_rust-avif-parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-avif-parse-devel-1.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-avif-parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-avif-parse-devel}"
SRC_URI[x86_64_v2_rust-avif-parse-devel.sha256sum] = "64074da11e12fb55d67baa813eceb15e4105b97b36810c1bd0349440d8b9dd51"

URI_aarch64_rust-avif-parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-parse+default-devel-1.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-avif-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-parse+default-devel}"
SRC_URI[aarch64_rust-avif-parse+default-devel.sha256sum] = "dc3e5e4d8de4c6678c676f8f2d27ce23c187898e89c877fb409eac546adc7e88"

URI_aarch64_rust-avif-parse+mp4parse_fallible-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-parse+mp4parse_fallible-devel-1.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-avif-parse+mp4parse_fallible-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-parse+mp4parse_fallible-devel}"
SRC_URI[aarch64_rust-avif-parse+mp4parse_fallible-devel.sha256sum] = "dfc280d3e9701cbbb835fc5aa81ce24430d3422547e75c7e6f0f121b68e1ae9b"

URI_aarch64_rust-avif-parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-avif-parse-devel-1.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-avif-parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-avif-parse-devel}"
SRC_URI[aarch64_rust-avif-parse-devel.sha256sum] = "e67e404e80f3d9163aff17563e066953c631a708858f66bf01ebf25150ea2729"

RDEPENDS:rust-avif-parse+default-devel = " \
 cargo \
 rust-avif-parse-devel \
 "
RDEPENDS:rust-avif-parse+mp4parse_fallible-devel = " \
 cargo \
 rust-avif-parse-devel \
 "
RDEPENDS:rust-avif-parse-devel = " \
 cargo \
 rust \
 rust-arrayvec+default-devel \
 rust-bitreader+default-devel \
 rust-byteorder+default-devel \
 rust-fallible_collections+std-devel \
 rust-fallible_collections-devel \
 rust-leb128+default-devel \
 rust-log+default-devel \
 "
