# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-platform-verifier0.5"
PV = "0.5.3"
PR = "3.el10_3"
PACKAGES = " \
 rust-rustls-platform-verifier0.5+base64-devel \
 rust-rustls-platform-verifier0.5+cert-logging-devel \
 rust-rustls-platform-verifier0.5+dbg-devel \
 rust-rustls-platform-verifier0.5+default-devel \
 rust-rustls-platform-verifier0.5+ffi-testing-devel \
 rust-rustls-platform-verifier0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-platform-verifier0.5-0.5.3-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "280845b016911b123841f4b15ed7d16b9ed73a480519cf56b309f90076d87d37"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+base64-devel-0.5.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+base64-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+base64-devel.sha256sum] = "720c4a96f52b4326ec5ed85495a5d7a7d8770b14689744c5045945c933feea88"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+cert-logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+cert-logging-devel-0.5.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+cert-logging-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+cert-logging-devel.sha256sum] = "70bd2ffe6d03645fd1d496dc905c4ed95ff154e62c1de1a5be7ccb69b3179e54"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+dbg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+dbg-devel-0.5.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+dbg-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+dbg-devel.sha256sum] = "86e06f36ae0a1dbd33a547d7424eea72f6cc5aaab57dec2a7d472a39b5edbb2b"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+default-devel-0.5.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+default-devel.sha256sum] = "9db4250cf31be0dff86a743cbb025f07dfe718c1cd70921cc033c77012e76f54"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+ffi-testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+ffi-testing-devel-0.5.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+ffi-testing-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+ffi-testing-devel.sha256sum] = "6d6fc3dff2f5aee92eb1d79273061b55624af8db94d0341b0507bc704941a726"

URI_x86_64_v2_rust-rustls-platform-verifier0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5-devel-0.5.3-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5-devel.sha256sum] = "6128f236159bf8fbc74fdf7959e83c2abb1b2a11d1c7c95315b80423bd9103f0"

URI_aarch64_rust-rustls-platform-verifier0.5+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+base64-devel-0.5.3-3.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+base64-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+base64-devel.sha256sum] = "eac78528f2873540221f2f1e805f22cda06f5f507f4fd3cbde9c30ee689c208c"

URI_aarch64_rust-rustls-platform-verifier0.5+cert-logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+cert-logging-devel-0.5.3-3.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+cert-logging-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+cert-logging-devel.sha256sum] = "a6e731bd112d2a70383f00cd96a5cde654097eb1417356e4d2fdefa0bc567aa3"

URI_aarch64_rust-rustls-platform-verifier0.5+dbg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+dbg-devel-0.5.3-3.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+dbg-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+dbg-devel.sha256sum] = "ad66d41e18459e541e34e370df5de64c64b24923724c32ce8e761b85b88775a8"

URI_aarch64_rust-rustls-platform-verifier0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+default-devel-0.5.3-3.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+default-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+default-devel.sha256sum] = "08d79a0be5011d247731fad372413db9bc2d9663603d4df829ff1880bc8976dc"

URI_aarch64_rust-rustls-platform-verifier0.5+ffi-testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+ffi-testing-devel-0.5.3-3.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+ffi-testing-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+ffi-testing-devel.sha256sum] = "d3df11b23179f933808f8034f3eb109c0042e3f31a5ecfcd2008d04b66c765c9"

URI_aarch64_rust-rustls-platform-verifier0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5-devel-0.5.3-3.el10_3.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5-devel.sha256sum] = "61e3b14c2247cf9c49bcbd149523f7348837a4f007681e1eaba53af87f226e21"

RDEPENDS:rust-rustls-platform-verifier0.5+base64-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5+cert-logging-devel = " \
 cargo \
 rust-rustls-platform-verifier0.5+base64-devel \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5+dbg-devel = " \
 cargo \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5+default-devel = " \
 cargo \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5+ffi-testing-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-once_cell+default-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-rustls-native-certs+default-devel \
 rust-rustls-webpki-devel \
 "
