# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xbae"
PV = "4.60.4"
PR = "59.el10_2"
PACKAGES = " \
 xbae \
 xbae-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xbae-4.60.4-59.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b540917af71070550f3bfa69c2b4971fb2c537ad8646af5b3dadd81252c4b74c"

URI_x86_64_v2_xbae = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xbae-4.60.4-59.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xbae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xbae}"
SRC_URI[x86_64_v2_xbae.sha256sum] = "1bd83dd0ca051f7e7270fa7f45f510703843c8e14ec12d72e86f851fd99be49e"

URI_x86_64_v2_xbae-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xbae-devel-4.60.4-59.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xbae-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xbae-devel}"
SRC_URI[x86_64_v2_xbae-devel.sha256sum] = "e4785c02b51a699a7aab39d03652e584c7ad76731187b4cb5e1789a580f21d32"

URI_aarch64_xbae = "${EPEL_MIRROR}/aarch64/Packages/x/xbae-4.60.4-59.el10_2.aarch64.rpm;name=aarch64_xbae;unpack=0"
SRC_URI:append = " ${URI_aarch64_xbae}"
SRC_URI[aarch64_xbae.sha256sum] = "b49b8c93e1bd0025f3ee16e11fabd9bf95bad1237f98d88cc5fd230b9ff423bb"

URI_aarch64_xbae-devel = "${EPEL_MIRROR}/aarch64/Packages/x/xbae-devel-4.60.4-59.el10_2.aarch64.rpm;name=aarch64_xbae-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xbae-devel}"
SRC_URI[aarch64_xbae-devel.sha256sum] = "8a3377801e551f379aea1339c9512c7f2962cc36f271ad84167b4a04490907a1"

RDEPENDS:xbae = " \
 glibc \
 libX11 \
 libXext \
 libXp \
 libXpm \
 libXt \
 motif \
 "
RDEPENDS:xbae-devel = " \
 automake \
 libXpm-devel \
 motif-devel \
 xbae \
 "
