# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel"
PV = "6.12.0"
PR = "211.49.1.el10_2"
PACKAGES:x86_64_v2 = " \
 kernel \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-debug-uki-virt \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"
PACKAGES:aarch64 = " \
 kernel \
 kernel-64k \
 kernel-64k-core \
 kernel-64k-debug \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 kernel-64k-debug-devel-matched \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 kernel-64k-devel \
 kernel-64k-devel-matched \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kernel-6.12.0-211.49.1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25b383ea8cbbb15f60269db7f5240e91564348b186ad7ad9ac94d7c105c0628c"

URI_x86_64_v2_kernel = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel}"
SRC_URI[x86_64_v2_kernel.sha256sum] = "266aae45d42d5ec3d7a085961d3e41d092f0fd4bdf5f8721922d116c5ebf30db"
RPROVIDES:kernel:x86_64_v2 = "virtual/kernel"

URI_x86_64_v2_kernel-abi-stablelists = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-abi-stablelists-6.12.0-211.49.1.el10_2.noarch.rpm;name=x86_64_v2_kernel-abi-stablelists;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-abi-stablelists}"
SRC_URI[x86_64_v2_kernel-abi-stablelists.sha256sum] = "82e793b8448d5032a5ebabc5c977fd65cc99cdb81e51e3dc392125c8a9142760"

URI_x86_64_v2_kernel-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-core-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-core}"
SRC_URI[x86_64_v2_kernel-core.sha256sum] = "b024bd3c5ccc9073169345cb9497d014fd268de479e601c43a72776d041a9e2c"
RPROVIDES:kernel-core:x86_64_v2 = "virtual/kernel virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2"

URI_x86_64_v2_kernel-cross-headers = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-cross-headers-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-cross-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-cross-headers}"
SRC_URI[x86_64_v2_kernel-cross-headers.sha256sum] = "af29fea63f4938a769174b8b1879bc20e4722c9c793b4c83a0c4f15775b66a41"

URI_x86_64_v2_kernel-debug = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug}"
SRC_URI[x86_64_v2_kernel-debug.sha256sum] = "095e74acf5bc1d07a16f30a00b3b75e2804a11cd91dfcda5dfa745b4e05b297a"

URI_x86_64_v2_kernel-debug-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-core-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-core}"
SRC_URI[x86_64_v2_kernel-debug-core.sha256sum] = "4a6d41c22da704775f38479f497c8970aaae7b4273380ccc01977752bb449ce1"
RPROVIDES:kernel-debug-core:x86_64_v2 = "virtual/kernel virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2+debug"

URI_x86_64_v2_kernel-debug-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-devel}"
SRC_URI[x86_64_v2_kernel-debug-devel.sha256sum] = "a7beeec21ab117d3af062a83ff29b08117157ec19bc2d6579b84e1b9944ece16"
RPROVIDES:kernel-debug-devel:x86_64_v2 = "virtual/kernel-devel-uname-r"

URI_x86_64_v2_kernel-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-matched-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-devel-matched}"
SRC_URI[x86_64_v2_kernel-debug-devel-matched.sha256sum] = "247fbd10a0e907662b73a08dd919514cba48a6ddb32c16c35be9c714f4557086"

URI_x86_64_v2_kernel-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules}"
SRC_URI[x86_64_v2_kernel-debug-modules.sha256sum] = "4bead78239849ebe1193330cf65fd6f6e24149ad4a86402a9ce068dd5147ab3e"
RPROVIDES:kernel-debug-modules:x86_64_v2 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_kernel-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-core-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules-core}"
SRC_URI[x86_64_v2_kernel-debug-modules-core.sha256sum] = "dbb2078cd538c82b212863f240c982a7250626bf43d924e24076d62d4a8b0c07"

URI_x86_64_v2_kernel-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-extra-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules-extra}"
SRC_URI[x86_64_v2_kernel-debug-modules-extra.sha256sum] = "d35bbef55bc11022dc8812f14b3d4e522032115cefe2b9cdcf987addb7a2f3a1"
RPROVIDES:kernel-debug-modules-extra:x86_64_v2 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_x86_64_v2_kernel-debug-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-uki-virt-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-uki-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-uki-virt}"
SRC_URI[x86_64_v2_kernel-debug-uki-virt.sha256sum] = "3e8c6ff789f7225bab89b64df125fd50749d761b12e454876fe533d92f31b23c"
RPROVIDES:kernel-debug-uki-virt:x86_64_v2 = "virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2+debug"

URI_x86_64_v2_kernel-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-devel}"
SRC_URI[x86_64_v2_kernel-devel.sha256sum] = "8bfaf769cbf0dad9d6d84aa29f084259968f6a241dcbb217af4473ee6a99dead"
RPROVIDES:kernel-devel:x86_64_v2 = "virtual/kernel-devel-uname-r"

URI_x86_64_v2_kernel-devel-matched = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-matched-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-devel-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-devel-matched}"
SRC_URI[x86_64_v2_kernel-devel-matched.sha256sum] = "fa0aa271a5107d8e7c76df7d5d7f84851635715ee107f8e7660e4563cce95715"

URI_x86_64_v2_kernel-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-doc-6.12.0-211.49.1.el10_2.noarch.rpm;name=x86_64_v2_kernel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-doc}"
SRC_URI[x86_64_v2_kernel-doc.sha256sum] = "246731a322c2c865a9e626b9c0be133018206f6db8652c48453d46fdc34459d6"

URI_x86_64_v2_kernel-headers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-headers-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-headers}"
SRC_URI[x86_64_v2_kernel-headers.sha256sum] = "744b1de98a33ec1d33c1ad7ab917f6bf57169b006e0d3345ed6aa387e678f104"

URI_x86_64_v2_kernel-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules}"
SRC_URI[x86_64_v2_kernel-modules.sha256sum] = "f03180860b4ce3fbb1f0288f9a658a3ba94a6e7841c3a14e952859a5f0f70190"
RPROVIDES:kernel-modules:x86_64_v2 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_kernel-modules-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-core-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-core}"
SRC_URI[x86_64_v2_kernel-modules-core.sha256sum] = "0635af55847ebca1b4ba7ef52be7d569b289be5f44e54652b0b5eaa19d786324"

URI_x86_64_v2_kernel-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-extra}"
SRC_URI[x86_64_v2_kernel-modules-extra.sha256sum] = "ab541a0544ab733fab58de1089fbd186ff7ce0d6ca13867077b6d80ba5bb1992"
RPROVIDES:kernel-modules-extra:x86_64_v2 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_x86_64_v2_kernel-modules-extra-matched = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-matched-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-extra-matched}"
SRC_URI[x86_64_v2_kernel-modules-extra-matched.sha256sum] = "a55775a805ba95acc38080145fa7e7c1b913ee664aab577aefe516f31048818b"

URI_x86_64_v2_kernel-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools}"
SRC_URI[x86_64_v2_kernel-tools.sha256sum] = "be6a6f976fc0c2a920c61cec6968d6af8e4157bc2555f4a556e78f90f61798fe"

URI_x86_64_v2_kernel-tools-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-libs-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools-libs}"
SRC_URI[x86_64_v2_kernel-tools-libs.sha256sum] = "7fa97e8d488e1e530e2fa61fa27bc193969364a91c85b0921da64f68f8d8fbd6"

URI_x86_64_v2_kernel-tools-libs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-tools-libs-devel-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools-libs-devel}"
SRC_URI[x86_64_v2_kernel-tools-libs-devel.sha256sum] = "f76f8b17fe70f1baa86dcd0019e4868ded3c796f14e6693390ac0015831969bc"

URI_x86_64_v2_kernel-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-uki-virt}"
SRC_URI[x86_64_v2_kernel-uki-virt.sha256sum] = "6a170fa6896fe2cefa2a50f3ac2b2fd41679bbcfad671743b297d02f2116ea13"
RPROVIDES:kernel-uki-virt:x86_64_v2 = "virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2"

URI_x86_64_v2_kernel-uki-virt-addons = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-addons-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-uki-virt-addons}"
SRC_URI[x86_64_v2_kernel-uki-virt-addons.sha256sum] = "1ad5c975ee69bf83e88e7e8e3cf02a1eeac2949f68109c56163e438ab06fb752"

URI_x86_64_v2_libperf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libperf-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libperf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libperf}"
SRC_URI[x86_64_v2_libperf.sha256sum] = "db1908aa64e99078e64bdb8e4b8343ad5d69cd1854ec0ef5e7cea63c3912e27c"

URI_x86_64_v2_perf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perf-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_perf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perf}"
SRC_URI[x86_64_v2_perf.sha256sum] = "b358e2855445c4be683ae69198fe443361cf8b32f9f6052408e9c2dd7d7d8c24"

URI_x86_64_v2_python3-perf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-perf-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-perf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-perf}"
SRC_URI[x86_64_v2_python3-perf.sha256sum] = "4e32d17504ca3df1034314f776a8873f4f98b44660238413814decb06356bd55"

URI_x86_64_v2_rtla = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rtla-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_rtla;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rtla}"
SRC_URI[x86_64_v2_rtla.sha256sum] = "66dfd785e82a7d6a0b0e4fa0d52ab8eddc27db4f26adf98ce8f30ad8393770a8"

URI_x86_64_v2_rv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rv-6.12.0-211.49.1.el10_2.x86_64_v2.rpm;name=x86_64_v2_rv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rv}"
SRC_URI[x86_64_v2_rv.sha256sum] = "648e9926d843639021a37e5c2bbdaea0f394c5e0d809d9f1a48d455d3f2df3b7"

URI_aarch64_kernel = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel}"
SRC_URI[aarch64_kernel.sha256sum] = "c474b11c2651e68eae94e389f712f7e8bbe5c66f1fb9f5920142210ed415d2d1"
RPROVIDES:kernel:aarch64 = "virtual/kernel"

URI_aarch64_kernel-64k = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k}"
SRC_URI[aarch64_kernel-64k.sha256sum] = "0a701300888c8c1794c127a43b3bfee35e71d3870769755a855e22e51bdd0921"

URI_aarch64_kernel-64k-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-core-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-core}"
SRC_URI[aarch64_kernel-64k-core.sha256sum] = "693dba0015c55783a7d7829d6e42d0efead87753c292b6330ffd012944b3edfd"
RPROVIDES:kernel-64k-core:aarch64 = "virtual/kernel"

URI_aarch64_kernel-64k-debug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug}"
SRC_URI[aarch64_kernel-64k-debug.sha256sum] = "907b0ba4284f96e209935c786fe8995ba49d87bd8210cc3ddc80d8e5d2cf9ef6"

URI_aarch64_kernel-64k-debug-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-core-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-core}"
SRC_URI[aarch64_kernel-64k-debug-core.sha256sum] = "1768fd2697fba2a0f4fcd45f2e555ac5fb5a1b7540f5080b046ed2b91393f426"
RPROVIDES:kernel-64k-debug-core:aarch64 = "virtual/kernel"

URI_aarch64_kernel-64k-debug-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-devel}"
SRC_URI[aarch64_kernel-64k-debug-devel.sha256sum] = "53869d594ccab3571dc8253b6680b54916bfb0b8f5fdfa028449253d5a95d0dc"
RPROVIDES:kernel-64k-debug-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-64k-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-matched-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-devel-matched}"
SRC_URI[aarch64_kernel-64k-debug-devel-matched.sha256sum] = "b0f8235d22b757ab73688ba9f3a69e35fc2ca5dabae75eb13a1c7546b1d5586e"

URI_aarch64_kernel-64k-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules}"
SRC_URI[aarch64_kernel-64k-debug-modules.sha256sum] = "525d1b4cf539d9050751d67f9a37926f9c185da693b6a7d3e5efbe924bc4135d"
RPROVIDES:kernel-64k-debug-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-64k-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-core-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules-core}"
SRC_URI[aarch64_kernel-64k-debug-modules-core.sha256sum] = "f0f89f6137cdda7557fc3a82ab58edd7c6fa4c0cb35af52c30916676ad49f990"

URI_aarch64_kernel-64k-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-extra-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules-extra}"
SRC_URI[aarch64_kernel-64k-debug-modules-extra.sha256sum] = "5e764215b93a4efba11ab6ea2198b0ef5f0a4353fcb1130d02605a53d9aa4267"
RPROVIDES:kernel-64k-debug-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-64k-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-devel}"
SRC_URI[aarch64_kernel-64k-devel.sha256sum] = "3ff57faca12952c74eae1673313cba0b7ff5cbf1bea9632dda650c19171137ad"
RPROVIDES:kernel-64k-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-64k-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-matched-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-devel-matched}"
SRC_URI[aarch64_kernel-64k-devel-matched.sha256sum] = "437bfd4b7868be91d3b6456156f9a066cb5903da5b549bbfc3ab0812797b12b3"

URI_aarch64_kernel-64k-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules}"
SRC_URI[aarch64_kernel-64k-modules.sha256sum] = "896fb9c353a3733e558a27f05ad69ba43029a56290ff902f5b89c3e2ddc3041d"
RPROVIDES:kernel-64k-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-64k-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-core-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules-core}"
SRC_URI[aarch64_kernel-64k-modules-core.sha256sum] = "5f692ad7b0ed118d59b0c2f7a664e9244076fca520ebc5846f613f0be338b6d0"

URI_aarch64_kernel-64k-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-extra-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-64k-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules-extra}"
SRC_URI[aarch64_kernel-64k-modules-extra.sha256sum] = "3c59c904a748d21f05f5627465bebe8f77ec2abb2462babbb44c8b60357dc5d2"
RPROVIDES:kernel-64k-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-abi-stablelists = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-abi-stablelists-6.12.0-211.49.1.el10_2.noarch.rpm;name=aarch64_kernel-abi-stablelists;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-abi-stablelists}"
SRC_URI[aarch64_kernel-abi-stablelists.sha256sum] = "82e793b8448d5032a5ebabc5c977fd65cc99cdb81e51e3dc392125c8a9142760"

URI_aarch64_kernel-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-core-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-core}"
SRC_URI[aarch64_kernel-core.sha256sum] = "615c5dd6552292cf1e996dce3f944b9613746aa5365d5cbb508531a627c02ee6"
RPROVIDES:kernel-core:aarch64 = "virtual/kernel virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.aarch64"

URI_aarch64_kernel-cross-headers = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-cross-headers-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-cross-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-cross-headers}"
SRC_URI[aarch64_kernel-cross-headers.sha256sum] = "90ddae753e9ca96b4b2506432a2c87dcaa66e6956c18f536b045b61078900485"

URI_aarch64_kernel-debug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug}"
SRC_URI[aarch64_kernel-debug.sha256sum] = "657a3322fdbf40e44058f0b5fed1a9d69c8a5538a07a263490433562dea21c21"

URI_aarch64_kernel-debug-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-core-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-core}"
SRC_URI[aarch64_kernel-debug-core.sha256sum] = "6160d72943936cf35ea0b22257cf99cff7c70d487f7637ddd41074479c58edef"
RPROVIDES:kernel-debug-core:aarch64 = "virtual/kernel"

URI_aarch64_kernel-debug-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-devel}"
SRC_URI[aarch64_kernel-debug-devel.sha256sum] = "b2d009ef8968570ffeb6e4ac1166b747116e70e2b4103e51094605dab9ba9a82"
RPROVIDES:kernel-debug-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-matched-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-devel-matched}"
SRC_URI[aarch64_kernel-debug-devel-matched.sha256sum] = "10c7bc50d649f7ab10467766fa50bdda7085cf262b3b27a4d3f45812dc90ada0"

URI_aarch64_kernel-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules}"
SRC_URI[aarch64_kernel-debug-modules.sha256sum] = "4e30beb7fe4c56f76a094b1d597fb9c147d62c3d46d40edb0a502b6fe772cbd1"
RPROVIDES:kernel-debug-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-core-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules-core}"
SRC_URI[aarch64_kernel-debug-modules-core.sha256sum] = "dcebc83e8d3364baada8501b8d3fcbaa1225bfc025e97dbce335c76208a98f27"

URI_aarch64_kernel-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-extra-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules-extra}"
SRC_URI[aarch64_kernel-debug-modules-extra.sha256sum] = "6e67756d32cdc4565f07dcd26ddc9c3484b80a783ba816c01c6397848f814fe5"
RPROVIDES:kernel-debug-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-devel}"
SRC_URI[aarch64_kernel-devel.sha256sum] = "9c238e7f4424f8bbd6a6465b981907ec8a0ece3d052dfb4a60dda5a78e34a682"
RPROVIDES:kernel-devel:aarch64 = "virtual/kernel-devel-uname-r"

URI_aarch64_kernel-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-matched-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-devel-matched}"
SRC_URI[aarch64_kernel-devel-matched.sha256sum] = "69796f0a7ec2fe9469945db1b64504c7207fd750a6929ecc50937413c7ecf535"

URI_aarch64_kernel-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-doc-6.12.0-211.49.1.el10_2.noarch.rpm;name=aarch64_kernel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-doc}"
SRC_URI[aarch64_kernel-doc.sha256sum] = "246731a322c2c865a9e626b9c0be133018206f6db8652c48453d46fdc34459d6"

URI_aarch64_kernel-headers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-headers-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-headers}"
SRC_URI[aarch64_kernel-headers.sha256sum] = "cd97e79d80054b25814f76217bd494c6dc8c75c4a8065a42643d7ba95e4e52dd"

URI_aarch64_kernel-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules}"
SRC_URI[aarch64_kernel-modules.sha256sum] = "6f8834baf2429d1515751b92103121698afb3311ac2cbf457b852e5dba285d98"
RPROVIDES:kernel-modules:aarch64 = "virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-core-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-core}"
SRC_URI[aarch64_kernel-modules-core.sha256sum] = "35799020b6bd72ab148cd85c90099e06bc242589df2f11b4ad7b47b005524c3b"

URI_aarch64_kernel-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-extra}"
SRC_URI[aarch64_kernel-modules-extra.sha256sum] = "ef07d74b90f869700323b462faf82f33c4ce79702d96d30f2dd834342fd06cd1"
RPROVIDES:kernel-modules-extra:aarch64 = "virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-modules-extra-matched = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-matched-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-modules-extra-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-extra-matched}"
SRC_URI[aarch64_kernel-modules-extra-matched.sha256sum] = "039810b1c67e311ee0fae6f98321c9a650a355a82d5d10bfd39616f4bfcf4f2d"

URI_aarch64_kernel-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools}"
SRC_URI[aarch64_kernel-tools.sha256sum] = "9063bbf43378abc3e0a186a17faaa1eb4115632c4e28b7274283a2d1730392a3"

URI_aarch64_kernel-tools-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-libs-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-tools-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools-libs}"
SRC_URI[aarch64_kernel-tools-libs.sha256sum] = "7463d9df00593d7fecb42eb5326485e667c6a31740ab1cca217587584e1bc2f6"

URI_aarch64_kernel-tools-libs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-tools-libs-devel-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-tools-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools-libs-devel}"
SRC_URI[aarch64_kernel-tools-libs-devel.sha256sum] = "031abd643575965da089cb983380041a6ee3eb6af165d4c29d56a5a1638c4e12"

URI_aarch64_kernel-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-uki-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-uki-virt}"
SRC_URI[aarch64_kernel-uki-virt.sha256sum] = "a75978167160d1dd054b7c40ec1c2b3272dbcf3256440b6e1c31134c8771de31"
RPROVIDES:kernel-uki-virt:aarch64 = "virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.aarch64"

URI_aarch64_kernel-uki-virt-addons = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-addons-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_kernel-uki-virt-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-uki-virt-addons}"
SRC_URI[aarch64_kernel-uki-virt-addons.sha256sum] = "1872f4754556b96f63b7b7e389143af57732b5043f3934748da24c478f54cfd5"

URI_aarch64_libperf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libperf-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_libperf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libperf}"
SRC_URI[aarch64_libperf.sha256sum] = "b1d1e481b8ef0df96bc1e9bf189864a7193a94e5aa3f64ec1487086e387d92a0"

URI_aarch64_perf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perf-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_perf;unpack=0"
SRC_URI:append = " ${URI_aarch64_perf}"
SRC_URI[aarch64_perf.sha256sum] = "c8149217301a62fb0ced9797c23e87f2687b7fc4df49048e20ef01fcfeee5928"

URI_aarch64_python3-perf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-perf-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_python3-perf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-perf}"
SRC_URI[aarch64_python3-perf.sha256sum] = "3be8f633c39061d0f4de82cf14f5611cf991187ea01a9178ecbc97adc7540eb5"

URI_aarch64_rtla = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rtla-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_rtla;unpack=0"
SRC_URI:append = " ${URI_aarch64_rtla}"
SRC_URI[aarch64_rtla.sha256sum] = "59cea1e9f807d7b9d2439638d73035b5a07645db519f4d18d7c4ae9d5d4b590f"

URI_aarch64_rv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rv-6.12.0-211.49.1.el10_2.aarch64.rpm;name=aarch64_rv;unpack=0"
SRC_URI:append = " ${URI_aarch64_rv}"
SRC_URI[aarch64_rv.sha256sum] = "61b597489c8c614b929efadc7c16b91b7078c431dfbb32179ea63aac0301ba98"

RDEPENDS:kernel = " \
 kernel-core \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 "
RDEPENDS:kernel-abi-stablelists = " \
 "
RDEPENDS:kernel-core = " \
 bash \
 dracut \
 kernel-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-cross-headers = " \
 "
RDEPENDS:kernel-debug = " \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 "
RDEPENDS:kernel-debug-core = " \
 bash \
 dracut \
 kernel-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-debug-devel-matched = " \
 kernel-debug-core \
 kernel-debug-devel \
 "
RDEPENDS:kernel-debug-modules:x86_64_v2 = " \
 bash \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-core:aarch64 = " \
 bash \
 kernel-debug-core \
"
RDEPENDS:kernel-debug-modules-extra:x86_64_v2 = " \
 bash \
 kernel-debug-modules \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-extra:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-uki-virt = " \
 bash \
 kernel-debug-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-devel-matched = " \
 kernel-core \
 kernel-devel \
 "
RDEPENDS:kernel-doc = " \
 "
RDEPENDS:kernel-headers = " \
 "
RDEPENDS:kernel-modules:x86_64_v2 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2 \
"
RDEPENDS:kernel-modules:aarch64 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.aarch64 \
"
RDEPENDS:kernel-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2 \
"
RDEPENDS:kernel-modules-core:aarch64 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.aarch64 \
"
RDEPENDS:kernel-modules-extra:x86_64_v2 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2 \
"
RDEPENDS:kernel-modules-extra:aarch64 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.aarch64 \
"
RDEPENDS:kernel-modules-extra-matched = " \
 "
RDEPENDS:kernel-tools:x86_64_v2 = " \
 glibc \
 kernel-tools-libs \
 libcap \
 libnl3 \
 ncurses-libs \
 pciutils-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools:aarch64 = " \
 glibc \
 kernel-tools-libs \
 ncurses-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools-libs = " \
 bash \
 glibc \
 "
RDEPENDS:kernel-tools-libs-devel = " \
 glibc \
 kernel-tools \
 kernel-tools-libs \
 python3 \
 "
RDEPENDS:kernel-uki-virt = " \
 bash \
 kernel-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-uki-virt-addons = " \
 kernel-uki-virt \
 systemd \
 "
RDEPENDS:libperf = " \
 glibc \
 "
RDEPENDS:perf:x86_64_v2 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:perf:aarch64 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:x86_64_v2 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:aarch64 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:rtla = " \
 glibc \
 kernel-tools-libs \
 libbpf \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:rv = " \
 glibc \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:kernel-64k = " \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 "
RDEPENDS:kernel-64k-core = " \
 bash \
 dracut \
 kernel-64k-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug = " \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 "
RDEPENDS:kernel-64k-debug-core = " \
 bash \
 dracut \
 kernel-64k-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-debug-devel-matched = " \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 "
RDEPENDS:kernel-64k-debug-modules = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-debug-modules-core = " \
 bash \
 kernel-64k-debug-core \
 "
RDEPENDS:kernel-64k-debug-modules-extra = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-devel-matched = " \
 kernel-64k-core \
 kernel-64k-devel \
 "
RDEPENDS:kernel-64k-modules = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules-core \
 "
RDEPENDS:kernel-64k-modules-core = " \
 bash \
 kernel-64k-core \
 "
RDEPENDS:kernel-64k-modules-extra = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ rpm/virtual/kernel rpm/virtual/kernel-devel-uname-r rpm/virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2 rpm/virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.x86_64_v2+debug rpm/virtual/kmod_cuse.ko_ rpm/virtual/kmod_l2tp_ppp.ko_"

PROVIDES:append:aarch64 = " rpm/virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ rpm/virtual/kernel rpm/virtual/kernel-devel-uname-r rpm/virtual/kernel-uname-r_eq_6.12.0-211.49.1.el10_2.aarch64 rpm/virtual/kmod_cuse.ko_ rpm/virtual/kmod_l2tp_ppp.ko_"
