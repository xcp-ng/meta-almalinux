# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xz"
PE = "1"
PV = "5.6.2"
PR = "4.el10_2.1"
PACKAGES = " \
 xz \
 xz-devel \
 xz-libs \
 xz-lzma-compat \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/xz-5.6.2-4.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e6f1f45ea0970c9eb3f9ba4d9d1d9ff8e6a63b54cdbe5a093be08a609a5f7818"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xz-5.6.2-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_xz;unpack=0"
SRC_URI[x86_64_v2_xz.sha256sum] = "ffaa855f68ff23c4723d929a9ed9ee3f456315dd56e38f7083dc0063dd5839ea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xz-devel-5.6.2-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_xz-devel;unpack=0"
SRC_URI[x86_64_v2_xz-devel.sha256sum] = "6d344df0b7b2d1fa9d30daad3f7d808689bddcbba366778e6dbbc6c1c2223902"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xz-libs-5.6.2-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_xz-libs;unpack=0"
SRC_URI[x86_64_v2_xz-libs.sha256sum] = "3de2ba5004b33f4a9fb550ae9f3c92a226103c7ace19966f9fd29f3f4722af58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xz-lzma-compat-5.6.2-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_xz-lzma-compat;unpack=0"
SRC_URI[x86_64_v2_xz-lzma-compat.sha256sum] = "4caeb0d2379b857a1b0b4d8e062a387ade2393d8344bb75b269c43664fe81093"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xz-5.6.2-4.el10_2.1.aarch64.rpm;name=aarch64_xz;unpack=0"
SRC_URI[aarch64_xz.sha256sum] = "50e2d5e40610767308a0f2ed6ae446d81e72264ba7866dd637c3b8d22f070272"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xz-devel-5.6.2-4.el10_2.1.aarch64.rpm;name=aarch64_xz-devel;unpack=0"
SRC_URI[aarch64_xz-devel.sha256sum] = "882198396cc1979261b25f5bd332549b44d2bdbe9c969d4e998d7ca31a3cb9b2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xz-libs-5.6.2-4.el10_2.1.aarch64.rpm;name=aarch64_xz-libs;unpack=0"
SRC_URI[aarch64_xz-libs.sha256sum] = "bd12ebafe1715a3ad2a46e9c04bad743a5488d22fb5877504a376dedfd61f3f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xz-lzma-compat-5.6.2-4.el10_2.1.aarch64.rpm;name=aarch64_xz-lzma-compat;unpack=0"
SRC_URI[aarch64_xz-lzma-compat.sha256sum] = "6f4a1b4fad201e4e93f3b8b3b379957dd95902b736bf4426b2dc871385d613f5"

RDEPENDS:xz = " \
 bash \
 glibc \
 grep \
 xz-libs \
 "
RDEPENDS:xz-devel = " \
 pkgconf-pkg-config \
 xz-libs \
 "
RDEPENDS:xz-libs = " \
 glibc \
 "
RDEPENDS:xz-lzma-compat = " \
 glibc \
 xz \
 xz-libs \
 "
