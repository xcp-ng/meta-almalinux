# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontactinterface"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kontactinterface \
 kontactinterface-devel \
 kontactinterface-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontactinterface-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bb0fe7d3a847a773b6f6b1eb31cde15733802668748da934d0e83308ecf61c6"

URI_x86_64_v2_kontactinterface = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface}"
SRC_URI[x86_64_v2_kontactinterface.sha256sum] = "c0110111f7b3a127208b5fe3dec35a3fc0dccacb5bae000d36c1616e517473cb"

URI_x86_64_v2_kontactinterface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontactinterface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface-devel}"
SRC_URI[x86_64_v2_kontactinterface-devel.sha256sum] = "95c5be17c890d26e39eb6d9cd35a3b4ef4f92d2db4ebf982b33bb2349e982d18"

URI_x86_64_v2_kontactinterface-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontactinterface-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kontactinterface-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontactinterface-doc}"
SRC_URI[x86_64_v2_kontactinterface-doc.sha256sum] = "747824fe819773c966ab9c6efcad48f5183a1e1550a01f2472c4a0d169818ab5"

URI_aarch64_kontactinterface = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kontactinterface;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface}"
SRC_URI[aarch64_kontactinterface.sha256sum] = "8ddec5853f2a6187b4214719f7feba8f4f07d8201b6981a7f8aa47dde5737a1a"

URI_aarch64_kontactinterface-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kontactinterface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface-devel}"
SRC_URI[aarch64_kontactinterface-devel.sha256sum] = "758ec2266154f149ec5fb46a9c1214a3fc16e90d113c1404c7035725a43e718e"

URI_aarch64_kontactinterface-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kontactinterface-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kontactinterface-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontactinterface-doc}"
SRC_URI[aarch64_kontactinterface-doc.sha256sum] = "446254a623ad05310540292aa088b6a011ba4aad445058f57e91ca98a952f847"

RDEPENDS:kontactinterface = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kontactinterface-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kontactinterface \
 "
RDEPENDS:kontactinterface-doc = " \
 "
