# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nordugrid-arc7"
PV = "7.1.1"
PR = "2.el10_1"
PACKAGES = " \
 nordugrid-arc7 \
 nordugrid-arc7-arc-exporter \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-archery-manage \
 nordugrid-arc7-arex \
 nordugrid-arc7-arex-lrms-contrib \
 nordugrid-arc7-client \
 nordugrid-arc7-community-rtes \
 nordugrid-arc7-datadelivery-service \
 nordugrid-arc7-devel \
 nordugrid-arc7-hed \
 nordugrid-arc7-infosys-ldap \
 nordugrid-arc7-monitor \
 nordugrid-arc7-plugins-gfal \
 nordugrid-arc7-plugins-globus \
 nordugrid-arc7-plugins-globus-common \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-internal \
 nordugrid-arc7-plugins-lcas-lcmaps \
 nordugrid-arc7-plugins-needed \
 nordugrid-arc7-plugins-python \
 nordugrid-arc7-plugins-s3 \
 nordugrid-arc7-plugins-xrootd \
 nordugrid-arc7-test-utils \
 nordugrid-arc7-wn \
 python3-arcrest \
 python3-nordugrid-arc7 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nordugrid-arc7-7.1.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "780e8f62b4afba11b6db7ea81d0090e1a1727f2465dec1e09733832a4edfe31d"

URI_x86_64_v2_nordugrid-arc7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7}"
SRC_URI[x86_64_v2_nordugrid-arc7.sha256sum] = "bdbed791a8e6f108d8281c4712757752afcc2d8f8182299b6a69c8ee92b67834"

URI_x86_64_v2_nordugrid-arc7-arc-exporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arc-exporter-7.1.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arc-exporter}"
SRC_URI[x86_64_v2_nordugrid-arc7-arc-exporter.sha256sum] = "1c9545c14158d5350b83604ceb597cf7600edcefeadb1b141e8f9c0b5cb2fe4c"

URI_x86_64_v2_nordugrid-arc7-arcctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arcctl}"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl.sha256sum] = "2be0e0f5213f7eb94f9d6a6d205ff6d501e688a36ad0b369f5a73c31d31318a7"

URI_x86_64_v2_nordugrid-arc7-arcctl-service = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arcctl-service-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arcctl-service}"
SRC_URI[x86_64_v2_nordugrid-arc7-arcctl-service.sha256sum] = "c8c822c934162a6bd8f29e908a4f50f740e78e3d08337fa51b7ff1a90669f6d8"

URI_x86_64_v2_nordugrid-arc7-archery-manage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-archery-manage-7.1.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-archery-manage}"
SRC_URI[x86_64_v2_nordugrid-arc7-archery-manage.sha256sum] = "7ad90d93bf1361a241ee22f2c0226c64e9558e379bf78d4438e18b7a58779274"

URI_x86_64_v2_nordugrid-arc7-arex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-arex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arex}"
SRC_URI[x86_64_v2_nordugrid-arc7-arex.sha256sum] = "1fb22fd82b56ba4a415ee3e5adbb6119d40d12bd076b5fce984a6f95a0d14197"

URI_x86_64_v2_nordugrid-arc7-arex-lrms-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-arex-lrms-contrib-7.1.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-arex-lrms-contrib}"
SRC_URI[x86_64_v2_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "667b5906f8290b77aaf984910db1ca3906c47ed86feb555d2786c7fe39683cbb"

URI_x86_64_v2_nordugrid-arc7-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-client-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-client}"
SRC_URI[x86_64_v2_nordugrid-arc7-client.sha256sum] = "837f801f31e9e2a3ed8a0422ebe8aea0ff4ff8859629b59177583e02d9f89cc2"

URI_x86_64_v2_nordugrid-arc7-community-rtes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-community-rtes-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-community-rtes}"
SRC_URI[x86_64_v2_nordugrid-arc7-community-rtes.sha256sum] = "49c45f3f0239b3d5f5111b19479a6a95eb9eeff367c927a64d13570f7899a0ed"

URI_x86_64_v2_nordugrid-arc7-datadelivery-service = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-datadelivery-service-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-datadelivery-service}"
SRC_URI[x86_64_v2_nordugrid-arc7-datadelivery-service.sha256sum] = "4f0ef9f0055a99d85e5ddd861009ea6a691be08d9b8ad1648952ad0bba055260"

URI_x86_64_v2_nordugrid-arc7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-devel-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-devel}"
SRC_URI[x86_64_v2_nordugrid-arc7-devel.sha256sum] = "274af2bd80d3c3f1e397de49c50f3c69e01a630cee7f2bf26f1f440f685bfb30"

URI_x86_64_v2_nordugrid-arc7-hed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-hed-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-hed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-hed}"
SRC_URI[x86_64_v2_nordugrid-arc7-hed.sha256sum] = "42f76b1737ab6c8df1b2fac40e6ee96cb584860fbeb4e82c2fede20825b871df"

URI_x86_64_v2_nordugrid-arc7-infosys-ldap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-infosys-ldap-7.1.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-infosys-ldap}"
SRC_URI[x86_64_v2_nordugrid-arc7-infosys-ldap.sha256sum] = "299803995333d3bff18c0c1cc36d8559aa3e2a40cc8c6cd20e6cd22c40b4f587"

URI_x86_64_v2_nordugrid-arc7-monitor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-monitor-7.1.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_nordugrid-arc7-monitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-monitor}"
SRC_URI[x86_64_v2_nordugrid-arc7-monitor.sha256sum] = "3fa2a381e45798dd12a67978ac73df5838e346465b2239e2065763a22c08959b"

URI_x86_64_v2_nordugrid-arc7-plugins-gfal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gfal-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-gfal}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gfal.sha256sum] = "64e6ee336aef208bab45fb9a46920eed310f7aec87b2aac48cc248a3e9a89971"

URI_x86_64_v2_nordugrid-arc7-plugins-globus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-globus}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus.sha256sum] = "cbe1d9a9e9fb7c2c86ee387985ace019ef9d7b0363c2d3d9f72fcfa1408006ce"

URI_x86_64_v2_nordugrid-arc7-plugins-globus-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-globus-common-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-globus-common}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-globus-common.sha256sum] = "d195bfd98e4112a6285eb72c361ec99d7eb0ef9f0e3840d5267b956595491a5b"

URI_x86_64_v2_nordugrid-arc7-plugins-gridftp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-gridftp-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-gridftp}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-gridftp.sha256sum] = "55a2acde028ce098327bca34824d29727fa5bd63e1d90650a37f35bb62b42dfa"

URI_x86_64_v2_nordugrid-arc7-plugins-internal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-internal-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-internal}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-internal.sha256sum] = "6ca75467c4723531056f241f5780964425e73fdc0eb5782f0c8b5967a48e34d8"

URI_x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-lcas-lcmaps-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "9bb2f3b585568961d23d22955fc6900d8a55bb1e87d4d73b01c2e4d1f7bf44eb"

URI_x86_64_v2_nordugrid-arc7-plugins-needed = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-needed-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-needed}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-needed.sha256sum] = "601ff11a307cc36eadeaf036323703a6e231a97c47878aaea2d65943a8139ed5"

URI_x86_64_v2_nordugrid-arc7-plugins-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-python-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-python}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-python.sha256sum] = "2d993108fef29f939a2ea50511d348d2ebc9eae327d2b934c55a383a412bb5e6"

URI_x86_64_v2_nordugrid-arc7-plugins-s3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-s3-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-s3}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-s3.sha256sum] = "b823ddcc54b1f856a5d8796c9fc9489d5ff2dce93d78c7a136c82ba5f5941525"

URI_x86_64_v2_nordugrid-arc7-plugins-xrootd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-plugins-xrootd-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-plugins-xrootd}"
SRC_URI[x86_64_v2_nordugrid-arc7-plugins-xrootd.sha256sum] = "0dba4b486c3c2f73107ce09ef5a3a6928a1b7691e952debc663512d9144f8c74"

URI_x86_64_v2_nordugrid-arc7-test-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-test-utils-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-test-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-test-utils}"
SRC_URI[x86_64_v2_nordugrid-arc7-test-utils.sha256sum] = "57e9d5a5c6aa6f8bff98f126c8cc7d22d88b2783cd113b588d400a0e13f00712"

URI_x86_64_v2_nordugrid-arc7-wn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nordugrid-arc7-wn-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nordugrid-arc7-wn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nordugrid-arc7-wn}"
SRC_URI[x86_64_v2_nordugrid-arc7-wn.sha256sum] = "016fdbe20e9d9f13aac3dfaf36c78acfda1369e061bb4c05c250b812fec7243e"

URI_x86_64_v2_python3-arcrest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-arcrest-7.1.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-arcrest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-arcrest}"
SRC_URI[x86_64_v2_python3-arcrest.sha256sum] = "3d2f5f1182f37a93aafa2bc9fac76b237b1453e2009354669f43f5236d6c1fc8"

URI_x86_64_v2_python3-nordugrid-arc7 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nordugrid-arc7-7.1.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nordugrid-arc7}"
SRC_URI[x86_64_v2_python3-nordugrid-arc7.sha256sum] = "7985db5308e7b6d5f16851829a198d31b57f61a3f12f9825ffae70495a3c9445"

URI_aarch64_nordugrid-arc7 = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7}"
SRC_URI[aarch64_nordugrid-arc7.sha256sum] = "baf11df5bec2c5a6871ca1454f16fb1819cce8629a070939266c15b52733b616"

URI_aarch64_nordugrid-arc7-arc-exporter = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arc-exporter-7.1.1-2.el10_1.noarch.rpm;name=aarch64_nordugrid-arc7-arc-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arc-exporter}"
SRC_URI[aarch64_nordugrid-arc7-arc-exporter.sha256sum] = "9950d46bf10fb4df97b85e1c5c9ed40034bcccb7f84b110e77777d519bf45e0b"

URI_aarch64_nordugrid-arc7-arcctl = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arcctl}"
SRC_URI[aarch64_nordugrid-arc7-arcctl.sha256sum] = "fd890a3cb30ef4b81f55315e334ca302d445c28a03ecc7df06aef10ac37ceb59"

URI_aarch64_nordugrid-arc7-arcctl-service = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arcctl-service-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-arcctl-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arcctl-service}"
SRC_URI[aarch64_nordugrid-arc7-arcctl-service.sha256sum] = "d2bc781e2f253c9cedea02b0e70fcfeaa827355d1f014772007cf26e2b3435e6"

URI_aarch64_nordugrid-arc7-archery-manage = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-archery-manage-7.1.1-2.el10_1.noarch.rpm;name=aarch64_nordugrid-arc7-archery-manage;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-archery-manage}"
SRC_URI[aarch64_nordugrid-arc7-archery-manage.sha256sum] = "f66eba36b8f47b9f3535439d2e775325a55305f922e3d66972e6ed1d5bf0bc25"

URI_aarch64_nordugrid-arc7-arex = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-arex;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arex}"
SRC_URI[aarch64_nordugrid-arc7-arex.sha256sum] = "031dc626f628da63d6ded94f01d177ad3ebd503d8957eb62855dd862eaeadee8"

URI_aarch64_nordugrid-arc7-arex-lrms-contrib = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-arex-lrms-contrib-7.1.1-2.el10_1.noarch.rpm;name=aarch64_nordugrid-arc7-arex-lrms-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-arex-lrms-contrib}"
SRC_URI[aarch64_nordugrid-arc7-arex-lrms-contrib.sha256sum] = "16e645f0ece9eb210a0629edf02dba0346dca8d2375e7e6dd4d43d163af96729"

URI_aarch64_nordugrid-arc7-client = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-client-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-client}"
SRC_URI[aarch64_nordugrid-arc7-client.sha256sum] = "89bb0dce3168471adbde4e9840ec71649f9998beefe27bceacc9a96ad31fefd2"

URI_aarch64_nordugrid-arc7-community-rtes = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-community-rtes-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-community-rtes;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-community-rtes}"
SRC_URI[aarch64_nordugrid-arc7-community-rtes.sha256sum] = "db2d2b4a5437c130d605066c2b21d5ddf958398dcb5181e1109e5461c435874b"

URI_aarch64_nordugrid-arc7-datadelivery-service = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-datadelivery-service-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-datadelivery-service;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-datadelivery-service}"
SRC_URI[aarch64_nordugrid-arc7-datadelivery-service.sha256sum] = "017c6226c6a71ac8d151599562067c00be794a84fac67034dc913d99dc313213"

URI_aarch64_nordugrid-arc7-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-devel-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-devel}"
SRC_URI[aarch64_nordugrid-arc7-devel.sha256sum] = "c76ff5732a8e54b9ef2ebd93c0246e7408505f7e187398224eaa0e17058c1ece"

URI_aarch64_nordugrid-arc7-hed = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-hed-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-hed;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-hed}"
SRC_URI[aarch64_nordugrid-arc7-hed.sha256sum] = "6c35283642b9d546f23d2ace1d1e1d56a1d833012f7aac36fc68bc3e31657f35"

URI_aarch64_nordugrid-arc7-infosys-ldap = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-infosys-ldap-7.1.1-2.el10_1.noarch.rpm;name=aarch64_nordugrid-arc7-infosys-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-infosys-ldap}"
SRC_URI[aarch64_nordugrid-arc7-infosys-ldap.sha256sum] = "2dd6da415eae2ac3f2ca2408bfe147d0061ee1774a275bad96829b46fc039d87"

URI_aarch64_nordugrid-arc7-monitor = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-monitor-7.1.1-2.el10_1.noarch.rpm;name=aarch64_nordugrid-arc7-monitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-monitor}"
SRC_URI[aarch64_nordugrid-arc7-monitor.sha256sum] = "40f44433908916cb869a090351768ab78a6830c1364e47f9c530116fb4ed1c24"

URI_aarch64_nordugrid-arc7-plugins-gfal = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gfal-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gfal;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-gfal}"
SRC_URI[aarch64_nordugrid-arc7-plugins-gfal.sha256sum] = "43e7551e295463e7fa88385cf3c914a685d24f49da44bfbe8fa487c75345294d"

URI_aarch64_nordugrid-arc7-plugins-globus = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-globus}"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus.sha256sum] = "87547eb7ac75f7fdf9e95a97fc972cbda370f7aaa70d19a0eef1ecc8e23f3928"

URI_aarch64_nordugrid-arc7-plugins-globus-common = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-globus-common-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-globus-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-globus-common}"
SRC_URI[aarch64_nordugrid-arc7-plugins-globus-common.sha256sum] = "4884b6804bfd2ede234017abbfaf1da44def3bc07445dcc29832490dda2a1aca"

URI_aarch64_nordugrid-arc7-plugins-gridftp = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-gridftp-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-gridftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-gridftp}"
SRC_URI[aarch64_nordugrid-arc7-plugins-gridftp.sha256sum] = "64d3ceb8af3ef6df51e7b59392e54331e99c4c26b7e6f75f09d1459be8753226"

URI_aarch64_nordugrid-arc7-plugins-internal = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-internal-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-internal;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-internal}"
SRC_URI[aarch64_nordugrid-arc7-plugins-internal.sha256sum] = "7cb0d31b243cf2c096fbcfd416d3d32e385fad74df1c149c92897287179ca07f"

URI_aarch64_nordugrid-arc7-plugins-lcas-lcmaps = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-lcas-lcmaps-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-lcas-lcmaps;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-lcas-lcmaps}"
SRC_URI[aarch64_nordugrid-arc7-plugins-lcas-lcmaps.sha256sum] = "2bfda00b366a25591606c8f4ecc53bad582eecaf2056a32e8da8c13a228d8435"

URI_aarch64_nordugrid-arc7-plugins-needed = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-needed-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-needed;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-needed}"
SRC_URI[aarch64_nordugrid-arc7-plugins-needed.sha256sum] = "e7b9e12cc34e402494b3afdf6e3ec07d2aabfbc6c3f760143330a4b775e0e869"

URI_aarch64_nordugrid-arc7-plugins-python = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-python-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-python}"
SRC_URI[aarch64_nordugrid-arc7-plugins-python.sha256sum] = "434129df980a33c27028ff326337209892673d7f5392915d11dbaaec64921069"

URI_aarch64_nordugrid-arc7-plugins-s3 = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-s3-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-s3;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-s3}"
SRC_URI[aarch64_nordugrid-arc7-plugins-s3.sha256sum] = "91379ffb8c206ab5badec91d99fc8fd56e3c092918e829757d1f579e1c2abc57"

URI_aarch64_nordugrid-arc7-plugins-xrootd = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-plugins-xrootd-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-plugins-xrootd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-plugins-xrootd}"
SRC_URI[aarch64_nordugrid-arc7-plugins-xrootd.sha256sum] = "7062971f022859e328683c0b71cd83c19153219b0e2ddfb0ca53f84707f6c042"

URI_aarch64_nordugrid-arc7-test-utils = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-test-utils-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-test-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-test-utils}"
SRC_URI[aarch64_nordugrid-arc7-test-utils.sha256sum] = "34f45e75eff9cd1f2c303cebe479b7fbf99c7112885ddc78fffd90af28c272ca"

URI_aarch64_nordugrid-arc7-wn = "${EPEL_MIRROR}/aarch64/Packages/n/nordugrid-arc7-wn-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_nordugrid-arc7-wn;unpack=0"
SRC_URI:append = " ${URI_aarch64_nordugrid-arc7-wn}"
SRC_URI[aarch64_nordugrid-arc7-wn.sha256sum] = "57104ef7db5d1026bdbdd0995b6df99c46d62ac2d7d35a201bda3af37a284ca6"

URI_aarch64_python3-arcrest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-arcrest-7.1.1-2.el10_1.noarch.rpm;name=aarch64_python3-arcrest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-arcrest}"
SRC_URI[aarch64_python3-arcrest.sha256sum] = "5f0f712f82507780535467be17b62ca2e31b4cf914088aa64a7d2812152b5b21"

URI_aarch64_python3-nordugrid-arc7 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nordugrid-arc7-7.1.1-2.el10_1.aarch64.rpm;name=aarch64_python3-nordugrid-arc7;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nordugrid-arc7}"
SRC_URI[aarch64_python3-nordugrid-arc7.sha256sum] = "bc8329a32a705dbc2b0978099fe1ac46eb9b4f9047b46a32c075484482617bfe"

RDEPENDS:nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 python3 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arc-exporter = " \
 python3 \
 python3-prometheus_client \
 "
RDEPENDS:nordugrid-arc7-arcctl = " \
 nordugrid-arc7 \
 python3 \
 python3-jwcrypto \
 "
RDEPENDS:nordugrid-arc7-arcctl-service = " \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 python3 \
 "
RDEPENDS:nordugrid-arc7-archery-manage = " \
 python3 \
 python3-dns \
 python3-ldap \
 "
RDEPENDS:nordugrid-arc7-arex = " \
 bash \
 findutils \
 glib2 \
 glibc \
 glibmm2.68 \
 hostname \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl \
 openssl-libs \
 perl-Data-Dumper \
 perl-Digest-SHA1 \
 perl-DirHandle \
 perl-English \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-JSON-XS \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-PathTools \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-XML-Simple \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-vars \
 procps-ng \
 python3 \
 sqlite-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-arex-lrms-contrib = " \
 bash \
 nordugrid-arc7-arex \
 perl-DBI \
 perl-Data-Dumper \
 perl-Exporter \
 perl-POSIX \
 perl-Sys-Hostname \
 perl-XML-Simple \
 perl-libs \
 "
RDEPENDS:nordugrid-arc7-client = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-community-rtes = " \
 gnupg2 \
 nordugrid-arc7-arcctl \
 nordugrid-arc7-arex \
 python3 \
 python3-dns \
 "
RDEPENDS:nordugrid-arc7-datadelivery-service = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 logrotate \
 nordugrid-arc7 \
 nordugrid-arc7-arcctl-service \
 nordugrid-arc7-hed \
 nordugrid-arc7-plugins-needed \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-devel = " \
 glib2 \
 glibc \
 glibmm2.68 \
 glibmm2.68-devel \
 libgcc \
 libstdc++ \
 libxml2-devel \
 nordugrid-arc7 \
 openssl-devel \
 "
RDEPENDS:nordugrid-arc7-hed = " \
 bash \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 systemd \
 systemd-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-infosys-ldap = " \
 bash \
 bdii \
 glue-schema \
 logrotate \
 nordugrid-arc7-arcctl-service \
 openldap-servers \
 policycoreutils-python-utils \
 systemd \
 "
RDEPENDS:nordugrid-arc7-monitor = " \
 nordugrid-arc7 \
 php \
 php-gd \
 php-ldap \
 "
RDEPENDS:nordugrid-arc7-plugins-gfal = " \
 gfal2 \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-globus = " \
 nordugrid-arc7-plugins-gridftp \
 nordugrid-arc7-plugins-lcas-lcmaps \
 "
RDEPENDS:nordugrid-arc7-plugins-globus-common = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-callback \
 globus-gssapi-gsi \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-gridftp = " \
 glib2 \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-ftp-client \
 globus-ftp-control \
 globus-io \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-internal = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nordugrid-arc7-arex \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-lcas-lcmaps = " \
 glibc \
 glibmm2.68 \
 globus-common \
 globus-gsi-cert-utils \
 globus-gsi-credential \
 globus-gssapi-gsi \
 libgcc \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-globus-common \
 openssl-libs \
 "
RDEPENDS:nordugrid-arc7-plugins-needed = " \
 glib2 \
 glibc \
 glibmm2.68 \
 ldns \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-python = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3-libs \
 python3-nordugrid-arc7 \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-s3 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libs3 \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-plugins-xrootd = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libuuid \
 libxml2 \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 xrootd-client-libs \
 zlib-ng-compat \
 "
RDEPENDS:nordugrid-arc7-test-utils = " \
 glibc \
 libgcc \
 libsigc++30 \
 libstdc++ \
 nordugrid-arc7 \
 nordugrid-arc7-plugins-needed \
 "
RDEPENDS:nordugrid-arc7-wn = " \
 glibc \
 "
RDEPENDS:python3-arcrest = " \
 python3 \
 python3-cryptography \
 "
RDEPENDS:python3-nordugrid-arc7 = " \
 glib2 \
 glibc \
 glibmm2.68 \
 libgcc \
 libsigc++30 \
 libstdc++ \
 libtool-ltdl \
 libuuid \
 libxml2 \
 libxslt \
 nordugrid-arc7 \
 nspr \
 nss \
 nss-util \
 openssl-libs \
 python3 \
 python3-libs \
 sqlite-libs \
 xmlsec1 \
 xmlsec1-openssl \
 zlib-ng-compat \
 "
