# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel"
PV = "6.12.0"
PR = "124.56.5.el10_1"
PACKAGES:x86_64_v2 = " \
 kernel \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-debug-uki-virt \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"
PACKAGES:aarch64 = " \
 kernel \
 kernel-64k \
 kernel-64k-core \
 kernel-64k-debug \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 kernel-64k-debug-devel-matched \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 kernel-64k-devel \
 kernel-64k-devel-matched \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kernel-6.12.0-124.56.5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57d8a023bb27207f694ae18670b598092bcbb4a303dcb21511fcda265fe5e7d8"

URI_x86_64_v2_kernel = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel}"
SRC_URI[x86_64_v2_kernel.sha256sum] = "81b23cf1036066db7bfcbedf47ce22fc6b0377b291e45aa0404579f4054ddd56"
RPROVIDES:kernel:append:x86_64_v2 = " virtual/kernel"

URI_x86_64_v2_kernel-abi-stablelists = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-abi-stablelists-6.12.0-124.56.5.el10_1.noarch.rpm;name=x86_64_v2_kernel-abi-stablelists;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-abi-stablelists}"
SRC_URI[x86_64_v2_kernel-abi-stablelists.sha256sum] = "57508a114acb4b9d36f36fd3a49c5a75cafde8bb1637149fccdb1ff223d3558c"

URI_x86_64_v2_kernel-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-core-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-core}"
SRC_URI[x86_64_v2_kernel-core.sha256sum] = "f66eaa52f5fbe7f1bb505d814b4af5f5364fe06e2e553a0dc1e52c44a5364152"
RPROVIDES:kernel-core:append:x86_64_v2 = " virtual/kernel virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2"

URI_x86_64_v2_kernel-cross-headers = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-cross-headers-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-cross-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-cross-headers}"
SRC_URI[x86_64_v2_kernel-cross-headers.sha256sum] = "a1294396af4977fca88f24006c18677bb987bf2b6d48ccea195834f26a565e11"

URI_x86_64_v2_kernel-debug = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-debug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug}"
SRC_URI[x86_64_v2_kernel-debug.sha256sum] = "3261209aebff4d24bb2d3ca399f4f1051f6e174ceafe7cc7022a3f0ac352efe3"

URI_x86_64_v2_kernel-debug-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-core-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-core}"
SRC_URI[x86_64_v2_kernel-debug-core.sha256sum] = "6b3bd18383aafddb4501d33eadc67eea13ddb4a08fe2e2d8021d688a92dcf3ac"
RPROVIDES:kernel-debug-core:append:x86_64_v2 = " virtual/kernel virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2+debug"

URI_x86_64_v2_kernel-debug-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-devel}"
SRC_URI[x86_64_v2_kernel-debug-devel.sha256sum] = "446f1e17d2f935d3be897fc00451f118cb3ada680c107ec9e6efc9dc42346a42"
RPROVIDES:kernel-debug-devel:append:x86_64_v2 = " virtual/kernel-devel-uname-r"

URI_x86_64_v2_kernel-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-matched-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-devel-matched}"
SRC_URI[x86_64_v2_kernel-debug-devel-matched.sha256sum] = "5e6e8f38c092c5af35d94c5c9d99e8dacab9f210ff86784d73ec03849caca1d3"

URI_x86_64_v2_kernel-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules}"
SRC_URI[x86_64_v2_kernel-debug-modules.sha256sum] = "de0712a3d60829ecb7132fc3c80b46c4bf729488c5cc5b4e6f7eb48a2f0e0fc1"
RPROVIDES:kernel-debug-modules:append:x86_64_v2 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_kernel-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-core-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules-core}"
SRC_URI[x86_64_v2_kernel-debug-modules-core.sha256sum] = "90a35c989b4ac8d660f860d25278ddab4de63e8692db431549326e934c65c5e2"

URI_x86_64_v2_kernel-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-extra-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-modules-extra}"
SRC_URI[x86_64_v2_kernel-debug-modules-extra.sha256sum] = "2d8ed5640cdfd3b1c4842cbc0efbdf7239f235b3229b46f47be6c18d5e1101fe"
RPROVIDES:kernel-debug-modules-extra:append:x86_64_v2 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_x86_64_v2_kernel-debug-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-uki-virt-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-uki-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-debug-uki-virt}"
SRC_URI[x86_64_v2_kernel-debug-uki-virt.sha256sum] = "a84fdf12ff482177cd2a9fdaf059730ffcd6dae201fbff49b1c25fa339e89bd8"
RPROVIDES:kernel-debug-uki-virt:append:x86_64_v2 = " virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2+debug"

URI_x86_64_v2_kernel-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-devel}"
SRC_URI[x86_64_v2_kernel-devel.sha256sum] = "8b97071b758eb8ad78c1140529603fd61eb8ea9553ec34ff2199e0dad448ed5b"
RPROVIDES:kernel-devel:append:x86_64_v2 = " virtual/kernel-devel-uname-r"

URI_x86_64_v2_kernel-devel-matched = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-matched-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-devel-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-devel-matched}"
SRC_URI[x86_64_v2_kernel-devel-matched.sha256sum] = "f79bac7cf44e0ff1c1f7ac737b59ccc073e7fb3af958c7b4374431d11b619ae8"

URI_x86_64_v2_kernel-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-doc-6.12.0-124.56.5.el10_1.noarch.rpm;name=x86_64_v2_kernel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-doc}"
SRC_URI[x86_64_v2_kernel-doc.sha256sum] = "cbea24514d417add9bdfde9a80375060ebd3c921893b222fbb8d80c2130bc011"

URI_x86_64_v2_kernel-headers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-headers-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-headers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-headers}"
SRC_URI[x86_64_v2_kernel-headers.sha256sum] = "3a1f5fd01ca118c737530326e1d6b38ee76001a21a7b966b042b300ab8b7e3cd"

URI_x86_64_v2_kernel-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules}"
SRC_URI[x86_64_v2_kernel-modules.sha256sum] = "a7e00b8720fc0ba4ea21e3b3fb18a853b2ac8d363365cf80278c4d4a52d8ec95"
RPROVIDES:kernel-modules:append:x86_64_v2 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_x86_64_v2_kernel-modules-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-core-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-core}"
SRC_URI[x86_64_v2_kernel-modules-core.sha256sum] = "cb6f82a90b500901aca4cb6341729603f04e1c5a14e345998939642244e4e778"

URI_x86_64_v2_kernel-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-extra}"
SRC_URI[x86_64_v2_kernel-modules-extra.sha256sum] = "322526921e0516ceeec051b1784a23d29f778cb73fadf15fd74fba3660500bd2"
RPROVIDES:kernel-modules-extra:append:x86_64_v2 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_x86_64_v2_kernel-modules-extra-matched = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-matched-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra-matched;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-modules-extra-matched}"
SRC_URI[x86_64_v2_kernel-modules-extra-matched.sha256sum] = "9488ab7e6edc10d589a12df7a8aef7b8ad18de709cf6b7e81db6b019f6eca170"

URI_x86_64_v2_kernel-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools}"
SRC_URI[x86_64_v2_kernel-tools.sha256sum] = "cb9d088e20004694a7774083fa35a8c2721a6bd2a1092d7408745328e356258a"

URI_x86_64_v2_kernel-tools-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-libs-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools-libs}"
SRC_URI[x86_64_v2_kernel-tools-libs.sha256sum] = "9cd90a7212619c8df2f862d6d21d5875f669433549b8145a1a96a4e852750fa8"

URI_x86_64_v2_kernel-tools-libs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-tools-libs-devel-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-tools-libs-devel}"
SRC_URI[x86_64_v2_kernel-tools-libs-devel.sha256sum] = "586604dc115133bffb81ff316216bd1e6c5b6b7614aeef8f09702e116dbdf9de"

URI_x86_64_v2_kernel-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-uki-virt}"
SRC_URI[x86_64_v2_kernel-uki-virt.sha256sum] = "3c1ffa38c602b3524108cd782fde9ca95eeacdffecf63a1de348f3f11ffd0a44"
RPROVIDES:kernel-uki-virt:append:x86_64_v2 = " virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2"

URI_x86_64_v2_kernel-uki-virt-addons = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-addons-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernel-uki-virt-addons}"
SRC_URI[x86_64_v2_kernel-uki-virt-addons.sha256sum] = "a6ca4e181fa8fe93494a0106388df7855f5f2b2483d7179e54c040b5bf39e970"

URI_x86_64_v2_libperf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libperf-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_libperf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libperf}"
SRC_URI[x86_64_v2_libperf.sha256sum] = "aec845b643b6a573ab081ba1ea53aaf683ea6567de53a5cb0805af9fb9ecb254"

URI_x86_64_v2_perf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perf-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_perf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perf}"
SRC_URI[x86_64_v2_perf.sha256sum] = "3e20429d7448bb8ca70762784b4888f5cc2b9240ff62117e6a71a13784f6eb0c"

URI_x86_64_v2_python3-perf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-perf-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-perf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-perf}"
SRC_URI[x86_64_v2_python3-perf.sha256sum] = "c46cb8a8f0f4aa2ccc5f1bdfcc3cfd15169dc505682671d6f32b4dc8d4f98b92"

URI_x86_64_v2_rtla = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rtla-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_rtla;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rtla}"
SRC_URI[x86_64_v2_rtla.sha256sum] = "cb6c530835dc746288d8adf1f5644a384a639414a47ed81e9912e8cf4f0b9f9e"

URI_x86_64_v2_rv = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rv-6.12.0-124.56.5.el10_1.x86_64_v2.rpm;name=x86_64_v2_rv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rv}"
SRC_URI[x86_64_v2_rv.sha256sum] = "f3cb482e415d1c9fae4cc1fd704e8860985d894dea4f15f535022e7809fc02da"

URI_aarch64_kernel = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel}"
SRC_URI[aarch64_kernel.sha256sum] = "097bef69b05709279f4e8c6e9c4eaa77d5d34252524d4b5821f4d7982edc7871"
RPROVIDES:kernel:append:aarch64 = " virtual/kernel"

URI_aarch64_kernel-64k = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k}"
SRC_URI[aarch64_kernel-64k.sha256sum] = "c8808655d9e8c58a25fb009bf279923cff42a4835d7904343e607adcf4c27cf5"

URI_aarch64_kernel-64k-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-core-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-core}"
SRC_URI[aarch64_kernel-64k-core.sha256sum] = "e784f9914a120a143cfcfb950cf9aa2b838c08800c801a8134c5d9814f5d5c0a"
RPROVIDES:kernel-64k-core:append:aarch64 = " virtual/kernel"

URI_aarch64_kernel-64k-debug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug}"
SRC_URI[aarch64_kernel-64k-debug.sha256sum] = "de6e9698c4dc9c7cc11ce80e5a7b7f82654adbae88adc48842b703710a3fc2b2"

URI_aarch64_kernel-64k-debug-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-core-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-debug-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-core}"
SRC_URI[aarch64_kernel-64k-debug-core.sha256sum] = "d85462042c6432c59e88074454a9e2bed60ebb276554d05dd743b22f55ef12e5"
RPROVIDES:kernel-64k-debug-core:append:aarch64 = " virtual/kernel"

URI_aarch64_kernel-64k-debug-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-devel}"
SRC_URI[aarch64_kernel-64k-debug-devel.sha256sum] = "8d75d1024e2d200832e249253197908b140859f0353b8786608024a80e2c2e39"
RPROVIDES:kernel-64k-debug-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

URI_aarch64_kernel-64k-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-matched-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-devel-matched}"
SRC_URI[aarch64_kernel-64k-debug-devel-matched.sha256sum] = "b55158b4e03b7d32f79497abecf91c4c0449f233fc7fb58afda96530eec60505"

URI_aarch64_kernel-64k-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-debug-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules}"
SRC_URI[aarch64_kernel-64k-debug-modules.sha256sum] = "af4824fe1223cef6020e53180782fea150480d3882ac733604c3533fbc696b26"
RPROVIDES:kernel-64k-debug-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-64k-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-core-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules-core}"
SRC_URI[aarch64_kernel-64k-debug-modules-core.sha256sum] = "80198fe7c3582cbb6fc2900689d9ef24ae23b63d9e80a536dc07beb77c3d91c2"

URI_aarch64_kernel-64k-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-extra-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-debug-modules-extra}"
SRC_URI[aarch64_kernel-64k-debug-modules-extra.sha256sum] = "845f394acee0bc87079045934a67f4ec938cef8b14d9c356e7ec6589386e350b"
RPROVIDES:kernel-64k-debug-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-64k-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-devel}"
SRC_URI[aarch64_kernel-64k-devel.sha256sum] = "e73637391ce8340deaf15ed523d249bbd1db946afa9005922893337459f76c97"
RPROVIDES:kernel-64k-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

URI_aarch64_kernel-64k-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-matched-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-devel-matched}"
SRC_URI[aarch64_kernel-64k-devel-matched.sha256sum] = "999211a7baa4c2c625b0fcf87c62f32403bb4abffada1c8c8d1c8ede41373406"

URI_aarch64_kernel-64k-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules}"
SRC_URI[aarch64_kernel-64k-modules.sha256sum] = "ee3347d2ad31a459f4797a32e6a9ec7ad52e0b0c9059eecc96c3a62071b76106"
RPROVIDES:kernel-64k-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-64k-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-core-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules-core}"
SRC_URI[aarch64_kernel-64k-modules-core.sha256sum] = "679dc1d7b9f2452f23ecd25d95a4933edc69e891ef94285e81658946a8e00498"

URI_aarch64_kernel-64k-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-extra-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-64k-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-64k-modules-extra}"
SRC_URI[aarch64_kernel-64k-modules-extra.sha256sum] = "fbf9cecf71f5b31dafb711a8393aeed626dfc707b6bb41fa50d438bea12de6f7"
RPROVIDES:kernel-64k-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-abi-stablelists = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-abi-stablelists-6.12.0-124.56.5.el10_1.noarch.rpm;name=aarch64_kernel-abi-stablelists;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-abi-stablelists}"
SRC_URI[aarch64_kernel-abi-stablelists.sha256sum] = "57508a114acb4b9d36f36fd3a49c5a75cafde8bb1637149fccdb1ff223d3558c"

URI_aarch64_kernel-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-core-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-core}"
SRC_URI[aarch64_kernel-core.sha256sum] = "2b38727d2c3337ccd09febd60e4b6230b65f0a89de60ee203f1982d9f6851887"
RPROVIDES:kernel-core:append:aarch64 = " virtual/kernel virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.aarch64"

URI_aarch64_kernel-cross-headers = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-cross-headers-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-cross-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-cross-headers}"
SRC_URI[aarch64_kernel-cross-headers.sha256sum] = "3a8b83a58bd502d541ca3c2244d042d74dd1b798316c34cd793e6aad736144a6"

URI_aarch64_kernel-debug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-debug;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug}"
SRC_URI[aarch64_kernel-debug.sha256sum] = "6fe1b184930b2dd3cc5b82d57f2f926e442b34e9e3c8415c1e5c690ce440fe7c"

URI_aarch64_kernel-debug-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-core-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-debug-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-core}"
SRC_URI[aarch64_kernel-debug-core.sha256sum] = "ead94dd27a87231dc7a266b6253a78198bafd6779687597ed25df0d23f3da678"
RPROVIDES:kernel-debug-core:append:aarch64 = " virtual/kernel"

URI_aarch64_kernel-debug-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-devel}"
SRC_URI[aarch64_kernel-debug-devel.sha256sum] = "db8a2369631ec2ab2ad97a9a1c8989fbcc9ae063fb1ba3e4b0ad4c41b8c077af"
RPROVIDES:kernel-debug-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

URI_aarch64_kernel-debug-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-matched-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-debug-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-devel-matched}"
SRC_URI[aarch64_kernel-debug-devel-matched.sha256sum] = "e4d242f88d974a19b3f147af67a4450d834829911288d23480c542f9ebb8ba18"

URI_aarch64_kernel-debug-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-debug-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules}"
SRC_URI[aarch64_kernel-debug-modules.sha256sum] = "b21c6468cc9e783694ae42ed242b275da5caf60b078c9ea4b8e65ff217b3ea2f"
RPROVIDES:kernel-debug-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-debug-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-core-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-debug-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules-core}"
SRC_URI[aarch64_kernel-debug-modules-core.sha256sum] = "722436f4b238512e705747d248ec3b60b86618b6126117dfc80ef9afa422a32a"

URI_aarch64_kernel-debug-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-extra-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-debug-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-debug-modules-extra}"
SRC_URI[aarch64_kernel-debug-modules-extra.sha256sum] = "5212d50ef8426d95a424615fbbce5197a9c907f4fa54603c82a3a1ec6bcd02b1"
RPROVIDES:kernel-debug-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-devel}"
SRC_URI[aarch64_kernel-devel.sha256sum] = "26a8e49aa0568ad32ebf40864659526d3cb51a6f3303a2526e2027dd3110d949"
RPROVIDES:kernel-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

URI_aarch64_kernel-devel-matched = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-matched-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-devel-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-devel-matched}"
SRC_URI[aarch64_kernel-devel-matched.sha256sum] = "958a9afa7316156ab4817e2bc9f242885a368adaa0fe2387ad75a49feba9d920"

URI_aarch64_kernel-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-doc-6.12.0-124.56.5.el10_1.noarch.rpm;name=aarch64_kernel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-doc}"
SRC_URI[aarch64_kernel-doc.sha256sum] = "cbea24514d417add9bdfde9a80375060ebd3c921893b222fbb8d80c2130bc011"

URI_aarch64_kernel-headers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-headers-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-headers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-headers}"
SRC_URI[aarch64_kernel-headers.sha256sum] = "7681c987ab3d7f626e7d2c2f4640470ca94136e4d439ad2505e30adac9c331f7"

URI_aarch64_kernel-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules}"
SRC_URI[aarch64_kernel-modules.sha256sum] = "18184e6a49cbbdc7e57cdbca07c71bf5b1971d8f8909d165ed3c9272f8dc0b27"
RPROVIDES:kernel-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

URI_aarch64_kernel-modules-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-core-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-modules-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-core}"
SRC_URI[aarch64_kernel-modules-core.sha256sum] = "9e44c57f7af6fd563deb569a5d4807a68ce0648e39306ed0c1b9268beb4dc64a"

URI_aarch64_kernel-modules-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-extra}"
SRC_URI[aarch64_kernel-modules-extra.sha256sum] = "ab8d3721d8f523e013daa7b06fccd886e1393fca8f4e9e2bd7f098caf283b812"
RPROVIDES:kernel-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

URI_aarch64_kernel-modules-extra-matched = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-matched-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-modules-extra-matched;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-modules-extra-matched}"
SRC_URI[aarch64_kernel-modules-extra-matched.sha256sum] = "0db0d8a6a517b4a6225d06eddb319d34a0ce403c1fe5bef5d4862862370c2fc3"

URI_aarch64_kernel-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools}"
SRC_URI[aarch64_kernel-tools.sha256sum] = "94929a1b148307965d0f14f3e061e0295b06571ba8f98a0895b8152d3ee0ef11"

URI_aarch64_kernel-tools-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-libs-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-tools-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools-libs}"
SRC_URI[aarch64_kernel-tools-libs.sha256sum] = "52bdbff107b8db74b1d7fd2ea4e564891577f8f186e972673e8a5a5b38e9698e"

URI_aarch64_kernel-tools-libs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-tools-libs-devel-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-tools-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-tools-libs-devel}"
SRC_URI[aarch64_kernel-tools-libs-devel.sha256sum] = "ba6e2aee5ee19ffd47207b0c66bc918fe94eb2fb62444695f88cf7af0b29ff7c"

URI_aarch64_kernel-uki-virt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-uki-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-uki-virt}"
SRC_URI[aarch64_kernel-uki-virt.sha256sum] = "ba88b99ee3cd608a58916dcfbe81643481475f2b65b28cb53ee2bdfa1db76136"
RPROVIDES:kernel-uki-virt:append:aarch64 = " virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.aarch64"

URI_aarch64_kernel-uki-virt-addons = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-addons-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_kernel-uki-virt-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernel-uki-virt-addons}"
SRC_URI[aarch64_kernel-uki-virt-addons.sha256sum] = "e7b077da34693bce13d63f01d7956d76b2d42fc5d0ef5eba67c928a03567a77b"

URI_aarch64_libperf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libperf-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_libperf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libperf}"
SRC_URI[aarch64_libperf.sha256sum] = "56d5727fe19ffc5316ebcab7274f0a3499a8c65a2174ee3ae0112e55f122ec4b"

URI_aarch64_perf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perf-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_perf;unpack=0"
SRC_URI:append = " ${URI_aarch64_perf}"
SRC_URI[aarch64_perf.sha256sum] = "ffc80afcee37e4d45d6726c1f7be0c40b28b1b82677e3579bdecf05879682d8a"

URI_aarch64_python3-perf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-perf-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_python3-perf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-perf}"
SRC_URI[aarch64_python3-perf.sha256sum] = "ece22d0703b815fcf5b8ec9133bea1024dfce8d55d32fd28e6bef1c5a9e4d554"

URI_aarch64_rtla = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rtla-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_rtla;unpack=0"
SRC_URI:append = " ${URI_aarch64_rtla}"
SRC_URI[aarch64_rtla.sha256sum] = "dad46c02967eea4678b0f81cd4ebb8050ff01ee7423c728eb7ba4991a68172a3"

URI_aarch64_rv = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rv-6.12.0-124.56.5.el10_1.aarch64.rpm;name=aarch64_rv;unpack=0"
SRC_URI:append = " ${URI_aarch64_rv}"
SRC_URI[aarch64_rv.sha256sum] = "f5d34ae7d06d514c33b4ac98f47170ad8a5c6eef2afdd95c5f541122565446a0"

RDEPENDS:kernel = " \
 kernel-core \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 "
RDEPENDS:kernel-abi-stablelists = " \
 "
RDEPENDS:kernel-core = " \
 bash \
 dracut \
 kernel-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-cross-headers = " \
 "
RDEPENDS:kernel-debug = " \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 "
RDEPENDS:kernel-debug-core = " \
 bash \
 dracut \
 kernel-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-debug-devel-matched = " \
 kernel-debug-core \
 kernel-debug-devel \
 "
RDEPENDS:kernel-debug-modules:x86_64_v2 = " \
 bash \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-core:aarch64 = " \
 bash \
 kernel-debug-core \
"
RDEPENDS:kernel-debug-modules-extra:x86_64_v2 = " \
 bash \
 kernel-debug-modules \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-extra:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-uki-virt = " \
 bash \
 kernel-debug-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-devel-matched = " \
 kernel-core \
 kernel-devel \
 "
RDEPENDS:kernel-doc = " \
 "
RDEPENDS:kernel-headers = " \
 "
RDEPENDS:kernel-modules:x86_64_v2 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2 \
"
RDEPENDS:kernel-modules:aarch64 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.aarch64 \
"
RDEPENDS:kernel-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2 \
"
RDEPENDS:kernel-modules-core:aarch64 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.aarch64 \
"
RDEPENDS:kernel-modules-extra:x86_64_v2 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.x86_64_v2 \
"
RDEPENDS:kernel-modules-extra:aarch64 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-124.56.5.el10_1.aarch64 \
"
RDEPENDS:kernel-modules-extra-matched = " \
 "
RDEPENDS:kernel-tools:x86_64_v2 = " \
 glibc \
 kernel-tools-libs \
 libcap \
 libnl3 \
 ncurses-libs \
 pciutils-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools:aarch64 = " \
 glibc \
 kernel-tools-libs \
 ncurses-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools-libs = " \
 bash \
 glibc \
 "
RDEPENDS:kernel-tools-libs-devel = " \
 kernel-tools \
 kernel-tools-libs \
 "
RDEPENDS:kernel-uki-virt = " \
 bash \
 kernel-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-uki-virt-addons = " \
 kernel-uki-virt \
 systemd \
 "
RDEPENDS:libperf = " \
 glibc \
 "
RDEPENDS:perf:x86_64_v2 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libbpf \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 openssl-libs \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:perf:aarch64 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libbpf \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 openssl-libs \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:x86_64_v2 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libbpf \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 openssl-libs \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:aarch64 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libbpf \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 openssl-libs \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:rtla = " \
 glibc \
 kernel-tools-libs \
 libbpf \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:rv = " \
 glibc \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:kernel-64k = " \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 "
RDEPENDS:kernel-64k-core = " \
 bash \
 dracut \
 kernel-64k-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug = " \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 "
RDEPENDS:kernel-64k-debug-core = " \
 bash \
 dracut \
 kernel-64k-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-debug-devel-matched = " \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 "
RDEPENDS:kernel-64k-debug-modules = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-debug-modules-core = " \
 bash \
 kernel-64k-debug-core \
 "
RDEPENDS:kernel-64k-debug-modules-extra = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-devel-matched = " \
 kernel-64k-core \
 kernel-64k-devel \
 "
RDEPENDS:kernel-64k-modules = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules-core \
 "
RDEPENDS:kernel-64k-modules-core = " \
 bash \
 kernel-64k-core \
 "
RDEPENDS:kernel-64k-modules-extra = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 "
