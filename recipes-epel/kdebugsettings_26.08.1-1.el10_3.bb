# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdebugsettings"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdebugsettings \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdebugsettings-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cc1d280115c244ae66b603c0e884225c9cd956032e2f622062ba49af2aaea28b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdebugsettings-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdebugsettings;unpack=0"
SRC_URI[x86_64_v2_kdebugsettings.sha256sum] = "927d5232e499bae42d35c655a6db854241d5a4aec6e9889551c6f8c2e00110b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdebugsettings-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdebugsettings;unpack=0"
SRC_URI[aarch64_kdebugsettings.sha256sum] = "b066ba43cefec23bd6def2add0a5cf248cc20a9bc14251498b17dd85e76ac69d"

RDEPENDS:kdebugsettings = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
