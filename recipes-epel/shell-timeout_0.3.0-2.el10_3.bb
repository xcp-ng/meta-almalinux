# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shell-timeout"
PV = "0.3.0"
PR = "2.el10_3"
PACKAGES = " \
 shell-timeout \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/shell-timeout-0.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6ad51eed1ffbdadbe544b462c7e9b90889d507617c8c938dbd6068c00f1818a"

URI_x86_64_v2_shell-timeout = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shell-timeout-0.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_shell-timeout;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shell-timeout}"
SRC_URI[x86_64_v2_shell-timeout.sha256sum] = "010d52b278b1bf8a3fdbaa26c50005b4a4da84d06e65ee547c55f43aa4d4adee"

URI_aarch64_shell-timeout = "${EPEL_MIRROR}/aarch64/Packages/s/shell-timeout-0.3.0-2.el10_3.noarch.rpm;name=aarch64_shell-timeout;unpack=0"
SRC_URI:append = " ${URI_aarch64_shell-timeout}"
SRC_URI[aarch64_shell-timeout.sha256sum] = "0fc5e6723dfd0a55189d484e9515583d3258c9993b8cbfef210646829608c49c"

RDEPENDS:shell-timeout = " \
 filesystem \
 sed \
 virtual/coreutils \
 "
