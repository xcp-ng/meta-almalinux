# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libglvnd"
PE = "1"
PV = "1.7.0"
PR = "7.el10"
PACKAGES = " \
 libglvnd \
 libglvnd-core-devel \
 libglvnd-devel \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libglvnd-opengl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libglvnd-1.7.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e82cab48d5d1bec9d04ae22dc2fdcad31ad2faec68357b7cc74f1722c9601716"

URI_x86_64_v2_libglvnd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libglvnd-1.7.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libglvnd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libglvnd}"
SRC_URI[x86_64_v2_libglvnd.sha256sum] = "8dc7bed1a65cd165b77dd07138296adae26b7ffdcf48e5cef999e225908965ea"

URI_x86_64_v2_libglvnd-core-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libglvnd-core-devel-1.7.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libglvnd-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libglvnd-core-devel}"
SRC_URI[x86_64_v2_libglvnd-core-devel.sha256sum] = "7a9c87259266099736cd4f47d2c4dbf0069cbbb05dbc7e2ba85654353cb1463b"

URI_x86_64_v2_libglvnd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libglvnd-devel-1.7.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libglvnd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libglvnd-devel}"
SRC_URI[x86_64_v2_libglvnd-devel.sha256sum] = "30d9b6ca17a41c460aa0c2814213179e275b1618aa8e129a8b4ea43b1099cb28"

URI_x86_64_v2_libglvnd-egl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libglvnd-egl-1.7.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libglvnd-egl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libglvnd-egl}"
SRC_URI[x86_64_v2_libglvnd-egl.sha256sum] = "6920fb6db70aa9d5de54cfef295a44960bb9b59c330a6049e4191deb02663fbb"

URI_x86_64_v2_libglvnd-gles = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libglvnd-gles-1.7.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libglvnd-gles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libglvnd-gles}"
SRC_URI[x86_64_v2_libglvnd-gles.sha256sum] = "3cfa90c2ccd60998ac9a11e85516bd76c5542beb1a3d35d9806a87b00d9987b2"

URI_x86_64_v2_libglvnd-glx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libglvnd-glx-1.7.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libglvnd-glx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libglvnd-glx}"
SRC_URI[x86_64_v2_libglvnd-glx.sha256sum] = "64d7275eb7b3cda8925d2099b7fccbd52a7eff5be09e6ab105a2fe9880bde9c5"

URI_x86_64_v2_libglvnd-opengl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libglvnd-opengl-1.7.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libglvnd-opengl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libglvnd-opengl}"
SRC_URI[x86_64_v2_libglvnd-opengl.sha256sum] = "c1aaf40895bca81144cfd268c1265b4ddcef2e17e6e79ec4c1155460f82c3475"

URI_aarch64_libglvnd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libglvnd-1.7.0-7.el10.aarch64.rpm;name=aarch64_libglvnd;unpack=0"
SRC_URI:append = " ${URI_aarch64_libglvnd}"
SRC_URI[aarch64_libglvnd.sha256sum] = "de60d61a704e51da2cae9f6e0a69e6c9fa951a9c81f2197cc4859ace222ff458"

URI_aarch64_libglvnd-core-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libglvnd-core-devel-1.7.0-7.el10.aarch64.rpm;name=aarch64_libglvnd-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libglvnd-core-devel}"
SRC_URI[aarch64_libglvnd-core-devel.sha256sum] = "0dfe39c259c4637f4f6006c9c1f10fd57d5af1530473c5a9322e00678af60c45"

URI_aarch64_libglvnd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libglvnd-devel-1.7.0-7.el10.aarch64.rpm;name=aarch64_libglvnd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libglvnd-devel}"
SRC_URI[aarch64_libglvnd-devel.sha256sum] = "910f1d6eb1ed64016a0bab624f80d008e16bc57ee8ba625f56fbba00586b950a"

URI_aarch64_libglvnd-egl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libglvnd-egl-1.7.0-7.el10.aarch64.rpm;name=aarch64_libglvnd-egl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libglvnd-egl}"
SRC_URI[aarch64_libglvnd-egl.sha256sum] = "d5a9ceab3bad6034f641b2ddfad43a5dae631fcf9056ff4526e2a24d3cca1e64"

URI_aarch64_libglvnd-gles = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libglvnd-gles-1.7.0-7.el10.aarch64.rpm;name=aarch64_libglvnd-gles;unpack=0"
SRC_URI:append = " ${URI_aarch64_libglvnd-gles}"
SRC_URI[aarch64_libglvnd-gles.sha256sum] = "fa3241aec470e799dc18c7816283bb605d25b8882dc5f5851fdea565878d3fa2"

URI_aarch64_libglvnd-glx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libglvnd-glx-1.7.0-7.el10.aarch64.rpm;name=aarch64_libglvnd-glx;unpack=0"
SRC_URI:append = " ${URI_aarch64_libglvnd-glx}"
SRC_URI[aarch64_libglvnd-glx.sha256sum] = "dfe9515f9f79b79bf11bcdbf71b42737b23495b86b5f06efc8d8ea9fa06fa5b1"

URI_aarch64_libglvnd-opengl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libglvnd-opengl-1.7.0-7.el10.aarch64.rpm;name=aarch64_libglvnd-opengl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libglvnd-opengl}"
SRC_URI[aarch64_libglvnd-opengl.sha256sum] = "e4ee94ef463daab1b33f4b83c6c4270e07a0c16b7737f1d515f4cba402bfd91c"

RDEPENDS:libglvnd = " \
 glibc \
 "
RDEPENDS:libglvnd-core-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:libglvnd-devel = " \
 libX11-devel \
 libglvnd \
 libglvnd-core-devel \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libglvnd-opengl \
 pkgconf-pkg-config \
 "
RDEPENDS:libglvnd-egl = " \
 glibc \
 libglvnd \
 mesa-libEGL \
 "
RDEPENDS:libglvnd-gles = " \
 glibc \
 libglvnd \
 mesa-libEGL \
 "
RDEPENDS:libglvnd-glx = " \
 glibc \
 libX11 \
 libXext \
 libglvnd \
 mesa-libGL \
 "
RDEPENDS:libglvnd-opengl = " \
 glibc \
 libglvnd \
 "
