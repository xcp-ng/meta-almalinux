# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-resolver"
PV = "0.24.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-hickory-resolver+backtrace-devel \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+dns-over-native-tls-devel \
 rust-hickory-resolver+dns-over-openssl-devel \
 rust-hickory-resolver+dns-over-tls-devel \
 rust-hickory-resolver+dnssec-devel \
 rust-hickory-resolver+dnssec-openssl-devel \
 rust-hickory-resolver+resolv-conf-devel \
 rust-hickory-resolver+serde-config-devel \
 rust-hickory-resolver+serde-devel \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+testing-devel \
 rust-hickory-resolver+tokio-devel \
 rust-hickory-resolver+tokio-native-tls-devel \
 rust-hickory-resolver+tokio-openssl-devel \
 rust-hickory-resolver+tokio-runtime-devel \
 rust-hickory-resolver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-resolver-0.24.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cc617fb4ba4cd80a55328aec015cd70914cb60df5722a3d4566000788ac0bac"

URI_x86_64_v2_rust-hickory-resolver+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+backtrace-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+backtrace-devel.sha256sum] = "32806569105532f49d73ebaa57ea900670300a676183995502d03c8b8eaf4070"

URI_x86_64_v2_rust-hickory-resolver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+default-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+default-devel.sha256sum] = "a965faa366626380502b035f5c18fd0797eceef10b8640122ba5e0e00ca34f11"

URI_x86_64_v2_rust-hickory-resolver+dns-over-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dns-over-native-tls-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dns-over-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dns-over-native-tls-devel.sha256sum] = "a46803b0c9c7371a8f9aa4404db6b8ab41fd28138b516afbbe5547db11275121"

URI_x86_64_v2_rust-hickory-resolver+dns-over-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dns-over-openssl-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dns-over-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dns-over-openssl-devel.sha256sum] = "86d732ef24fd3f1268d773d04d884d9f55b3ea5bee220f916ee3f5a31ce77b3e"

URI_x86_64_v2_rust-hickory-resolver+dns-over-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dns-over-tls-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dns-over-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dns-over-tls-devel.sha256sum] = "015c97c0b69b62e1edc48cb5e09f71c0020ba0341956a81cac4346b1a864699d"

URI_x86_64_v2_rust-hickory-resolver+dnssec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dnssec-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dnssec-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dnssec-devel.sha256sum] = "983706b5274b816d7bee115069348ca2817b7e1c97f99382a3ccb5c7c4a91309"

URI_x86_64_v2_rust-hickory-resolver+dnssec-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+dnssec-openssl-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+dnssec-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+dnssec-openssl-devel.sha256sum] = "1d498e655f2aa6be0b6afe86f63759a9f5acb07e9cab4652e80240ec5e99f5a1"

URI_x86_64_v2_rust-hickory-resolver+resolv-conf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+resolv-conf-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+resolv-conf-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+resolv-conf-devel.sha256sum] = "2485d1ed2df386c282aa6efb7e7a13f0ffee31342999c47b7d94deed53cf416d"

URI_x86_64_v2_rust-hickory-resolver+serde-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+serde-config-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+serde-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+serde-config-devel.sha256sum] = "4951c37002a464eaca859afd837aaee51504385eece9fbab65e0615c81b56eca"

URI_x86_64_v2_rust-hickory-resolver+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+serde-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+serde-devel.sha256sum] = "c22f3cc432542aec1d4795073b6032fb21f0a7516ef4fc08a72af6f314deb233"

URI_x86_64_v2_rust-hickory-resolver+system-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+system-config-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+system-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+system-config-devel.sha256sum] = "4befefd80f7e1d94a13f0f499e88a6278bcd13f11f7f95501c79824622d55839"

URI_x86_64_v2_rust-hickory-resolver+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+testing-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+testing-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+testing-devel.sha256sum] = "d37b02c9bb1ca1f8ab21f32abc3718faa8f776b752eeee4b238a32c4c5c3fb02"

URI_x86_64_v2_rust-hickory-resolver+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-devel.sha256sum] = "7f8d424f9308e2829d86ec4a652c0c0786c603bbe0bc3f097f46235aec8f2119"

URI_x86_64_v2_rust-hickory-resolver+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-native-tls-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-native-tls-devel.sha256sum] = "5da5d6e8b411e75011b448f0807d9cf88f81636cb379af08ebc2db18094d2c5e"

URI_x86_64_v2_rust-hickory-resolver+tokio-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-openssl-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-openssl-devel.sha256sum] = "1e0416794dc9feeaed2c28d9d65080803d79da6df19228e9c5ee4f5c42efe3bf"

URI_x86_64_v2_rust-hickory-resolver+tokio-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-runtime-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver+tokio-runtime-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-runtime-devel.sha256sum] = "9def3c0d6a623e52fbba8ba2d48f581d8ab772cd186a56810efa948417f1b894"

URI_x86_64_v2_rust-hickory-resolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-resolver-devel}"
SRC_URI[x86_64_v2_rust-hickory-resolver-devel.sha256sum] = "b83e7915401f20c1a3efbac7c246677385ee073e4fcbfa7ee804a3b6f4d7377c"

URI_aarch64_rust-hickory-resolver+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+backtrace-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-resolver+backtrace-devel.sha256sum] = "f6f2eef27a222f4189286b5a18641215fcd4497d52b04078fb8b48a8baac0eac"

URI_aarch64_rust-hickory-resolver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+default-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+default-devel}"
SRC_URI[aarch64_rust-hickory-resolver+default-devel.sha256sum] = "1ec6f2f4fc131e24f52bb6faf16f3c0b34a68516bf813bd5b977d46e70764e48"

URI_aarch64_rust-hickory-resolver+dns-over-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dns-over-native-tls-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dns-over-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dns-over-native-tls-devel.sha256sum] = "db988d79675a555e04d990e6fb8c4ff8ecd0de49839ea5c9e5df3d8055a54281"

URI_aarch64_rust-hickory-resolver+dns-over-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dns-over-openssl-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dns-over-openssl-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dns-over-openssl-devel.sha256sum] = "32799d1d6b3734fdd5c68937d75c1a55c992d2c7ab055e252750876cc3ab25dc"

URI_aarch64_rust-hickory-resolver+dns-over-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dns-over-tls-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dns-over-tls-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dns-over-tls-devel.sha256sum] = "4ebf332b99aff82144007dae963cad219582a7fcccb4c8faf05a0577240328c1"

URI_aarch64_rust-hickory-resolver+dnssec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dnssec-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dnssec-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dnssec-devel.sha256sum] = "f5a351408aeb065dfdefa5c665c33425305114bc0a906997c9fc8aa0f718d044"

URI_aarch64_rust-hickory-resolver+dnssec-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+dnssec-openssl-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+dnssec-openssl-devel}"
SRC_URI[aarch64_rust-hickory-resolver+dnssec-openssl-devel.sha256sum] = "a06edb8b7cc417abdee2014fd286004c4cb0c33dd12b37e0e1c12b312435693e"

URI_aarch64_rust-hickory-resolver+resolv-conf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+resolv-conf-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+resolv-conf-devel}"
SRC_URI[aarch64_rust-hickory-resolver+resolv-conf-devel.sha256sum] = "a67c0c0fd8f1887b7aab4c64c7816d17e1cc85963714eb4967e0c04036e6f791"

URI_aarch64_rust-hickory-resolver+serde-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+serde-config-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+serde-config-devel}"
SRC_URI[aarch64_rust-hickory-resolver+serde-config-devel.sha256sum] = "98840dabed48af5cc11d2b7ab0dbf6919a8dff9c268f4e5f1a78f6015dc6c1bc"

URI_aarch64_rust-hickory-resolver+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+serde-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+serde-devel}"
SRC_URI[aarch64_rust-hickory-resolver+serde-devel.sha256sum] = "db45f646e50bdedab9e64e046f9aee60e80462e956f0795cf2d49eb9e8be6437"

URI_aarch64_rust-hickory-resolver+system-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+system-config-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+system-config-devel}"
SRC_URI[aarch64_rust-hickory-resolver+system-config-devel.sha256sum] = "e7ff3e64732647478128341e27b424dcdf1e76be7ac582262a0fbf7f020881ed"

URI_aarch64_rust-hickory-resolver+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+testing-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+testing-devel}"
SRC_URI[aarch64_rust-hickory-resolver+testing-devel.sha256sum] = "3cf0ac89a71e635e27fd2abedc9605621eb6e2f5aada0ac96eac7543d726cdf5"

URI_aarch64_rust-hickory-resolver+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-devel.sha256sum] = "e670b8942aa5b650b8a86ada02d217baeef700d34a5ab9e5aafffbcdc86c39b5"

URI_aarch64_rust-hickory-resolver+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-native-tls-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-native-tls-devel.sha256sum] = "aa5249ba4c04d6e62c52fb37c9df1fd70ec434443fca3cda2209ea1539ef0281"

URI_aarch64_rust-hickory-resolver+tokio-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-openssl-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-openssl-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-openssl-devel.sha256sum] = "e5a32846e47a68b763fd576f9364e4affcbab744b4931c6e92fc9b681e6043b8"

URI_aarch64_rust-hickory-resolver+tokio-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-runtime-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver+tokio-runtime-devel}"
SRC_URI[aarch64_rust-hickory-resolver+tokio-runtime-devel.sha256sum] = "5933a69e7e4d5654cffc9891d69cea24a3005abdadb395685f4f9de858ebde1f"

URI_aarch64_rust-hickory-resolver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-resolver-devel}"
SRC_URI[aarch64_rust-hickory-resolver-devel.sha256sum] = "c32ef48639be903646ca6f349601d88fd0508de26569e0c288e71e88d1013a24"

RDEPENDS:rust-hickory-resolver+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto+backtrace-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+default-devel = " \
 cargo \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+tokio-runtime-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dns-over-native-tls-devel = " \
 cargo \
 rust-hickory-proto+dns-over-native-tls-devel \
 rust-hickory-resolver+dns-over-tls-devel \
 rust-hickory-resolver+tokio-native-tls-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dns-over-openssl-devel = " \
 cargo \
 rust-hickory-proto+dns-over-openssl-devel \
 rust-hickory-resolver+dns-over-tls-devel \
 rust-hickory-resolver+tokio-openssl-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dns-over-tls-devel = " \
 cargo \
 rust-hickory-resolver+tokio-runtime-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dnssec-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+dnssec-openssl-devel = " \
 cargo \
 rust-hickory-proto+dnssec-openssl-devel \
 rust-hickory-resolver+dnssec-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+resolv-conf-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 "
RDEPENDS:rust-hickory-resolver+serde-config-devel = " \
 cargo \
 rust-hickory-proto+serde-config-devel \
 rust-hickory-resolver+serde-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+serde-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-hickory-resolver+system-config-devel = " \
 cargo \
 rust-hickory-resolver+resolv-conf-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+testing-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-native-tls-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-openssl-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-tokio-openssl+default-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-runtime-devel = " \
 cargo \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-resolver-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-hickory-resolver-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-proto-devel \
 rust-lru-cache+default-devel \
 rust-once_cell+default-devel \
 rust-parking_lot+default-devel \
 rust-rand0.8+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror1+default-devel \
 rust-tracing+default-devel \
 "
