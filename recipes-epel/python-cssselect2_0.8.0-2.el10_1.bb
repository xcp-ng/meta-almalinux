# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cssselect2"
PV = "0.8.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-cssselect2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cssselect2-0.8.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d93ab4c2079ac03c2a0f653ebe3017f098b5f444a3a6b951c79e7eb8983314ef"

URI_x86_64_v2_python3-cssselect2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cssselect2-0.8.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cssselect2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cssselect2}"
SRC_URI[x86_64_v2_python3-cssselect2.sha256sum] = "41998f1124e13e229943d82bd8ba26252a9db199208cd48b82a1aca515fbd3b2"

URI_aarch64_python3-cssselect2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cssselect2-0.8.0-2.el10_1.noarch.rpm;name=aarch64_python3-cssselect2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cssselect2}"
SRC_URI[aarch64_python3-cssselect2.sha256sum] = "b8cf7e5f3722709e1b3701eb5ece050c636ebb2cd45ae3cc664d43e2f4383bf6"

RDEPENDS:python3-cssselect2 = " \
 python3 \
 python3-tinycss2 \
 python3-webencodings \
 "
