# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwayland"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtwayland \
 qt6-qtwayland-devel \
 qt6-qtwayland-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtwayland-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f665fd94f2c87fccb9ca6eb0691ef40370244017db569315cbb9c8615f6da0d"

URI_x86_64_v2_qt6-qtwayland = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwayland-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwayland}"
SRC_URI[x86_64_v2_qt6-qtwayland.sha256sum] = "f379b7c3d6aae5dfe429928af22ffb79a6853a31b452b2de750336cb4f4b7fc2"

URI_x86_64_v2_qt6-qtwayland-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtwayland-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwayland-devel}"
SRC_URI[x86_64_v2_qt6-qtwayland-devel.sha256sum] = "ca302fbcde9dc378f1dac0b90083441375042b53541c9310d8c47652ff024c51"

URI_x86_64_v2_qt6-qtwayland-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtwayland-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwayland-examples}"
SRC_URI[x86_64_v2_qt6-qtwayland-examples.sha256sum] = "651779b385ac91e5c4900df4aeb9eb81c3d1ace89ac377167d85647f07da5c50"

URI_aarch64_qt6-qtwayland = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwayland-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwayland}"
SRC_URI[aarch64_qt6-qtwayland.sha256sum] = "19c07423b1dec22fdb2d7ccd8f0f83f5be469f748409f3e402361c1f88b66887"

URI_aarch64_qt6-qtwayland-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtwayland-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwayland-devel}"
SRC_URI[aarch64_qt6-qtwayland-devel.sha256sum] = "7baef52eeefc26823da5aaeca631ce297b38946b77446bb8a6f239d9802aa71b"

URI_aarch64_qt6-qtwayland-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtwayland-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtwayland-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwayland-examples}"
SRC_URI[aarch64_qt6-qtwayland-examples.sha256sum] = "37f0a7f555680abb304c8f553882720e77443f8d45fd262a141dffbd7cfae64c"

RDEPENDS:qt6-qtwayland = " \
 glibc \
 libglvnd-egl \
 libglvnd-opengl \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 libxkbcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtwayland-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtwayland \
 wayland-devel \
 "
RDEPENDS:qt6-qtwayland-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 libwayland-client \
 libwayland-server \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
