# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum"
PV = "0.26.3"
PR = "2.el10_0"
PACKAGES = " \
 rust-strum+default-devel \
 rust-strum+derive-devel \
 rust-strum+phf-devel \
 rust-strum+std-devel \
 rust-strum+strum_macros-devel \
 rust-strum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum-0.26.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4fc68c1d6ea49e6d86858c87f4e349bbbf2dda5855b8ba31f921464001b1da4"

URI_x86_64_v2_rust-strum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+default-devel-0.26.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+default-devel}"
SRC_URI[x86_64_v2_rust-strum+default-devel.sha256sum] = "f2c6cb6a3a82cd0f306ab70d32a23c24004bf9f0537f4343f1b0ec9cad0974d4"

URI_x86_64_v2_rust-strum+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+derive-devel-0.26.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+derive-devel}"
SRC_URI[x86_64_v2_rust-strum+derive-devel.sha256sum] = "2a6d526b0eb9094f3623b08a847dcb936919aae1a88197acb781dd12677a97bf"

URI_x86_64_v2_rust-strum+phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+phf-devel-0.26.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+phf-devel}"
SRC_URI[x86_64_v2_rust-strum+phf-devel.sha256sum] = "2cdb48b24006c75107bb9c5f37b296fdde52b6411cd83d2ba76fd432f94597a0"

URI_x86_64_v2_rust-strum+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+std-devel-0.26.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+std-devel}"
SRC_URI[x86_64_v2_rust-strum+std-devel.sha256sum] = "316916e9e276bf83216d4452a81b75b3ce08c1a37c25e6eb48aaaecf4c252f8a"

URI_x86_64_v2_rust-strum+strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum+strum_macros-devel-0.26.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum+strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum+strum_macros-devel.sha256sum] = "3069897c3e8d8430453efe353bac13f5162a5c853b33a062de413c45be922545"

URI_x86_64_v2_rust-strum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum-devel-0.26.3-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum-devel}"
SRC_URI[x86_64_v2_rust-strum-devel.sha256sum] = "b9caccea6788138b74e4607f4ca27153a0aea1a64a648476088976789bfd996e"

URI_aarch64_rust-strum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+default-devel-0.26.3-2.el10_0.noarch.rpm;name=aarch64_rust-strum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+default-devel}"
SRC_URI[aarch64_rust-strum+default-devel.sha256sum] = "904670e6ae832b9e7b840258962d64eee752b6cfd483daa41310145ebdc430e0"

URI_aarch64_rust-strum+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+derive-devel-0.26.3-2.el10_0.noarch.rpm;name=aarch64_rust-strum+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+derive-devel}"
SRC_URI[aarch64_rust-strum+derive-devel.sha256sum] = "858d7f220427fff6829c2c7160209d4ee1ddba7e654b43e4c85a52e381d844b7"

URI_aarch64_rust-strum+phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+phf-devel-0.26.3-2.el10_0.noarch.rpm;name=aarch64_rust-strum+phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+phf-devel}"
SRC_URI[aarch64_rust-strum+phf-devel.sha256sum] = "54eb3272ed35cbafc9bd29952f8e46715fb6244fcbca06ba484aeaa8663ce676"

URI_aarch64_rust-strum+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+std-devel-0.26.3-2.el10_0.noarch.rpm;name=aarch64_rust-strum+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+std-devel}"
SRC_URI[aarch64_rust-strum+std-devel.sha256sum] = "fe228b52f8f45ee472231a95adfcb77394936be541f1032f1161f16c15763c50"

URI_aarch64_rust-strum+strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum+strum_macros-devel-0.26.3-2.el10_0.noarch.rpm;name=aarch64_rust-strum+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum+strum_macros-devel}"
SRC_URI[aarch64_rust-strum+strum_macros-devel.sha256sum] = "fa012a6accc10d0c93c46b9a597f0c0f7116ffcaceb6747fd0f1946cef3039d8"

URI_aarch64_rust-strum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum-devel-0.26.3-2.el10_0.noarch.rpm;name=aarch64_rust-strum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum-devel}"
SRC_URI[aarch64_rust-strum-devel.sha256sum] = "7b6e1fbe8923eea58c0c1a55f4b54d4925717a70936a6852c99e2e2dd95ec058"

RDEPENDS:rust-strum+default-devel = " \
 cargo \
 rust-strum+std-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+derive-devel = " \
 cargo \
 rust-strum+strum_macros-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+phf-devel = " \
 cargo \
 rust-phf+default-devel \
 rust-phf+macros-devel \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+std-devel = " \
 cargo \
 rust-strum-devel \
 "
RDEPENDS:rust-strum+strum_macros-devel = " \
 cargo \
 rust-strum-devel \
 rust-strum_macros+default-devel \
 "
RDEPENDS:rust-strum-devel = " \
 cargo \
 "
