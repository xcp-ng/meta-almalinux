# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dd_rescue"
PV = "1.99.16"
PR = "1.el10_0"
PACKAGES = " \
 dd_rescue \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dd_rescue-1.99.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67c664fe074997c2ec89112dc5811fba56fb5313d47d9c7b8dedf9d8bdf09fcd"

URI_x86_64_v2_dd_rescue = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dd_rescue-1.99.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dd_rescue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dd_rescue}"
SRC_URI[x86_64_v2_dd_rescue.sha256sum] = "de4d99bed74f9a65ef8feb8423c4ef9e48bee0310edccdd88d2a9f0d725692dd"

URI_aarch64_dd_rescue = "${EPEL_MIRROR}/aarch64/Packages/d/dd_rescue-1.99.16-1.el10_0.aarch64.rpm;name=aarch64_dd_rescue;unpack=0"
SRC_URI:append = " ${URI_aarch64_dd_rescue}"
SRC_URI[aarch64_dd_rescue.sha256sum] = "35e740f1b391d7d9098640435e93226d1bc536eddafee58edbfc91d10020d04c"

RDEPENDS:dd_rescue = " \
 bash \
 bc \
 glibc \
 grep \
 lzo \
 sed \
 virtual/coreutils \
 "
