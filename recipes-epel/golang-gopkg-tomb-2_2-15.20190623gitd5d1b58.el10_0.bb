# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-tomb-2"
PV = "2"
PR = "15.20190623gitd5d1b58.el10_0"
PACKAGES = " \
 compat-golang-github-tomb-devel \
 compat-golang-gopkg-2-tomb-devel \
 golang-gopkg-tomb-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-tomb-2-2-15.20190623gitd5d1b58.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "440e6bd3ed5215a546249f97159afcc2f5d7b31b4e24f3a6c88ec15a5b909d31"

URI_aarch64_compat-golang-github-tomb-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-tomb-devel-2-15.20190623gitd5d1b58.el10_0.noarch.rpm;name=aarch64_compat-golang-github-tomb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-tomb-devel}"
SRC_URI[aarch64_compat-golang-github-tomb-devel.sha256sum] = "f005b7d40c84d1354be13e3705b320abe3dcedf7390c1d1e25be3ee8da18e981"

URI_aarch64_compat-golang-gopkg-2-tomb-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-gopkg-2-tomb-devel-2-15.20190623gitd5d1b58.el10_0.noarch.rpm;name=aarch64_compat-golang-gopkg-2-tomb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-gopkg-2-tomb-devel}"
SRC_URI[aarch64_compat-golang-gopkg-2-tomb-devel.sha256sum] = "67d08d2301495363752d3acd1265e4d62ad1c7fda3fff387661d004dcee63e99"

URI_aarch64_golang-gopkg-tomb-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-tomb-2-devel-2-15.20190623gitd5d1b58.el10_0.noarch.rpm;name=aarch64_golang-gopkg-tomb-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-tomb-2-devel}"
SRC_URI[aarch64_golang-gopkg-tomb-2-devel.sha256sum] = "907ccc21a5f262f6a6b7325a65549a2e9e7bc9343394fcc49ccc94b2a2ff36f8"

RDEPENDS:compat-golang-github-tomb-devel = " \
 go-filesystem \
 golang-gopkg-tomb-2-devel \
 "
RDEPENDS:compat-golang-gopkg-2-tomb-devel = " \
 go-filesystem \
 golang-gopkg-tomb-2-devel \
 "
RDEPENDS:golang-gopkg-tomb-2-devel = " \
 go-filesystem \
 "
