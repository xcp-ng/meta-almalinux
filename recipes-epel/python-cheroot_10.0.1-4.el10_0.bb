# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cheroot"
PV = "10.0.1"
PR = "4.el10_0"
PACKAGES = " \
 python3-cheroot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cheroot-10.0.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47f6a55d7fe425489f20a925f6128f5734bdc9f5b45a30896d4fce7243fa086d"

URI_x86_64_v2_python3-cheroot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cheroot-10.0.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cheroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cheroot}"
SRC_URI[x86_64_v2_python3-cheroot.sha256sum] = "1d2300a6595102f60be61c5a42896d30561fd8d8b2a3b8aec8398144435b99da"

URI_aarch64_python3-cheroot = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cheroot-10.0.1-4.el10_0.noarch.rpm;name=aarch64_python3-cheroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cheroot}"
SRC_URI[aarch64_python3-cheroot.sha256sum] = "245a6bf9fbebd8b7a51b415b8fb80f0f7e7ac0f21711e6642e11bc7929952dd0"

RDEPENDS:python3-cheroot = " \
 python3 \
 python3-jaraco-functools \
 python3-more-itertools \
 python3-pyOpenSSL \
 python3-six \
 "
