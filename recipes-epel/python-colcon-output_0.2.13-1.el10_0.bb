# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-output"
PV = "0.2.13"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-output \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-output-0.2.13-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43e79d91a9c4554e9c24928ea5b2db2bd1de6f7f708bf68b1dde45efe255e829"

URI_x86_64_v2_python3-colcon-output = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-output-0.2.13-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-output;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-output}"
SRC_URI[x86_64_v2_python3-colcon-output.sha256sum] = "940105fdd977ad22f09812e1a0e4d33d2c2b0ba65df45b30ea8f67b784eaffc2"

URI_aarch64_python3-colcon-output = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-output-0.2.13-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-output;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-output}"
SRC_URI[aarch64_python3-colcon-output.sha256sum] = "8367fafe50c1bd6e90b14d7c5747e20a4451e4d8ed68bf554df9cb0b4df18eaa"

RDEPENDS:python3-colcon-output = " \
 python3 \
 python3-colcon-core \
 "
