# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "autolink-java"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 autolink-java \
 autolink-java-javadoc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/autolink-java-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e297753299c51182c58e592fa3a0135514c2bde758733b90ab53261493c87c82"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/autolink-java-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_autolink-java;unpack=0"
SRC_URI[x86_64_v2_autolink-java.sha256sum] = "edb8f349151f34cacf885b3b61a5dae0aae205dd1d84070f1c3526b8dc78b3cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/autolink-java-javadoc-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_autolink-java-javadoc;unpack=0"
SRC_URI[x86_64_v2_autolink-java-javadoc.sha256sum] = "f1b8b128364e35b79b38bda382264c9de57f93ec7171a63d0181d0991734ca69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/autolink-java-0.11.0-1.el10_3.noarch.rpm;name=aarch64_autolink-java;unpack=0"
SRC_URI[aarch64_autolink-java.sha256sum] = "e40f68a164f926b93f6e75b887676bec563f8aa6209327147a070fc0bb2e4c6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/autolink-java-javadoc-0.11.0-1.el10_3.noarch.rpm;name=aarch64_autolink-java-javadoc;unpack=0"
SRC_URI[aarch64_autolink-java-javadoc.sha256sum] = "6a44deb6aeb5c79ca75d93840c808600c2d0c2f217533d473b66a5e7e5e34e8b"

RDEPENDS:autolink-java = " \
 javapackages-filesystem \
 "
RDEPENDS:autolink-java-javadoc = " \
 javapackages-filesystem \
 "
