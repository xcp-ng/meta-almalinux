# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-macros"
PV = "2.7.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-tokio-macros+default-devel \
 rust-tokio-macros-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-macros-2.7.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "50d0a1e3e401eb3ea14a110c473c1d523eff9fb8c75d830ce48b6fdcdc431976"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-macros+default-devel-2.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-macros+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-macros+default-devel.sha256sum] = "6f4356e37db85de5eb8b4c136917e0117f2a80df5f9461625e265516ebae7c85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-macros-devel-2.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tokio-macros-devel.sha256sum] = "fe8ce91324d6f0f3860dfd900e52d19be2bacf06919ed7e47928ec487ede9b55"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-macros+default-devel-2.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-macros+default-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-macros+default-devel.sha256sum] = "e3edf02b9500dbc84091992fdcfe4041eda2b897e0d53ae7d0f6ffd988971b68"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-macros-devel-2.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-macros-devel;unpack=0"
SRC_URI[aarch64_rust-tokio-macros-devel.sha256sum] = "9b7c760d4b64882499c208e77e2ecf8e825703dfa0a37d5d9f835645a20a9b00"

RDEPENDS:rust-tokio-macros+default-devel = " \
 cargo \
 rust-tokio-macros-devel \
 "
RDEPENDS:rust-tokio-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
