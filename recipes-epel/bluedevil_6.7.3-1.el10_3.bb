# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluedevil"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 bluedevil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluedevil-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb96e851617aa3aa48e00559846b549fee7468815fc383d84a5adb66f0218046"

URI_x86_64_v2_bluedevil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluedevil-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluedevil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluedevil}"
SRC_URI[x86_64_v2_bluedevil.sha256sum] = "0bf8e4aec666fa7f342993d43a1c2c133418cb0cf484cd1192a4b420a5dfba65"

URI_aarch64_bluedevil = "${EPEL_MIRROR}/aarch64/Packages/b/bluedevil-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_bluedevil;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluedevil}"
SRC_URI[aarch64_bluedevil.sha256sum] = "c15230cd14eddb4f543686f556013dd014b3301475e0c25ceb20973a6157840e"

RDEPENDS:bluedevil = " \
 bluez \
 bluez-obexd \
 glibc \
 kf6-bluez-qt \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libplasma \
 libstdc++ \
 pipewire-pulseaudio \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
