# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolf"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kolf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kolf-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85bed26285e3a674e79ff691ef2bb49327351692a018edd50799bb1a6757fa8b"

URI_x86_64_v2_kolf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolf-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolf}"
SRC_URI[x86_64_v2_kolf.sha256sum] = "db38137480dc3540813a0fc5b13b9db95101092d5b589fa9fc9da8dc857dcdac"

URI_aarch64_kolf = "${EPEL_MIRROR}/aarch64/Packages/k/kolf-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kolf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolf}"
SRC_URI[aarch64_kolf.sha256sum] = "12b2d8c4f26b74885e77a33ef0d3f0368a58d440014632c200c9e41d4318d97f"

RDEPENDS:kolf = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
