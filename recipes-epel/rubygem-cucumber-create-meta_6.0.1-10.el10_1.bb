# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-create-meta"
PV = "6.0.1"
PR = "10.el10_1"
PACKAGES = " \
 rubygem-cucumber-create-meta \
 rubygem-cucumber-create-meta-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-create-meta-6.0.1-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a7f459f60ed0214cd9eedffc859bb56a1f7d5f9c4ab21b754555ac3d32bd3db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-create-meta-6.0.1-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-create-meta;unpack=0"
SRC_URI[x86_64_v2_rubygem-cucumber-create-meta.sha256sum] = "54a4455e3b307153cb9871dff395db0c167d3848dab694ec95a6e07f2b8ca2d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-create-meta-doc-6.0.1-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-create-meta-doc;unpack=0"
SRC_URI[x86_64_v2_rubygem-cucumber-create-meta-doc.sha256sum] = "e3adc56f91b6677f47e0b9f156da7840b9787968ffb509323233f3166bfc6113"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-create-meta-6.0.1-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-create-meta;unpack=0"
SRC_URI[aarch64_rubygem-cucumber-create-meta.sha256sum] = "8af541eb3fb459156d95edba4a6af0a36c05952d5856eba2bceb5c36f44fd7f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-create-meta-doc-6.0.1-10.el10_1.noarch.rpm;name=aarch64_rubygem-cucumber-create-meta-doc;unpack=0"
SRC_URI[aarch64_rubygem-cucumber-create-meta-doc.sha256sum] = "90743b69fec5fbb12c9f4cd3ecd73217d8361eca2c807c463c002ef17b5ecdd2"

RDEPENDS:rubygem-cucumber-create-meta = " \
 rubygem-cucumber-messages \
 rubygem-sys-uname \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-create-meta-doc = " \
 rubygem-cucumber-create-meta \
 "
