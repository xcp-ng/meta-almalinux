# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lddtree"
PV = "0.3.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-lddtree+default-devel \
 rust-lddtree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lddtree-0.3.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5355e7ad68f26a450c61c9c7d3b4f2e706cbaa62f12bab050d2827c832e56ed"

URI_x86_64_v2_rust-lddtree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lddtree+default-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lddtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lddtree+default-devel}"
SRC_URI[x86_64_v2_rust-lddtree+default-devel.sha256sum] = "e56057aa88adfe55da111ccf6ea4bdb2fef7a689d7400cbb81eb9a658613385c"

URI_x86_64_v2_rust-lddtree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lddtree-devel-0.3.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lddtree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lddtree-devel}"
SRC_URI[x86_64_v2_rust-lddtree-devel.sha256sum] = "0fefeb07dc521af3324b7d5efdff2f8e23c1b66bc33b555ff35fb2ddc90d1c50"

URI_aarch64_rust-lddtree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lddtree+default-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-lddtree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lddtree+default-devel}"
SRC_URI[aarch64_rust-lddtree+default-devel.sha256sum] = "d3577859866e1759f7afafc7be70700dda83594094f92b8064660225eb351d46"

URI_aarch64_rust-lddtree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lddtree-devel-0.3.8-1.el10_1.noarch.rpm;name=aarch64_rust-lddtree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lddtree-devel}"
SRC_URI[aarch64_rust-lddtree-devel.sha256sum] = "8a7986845466db53d3457f24e31cc6b242b73a517a7b8d1a91fd4d61323bddaf"

RDEPENDS:rust-lddtree+default-devel = " \
 cargo \
 rust-lddtree-devel \
 "
RDEPENDS:rust-lddtree-devel = " \
 cargo \
 rust-fs-err+default-devel \
 rust-glob+default-devel \
 rust-goblin+default-devel \
 "
