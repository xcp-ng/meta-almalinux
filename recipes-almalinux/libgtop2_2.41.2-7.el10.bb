# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgtop2"
PV = "2.41.2"
PR = "7.el10"
PACKAGES = " \
 libgtop2 \
 libgtop2-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libgtop2-2.41.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6cf5e4dffc7b773579428f1d47e080e72610fe18693ac4b0dee7268bf5129db2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgtop2-2.41.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_libgtop2;unpack=0"
SRC_URI[x86_64_v2_libgtop2.sha256sum] = "29839baf7e27615403f6eaf28062dee298dd6024ba454298dbf8347f4a63251b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgtop2-devel-2.41.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_libgtop2-devel;unpack=0"
SRC_URI[x86_64_v2_libgtop2-devel.sha256sum] = "1d4767aa1a3a4ddf792c774c4d92b9d8413c6bf2ccbdb99b5297a797772c167b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgtop2-2.41.2-7.el10.aarch64.rpm;name=aarch64_libgtop2;unpack=0"
SRC_URI[aarch64_libgtop2.sha256sum] = "39d5f7f309c751756ef6ee33e19b14a752d3fb11d81e449d3b6cc05a637b3d2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgtop2-devel-2.41.2-7.el10.aarch64.rpm;name=aarch64_libgtop2-devel;unpack=0"
SRC_URI[aarch64_libgtop2-devel.sha256sum] = "8ca81d4d8f2c20b9b4da4870288a7c603a6b7839338b1763793b3f664d624e5b"

RDEPENDS:libgtop2 = " \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:libgtop2-devel = " \
 glib2-devel \
 libgtop2 \
 pkgconf-pkg-config \
 "
