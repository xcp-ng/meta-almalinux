# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "singularity-ce"
PV = "4.5.0"
PR = "1.el10_2"
PACKAGES = " \
 singularity-ce \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/singularity-ce-4.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "710c1da91a498ec7252d66484a5f51164a435825476a252d8a4d5b30f1aeddb2"

URI_x86_64_v2_singularity-ce = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/singularity-ce-4.5.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_singularity-ce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_singularity-ce}"
SRC_URI[x86_64_v2_singularity-ce.sha256sum] = "8068e488cbdaec1c55b76b0001f54ef41a20dbc8b25839743e15315f967d5442"

URI_aarch64_singularity-ce = "${EPEL_MIRROR}/aarch64/Packages/s/singularity-ce-4.5.0-1.el10_2.aarch64.rpm;name=aarch64_singularity-ce;unpack=0"
SRC_URI:append = " ${URI_aarch64_singularity-ce}"
SRC_URI[aarch64_singularity-ce.sha256sum] = "83bd577fd69c5af04a5e33147d37f5e51bf41aea2844a5c80f9a97227abebc70"

RDEPENDS:singularity-ce = " \
 bash \
 conmon \
 crun \
 cryptsetup \
 fuse \
 fuse3 \
 glibc \
 libseccomp \
 shadow-utils \
 shadow-utils-subid \
 squashfs-tools \
 squashfuse \
 "
