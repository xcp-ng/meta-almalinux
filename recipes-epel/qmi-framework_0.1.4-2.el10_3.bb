# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qmi-framework"
PV = "0.1.4"
PR = "2.el10_3"
PACKAGES = " \
 qmi-framework \
 qmi-framework-devel \
 qmi-framework-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qmi-framework-0.1.4-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8873d4f81c1eac07c044e6c3ebbb80659fe24b4cfbd8d6762c1d69890e3517ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmi-framework-0.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmi-framework;unpack=0"
SRC_URI[x86_64_v2_qmi-framework.sha256sum] = "36e9b7f0ba6e283d07e155c671a8deb72c62861a81319627bde90eee7b121be1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmi-framework-devel-0.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmi-framework-devel;unpack=0"
SRC_URI[x86_64_v2_qmi-framework-devel.sha256sum] = "c4c0b4fad4f91876b03446c4023193c636b36db3bb033b0dc70fbdc036064816"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmi-framework-utils-0.1.4-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmi-framework-utils;unpack=0"
SRC_URI[x86_64_v2_qmi-framework-utils.sha256sum] = "9e2b410d90e8302cd18dd653ab5b12d84e856b475cb4d0e244a5d58666fdee5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qmi-framework-0.1.4-2.el10_3.aarch64.rpm;name=aarch64_qmi-framework;unpack=0"
SRC_URI[aarch64_qmi-framework.sha256sum] = "7499c5c71c0e0e7056b3876bf5c1771384a87ebc6a8599755313aa1e182e4154"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qmi-framework-devel-0.1.4-2.el10_3.aarch64.rpm;name=aarch64_qmi-framework-devel;unpack=0"
SRC_URI[aarch64_qmi-framework-devel.sha256sum] = "a294cad450df858a31b2922e5ea423f1dd7f789f59feda9b49c4dbd21cbadab4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qmi-framework-utils-0.1.4-2.el10_3.aarch64.rpm;name=aarch64_qmi-framework-utils;unpack=0"
SRC_URI[aarch64_qmi-framework-utils.sha256sum] = "9a8506d36319acae6458818d8290e60389797ee1b32068564080155dbf37e497"

RDEPENDS:qmi-framework = " \
 glibc \
 "
RDEPENDS:qmi-framework-devel = " \
 pkgconf-pkg-config \
 qmi-framework \
 "
RDEPENDS:qmi-framework-utils = " \
 glibc \
 qmi-framework \
 "
