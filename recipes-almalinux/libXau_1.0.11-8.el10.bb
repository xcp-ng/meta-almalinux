# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXau"
PV = "1.0.11"
PR = "8.el10"
PACKAGES = " \
 libXau \
 libXau-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXau-1.0.11-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f91097805549c260b10ecb573ed1e450d31bf7778faa0bcdbc7f3047bfe8d5d6"

URI_x86_64_v2_libXau = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXau-1.0.11-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXau;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXau}"
SRC_URI[x86_64_v2_libXau.sha256sum] = "9e94d413a2855f3bff9b74c6a1ac61afb2249b965c3e2b18531b4e896d9fee8e"

URI_x86_64_v2_libXau-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXau-devel-1.0.11-8.el10.x86_64_v2.rpm;name=x86_64_v2_libXau-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXau-devel}"
SRC_URI[x86_64_v2_libXau-devel.sha256sum] = "400a1bde64584160f21623d56e960c07aa1cad6196d025bb01b59b09d345f35e"

URI_aarch64_libXau = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXau-1.0.11-8.el10.aarch64.rpm;name=aarch64_libXau;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXau}"
SRC_URI[aarch64_libXau.sha256sum] = "d07cf55a3bb8e615176df95302ccf579160d6c364a8f451cdf2f91d4b76a9060"

URI_aarch64_libXau-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXau-devel-1.0.11-8.el10.aarch64.rpm;name=aarch64_libXau-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXau-devel}"
SRC_URI[aarch64_libXau-devel.sha256sum] = "ca84f95b779a8b1e699a19cbcd8b2093c6ebe66852c561cc5ca030d9758d056f"

RDEPENDS:libXau = " \
 glibc \
 "
RDEPENDS:libXau-devel = " \
 libXau \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
