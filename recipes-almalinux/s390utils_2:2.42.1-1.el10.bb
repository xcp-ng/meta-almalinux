# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "s390utils"
PE = "2"
PV = "2.42.1"
PR = "1.el10"
PACKAGES = " \
 s390utils \
 s390utils-se-data \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/s390utils-2.42.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f61526c584bea03a21957e162db894c89d7d1411a9d85b809ca844457a3c09ab"

URI_x86_64_v2_s390utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/s390utils-2.42.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_s390utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s390utils}"
SRC_URI[x86_64_v2_s390utils.sha256sum] = "5b51309097138f4bb0cef64b63004432e8289c34366726424fab6133ea4c6286"

URI_x86_64_v2_s390utils-se-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/s390utils-se-data-2.42.1-1.el10.noarch.rpm;name=x86_64_v2_s390utils-se-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_s390utils-se-data}"
SRC_URI[x86_64_v2_s390utils-se-data.sha256sum] = "6c2978776b1f91ecf5dba69b5395826393d89e344815c5fb876bfaa3fe6d8209"

URI_aarch64_s390utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/s390utils-2.42.1-1.el10.aarch64.rpm;name=aarch64_s390utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_s390utils}"
SRC_URI[aarch64_s390utils.sha256sum] = "9227d2b9831afa2f00c5d44ff564c385d6e371cc41ca1738f770a04b7ee335c5"

URI_aarch64_s390utils-se-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/s390utils-se-data-2.42.1-1.el10.noarch.rpm;name=aarch64_s390utils-se-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_s390utils-se-data}"
SRC_URI[aarch64_s390utils-se-data.sha256sum] = "6c2978776b1f91ecf5dba69b5395826393d89e344815c5fb876bfaa3fe6d8209"

RDEPENDS:s390utils = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 s390utils-se-data \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:s390utils-se-data = " \
 "
