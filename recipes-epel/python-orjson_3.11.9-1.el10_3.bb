# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-orjson"
PV = "3.11.9"
PR = "1.el10_3"
PACKAGES = " \
 python3-orjson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-orjson-3.11.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afe8eb9952112cb461e49771c7fe0e0fd44a5394ff53170493c5387f90a3a6e3"

URI_x86_64_v2_python3-orjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-orjson-3.11.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-orjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-orjson}"
SRC_URI[x86_64_v2_python3-orjson.sha256sum] = "3f93643be168105f5429eef0267806b279d117d527bc2de01ee607cfc385eea0"

URI_aarch64_python3-orjson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-orjson-3.11.9-1.el10_3.aarch64.rpm;name=aarch64_python3-orjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-orjson}"
SRC_URI[aarch64_python3-orjson.sha256sum] = "893b1913e4008e74e25b897203033f0883e0d0b8409e47dc6960bafc2a00d187"

RDEPENDS:python3-orjson = " \
 glibc \
 libgcc \
 python3 \
 "
