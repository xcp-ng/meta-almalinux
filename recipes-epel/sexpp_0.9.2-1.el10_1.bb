# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sexpp"
PV = "0.9.2"
PR = "1.el10_1"
PACKAGES = " \
 libsexpp \
 libsexpp-devel \
 sexpp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sexpp-0.9.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83b9c1bc9910b631ce7822b463544cac84419d0c2755e3aa9f506d1079279aab"

URI_x86_64_v2_libsexpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsexpp-0.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsexpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsexpp}"
SRC_URI[x86_64_v2_libsexpp.sha256sum] = "8e27f16238bb64a90c7fa1ca9d53909b2470a3e12879e3a51646b7999ff845a2"

URI_x86_64_v2_libsexpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsexpp-devel-0.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsexpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsexpp-devel}"
SRC_URI[x86_64_v2_libsexpp-devel.sha256sum] = "e565b28012db3a7f304b5f030d95d43a1672228b1cd727ffe63795dd4f6c3963"

URI_x86_64_v2_sexpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sexpp-0.9.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sexpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sexpp}"
SRC_URI[x86_64_v2_sexpp.sha256sum] = "976b2f2217a767528e12422ec75485df37b12e3b389896d5d6480449aa8d6058"

URI_aarch64_libsexpp = "${EPEL_MIRROR}/aarch64/Packages/l/libsexpp-0.9.2-1.el10_1.aarch64.rpm;name=aarch64_libsexpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsexpp}"
SRC_URI[aarch64_libsexpp.sha256sum] = "53d513d34959847eb78ef65a4405e3481d6c0a3ff6857fd44fd25bb1c438c71b"

URI_aarch64_libsexpp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsexpp-devel-0.9.2-1.el10_1.aarch64.rpm;name=aarch64_libsexpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsexpp-devel}"
SRC_URI[aarch64_libsexpp-devel.sha256sum] = "06b362f5e091c76b955d24dab1a05c2a2642d02626d887d4aa6ec481ccd7ecca"

URI_aarch64_sexpp = "${EPEL_MIRROR}/aarch64/Packages/s/sexpp-0.9.2-1.el10_1.aarch64.rpm;name=aarch64_sexpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_sexpp}"
SRC_URI[aarch64_sexpp.sha256sum] = "5a283541dcf039621f8c41ebbd7fba5b661050e2f23bba61532fc4300f9bffa6"

RDEPENDS:libsexpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libsexpp-devel = " \
 libsexpp \
 pkgconf-pkg-config \
 "
RDEPENDS:sexpp = " \
 glibc \
 libgcc \
 libsexpp \
 libstdc++ \
 "
