# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvorbis"
PE = "1"
PV = "1.3.7"
PR = "12.el10"
PACKAGES = " \
 libvorbis \
 libvorbis-devel \
 libvorbis-devel-docs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvorbis-1.3.7-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfdd6322fe6ddee3faf166f470a8db911e32b5852dcc507d238103425e119839"

URI_x86_64_v2_libvorbis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvorbis-1.3.7-12.el10.x86_64_v2.rpm;name=x86_64_v2_libvorbis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvorbis}"
SRC_URI[x86_64_v2_libvorbis.sha256sum] = "aaa2db5cf4d583a0ae45d17fd0f7b39514791be63898c81cd3dc74ceba422da5"

URI_x86_64_v2_libvorbis-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvorbis-devel-1.3.7-12.el10.x86_64_v2.rpm;name=x86_64_v2_libvorbis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvorbis-devel}"
SRC_URI[x86_64_v2_libvorbis-devel.sha256sum] = "607b78c4960717f83429895e7c2c16ae378c406b29b832fd32909e981c8cc4fd"

URI_x86_64_v2_libvorbis-devel-docs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvorbis-devel-docs-1.3.7-12.el10.noarch.rpm;name=x86_64_v2_libvorbis-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvorbis-devel-docs}"
SRC_URI[x86_64_v2_libvorbis-devel-docs.sha256sum] = "bb009b03104df3a906f3fa2ad21f3a79e0536c6fb2308edd07b35d229d09ef89"

URI_aarch64_libvorbis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvorbis-1.3.7-12.el10.aarch64.rpm;name=aarch64_libvorbis;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvorbis}"
SRC_URI[aarch64_libvorbis.sha256sum] = "4fc6d0e2710c803b7d06778500a120368d9c6b0f1c4a706fcdd5ca85d7b09db3"

URI_aarch64_libvorbis-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvorbis-devel-1.3.7-12.el10.aarch64.rpm;name=aarch64_libvorbis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvorbis-devel}"
SRC_URI[aarch64_libvorbis-devel.sha256sum] = "142d484abbec3ae98d77fea18742915c613d81dfd6e352317a0933121739e528"

URI_aarch64_libvorbis-devel-docs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvorbis-devel-docs-1.3.7-12.el10.noarch.rpm;name=aarch64_libvorbis-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvorbis-devel-docs}"
SRC_URI[aarch64_libvorbis-devel-docs.sha256sum] = "bb009b03104df3a906f3fa2ad21f3a79e0536c6fb2308edd07b35d229d09ef89"

RDEPENDS:libvorbis = " \
 glibc \
 libogg \
 "
RDEPENDS:libvorbis-devel = " \
 libogg-devel \
 libvorbis \
 libvorbis-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libvorbis-devel-docs = " \
 libvorbis-devel \
 "
