# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libc"
PV = "0.2.177"
PR = "1.el10_0"
PACKAGES = " \
 rust-libc+align-devel \
 rust-libc+const-extern-fn-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 rust-libc+std-devel \
 rust-libc+use_std-devel \
 rust-libc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libc-0.2.177-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aecaa88554a907bddecd9fb36469427c468e5ff2b2ff23e738da99797049b600"

URI_x86_64_v2_rust-libc+align-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+align-devel-0.2.177-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+align-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+align-devel}"
SRC_URI[x86_64_v2_rust-libc+align-devel.sha256sum] = "08a76eb88d9b3e9094b5493d91a1a3c64c28581ebdee461f193f045521fe18a3"

URI_x86_64_v2_rust-libc+const-extern-fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+const-extern-fn-devel-0.2.177-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+const-extern-fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+const-extern-fn-devel}"
SRC_URI[x86_64_v2_rust-libc+const-extern-fn-devel.sha256sum] = "1d21b3ee50602265aa6a2b783338cdab83b334a19eda6ebcef981b0e54da0b6b"

URI_x86_64_v2_rust-libc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+default-devel-0.2.177-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+default-devel}"
SRC_URI[x86_64_v2_rust-libc+default-devel.sha256sum] = "c8bdaef73b53d923ae52f58229b28b2f85e456a8cefb53520a80de80c8814e5c"

URI_x86_64_v2_rust-libc+extra_traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+extra_traits-devel-0.2.177-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+extra_traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+extra_traits-devel}"
SRC_URI[x86_64_v2_rust-libc+extra_traits-devel.sha256sum] = "1467da42df2b7a3dc36e33f13d218910cea4d07cc6527c024e6cd6519e869984"

URI_x86_64_v2_rust-libc+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+std-devel-0.2.177-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+std-devel}"
SRC_URI[x86_64_v2_rust-libc+std-devel.sha256sum] = "5837c78df548ca61e0fbdb0df64a5c570558cd20df87b185ed35c3a31dbf4e53"

URI_x86_64_v2_rust-libc+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc+use_std-devel-0.2.177-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc+use_std-devel}"
SRC_URI[x86_64_v2_rust-libc+use_std-devel.sha256sum] = "042ae56012484aa93a94b1cf8bd28e3ae09db29b0ae3b20eeb20d7772c183fee"

URI_x86_64_v2_rust-libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libc-devel-0.2.177-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libc-devel}"
SRC_URI[x86_64_v2_rust-libc-devel.sha256sum] = "e6c7b5a95058379c9c4cd46f4a8390ec8db833880455e72e6cd89a16e1557216"

URI_aarch64_rust-libc+align-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+align-devel-0.2.177-1.el10_0.noarch.rpm;name=aarch64_rust-libc+align-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+align-devel}"
SRC_URI[aarch64_rust-libc+align-devel.sha256sum] = "9d7c2a19be018b37cced5b046af5d54180320da20329a5c4a144faaeaeae085c"

URI_aarch64_rust-libc+const-extern-fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+const-extern-fn-devel-0.2.177-1.el10_0.noarch.rpm;name=aarch64_rust-libc+const-extern-fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+const-extern-fn-devel}"
SRC_URI[aarch64_rust-libc+const-extern-fn-devel.sha256sum] = "3b624ecc1db4df46538e04b1618583a971cc34faed8c0ddc4bf4dfc60c624414"

URI_aarch64_rust-libc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+default-devel-0.2.177-1.el10_0.noarch.rpm;name=aarch64_rust-libc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+default-devel}"
SRC_URI[aarch64_rust-libc+default-devel.sha256sum] = "a28e87f1283ee0194b30736041218012d12b1e3ad89bda63942d1d92c4356826"

URI_aarch64_rust-libc+extra_traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+extra_traits-devel-0.2.177-1.el10_0.noarch.rpm;name=aarch64_rust-libc+extra_traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+extra_traits-devel}"
SRC_URI[aarch64_rust-libc+extra_traits-devel.sha256sum] = "20a46d87a8d66341d8ebf551835d42b9b4f77dff08000edd43c6ebeae850c58e"

URI_aarch64_rust-libc+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+std-devel-0.2.177-1.el10_0.noarch.rpm;name=aarch64_rust-libc+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+std-devel}"
SRC_URI[aarch64_rust-libc+std-devel.sha256sum] = "314f65dabfc8bc6f3c44ee409c2e7c7e9c0e8b0309d0e7d13d70af949414342e"

URI_aarch64_rust-libc+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc+use_std-devel-0.2.177-1.el10_0.noarch.rpm;name=aarch64_rust-libc+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc+use_std-devel}"
SRC_URI[aarch64_rust-libc+use_std-devel.sha256sum] = "eb2d59d214bc1b8bea1d36a4bd47720ca0998edbf8983847ef80532693efa99a"

URI_aarch64_rust-libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libc-devel-0.2.177-1.el10_0.noarch.rpm;name=aarch64_rust-libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libc-devel}"
SRC_URI[aarch64_rust-libc-devel.sha256sum] = "41acc9a51115cafada6025d3254b9d775c14f3ad5062f120fc857fbdd8b529e8"

RDEPENDS:rust-libc+align-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+const-extern-fn-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+default-devel = " \
 cargo \
 rust-libc+std-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+extra_traits-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+std-devel = " \
 cargo \
 rust-libc-devel \
 "
RDEPENDS:rust-libc+use_std-devel = " \
 cargo \
 rust-libc+std-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-libc-devel = " \
 bash \
 cargo \
 glibc-devel \
 rust \
 "
