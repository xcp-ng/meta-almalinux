# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xz"
PE = "1"
PV = "5.6.2"
PR = "4.el10"
PACKAGES = " \
 xz \
 xz-devel \
 xz-libs \
 xz-lzma-compat \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/xz-5.6.2-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0f594cf852e7c054a52a350451b08090db02f8ee6df93654969c0d9603c4064"

URI_x86_64_v2_xz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xz-5.6.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_xz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz}"
SRC_URI[x86_64_v2_xz.sha256sum] = "d342813f8d8b463667083319cb89aea748a3aaf8f8a12adc49a037a14e5ddeda"

URI_x86_64_v2_xz-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xz-devel-5.6.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz-devel}"
SRC_URI[x86_64_v2_xz-devel.sha256sum] = "9fbfbbd0d847caf50faa01f34499d4a7b738a55a57d82df0758d2ece1ffbb11f"

URI_x86_64_v2_xz-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/xz-libs-5.6.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_xz-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz-libs}"
SRC_URI[x86_64_v2_xz-libs.sha256sum] = "5ce7f2fc36d8f6f1d981d8fdb3f2943ee159129a012a0c974dce1b4a63bb2e66"

URI_x86_64_v2_xz-lzma-compat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xz-lzma-compat-5.6.2-4.el10.x86_64_v2.rpm;name=x86_64_v2_xz-lzma-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xz-lzma-compat}"
SRC_URI[x86_64_v2_xz-lzma-compat.sha256sum] = "a1074fd5e8079ec4adcdc7c345cd99f6b7d9d4e00911465f4eab9a0dc33289fc"

URI_aarch64_xz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xz-5.6.2-4.el10.aarch64.rpm;name=aarch64_xz;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz}"
SRC_URI[aarch64_xz.sha256sum] = "23792d54526109a1212be806ac6c1ba68b79be2f1fbfba7794462304fb26b4db"

URI_aarch64_xz-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xz-devel-5.6.2-4.el10.aarch64.rpm;name=aarch64_xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz-devel}"
SRC_URI[aarch64_xz-devel.sha256sum] = "31f703b41f24df6c5c92ccbde5b3b7e6daad8f02380decc94ca19658bee7dfe7"

URI_aarch64_xz-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/xz-libs-5.6.2-4.el10.aarch64.rpm;name=aarch64_xz-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz-libs}"
SRC_URI[aarch64_xz-libs.sha256sum] = "949216363cbab6fd44476559215f00498c1b9178176ac31eef828777a3997654"

URI_aarch64_xz-lzma-compat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xz-lzma-compat-5.6.2-4.el10.aarch64.rpm;name=aarch64_xz-lzma-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_xz-lzma-compat}"
SRC_URI[aarch64_xz-lzma-compat.sha256sum] = "d1aa8da9e93861c97fcf69963f59e710bdfef1183e0e1ac4ecdf68f695d07ca2"

RDEPENDS:xz = " \
 bash \
 glibc \
 grep \
 xz-libs \
 "
RDEPENDS:xz-devel = " \
 pkgconf-pkg-config \
 xz-libs \
 "
RDEPENDS:xz-libs = " \
 glibc \
 "
RDEPENDS:xz-lzma-compat = " \
 glibc \
 xz \
 xz-libs \
 "
