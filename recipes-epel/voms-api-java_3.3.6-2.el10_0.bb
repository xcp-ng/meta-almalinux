# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms-api-java"
PV = "3.3.6"
PR = "2.el10_0"
PACKAGES = " \
 voms-api-java \
 voms-api-java-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/voms-api-java-3.3.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15db2a2c19329e4475fb35711fae290a6cbd514373c90dc86aaaecc6f008f17e"

URI_x86_64_v2_voms-api-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-api-java-3.3.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_voms-api-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-api-java}"
SRC_URI[x86_64_v2_voms-api-java.sha256sum] = "aceb40a2b0bf600d1db414def6a8ef6e13d1dd229d88bb2efe4adecb62b3740d"

URI_x86_64_v2_voms-api-java-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-api-java-javadoc-3.3.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_voms-api-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-api-java-javadoc}"
SRC_URI[x86_64_v2_voms-api-java-javadoc.sha256sum] = "14ed4aa250be06e2780a7ab939038fce7420436f31c0c75bf33fa493a63f412c"

URI_aarch64_voms-api-java = "${EPEL_MIRROR}/aarch64/Packages/v/voms-api-java-3.3.6-2.el10_0.noarch.rpm;name=aarch64_voms-api-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-api-java}"
SRC_URI[aarch64_voms-api-java.sha256sum] = "7d2111364e358a519ea9735ccde58b83c8f25b7ceb77e93313612b6948ad5678"

URI_aarch64_voms-api-java-javadoc = "${EPEL_MIRROR}/aarch64/Packages/v/voms-api-java-javadoc-3.3.6-2.el10_0.noarch.rpm;name=aarch64_voms-api-java-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-api-java-javadoc}"
SRC_URI[aarch64_voms-api-java-javadoc.sha256sum] = "89543a48d632b532318b2154238947910a00ee39fbbdc332c7bf0b547793ca12"

RDEPENDS:voms-api-java = " \
 bouncycastle \
 bouncycastle-pkix \
 canl-java \
 javapackages-filesystem \
 "
RDEPENDS:voms-api-java-javadoc = " \
 javapackages-filesystem \
 "
