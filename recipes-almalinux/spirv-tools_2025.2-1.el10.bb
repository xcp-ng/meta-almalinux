# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spirv-tools"
PV = "2025.2"
PR = "1.el10"
PACKAGES = " \
 spirv-tools \
 spirv-tools-devel \
 spirv-tools-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/spirv-tools-2025.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23cbe2cfa2e6c4168b8fa171f8a76d4783fb3124bd9105aa8709e6aac2aa7be7"

URI_x86_64_v2_spirv-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/spirv-tools-2025.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_spirv-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-tools}"
SRC_URI[x86_64_v2_spirv-tools.sha256sum] = "bd7ac40695b1d58fa2330563055929ec1a19a556ea40630fbcf9073dd8a4804e"

URI_x86_64_v2_spirv-tools-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/spirv-tools-devel-2025.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_spirv-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-tools-devel}"
SRC_URI[x86_64_v2_spirv-tools-devel.sha256sum] = "0eccce8f97e07b52550639b598fab6b0f3c53fe41bc852732245be5c8f6a05b9"

URI_x86_64_v2_spirv-tools-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/spirv-tools-libs-2025.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_spirv-tools-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spirv-tools-libs}"
SRC_URI[x86_64_v2_spirv-tools-libs.sha256sum] = "a6126276b8f5d79d1534f877b9b6a3ce77644196fc90717425387a5f3e16c5e5"

URI_aarch64_spirv-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/spirv-tools-2025.2-1.el10.aarch64.rpm;name=aarch64_spirv-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-tools}"
SRC_URI[aarch64_spirv-tools.sha256sum] = "ea1fde26afec07f092bc19a0395ea80fa9c5e338f262767549548622a8df0a97"

URI_aarch64_spirv-tools-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/spirv-tools-devel-2025.2-1.el10.aarch64.rpm;name=aarch64_spirv-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-tools-devel}"
SRC_URI[aarch64_spirv-tools-devel.sha256sum] = "49bdb4611457e421292ecf1d3759a5fd24658eb7def7fe9d543c4919d67921bd"

URI_aarch64_spirv-tools-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/spirv-tools-libs-2025.2-1.el10.aarch64.rpm;name=aarch64_spirv-tools-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_spirv-tools-libs}"
SRC_URI[aarch64_spirv-tools-libs.sha256sum] = "7e29571d6da080b4c85a658392205173bfb54511e918a94f0ed7bb413fdd0502"

RDEPENDS:spirv-tools = " \
 bash \
 glibc \
 libstdc++ \
 spirv-tools-libs \
 "
RDEPENDS:spirv-tools-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 spirv-tools-libs \
 "
RDEPENDS:spirv-tools-libs = " \
 glibc \
 libstdc++ \
 "
