# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "incidenceeditor"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 incidenceeditor \
 incidenceeditor-devel \
 incidenceeditor-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/incidenceeditor-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "522e4acfb343636f49795ea7a57b29d3183a6aa739cb6fd52def2bd72d6e815d"

URI_x86_64_v2_incidenceeditor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_incidenceeditor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incidenceeditor}"
SRC_URI[x86_64_v2_incidenceeditor.sha256sum] = "8e91e1759afc86c0f244ebf600f7d7cb48bdb2f07cb792efeaf0bdd70f6e68b4"

URI_x86_64_v2_incidenceeditor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_incidenceeditor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incidenceeditor-devel}"
SRC_URI[x86_64_v2_incidenceeditor-devel.sha256sum] = "68557845c37fe3fb41464dd60adb088a326812754dcdbbf95c19ca55e4cc5342"

URI_x86_64_v2_incidenceeditor-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_incidenceeditor-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_incidenceeditor-doc}"
SRC_URI[x86_64_v2_incidenceeditor-doc.sha256sum] = "4a790f6fff8995cece4b2d0c0965db9aa0b209df91a4d56e81b50ef66c475fc1"

URI_aarch64_incidenceeditor = "${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_incidenceeditor;unpack=0"
SRC_URI:append = " ${URI_aarch64_incidenceeditor}"
SRC_URI[aarch64_incidenceeditor.sha256sum] = "8a05edf22d531bf4771e63e00c9a289b61c6238c63504e65ef07ba9d670a27bb"

URI_aarch64_incidenceeditor-devel = "${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_incidenceeditor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_incidenceeditor-devel}"
SRC_URI[aarch64_incidenceeditor-devel.sha256sum] = "b02468dc43151a24a0a7977d5a9c0ac54ce8d601d2a789d3bdf1177835885cd6"

URI_aarch64_incidenceeditor-doc = "${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_incidenceeditor-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_incidenceeditor-doc}"
SRC_URI[aarch64_incidenceeditor-doc.sha256sum] = "fe688ee80ec2121c04970ebcdb7dfea1b302b0bd0e611d33c9e0608e2483d4d9"

RDEPENDS:incidenceeditor = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 calendarsupport \
 eventviews \
 glibc \
 kcalutils \
 kdiagram \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kldap \
 kmime \
 kpimtextedit \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:incidenceeditor-devel = " \
 calendarsupport-devel \
 cmake-filesystem \
 eventviews-devel \
 incidenceeditor \
 kcalutils-devel \
 kf6-kcalendarcore-devel \
 kmime-devel \
 "
RDEPENDS:incidenceeditor-doc = " \
 "
