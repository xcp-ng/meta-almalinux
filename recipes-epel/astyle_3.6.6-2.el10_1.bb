# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "astyle"
PV = "3.6.6"
PR = "2.el10_1"
PACKAGES = " \
 astyle \
 astyle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/astyle-3.6.6-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ad71646bb3e5788ecbff4fa4929b357885f6e9f519d1cf2617f3528006ebb0b"

URI_x86_64_v2_astyle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/astyle-3.6.6-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_astyle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_astyle}"
SRC_URI[x86_64_v2_astyle.sha256sum] = "c2a0ef75c060d5340c2021c0d6daa4fd17e34fbf29f5f189cc953c8a734cd587"

URI_x86_64_v2_astyle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/astyle-devel-3.6.6-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_astyle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_astyle-devel}"
SRC_URI[x86_64_v2_astyle-devel.sha256sum] = "6d534735a90f5c4ec591934a7a2a0af2f90a402720900e9ecadb80f8a4bb6d01"

URI_aarch64_astyle = "${EPEL_MIRROR}/aarch64/Packages/a/astyle-3.6.6-2.el10_1.aarch64.rpm;name=aarch64_astyle;unpack=0"
SRC_URI:append = " ${URI_aarch64_astyle}"
SRC_URI[aarch64_astyle.sha256sum] = "7f89e815ce3a676e32adcaa3661882175964fc7a9e42ded0828196a927becac3"

URI_aarch64_astyle-devel = "${EPEL_MIRROR}/aarch64/Packages/a/astyle-devel-3.6.6-2.el10_1.aarch64.rpm;name=aarch64_astyle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_astyle-devel}"
SRC_URI[aarch64_astyle-devel.sha256sum] = "179c1663b37bb1058ad353031617eea2bdaa15fb3c9722898044317ec02f4cba"

RDEPENDS:astyle = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:astyle-devel = " \
 astyle \
 "
