# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dirs-next"
PV = "2.0.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-dirs-next+default-devel \
 rust-dirs-next-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dirs-next-2.0.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b5b12759f62c8920719a8109f966362b7b4c790a542649ec906566004bf19a0"

URI_x86_64_v2_rust-dirs-next+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-next+default-devel-2.0.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-next+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-next+default-devel}"
SRC_URI[x86_64_v2_rust-dirs-next+default-devel.sha256sum] = "9b51cc6586b2b7d89e2646496e30ce926fddef122309c4a1af2ba4494b2f8c08"

URI_x86_64_v2_rust-dirs-next-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-next-devel-2.0.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-next-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-next-devel}"
SRC_URI[x86_64_v2_rust-dirs-next-devel.sha256sum] = "1c764202390f6944906d56f8797106a2f967dc9c60cf97767d29c31be84d5ee0"

URI_aarch64_rust-dirs-next+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-next+default-devel-2.0.0-11.el10_0.noarch.rpm;name=aarch64_rust-dirs-next+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-next+default-devel}"
SRC_URI[aarch64_rust-dirs-next+default-devel.sha256sum] = "c0c8fc8787870f5faccf15465cb7f93df2ef1e10df91f1da0b80fa5e1651fd19"

URI_aarch64_rust-dirs-next-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-next-devel-2.0.0-11.el10_0.noarch.rpm;name=aarch64_rust-dirs-next-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-next-devel}"
SRC_URI[aarch64_rust-dirs-next-devel.sha256sum] = "96b760876d497a17cc508399ee7b72afd59a87df29b6d9df71cf9e6495a80b7f"

RDEPENDS:rust-dirs-next+default-devel = " \
 cargo \
 rust-dirs-next-devel \
 "
RDEPENDS:rust-dirs-next-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-dirs-sys-next+default-devel \
 "
