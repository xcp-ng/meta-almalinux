# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-equivalent"
PV = "1.0.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-equivalent+default-devel \
 rust-equivalent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-equivalent-1.0.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1383c99a02a0db7ff7eedae5f6dd19fcc02e81156fa5c17dadbd23dadda64cb"

URI_x86_64_v2_rust-equivalent+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equivalent+default-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equivalent+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equivalent+default-devel}"
SRC_URI[x86_64_v2_rust-equivalent+default-devel.sha256sum] = "66c0a55ce8bbfbd6fd20a5efdd2701d0e6c44427f32e8f4bbaabe3b1e466e834"

URI_x86_64_v2_rust-equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equivalent-devel-1.0.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equivalent-devel}"
SRC_URI[x86_64_v2_rust-equivalent-devel.sha256sum] = "396928ff82d3cf022e1e48bcdb6645ab797f78e5630be858907b025b3275d81f"

URI_aarch64_rust-equivalent+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equivalent+default-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-equivalent+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equivalent+default-devel}"
SRC_URI[aarch64_rust-equivalent+default-devel.sha256sum] = "a60128fae7d5bffce400ed76857b100fa42a8123ecb707d370d5b3b3e1470493"

URI_aarch64_rust-equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equivalent-devel-1.0.2-1.el10_0.noarch.rpm;name=aarch64_rust-equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equivalent-devel}"
SRC_URI[aarch64_rust-equivalent-devel.sha256sum] = "6a1e8a7378d942afbee85e9d94038965a52c633aebc18ed9ab393a5579fd9abb"

RDEPENDS:rust-equivalent+default-devel = " \
 cargo \
 rust-equivalent-devel \
 "
RDEPENDS:rust-equivalent-devel = " \
 cargo \
 rust \
 "
