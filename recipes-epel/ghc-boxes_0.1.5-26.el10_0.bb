# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-boxes"
PV = "0.1.5"
PR = "26.el10_0"
PACKAGES = " \
 ghc-boxes \
 ghc-boxes-devel \
 ghc-boxes-doc \
 ghc-boxes-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-boxes-0.1.5-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d530b4bf63ca740b1968640d4e6a71ea6cea0a16e021f2db371e5295a55d0b9"

URI_x86_64_v2_ghc-boxes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-boxes-0.1.5-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-boxes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-boxes}"
SRC_URI[x86_64_v2_ghc-boxes.sha256sum] = "d6d6bea00b388fc0a0acc56d8ea87201584f8da225bd1d6eb78fe1cf488bc9da"

URI_x86_64_v2_ghc-boxes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-boxes-devel-0.1.5-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-boxes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-boxes-devel}"
SRC_URI[x86_64_v2_ghc-boxes-devel.sha256sum] = "d29e590eca84437663fcbb64c40151373eb7806cf6a81be91f25196998ee365a"

URI_x86_64_v2_ghc-boxes-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-boxes-doc-0.1.5-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-boxes-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-boxes-doc}"
SRC_URI[x86_64_v2_ghc-boxes-doc.sha256sum] = "9193e3408bd5fefa35d650befa4b3853bc569b93f9ffbaf2ff499bced0ba919e"

URI_x86_64_v2_ghc-boxes-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-boxes-prof-0.1.5-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-boxes-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-boxes-prof}"
SRC_URI[x86_64_v2_ghc-boxes-prof.sha256sum] = "36fbdd8a5b6ff49078b440b3f5b968c02cd5c95e1e21085c75e95b80eba47cda"

URI_aarch64_ghc-boxes = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-boxes-0.1.5-26.el10_0.aarch64.rpm;name=aarch64_ghc-boxes;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-boxes}"
SRC_URI[aarch64_ghc-boxes.sha256sum] = "9e1dcba7674e541b1e7b0f737fb24eea225794e057d56391854a8cc8eb3a00d1"

URI_aarch64_ghc-boxes-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-boxes-devel-0.1.5-26.el10_0.aarch64.rpm;name=aarch64_ghc-boxes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-boxes-devel}"
SRC_URI[aarch64_ghc-boxes-devel.sha256sum] = "8e627bd27bdb9e4aea2bee31225aae34d8eef4ab710101472d31687bf63e1ec6"

URI_aarch64_ghc-boxes-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-boxes-doc-0.1.5-26.el10_0.noarch.rpm;name=aarch64_ghc-boxes-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-boxes-doc}"
SRC_URI[aarch64_ghc-boxes-doc.sha256sum] = "2c541beaa3710117bbb96d63c540775ed2d3983baec74d480a87daef84be7550"

URI_aarch64_ghc-boxes-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-boxes-prof-0.1.5-26.el10_0.aarch64.rpm;name=aarch64_ghc-boxes-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-boxes-prof}"
SRC_URI[aarch64_ghc-boxes-prof.sha256sum] = "fd204683612aa48937944405e6da359c122907fe6ac796b0ef933d04dd926ff4"

RDEPENDS:ghc-boxes = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-split \
 glibc \
 gmp \
 "
RDEPENDS:ghc-boxes-devel = " \
 ghc-base-devel \
 ghc-boxes \
 ghc-compiler \
 ghc-split-devel \
 "
RDEPENDS:ghc-boxes-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-boxes-prof = " \
 ghc-base-prof \
 ghc-boxes-devel \
 ghc-split-prof \
 "
