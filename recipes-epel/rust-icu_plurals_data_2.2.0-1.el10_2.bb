# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_plurals_data"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_plurals_data+default-devel \
 rust-icu_plurals_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_plurals_data-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de35213f7b0316186087c1f1ef43b94b56e5d5cfe897e91807d42d3c73ec0cbc"

URI_x86_64_v2_rust-icu_plurals_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals_data+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals_data+default-devel.sha256sum] = "a98315ec352498c81ad382fe7ec0dee256c8fef27244becf9f2c103ce5630ab5"

URI_x86_64_v2_rust-icu_plurals_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals_data-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals_data-devel.sha256sum] = "f73eeb928442a600ec68a90d8c9b9093deb9467a15f379c473cf5a1dad2e4eb3"

URI_aarch64_rust-icu_plurals_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals_data+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_plurals_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals_data+default-devel}"
SRC_URI[aarch64_rust-icu_plurals_data+default-devel.sha256sum] = "2a0b3357d4496f6f4cfe88bcb95eefa68cd6b9d175f7f20759c6d48a4d8fa1fc"

URI_aarch64_rust-icu_plurals_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_plurals_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals_data-devel}"
SRC_URI[aarch64_rust-icu_plurals_data-devel.sha256sum] = "a3fcccb5d4ad0d8168a72f94e9ddf593f2cffdaebc993d183c97713e2fd67afe"

RDEPENDS:rust-icu_plurals_data+default-devel = " \
 cargo \
 rust-icu_plurals_data-devel \
 "
RDEPENDS:rust-icu_plurals_data-devel = " \
 cargo \
 rust \
 "
