# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-collectd_cvmfs"
PV = "1.4.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-collectd_cvmfs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-collectd_cvmfs-1.4.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0a9d6bb887ea50d40c0cbaa1c89c6159b059e314f058fbda66dde202de4ecad"

URI_x86_64_v2_python3-collectd_cvmfs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-collectd_cvmfs-1.4.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-collectd_cvmfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-collectd_cvmfs}"
SRC_URI[x86_64_v2_python3-collectd_cvmfs.sha256sum] = "2617767f69a4078c46a5304477ca96325329875c3fa56ff85e893b28cdeefcfb"

URI_aarch64_python3-collectd_cvmfs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-collectd_cvmfs-1.4.0-2.el10_0.noarch.rpm;name=aarch64_python3-collectd_cvmfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-collectd_cvmfs}"
SRC_URI[aarch64_python3-collectd_cvmfs.sha256sum] = "c7c09c101a2443ca664e5201117e02c571efdffca8191753901bf5acb1479dd6"

RDEPENDS:python3-collectd_cvmfs = " \
 python3 \
 python3-psutil \
 python3-pyxattr \
 "
