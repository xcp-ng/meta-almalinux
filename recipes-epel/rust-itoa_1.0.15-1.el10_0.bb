# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-itoa"
PV = "1.0.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-itoa+default-devel \
 rust-itoa+no-panic-devel \
 rust-itoa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-itoa-1.0.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce00ef189f1a397f67afd3b27f3da93d81ddfe08324dd15bcfe27c2aecf44fc3"

URI_x86_64_v2_rust-itoa+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa+default-devel-1.0.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa+default-devel}"
SRC_URI[x86_64_v2_rust-itoa+default-devel.sha256sum] = "2b3703987d8606dc1503c82688bedc077dd74ec4977342e3e4fe2c8b52f9df8f"

URI_x86_64_v2_rust-itoa+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa+no-panic-devel-1.0.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa+no-panic-devel}"
SRC_URI[x86_64_v2_rust-itoa+no-panic-devel.sha256sum] = "05380469a4f4fb5cd6318549f7a689fa7aaafe41b0b0e24a6ec6cb53b7347446"

URI_x86_64_v2_rust-itoa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-itoa-devel-1.0.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-itoa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-itoa-devel}"
SRC_URI[x86_64_v2_rust-itoa-devel.sha256sum] = "11369d569014451582093c3f0e466a66d457f638d34f39993057c6406616130b"

URI_aarch64_rust-itoa+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa+default-devel-1.0.15-1.el10_0.noarch.rpm;name=aarch64_rust-itoa+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa+default-devel}"
SRC_URI[aarch64_rust-itoa+default-devel.sha256sum] = "b5820b8f9d13dd9124dd8b2fa3baa87274439c96538e513fb8b250f2b0d76459"

URI_aarch64_rust-itoa+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa+no-panic-devel-1.0.15-1.el10_0.noarch.rpm;name=aarch64_rust-itoa+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa+no-panic-devel}"
SRC_URI[aarch64_rust-itoa+no-panic-devel.sha256sum] = "5e9a1e812df7ddbc70fa0ba8aa9fba1eb8fd56c2d8b752736ccc1985763c2d56"

URI_aarch64_rust-itoa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-itoa-devel-1.0.15-1.el10_0.noarch.rpm;name=aarch64_rust-itoa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-itoa-devel}"
SRC_URI[aarch64_rust-itoa-devel.sha256sum] = "31798f1a7eb83f99667bd2347811ea9f94eefc2dcafab34bc7461c7489f26d70"

RDEPENDS:rust-itoa+default-devel = " \
 cargo \
 rust-itoa-devel \
 "
RDEPENDS:rust-itoa+no-panic-devel = " \
 cargo \
 rust-itoa-devel \
 rust-no-panic+default-devel \
 "
RDEPENDS:rust-itoa-devel = " \
 cargo \
 rust \
 "
