# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-middleware0.4"
PV = "0.4.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqwest-middleware0.4+charset-devel \
 rust-reqwest-middleware0.4+default-devel \
 rust-reqwest-middleware0.4+http2-devel \
 rust-reqwest-middleware0.4+json-devel \
 rust-reqwest-middleware0.4+multipart-devel \
 rust-reqwest-middleware0.4+rustls-tls-devel \
 rust-reqwest-middleware0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-middleware0.4-0.4.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb0a842d22a6b5c08622ad8007493ad84e647c7af1ae31929870a0502f95503a"

URI_x86_64_v2_rust-reqwest-middleware0.4+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware0.4+charset-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware0.4+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware0.4+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware0.4+charset-devel.sha256sum] = "554bbf2496080fc5e7aa12dce7ed5c100f77c5d20b9225cda7570bd37ea5e08f"

URI_x86_64_v2_rust-reqwest-middleware0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware0.4+default-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware0.4+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware0.4+default-devel.sha256sum] = "7f463e13e1afc6a11668dca62e4a6c3caa53b5e73aea3d7ec9593e73c2fd7803"

URI_x86_64_v2_rust-reqwest-middleware0.4+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware0.4+http2-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware0.4+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware0.4+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware0.4+http2-devel.sha256sum] = "85243a62ecd632e2e7f5ab09fed0706e17bf2bd2679aafe2ea3d951470460742"

URI_x86_64_v2_rust-reqwest-middleware0.4+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware0.4+json-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware0.4+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware0.4+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware0.4+json-devel.sha256sum] = "75e6e29a858fa1a49c396fe9e882022f61a184e67e380043ebe4492d4864503e"

URI_x86_64_v2_rust-reqwest-middleware0.4+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware0.4+multipart-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware0.4+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware0.4+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware0.4+multipart-devel.sha256sum] = "45bd0fa4288fe8d20c00c87cd613cb5c8f4d885d5955134ece8615774e5cad91"

URI_x86_64_v2_rust-reqwest-middleware0.4+rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware0.4+rustls-tls-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware0.4+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware0.4+rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware0.4+rustls-tls-devel.sha256sum] = "bebd5ae4d5e15da553ae0a0cf6859340bda97a99155a34526d010f7977b1f55b"

URI_x86_64_v2_rust-reqwest-middleware0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware0.4-devel-0.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware0.4-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware0.4-devel.sha256sum] = "47031bb90bf012b1c5e6871b4419cba7a60cfef4256a1f45e0767b4494f4c355"

URI_aarch64_rust-reqwest-middleware0.4+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware0.4+charset-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware0.4+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware0.4+charset-devel}"
SRC_URI[aarch64_rust-reqwest-middleware0.4+charset-devel.sha256sum] = "9a517b22b98d710994e3797585fb4adc6277960628c2ba5deff49a6b36fa7fc9"

URI_aarch64_rust-reqwest-middleware0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware0.4+default-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware0.4+default-devel}"
SRC_URI[aarch64_rust-reqwest-middleware0.4+default-devel.sha256sum] = "499895aad97359dd701a1793cb7c89e578a7dccf246dd88db1a2c599bd806a95"

URI_aarch64_rust-reqwest-middleware0.4+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware0.4+http2-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware0.4+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware0.4+http2-devel}"
SRC_URI[aarch64_rust-reqwest-middleware0.4+http2-devel.sha256sum] = "0c297ef28be6869fb1c9074d56198acee30700543ee5d3308006fa62e57a5ea8"

URI_aarch64_rust-reqwest-middleware0.4+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware0.4+json-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware0.4+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware0.4+json-devel}"
SRC_URI[aarch64_rust-reqwest-middleware0.4+json-devel.sha256sum] = "5719aad1c61ec99b1b2ba4cc337af1060d15017bc50aacfbdc84e630f16aff85"

URI_aarch64_rust-reqwest-middleware0.4+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware0.4+multipart-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware0.4+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware0.4+multipart-devel}"
SRC_URI[aarch64_rust-reqwest-middleware0.4+multipart-devel.sha256sum] = "7c295b2fafcf8b482571c19b74d56adb1f2e4d6f02fedc258bb78abf5432a6b8"

URI_aarch64_rust-reqwest-middleware0.4+rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware0.4+rustls-tls-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware0.4+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware0.4+rustls-tls-devel}"
SRC_URI[aarch64_rust-reqwest-middleware0.4+rustls-tls-devel.sha256sum] = "4626a59ea8e249929236f70d2ef7e843f5e7e3459bc6ee802cfe570307d2dc02"

URI_aarch64_rust-reqwest-middleware0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware0.4-devel-0.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-middleware0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware0.4-devel}"
SRC_URI[aarch64_rust-reqwest-middleware0.4-devel.sha256sum] = "c6b01951ad87d2e63088f7b594009f47bc055b61753fcf7e0485ee8f2ec94b03"

RDEPENDS:rust-reqwest-middleware0.4+charset-devel = " \
 cargo \
 rust-reqwest-middleware0.4-devel \
 rust-reqwest0.12+charset-devel \
 "
RDEPENDS:rust-reqwest-middleware0.4+default-devel = " \
 cargo \
 rust-reqwest-middleware0.4-devel \
 "
RDEPENDS:rust-reqwest-middleware0.4+http2-devel = " \
 cargo \
 rust-reqwest-middleware0.4-devel \
 rust-reqwest0.12+http2-devel \
 "
RDEPENDS:rust-reqwest-middleware0.4+json-devel = " \
 cargo \
 rust-reqwest-middleware0.4-devel \
 rust-reqwest0.12+json-devel \
 "
RDEPENDS:rust-reqwest-middleware0.4+multipart-devel = " \
 cargo \
 rust-reqwest-middleware0.4-devel \
 rust-reqwest0.12+multipart-devel \
 "
RDEPENDS:rust-reqwest-middleware0.4+rustls-tls-devel = " \
 cargo \
 rust-reqwest-middleware0.4-devel \
 rust-reqwest0.12+rustls-tls-devel \
 "
RDEPENDS:rust-reqwest-middleware0.4-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-reqwest0.12-devel \
 rust-serde+default-devel \
 rust-thiserror1+default-devel \
 rust-tower-service+default-devel \
 "
