# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-camino"
PV = "1.2.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-camino+default-devel \
 rust-camino+proptest1-devel \
 rust-camino+serde1-devel \
 rust-camino-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-camino-1.2.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b34621f24e58c4adac439fe4762b3a32c1de5bc2808159fb25c2b66d7ab78930"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+default-devel-1.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camino+default-devel.sha256sum] = "a917423c2b9828dd132ef6d21abc317d81e7f5468f6332cd50f99a415b410097"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+proptest1-devel-1.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+proptest1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camino+proptest1-devel.sha256sum] = "54c9565018687294592811a1f2e4df3547ea742d0a16b789b66fad0a414f0ed1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+serde1-devel-1.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+serde1-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camino+serde1-devel.sha256sum] = "842c22e9f245f30086fbb42f1dddb1587acaf140ab6f7c9688153b0091a4ab9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino-devel-1.2.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino-devel;unpack=0"
SRC_URI[x86_64_v2_rust-camino-devel.sha256sum] = "c858b7cdc0784182fed804340ae7a5ffe081f069517fb0e5f3bfe20c8d3f3f90"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+default-devel-1.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-camino+default-devel;unpack=0"
SRC_URI[aarch64_rust-camino+default-devel.sha256sum] = "f5f4186e932a4ea4333405c0cf0be3c6c562be8394cc368ed5973f2f9e52d760"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+proptest1-devel-1.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-camino+proptest1-devel;unpack=0"
SRC_URI[aarch64_rust-camino+proptest1-devel.sha256sum] = "baac8f3889bd275f6318225e97b0de8737948d8ec8afcbd175d35ba1fbf70929"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+serde1-devel-1.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-camino+serde1-devel;unpack=0"
SRC_URI[aarch64_rust-camino+serde1-devel.sha256sum] = "1207c9ad10ee50037b237d7cbd067bbcb10dbbaa4360caa01fb163fcca27447b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-camino-devel-1.2.6-1.el10_2.noarch.rpm;name=aarch64_rust-camino-devel;unpack=0"
SRC_URI[aarch64_rust-camino-devel.sha256sum] = "f1b170d4c33378d9e259c961f97cc507cd21e33c89b47336fc930e4fb2861bfa"

RDEPENDS:rust-camino+default-devel = " \
 cargo \
 rust-camino-devel \
 "
RDEPENDS:rust-camino+proptest1-devel = " \
 cargo \
 rust-camino-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-camino+serde1-devel = " \
 cargo \
 rust-camino-devel \
 rust-serde_core+default-devel \
 "
RDEPENDS:rust-camino-devel = " \
 cargo \
 rust \
 "
