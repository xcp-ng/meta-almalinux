# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "container-selinux"
PE = "4"
PV = "2.248.0"
PR = "1.el10_2"
PACKAGES = " \
 container-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/container-selinux-2.248.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6cd2e669ece4e92db5b0e696ccc392c72353c97e148b577d222ae95ac1a6fa80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/container-selinux-2.248.0-1.el10_2.noarch.rpm;name=x86_64_v2_container-selinux;unpack=0"
SRC_URI[x86_64_v2_container-selinux.sha256sum] = "b89b4e2d1438d98ba0ec3c460b273d2321338c8a18dca8e2c1395f819ad4d8da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/container-selinux-2.248.0-1.el10_2.noarch.rpm;name=aarch64_container-selinux;unpack=0"
SRC_URI[aarch64_container-selinux.sha256sum] = "b89b4e2d1438d98ba0ec3c460b273d2321338c8a18dca8e2c1395f819ad4d8da"

RDEPENDS:container-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 sed \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.18 \
 "
