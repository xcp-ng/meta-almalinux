# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ddiskit"
PV = "3.6"
PR = "28.20250206gitd857c77.el10"
PACKAGES = " \
 ddiskit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ddiskit-3.6-28.20250206gitd857c77.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "346aaa63d4089c1141bcc3a38744c7f471cbd159dd56ed781c61f46ffcb7ced8"

URI_x86_64_v2_ddiskit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ddiskit-3.6-28.20250206gitd857c77.el10.noarch.rpm;name=x86_64_v2_ddiskit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ddiskit}"
SRC_URI[x86_64_v2_ddiskit.sha256sum] = "85dfea9243035deed19e9dfc5d79929a0f5bb5f39e3112b86b4a2ced29af6644"

URI_aarch64_ddiskit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ddiskit-3.6-28.20250206gitd857c77.el10.noarch.rpm;name=aarch64_ddiskit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ddiskit}"
SRC_URI[aarch64_ddiskit.sha256sum] = "85dfea9243035deed19e9dfc5d79929a0f5bb5f39e3112b86b4a2ced29af6644"

RDEPENDS:ddiskit = " \
 createrepo_c \
 python3 \
 rpm \
 virtual//usr/bin/mkisofs \
 "
