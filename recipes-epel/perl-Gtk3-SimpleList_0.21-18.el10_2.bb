# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Gtk3-SimpleList"
PV = "0.21"
PR = "18.el10_2"
PACKAGES = " \
 perl-Gtk3-SimpleList \
 perl-Gtk3-SimpleList-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Gtk3-SimpleList-0.21-18.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1930ffa943093fe22442333fb02b889d1b5778c19ac4de06afadab7ebe45eb0"

URI_x86_64_v2_perl-Gtk3-SimpleList = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-SimpleList-0.21-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-SimpleList;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-SimpleList}"
SRC_URI[x86_64_v2_perl-Gtk3-SimpleList.sha256sum] = "1741239052b91fbdf7dc30a98a746c4047f59f034161157d28106b2c0937a62f"

URI_x86_64_v2_perl-Gtk3-SimpleList-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-SimpleList-tests-0.21-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-SimpleList-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-SimpleList-tests}"
SRC_URI[x86_64_v2_perl-Gtk3-SimpleList-tests.sha256sum] = "36858fb0f7ad21e356f36e096c7f500871c3ab825665624a34f2fdc9cfef9025"

URI_aarch64_perl-Gtk3-SimpleList = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-SimpleList-0.21-18.el10_2.noarch.rpm;name=aarch64_perl-Gtk3-SimpleList;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-SimpleList}"
SRC_URI[aarch64_perl-Gtk3-SimpleList.sha256sum] = "f914927867424bfbda03c2bd9da6f6ec37a6ef78d4f49748aebfef9e9f1d1a5a"

URI_aarch64_perl-Gtk3-SimpleList-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-SimpleList-tests-0.21-18.el10_2.noarch.rpm;name=aarch64_perl-Gtk3-SimpleList-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-SimpleList-tests}"
SRC_URI[aarch64_perl-Gtk3-SimpleList-tests.sha256sum] = "91357a8465b077521f5402892fb8101ff7c471e29e4a02188dd2699115e354f4"

RDEPENDS:perl-Gtk3-SimpleList = " \
 perl-Carp \
 perl-Gtk3 \
 perl-libs \
 "
RDEPENDS:perl-Gtk3-SimpleList-tests = " \
 bash \
 perl-Gtk3-SimpleList \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 "
