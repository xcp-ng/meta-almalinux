# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libev"
PV = "4.33"
PR = "14.el10"
PACKAGES = " \
 libev \
 libev-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libev-4.33-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a196fe3454923ed98d9c806a110e2c45e2fabf7dad335b7af687ca0671daaff"

URI_x86_64_v2_libev = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libev-4.33-14.el10.x86_64_v2.rpm;name=x86_64_v2_libev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libev}"
SRC_URI[x86_64_v2_libev.sha256sum] = "7fc570220fba69dfcb652e38aa86bbf649fdcb12031c80eb1f1ddd5fbf6a13a5"

URI_x86_64_v2_libev-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libev-devel-4.33-14.el10.x86_64_v2.rpm;name=x86_64_v2_libev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libev-devel}"
SRC_URI[x86_64_v2_libev-devel.sha256sum] = "2200b3b7dac5d9249debc6bc76609d40e424e509ae4ad8e6707c9c77751bbc0a"

URI_aarch64_libev = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libev-4.33-14.el10.aarch64.rpm;name=aarch64_libev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libev}"
SRC_URI[aarch64_libev.sha256sum] = "95b6c517f2dcad9fd268547117e0e53696acd0f770de840e203a155868ab5752"

URI_aarch64_libev-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libev-devel-4.33-14.el10.aarch64.rpm;name=aarch64_libev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libev-devel}"
SRC_URI[aarch64_libev-devel.sha256sum] = "749f496e7010f465ee14929a83bead21653d89f8805fea1bce268c369dfb776f"

RDEPENDS:libev = " \
 glibc \
 "
RDEPENDS:libev-devel = " \
 libev \
 "
