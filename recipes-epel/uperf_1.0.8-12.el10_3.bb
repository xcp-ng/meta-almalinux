# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uperf"
PV = "1.0.8"
PR = "12.el10_3"
PACKAGES = " \
 uperf \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/uperf-1.0.8-12.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bcc1124a501bfacf4008823fb8f337edeb4489b0b40a98d5516f04d9969617f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uperf-1.0.8-12.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uperf;unpack=0"
SRC_URI[x86_64_v2_uperf.sha256sum] = "b79d2b5ad66da982694b2a523ccee510919952e6fbbe0540244b93a4c9578332"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/uperf-1.0.8-12.el10_3.aarch64.rpm;name=aarch64_uperf;unpack=0"
SRC_URI[aarch64_uperf.sha256sum] = "f81ed7c145980cbfee6dc4b04bb65e80e368412be1ba91bd29cefceea8975ede"

RDEPENDS:uperf = " \
 glibc \
 lksctp-tools \
 openssl-libs \
 "
