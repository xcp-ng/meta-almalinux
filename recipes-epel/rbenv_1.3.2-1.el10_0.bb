# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rbenv"
PV = "1.3.2"
PR = "1.el10_0"
PACKAGES = " \
 rbenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rbenv-1.3.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b96f9cf045f984951dcc70ffec23002c20f05e70ddc0eb1696e14ffcaa07f24b"

URI_x86_64_v2_rbenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rbenv-1.3.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rbenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rbenv}"
SRC_URI[x86_64_v2_rbenv.sha256sum] = "b13a5895ac2505af29c5c5cdd6040d8cb135efde6105695640b6821b01a26aba"

URI_aarch64_rbenv = "${EPEL_MIRROR}/aarch64/Packages/r/rbenv-1.3.2-1.el10_0.aarch64.rpm;name=aarch64_rbenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_rbenv}"
SRC_URI[aarch64_rbenv.sha256sum] = "00ef21f0eee9a7606b48f983a5e7bbe3cd6bbbf41926cfa1acc452b46590301e"

RDEPENDS:rbenv = " \
 bash \
 gawk \
 "
