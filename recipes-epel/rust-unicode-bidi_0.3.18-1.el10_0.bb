# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-bidi"
PV = "0.3.18"
PR = "1.el10_0"
PACKAGES = " \
 rust-unicode-bidi+bench_it-devel \
 rust-unicode-bidi+default-devel \
 rust-unicode-bidi+hardcoded-data-devel \
 rust-unicode-bidi+serde-devel \
 rust-unicode-bidi+smallvec-devel \
 rust-unicode-bidi+std-devel \
 rust-unicode-bidi+unstable-devel \
 rust-unicode-bidi+with_serde-devel \
 rust-unicode-bidi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-bidi-0.3.18-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfb624f4d560aa7cc86e0e9a6070ea8c7e99c5abc2c500f4c92fb5cb2ca01bae"

URI_x86_64_v2_rust-unicode-bidi+bench_it-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bidi+bench_it-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bidi+bench_it-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bidi+bench_it-devel}"
SRC_URI[x86_64_v2_rust-unicode-bidi+bench_it-devel.sha256sum] = "856d95c6a5afa012704051389a13c29a6cfb330c92675a286cd984fdb115e149"

URI_x86_64_v2_rust-unicode-bidi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bidi+default-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bidi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bidi+default-devel}"
SRC_URI[x86_64_v2_rust-unicode-bidi+default-devel.sha256sum] = "435e8fecb3b097277efee1c7f05fb3a882daafc98d8b193a30b5045ef1be2094"

URI_x86_64_v2_rust-unicode-bidi+hardcoded-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bidi+hardcoded-data-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bidi+hardcoded-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bidi+hardcoded-data-devel}"
SRC_URI[x86_64_v2_rust-unicode-bidi+hardcoded-data-devel.sha256sum] = "2d6862c9a347917b304a65efac9afa1bcd6a74493d3c6be2fd44514ef729e8c3"

URI_x86_64_v2_rust-unicode-bidi+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bidi+serde-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bidi+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bidi+serde-devel}"
SRC_URI[x86_64_v2_rust-unicode-bidi+serde-devel.sha256sum] = "cb30ac38b5e31a3082cde66b90f316429aebdc0e53b7532cf9e5ea0ce6521d16"

URI_x86_64_v2_rust-unicode-bidi+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bidi+smallvec-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bidi+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bidi+smallvec-devel}"
SRC_URI[x86_64_v2_rust-unicode-bidi+smallvec-devel.sha256sum] = "6d9558446cd66494842dbee4d77252f8a8072e2a2f273b83a89a3277e4fd66d0"

URI_x86_64_v2_rust-unicode-bidi+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bidi+std-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bidi+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bidi+std-devel}"
SRC_URI[x86_64_v2_rust-unicode-bidi+std-devel.sha256sum] = "8449dfeb9d07f155192d83abda4539cbf53e70752b323b60c83271332026b651"

URI_x86_64_v2_rust-unicode-bidi+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bidi+unstable-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bidi+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bidi+unstable-devel}"
SRC_URI[x86_64_v2_rust-unicode-bidi+unstable-devel.sha256sum] = "51d1a4dd4b762683734b56a66722e2a4ad6a9a1e1fe125167b051c9ad80f9be0"

URI_x86_64_v2_rust-unicode-bidi+with_serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bidi+with_serde-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bidi+with_serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bidi+with_serde-devel}"
SRC_URI[x86_64_v2_rust-unicode-bidi+with_serde-devel.sha256sum] = "391c7ea30e3068ac989ccc729d436d6d9f7445a16e2f383d5e27a6412cd413c8"

URI_x86_64_v2_rust-unicode-bidi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-bidi-devel-0.3.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-bidi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unicode-bidi-devel}"
SRC_URI[x86_64_v2_rust-unicode-bidi-devel.sha256sum] = "1787d8664befa0159123fd628537a3c93d66cea20e1e7dcc387ec594eaa02b7f"

URI_aarch64_rust-unicode-bidi+bench_it-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bidi+bench_it-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-bidi+bench_it-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bidi+bench_it-devel}"
SRC_URI[aarch64_rust-unicode-bidi+bench_it-devel.sha256sum] = "4ae98e3ec221d9cec2126535424112a881c4de1b9d52df303cca29a41ee70bee"

URI_aarch64_rust-unicode-bidi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bidi+default-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-bidi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bidi+default-devel}"
SRC_URI[aarch64_rust-unicode-bidi+default-devel.sha256sum] = "e0d4b9999e7457f1b7e6a991da4c28534445c495d53e32af6c5b73f9de525783"

URI_aarch64_rust-unicode-bidi+hardcoded-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bidi+hardcoded-data-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-bidi+hardcoded-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bidi+hardcoded-data-devel}"
SRC_URI[aarch64_rust-unicode-bidi+hardcoded-data-devel.sha256sum] = "d6bf99e2c1bbdfadbbf79def64570efe8717fc38e8091f44345f599ea3d4008f"

URI_aarch64_rust-unicode-bidi+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bidi+serde-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-bidi+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bidi+serde-devel}"
SRC_URI[aarch64_rust-unicode-bidi+serde-devel.sha256sum] = "2b92bb2c2d5cea5a301ca482635122b93d7984cc580ac51222b17027b6854d68"

URI_aarch64_rust-unicode-bidi+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bidi+smallvec-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-bidi+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bidi+smallvec-devel}"
SRC_URI[aarch64_rust-unicode-bidi+smallvec-devel.sha256sum] = "7f24dd2280ec438d900a71921c69eac2e55293d1fbda14146c2298f8230e5ed4"

URI_aarch64_rust-unicode-bidi+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bidi+std-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-bidi+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bidi+std-devel}"
SRC_URI[aarch64_rust-unicode-bidi+std-devel.sha256sum] = "6cc45568985c1f42b4ef38c529e3b0e4a0bbc5511ad0d77cb99d174a4f66b873"

URI_aarch64_rust-unicode-bidi+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bidi+unstable-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-bidi+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bidi+unstable-devel}"
SRC_URI[aarch64_rust-unicode-bidi+unstable-devel.sha256sum] = "93a4100c9075f8d4273db4208da2f5e55650e4022adb2697fd15902f8fa0452d"

URI_aarch64_rust-unicode-bidi+with_serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bidi+with_serde-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-bidi+with_serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bidi+with_serde-devel}"
SRC_URI[aarch64_rust-unicode-bidi+with_serde-devel.sha256sum] = "da797dc0bb12190cefe7cf69b57ace2f06bca0029afdaffc02b53738f66477d9"

URI_aarch64_rust-unicode-bidi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-bidi-devel-0.3.18-1.el10_0.noarch.rpm;name=aarch64_rust-unicode-bidi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unicode-bidi-devel}"
SRC_URI[aarch64_rust-unicode-bidi-devel.sha256sum] = "2ec2b11c09ab2146eb1aa0c568c34c3ecb7d9969fe06c26eaf375d18bfd59fb8"

RDEPENDS:rust-unicode-bidi+bench_it-devel = " \
 cargo \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-unicode-bidi+default-devel = " \
 cargo \
 rust-unicode-bidi+hardcoded-data-devel \
 rust-unicode-bidi+std-devel \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-unicode-bidi+hardcoded-data-devel = " \
 cargo \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-unicode-bidi+serde-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-unicode-bidi+smallvec-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-unicode-bidi+std-devel = " \
 cargo \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-unicode-bidi+unstable-devel = " \
 cargo \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-unicode-bidi+with_serde-devel = " \
 cargo \
 rust-unicode-bidi+serde-devel \
 rust-unicode-bidi-devel \
 "
RDEPENDS:rust-unicode-bidi-devel = " \
 cargo \
 rust \
 "
