# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cookie"
PV = "0.4.6"
PR = "7.el10_0"
PACKAGES = " \
 ghc-cookie \
 ghc-cookie-devel \
 ghc-cookie-doc \
 ghc-cookie-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cookie-0.4.6-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c6d35be50a8a02368d84e178e197068058c759b635df354eff10601da9df703"

URI_x86_64_v2_ghc-cookie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cookie-0.4.6-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cookie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cookie}"
SRC_URI[x86_64_v2_ghc-cookie.sha256sum] = "75fda2a53aff9287caf48eb99a2d6aee93e61d811e46afe4c47aeed89ebf6033"

URI_x86_64_v2_ghc-cookie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cookie-devel-0.4.6-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cookie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cookie-devel}"
SRC_URI[x86_64_v2_ghc-cookie-devel.sha256sum] = "34306f422d710e3572c194e27021b39978f884cc485f6193340dfaac86f33a82"

URI_x86_64_v2_ghc-cookie-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cookie-doc-0.4.6-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-cookie-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cookie-doc}"
SRC_URI[x86_64_v2_ghc-cookie-doc.sha256sum] = "fd845d62b605024132af5b8b1708f2377a2eb6b66e3a3a023ab972537b7b5e94"

URI_x86_64_v2_ghc-cookie-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cookie-prof-0.4.6-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cookie-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cookie-prof}"
SRC_URI[x86_64_v2_ghc-cookie-prof.sha256sum] = "f4abed8145b8c633d0de0a73fd1017d81f0e351590c26d9a5b684111865927c9"

URI_aarch64_ghc-cookie = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cookie-0.4.6-7.el10_0.aarch64.rpm;name=aarch64_ghc-cookie;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cookie}"
SRC_URI[aarch64_ghc-cookie.sha256sum] = "e2c465237e857d596d552392c201e14aec1c0f859f29690dfd89de598035692d"

URI_aarch64_ghc-cookie-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cookie-devel-0.4.6-7.el10_0.aarch64.rpm;name=aarch64_ghc-cookie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cookie-devel}"
SRC_URI[aarch64_ghc-cookie-devel.sha256sum] = "cf72ea92d48c923ed16c501f68c69c1f2bb946d24fde5c0e30371c9b02e69ae4"

URI_aarch64_ghc-cookie-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cookie-doc-0.4.6-7.el10_0.noarch.rpm;name=aarch64_ghc-cookie-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cookie-doc}"
SRC_URI[aarch64_ghc-cookie-doc.sha256sum] = "0d910d57e14441bf95004e71a8e91b81a046168f97d2c8fe73dfc8d9e211f2e3"

URI_aarch64_ghc-cookie-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cookie-prof-0.4.6-7.el10_0.aarch64.rpm;name=aarch64_ghc-cookie-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cookie-prof}"
SRC_URI[aarch64_ghc-cookie-prof.sha256sum] = "9c4441898807c5da89302e8b62f9c11e19ce1a611a5b8244dad410f27f5dbfbb"

RDEPENDS:ghc-cookie = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-data-default-class \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cookie-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-cookie \
 ghc-data-default-class-devel \
 ghc-deepseq-devel \
 ghc-text-devel \
 ghc-time-devel \
 "
RDEPENDS:ghc-cookie-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cookie-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-cookie-devel \
 ghc-data-default-class-prof \
 ghc-deepseq-prof \
 ghc-text-prof \
 ghc-time-prof \
 "
