# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_isaac0.3"
PV = "0.3.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_isaac0.3+default-devel \
 rust-rand_isaac0.3+serde-devel \
 rust-rand_isaac0.3+serde1-devel \
 rust-rand_isaac0.3+serde_derive-devel \
 rust-rand_isaac0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_isaac0.3-0.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "799b0d169e64d4b9b583454423daceece80eea27d013d078ebee1046359586a8"

URI_x86_64_v2_rust-rand_isaac0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac0.3+default-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac0.3+default-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac0.3+default-devel.sha256sum] = "45d05b01c82d76d02e45e084a99360924a1e62e908b55ba2e5b3a215fe532de5"

URI_x86_64_v2_rust-rand_isaac0.3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac0.3+serde-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac0.3+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac0.3+serde-devel.sha256sum] = "73a6da329d5b95aadcabceb512e9b565dbf76f2e71a7be182baa381c65cba762"

URI_x86_64_v2_rust-rand_isaac0.3+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac0.3+serde1-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac0.3+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac0.3+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac0.3+serde1-devel.sha256sum] = "c79a1aa7309f952c7929fdc3493e94b58864c2745af5e66f541d82e6025b662c"

URI_x86_64_v2_rust-rand_isaac0.3+serde_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac0.3+serde_derive-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac0.3+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac0.3+serde_derive-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac0.3+serde_derive-devel.sha256sum] = "f2b5c9d85256a5800fa5517fa942573ee65de68fb0e3d25e788b30fe7eda3317"

URI_x86_64_v2_rust-rand_isaac0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac0.3-devel-0.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac0.3-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac0.3-devel.sha256sum] = "47825f7708f16dbbef0db04ee2840d20d31ff61a23956baa9014eb8d7383718d"

URI_aarch64_rust-rand_isaac0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac0.3+default-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac0.3+default-devel}"
SRC_URI[aarch64_rust-rand_isaac0.3+default-devel.sha256sum] = "76259f46b917e0fca8ca50099985aec8688d81f5f7b8ad93d60c8bb87e4b5e77"

URI_aarch64_rust-rand_isaac0.3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac0.3+serde-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac0.3+serde-devel}"
SRC_URI[aarch64_rust-rand_isaac0.3+serde-devel.sha256sum] = "a2907403003fb5dcfad8cd4ca39abef6cec0b605fa9439c05524b92a2162ec93"

URI_aarch64_rust-rand_isaac0.3+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac0.3+serde1-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac0.3+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac0.3+serde1-devel}"
SRC_URI[aarch64_rust-rand_isaac0.3+serde1-devel.sha256sum] = "b8ffa92ce3a93c23e8f214fdd9bfafdfdb6f4ebf265c3fd906b0e9a96d4245da"

URI_aarch64_rust-rand_isaac0.3+serde_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac0.3+serde_derive-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac0.3+serde_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac0.3+serde_derive-devel}"
SRC_URI[aarch64_rust-rand_isaac0.3+serde_derive-devel.sha256sum] = "d987ac9da8109de0334fd542eb8cdd4a29a164bced91be705c4f3105569b4a90"

URI_aarch64_rust-rand_isaac0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac0.3-devel-0.3.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac0.3-devel}"
SRC_URI[aarch64_rust-rand_isaac0.3-devel.sha256sum] = "585350e761088d0003d94775c4ec54ae1a073b066345ff92b05670cdf590bc30"

RDEPENDS:rust-rand_isaac0.3+default-devel = " \
 cargo \
 rust-rand_isaac0.3-devel \
 "
RDEPENDS:rust-rand_isaac0.3+serde-devel = " \
 cargo \
 rust-rand_isaac0.3-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_isaac0.3+serde1-devel = " \
 cargo \
 rust-rand_core0.6+serde1-devel \
 rust-rand_isaac0.3+serde-devel \
 rust-rand_isaac0.3-devel \
 "
RDEPENDS:rust-rand_isaac0.3+serde_derive-devel = " \
 cargo \
 rust-rand_isaac0.3-devel \
 rust-serde_derive+default-devel \
 "
RDEPENDS:rust-rand_isaac0.3-devel = " \
 cargo \
 rust-rand_core0.6+default-devel \
 "
