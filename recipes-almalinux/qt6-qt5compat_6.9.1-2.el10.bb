# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qt5compat"
PV = "6.9.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qt5compat \
 qt6-qt5compat-devel \
 qt6-qt5compat-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qt5compat-6.9.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5800b171c7ed3069249efa2187e0af87ce199d067b98d636327a1a3f25521794"

URI_x86_64_v2_qt6-qt5compat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt5compat-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt5compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt5compat}"
SRC_URI[x86_64_v2_qt6-qt5compat.sha256sum] = "5457adcae9eeb4ff24dfd6d0338fd21da807bc06f69bc5ef4dd7580aa8a88b04"

URI_x86_64_v2_qt6-qt5compat-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qt5compat-devel-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt5compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt5compat-devel}"
SRC_URI[x86_64_v2_qt6-qt5compat-devel.sha256sum] = "88647699c561991ff8ff8b766ac60a51fc151b3bce82777dc03f486aa7629679"

URI_x86_64_v2_qt6-qt5compat-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qt5compat-examples-6.9.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qt5compat-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qt5compat-examples}"
SRC_URI[x86_64_v2_qt6-qt5compat-examples.sha256sum] = "ea23e9f62f54e5896ed7e1e4bb8d8bc39d4ad1f7989a0a90e802c99728b72369"

URI_aarch64_qt6-qt5compat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt5compat-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qt5compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt5compat}"
SRC_URI[aarch64_qt6-qt5compat.sha256sum] = "5f67c0dc6a0f830b865148564d2a383785343c4b2fb273ad7479f4ebc1fe3a6e"

URI_aarch64_qt6-qt5compat-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qt5compat-devel-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qt5compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt5compat-devel}"
SRC_URI[aarch64_qt6-qt5compat-devel.sha256sum] = "46d1419892267328b6128bea5e86c09c01ee5c44e41af5d7714a4aa7ede36cdc"

URI_aarch64_qt6-qt5compat-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qt5compat-examples-6.9.1-2.el10.aarch64.rpm;name=aarch64_qt6-qt5compat-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qt5compat-examples}"
SRC_URI[aarch64_qt6-qt5compat-examples.sha256sum] = "68d869873413554b078f72b0d4919074414b84eb252c0bed94837b147d07e28f"

RDEPENDS:qt6-qt5compat = " \
 glibc \
 libicu \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtshadertools \
 "
RDEPENDS:qt6-qt5compat-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qt5compat \
 qt6-qtbase-devel \
 "
RDEPENDS:qt6-qt5compat-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
