# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-ugly-free"
PV = "1.24.11"
PR = "1.el10"
PACKAGES = " \
 gstreamer1-plugins-ugly-free \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-ugly-free-1.24.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fecd5e4628314f6aad8396c24c11c265b3718e85b41c28cb8be15c1dee3f9af5"

URI_x86_64_v2_gstreamer1-plugins-ugly-free = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-ugly-free-1.24.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-ugly-free}"
SRC_URI[x86_64_v2_gstreamer1-plugins-ugly-free.sha256sum] = "e93faedcb8c314b3c1292fef63846ef1c52e11c8cb6167cab204e3febe9b558a"

URI_aarch64_gstreamer1-plugins-ugly-free = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-ugly-free-1.24.11-1.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-ugly-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-ugly-free}"
SRC_URI[aarch64_gstreamer1-plugins-ugly-free.sha256sum] = "25254b84bbc4cb775aa37c7ab99143b838c395647435ac06ed6f70d01f20050f"

RDEPENDS:gstreamer1-plugins-ugly-free = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 liba52 \
 libcdio \
 libdvdread \
 libmpeg2 \
 orc \
 "
