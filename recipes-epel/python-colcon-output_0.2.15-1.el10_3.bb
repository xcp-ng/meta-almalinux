# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-output"
PV = "0.2.15"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-output \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-output-0.2.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "413982385943fe77984acf5a9f3d7d1495fb3b3924201221d68b0bb8b9b8546e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-output-0.2.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-output;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-output.sha256sum] = "35c736bc9e87600b71a8ba45d5a4002cc6bae8097eed77a39bdabe28dc05a661"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-output-0.2.15-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-output;unpack=0"
SRC_URI[aarch64_python3-colcon-output.sha256sum] = "26bd886fa7bac1349a2f0f865616603c6fa68b8c7a4cc5a0947dd11ddcb8034a"

RDEPENDS:python3-colcon-output = " \
 python3 \
 python3-colcon-core \
 "
