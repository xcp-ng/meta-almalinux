# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-remote-desktop"
PV = "49.3"
PR = "12.el10.alma.1"
PACKAGES = " \
 gnome-remote-desktop \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-remote-desktop-49.3-12.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6f9588e0df731966c7e2eadc0805312c370b440faff0513b14d3a0e02807aade"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-remote-desktop-49.3-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-remote-desktop;unpack=0"
SRC_URI[x86_64_v2_gnome-remote-desktop.sha256sum] = "0405efa1bb16fa63a9db4ae2b3199f4bbe371833b4ac5bf406a0e1271f3a57ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-remote-desktop-49.3-12.el10.alma.1.aarch64.rpm;name=aarch64_gnome-remote-desktop;unpack=0"
SRC_URI[aarch64_gnome-remote-desktop.sha256sum] = "dc61753d7efba58c6e4da955c0418c7c0b02ba8b33a512ad287e0017a46689e3"

RDEPENDS:gnome-remote-desktop = " \
 bash \
 cairo \
 fdk-aac-free \
 freerdp-libs \
 fuse3-libs \
 glib2 \
 glibc \
 krb5-libs \
 libei \
 libepoxy \
 libgcc \
 libnotify \
 libsecret \
 libva \
 libwinpr \
 libxkbcommon \
 opus \
 pipewire \
 pipewire-libs \
 polkit-libs \
 systemd-libs \
 tpm2-tss \
 vulkan-loader \
 "
