# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gsi-openssl-error"
PV = "4.4"
PR = "4.el10_0"
PACKAGES = " \
 globus-gsi-openssl-error \
 globus-gsi-openssl-error-devel \
 globus-gsi-openssl-error-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/globus-gsi-openssl-error-4.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b4911cf8e80bed06c9aac7efde9f2035ff745088fc14f7e2424ed5d522aacaf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-openssl-error-4.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-openssl-error;unpack=0"
SRC_URI[x86_64_v2_globus-gsi-openssl-error.sha256sum] = "93caf47ddabe2c5f8216931baa6d21f83baa3a573db1e91b2aa628f6696945b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-openssl-error-devel-4.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gsi-openssl-error-devel;unpack=0"
SRC_URI[x86_64_v2_globus-gsi-openssl-error-devel.sha256sum] = "6451afa1fe8a7c7b912e1f5db0861e051f0199c61bc4dcbe94ab272147afdc62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gsi-openssl-error-doc-4.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gsi-openssl-error-doc;unpack=0"
SRC_URI[x86_64_v2_globus-gsi-openssl-error-doc.sha256sum] = "e6a0942fa4409098397d61d7061ce4912194f5ad941a723a555c9cec0195b898"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-openssl-error-4.4-4.el10_0.aarch64.rpm;name=aarch64_globus-gsi-openssl-error;unpack=0"
SRC_URI[aarch64_globus-gsi-openssl-error.sha256sum] = "16535f4e783bed26c5d55e7dd6f1b796c0c9fc5cb85edbf292a3dc5746dfc8e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-openssl-error-devel-4.4-4.el10_0.aarch64.rpm;name=aarch64_globus-gsi-openssl-error-devel;unpack=0"
SRC_URI[aarch64_globus-gsi-openssl-error-devel.sha256sum] = "8a8a0af4327cea628207020fc35615713c0b6b15c22aff5abeb09210ad682104"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gsi-openssl-error-doc-4.4-4.el10_0.noarch.rpm;name=aarch64_globus-gsi-openssl-error-doc;unpack=0"
SRC_URI[aarch64_globus-gsi-openssl-error-doc.sha256sum] = "81254322be68c372ff09dab3f2b2bf269082923d0defdbc479a6c2f29948b912"

RDEPENDS:globus-gsi-openssl-error = " \
 glibc \
 globus-common \
 openssl-libs \
 "
RDEPENDS:globus-gsi-openssl-error-devel = " \
 globus-common-devel \
 globus-gsi-openssl-error \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gsi-openssl-error-doc = " \
 "
