# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-ini"
PV = "0.21.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-rust-ini+brackets-in-section-names-devel \
 rust-rust-ini+case-insensitive-devel \
 rust-rust-ini+default-devel \
 rust-rust-ini+inline-comment-devel \
 rust-rust-ini+unicase-devel \
 rust-rust-ini-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-ini-0.21.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "859e28bd7fad03eb805884e3535e6f54a032e2fcb58097dcc4f8b803d0c4d166"

URI_x86_64_v2_rust-rust-ini+brackets-in-section-names-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+brackets-in-section-names-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+brackets-in-section-names-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+brackets-in-section-names-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+brackets-in-section-names-devel.sha256sum] = "952af54c94ca46d69bfbb5a91177e64157666d0cb5d02433bf6e8816ca729482"

URI_x86_64_v2_rust-rust-ini+case-insensitive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+case-insensitive-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+case-insensitive-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+case-insensitive-devel.sha256sum] = "3310dc930b354d068b77b4859162263e96d8ebbee228a9c2c555a72896b564ed"

URI_x86_64_v2_rust-rust-ini+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+default-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+default-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+default-devel.sha256sum] = "4f31db0a68f04b312b1c51d011304971257a375427ab70a4cf5d7d7c019c43e8"

URI_x86_64_v2_rust-rust-ini+inline-comment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+inline-comment-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+inline-comment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+inline-comment-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+inline-comment-devel.sha256sum] = "ba31a382b2ce930a5afb661ae6c3b8fdfa307cc9618d1ce024b6c79df3a28d44"

URI_x86_64_v2_rust-rust-ini+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini+unicase-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini+unicase-devel}"
SRC_URI[x86_64_v2_rust-rust-ini+unicase-devel.sha256sum] = "9dda6c69419eeaf0f68a3a1d06d44056a0200252bdbd7f3b9254a7ff2dac6005"

URI_x86_64_v2_rust-rust-ini-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-ini-devel-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-ini-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-ini-devel}"
SRC_URI[x86_64_v2_rust-rust-ini-devel.sha256sum] = "5ceaf25dadb85df3a044a4079c8879fb46d30202032717fedbd6d3ffec95e411"

URI_aarch64_rust-rust-ini+brackets-in-section-names-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+brackets-in-section-names-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-rust-ini+brackets-in-section-names-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+brackets-in-section-names-devel}"
SRC_URI[aarch64_rust-rust-ini+brackets-in-section-names-devel.sha256sum] = "479abed9007f8768ad80e338e084b09de5aaff6c87f4cd95fe24559cb8780c03"

URI_aarch64_rust-rust-ini+case-insensitive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+case-insensitive-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-rust-ini+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+case-insensitive-devel}"
SRC_URI[aarch64_rust-rust-ini+case-insensitive-devel.sha256sum] = "3a004e61d94090cab81ab3bd474bf1dc35a0f5588f8cdf6344e76eaf6cae4dfc"

URI_aarch64_rust-rust-ini+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+default-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-rust-ini+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+default-devel}"
SRC_URI[aarch64_rust-rust-ini+default-devel.sha256sum] = "ea0dc9c21dc96356a8a5ac7dfcec5ec5fba17e1017255007a002a5746cb3d653"

URI_aarch64_rust-rust-ini+inline-comment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+inline-comment-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-rust-ini+inline-comment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+inline-comment-devel}"
SRC_URI[aarch64_rust-rust-ini+inline-comment-devel.sha256sum] = "6b42a046011750d52508af7971e426b34aa2b4414266d774fbe75406af32fdff"

URI_aarch64_rust-rust-ini+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini+unicase-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-rust-ini+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini+unicase-devel}"
SRC_URI[aarch64_rust-rust-ini+unicase-devel.sha256sum] = "45f7d254a2cb47a0309894bd3b73a9b34699a58075237fc9fbb898c1e841e8c8"

URI_aarch64_rust-rust-ini-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-ini-devel-0.21.3-1.el10_2.noarch.rpm;name=aarch64_rust-rust-ini-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-ini-devel}"
SRC_URI[aarch64_rust-rust-ini-devel.sha256sum] = "15fa0d05b37dc0948670bb683ed0fd867c01363acf4d64970bc4f5face8f4157"

RDEPENDS:rust-rust-ini+brackets-in-section-names-devel = " \
 cargo \
 rust-rust-ini-devel \
 "
RDEPENDS:rust-rust-ini+case-insensitive-devel = " \
 cargo \
 rust-rust-ini+unicase-devel \
 rust-rust-ini-devel \
 "
RDEPENDS:rust-rust-ini+default-devel = " \
 cargo \
 rust-rust-ini-devel \
 "
RDEPENDS:rust-rust-ini+inline-comment-devel = " \
 cargo \
 rust-rust-ini-devel \
 "
RDEPENDS:rust-rust-ini+unicase-devel = " \
 cargo \
 rust-rust-ini-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-rust-ini-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-ordered-multimap+default-devel \
 "
