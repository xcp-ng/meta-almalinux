# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-bigint-dig0.8"
PV = "0.8.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-num-bigint-dig0.8+arbitrary-devel \
 rust-num-bigint-dig0.8+default-devel \
 rust-num-bigint-dig0.8+fuzz-devel \
 rust-num-bigint-dig0.8+i128-devel \
 rust-num-bigint-dig0.8+prime-devel \
 rust-num-bigint-dig0.8+rand-devel \
 rust-num-bigint-dig0.8+serde-devel \
 rust-num-bigint-dig0.8+std-devel \
 rust-num-bigint-dig0.8+u64_digit-devel \
 rust-num-bigint-dig0.8+zeroize-devel \
 rust-num-bigint-dig0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-bigint-dig0.8-0.8.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4823558e57d6a26aa5324d0916a0a60729311a2d042fbcc0b916fb729b9b9c47"

URI_x86_64_v2_rust-num-bigint-dig0.8+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+arbitrary-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+arbitrary-devel.sha256sum] = "386e65c6683345e4436447e39b0d861878e119c844d6e65bb8051dab32fb6547"

URI_x86_64_v2_rust-num-bigint-dig0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+default-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+default-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+default-devel.sha256sum] = "7ca0cf31019cd800def5ef4f1f72993213e62cbd3c496d9d9528b1d03bb55357"

URI_x86_64_v2_rust-num-bigint-dig0.8+fuzz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+fuzz-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+fuzz-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+fuzz-devel.sha256sum] = "abab7b385657a4a1f53c7dfef1bd3c805b704b14eede5917271347053435ffe2"

URI_x86_64_v2_rust-num-bigint-dig0.8+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+i128-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+i128-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+i128-devel.sha256sum] = "cf5c4ff2fc659736a2c5f93497ea4ec44a3d2fcb6db139b7945f5ec07cfa39e5"

URI_x86_64_v2_rust-num-bigint-dig0.8+prime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+prime-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+prime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+prime-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+prime-devel.sha256sum] = "15d47933196a5f44b3c08356de436300bfed492185c0dd4c13f096ff0fe0df66"

URI_x86_64_v2_rust-num-bigint-dig0.8+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+rand-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+rand-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+rand-devel.sha256sum] = "e7b08ff4c800809b7848caa13de3810cdbeca165f1bf7cb9b6b532f63f73e854"

URI_x86_64_v2_rust-num-bigint-dig0.8+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+serde-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+serde-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+serde-devel.sha256sum] = "c84bc138bed33f0a2b653a8a104d3a7a570f44fadaf1f811b27fe8b5d32f4aef"

URI_x86_64_v2_rust-num-bigint-dig0.8+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+std-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+std-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+std-devel.sha256sum] = "da400b2d802747dd7969639d7b44d5cc6be8c196c42b1561f0ce67bb04f176ce"

URI_x86_64_v2_rust-num-bigint-dig0.8+u64_digit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+u64_digit-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+u64_digit-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+u64_digit-devel.sha256sum] = "a622fa993ddfa914836df7609af1ac0c7acb71eb29210196af30e06eaaed846f"

URI_x86_64_v2_rust-num-bigint-dig0.8+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8+zeroize-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8+zeroize-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8+zeroize-devel.sha256sum] = "4a3fe41a97c1b901c46499852cd681493e67d9de2f92837d43a9ee17a29563e1"

URI_x86_64_v2_rust-num-bigint-dig0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-bigint-dig0.8-devel-0.8.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-bigint-dig0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-bigint-dig0.8-devel}"
SRC_URI[x86_64_v2_rust-num-bigint-dig0.8-devel.sha256sum] = "cc20f4b098fdca360d5e31a40d8e23aa0fecaa838ce3ddddbb036546a300b7ba"

URI_aarch64_rust-num-bigint-dig0.8+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+arbitrary-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+arbitrary-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+arbitrary-devel.sha256sum] = "72586d222b7012a573fb508800e80c06cde08a07867eaf7bb30f9b620874dac5"

URI_aarch64_rust-num-bigint-dig0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+default-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+default-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+default-devel.sha256sum] = "abc33c34ef2774e9ad2a0e7829581add9dfa51079607ee5cce4dbec182f68d60"

URI_aarch64_rust-num-bigint-dig0.8+fuzz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+fuzz-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+fuzz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+fuzz-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+fuzz-devel.sha256sum] = "273b9dde4e834251d36a2a32d01a896848e853c1ef337df58b3abe251308d3b6"

URI_aarch64_rust-num-bigint-dig0.8+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+i128-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+i128-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+i128-devel.sha256sum] = "acdcd3817ceea3ea842c450b6cbd8591037db339879a8a8463ce841707551421"

URI_aarch64_rust-num-bigint-dig0.8+prime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+prime-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+prime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+prime-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+prime-devel.sha256sum] = "bc07d5a52994ce1ce75e1fe946f35387e4e5b407979e5a1b200a1525b7c219d3"

URI_aarch64_rust-num-bigint-dig0.8+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+rand-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+rand-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+rand-devel.sha256sum] = "6075bc842ee64a73071f5382fa30f0d6f70dac20145b229326faecc79e9b1883"

URI_aarch64_rust-num-bigint-dig0.8+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+serde-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+serde-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+serde-devel.sha256sum] = "7e0f5f147def20de562e59dfdeb5e1f587460fd5653a5c60d6ae1a0f2f7c3cc0"

URI_aarch64_rust-num-bigint-dig0.8+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+std-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+std-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+std-devel.sha256sum] = "b5002daebc4aa58edc787066cc3f9cef57dd5f2f95e089bcad0103864f587c9f"

URI_aarch64_rust-num-bigint-dig0.8+u64_digit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+u64_digit-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+u64_digit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+u64_digit-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+u64_digit-devel.sha256sum] = "e5b55d602651c9eb7ace5c30a2600935d0928dd5190ede4b890d012a2f1625ea"

URI_aarch64_rust-num-bigint-dig0.8+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8+zeroize-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8+zeroize-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8+zeroize-devel.sha256sum] = "c9c6ee814fa8b7d0cf02b9c478599dec0983084dbe8c10cf0a65342f94169f82"

URI_aarch64_rust-num-bigint-dig0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-bigint-dig0.8-devel-0.8.6-1.el10_3.noarch.rpm;name=aarch64_rust-num-bigint-dig0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-bigint-dig0.8-devel}"
SRC_URI[aarch64_rust-num-bigint-dig0.8-devel.sha256sum] = "d3f186a4556d0d5d09d588388b6b17e9fb90c18d3de0cb94e55c34b73ee56fde"

RDEPENDS:rust-num-bigint-dig0.8+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-num-bigint-dig0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8+default-devel = " \
 cargo \
 rust-num-bigint-dig0.8+std-devel \
 rust-num-bigint-dig0.8+u64_digit-devel \
 rust-num-bigint-dig0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8+fuzz-devel = " \
 cargo \
 rust-num-bigint-dig0.8+arbitrary-devel \
 rust-num-bigint-dig0.8-devel \
 rust-smallvec+arbitrary-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8+i128-devel = " \
 cargo \
 rust-num-bigint-dig0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8+prime-devel = " \
 cargo \
 rust-num-bigint-dig0.8-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8+rand-devel = " \
 cargo \
 rust-num-bigint-dig0.8-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8+serde-devel = " \
 cargo \
 rust-num-bigint-dig0.8-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8+std-devel = " \
 cargo \
 rust-num-bigint-dig0.8-devel \
 rust-num-integer+std-devel \
 rust-num-traits+std-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8-devel \
 rust-serde+alloc-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-smallvec+write-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8+u64_digit-devel = " \
 cargo \
 rust-num-bigint-dig0.8-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8+zeroize-devel = " \
 cargo \
 rust-num-bigint-dig0.8-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-num-bigint-dig0.8-devel = " \
 bash \
 cargo \
 rust \
 rust-lazy_static+spin_no_std-devel \
 rust-lazy_static-devel \
 rust-libm+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer-devel \
 rust-num-iter-devel \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 rust-smallvec-devel \
 "
