# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-brotli"
PV = "1.0.0~rc"
PR = "1.el10_0"
PACKAGES = " \
 nginx-mod-brotli \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-brotli-1.0.0~rc-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ea345a77c179b266e757c6d95fd6414948f12b91f238cb014444c22622d0e6fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-brotli-1.0.0~rc-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-brotli;unpack=0"
SRC_URI[x86_64_v2_nginx-mod-brotli.sha256sum] = "96507e6b2e704f547e3caeea27b1798ee4784e2afae39651fbed006b831a721a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-brotli-1.0.0~rc-1.el10_0.aarch64.rpm;name=aarch64_nginx-mod-brotli;unpack=0"
SRC_URI[aarch64_nginx-mod-brotli.sha256sum] = "ea3fc51198d8492bed0542dacfc4b2de9d078dadc7bcad5e4d2b52e66c825f3c"

RDEPENDS:nginx-mod-brotli = " \
 glibc \
 libbrotli \
 nginx \
 "
