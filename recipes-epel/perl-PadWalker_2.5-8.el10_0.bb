# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-PadWalker"
PV = "2.5"
PR = "8.el10_0"
PACKAGES = " \
 perl-PadWalker \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-PadWalker-2.5-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "abd9ff030f2eff11c83bc1bebe10651afb76411b0a7aedd28239952dacfdcd41"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-PadWalker-2.5-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-PadWalker;unpack=0"
SRC_URI[x86_64_v2_perl-PadWalker.sha256sum] = "8f1ee1d46cd91321511a07a4a0d9fd873674d3570130c0b5092af95aaff3588f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-PadWalker-2.5-8.el10_0.aarch64.rpm;name=aarch64_perl-PadWalker;unpack=0"
SRC_URI[aarch64_perl-PadWalker.sha256sum] = "73a158e580d404cfa358e07d087a3f35a773043a360ee7e18ed1851e0c36a508"

RDEPENDS:perl-PadWalker = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
