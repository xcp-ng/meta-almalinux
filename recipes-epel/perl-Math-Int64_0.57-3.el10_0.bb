# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Math-Int64"
PV = "0.57"
PR = "3.el10_0"
PACKAGES = " \
 perl-Math-Int64 \
 perl-Math-Int64-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Math-Int64-0.57-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c028936c888f849c49b1d2a116515ae87035d4a79655d464fe6bed1ea344b17b"

URI_x86_64_v2_perl-Math-Int64 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-Int64-0.57-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Math-Int64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-Int64}"
SRC_URI[x86_64_v2_perl-Math-Int64.sha256sum] = "63691a966e263582234c17631230b73f923f409ea82547529b3ee50c3fd774a6"

URI_x86_64_v2_perl-Math-Int64-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-Int64-tests-0.57-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Math-Int64-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-Int64-tests}"
SRC_URI[x86_64_v2_perl-Math-Int64-tests.sha256sum] = "e9b5e8c8471f829cb67c610dcecfd22118f171635b3eb7856105206419877fc0"

URI_aarch64_perl-Math-Int64 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-Int64-0.57-3.el10_0.aarch64.rpm;name=aarch64_perl-Math-Int64;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-Int64}"
SRC_URI[aarch64_perl-Math-Int64.sha256sum] = "71da2f74ff8f95866ed2214a72d15a37215ae86af73a322c7f8321781d89a4e2"

URI_aarch64_perl-Math-Int64-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-Int64-tests-0.57-3.el10_0.aarch64.rpm;name=aarch64_perl-Math-Int64-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-Int64-tests}"
SRC_URI[aarch64_perl-Math-Int64-tests.sha256sum] = "2a96d08e712a053cef0f8be0a17208ce983e35ad1ac597ffc8646f0cee74b279"

RDEPENDS:perl-Math-Int64 = " \
 glibc \
 perl-Exporter \
 perl-Math-Int64 \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Math-Int64-tests = " \
 bash \
 perl-Math-Int64 \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
