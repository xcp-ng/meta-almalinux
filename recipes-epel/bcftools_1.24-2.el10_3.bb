# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcftools"
PV = "1.24"
PR = "2.el10_3"
PACKAGES = " \
 bcftools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bcftools-1.24-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c1ae94d8f032c19724866d888f1ad91376a36d545e53b0344e9319e31fe7ee8"

URI_x86_64_v2_bcftools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bcftools-1.24-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bcftools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcftools}"
SRC_URI[x86_64_v2_bcftools.sha256sum] = "a576ee8d8a9cf00563441a067e7732db0c9d406da4e08d7069c8da7d463c9a6b"

URI_aarch64_bcftools = "${EPEL_MIRROR}/aarch64/Packages/b/bcftools-1.24-2.el10_3.aarch64.rpm;name=aarch64_bcftools;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcftools}"
SRC_URI[aarch64_bcftools.sha256sum] = "79f5f50a7739de183a2b7cfd0196e3dbd83def02f6b8d92c3904882332e2960f"

RDEPENDS:bcftools = " \
 glibc \
 gsl \
 htslib \
 perl-interpreter \
 perl-libs \
 python3 \
 "
