# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom"
PV = "0.4.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-getrandom+sys_rng-devel \
 rust-getrandom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom-0.4.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48ce08f45c345d93c3f769e6cd69c68bff3a5d9c0a95821179a8eea4b1251d28"

URI_x86_64_v2_rust-getrandom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+default-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom+default-devel.sha256sum] = "031bb5d4d6bbcce6dc16416239b744be7ae24c1e785c86c90bcf77e255cc0730"
RPROVIDES:rust-getrandom+default-devel:x86_64_v2 = "virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~"

URI_x86_64_v2_rust-getrandom+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+std-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom+std-devel.sha256sum] = "598b71ef6378cac9d72418f90b6b65c54a77c9a8f9d80f873d8ee7c8e28b2dd2"

URI_x86_64_v2_rust-getrandom+sys_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom+sys_rng-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom+sys_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom+sys_rng-devel}"
SRC_URI[x86_64_v2_rust-getrandom+sys_rng-devel.sha256sum] = "fe0a67a9fdbd92704f1ee32578a9129266f4a5a26c69b1796c59552439bc612e"

URI_x86_64_v2_rust-getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom-devel-0.4.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom-devel}"
SRC_URI[x86_64_v2_rust-getrandom-devel.sha256sum] = "683093f57365a116947914d4ae1452c2a72009fb1c442817f8d0b80b44ffc009"
RPROVIDES:rust-getrandom-devel:x86_64_v2 = "virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"

URI_aarch64_rust-getrandom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+default-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+default-devel}"
SRC_URI[aarch64_rust-getrandom+default-devel.sha256sum] = "3756eed763bc797839339d47048434968d3e63ba5ef3a2f23ac20dbc0777e8c0"
RPROVIDES:rust-getrandom+default-devel:aarch64 = "virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~"

URI_aarch64_rust-getrandom+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+std-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+std-devel}"
SRC_URI[aarch64_rust-getrandom+std-devel.sha256sum] = "4fc0adc65ba9e1932efc98179e1ef605015c5571119e46d22f1b81955d98ce83"

URI_aarch64_rust-getrandom+sys_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom+sys_rng-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom+sys_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom+sys_rng-devel}"
SRC_URI[aarch64_rust-getrandom+sys_rng-devel.sha256sum] = "9759695bc6bddd5bdc596141882c79676c0f4d50f2a8eed48029c81ed2a8338b"

URI_aarch64_rust-getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom-devel-0.4.3-1.el10_3.noarch.rpm;name=aarch64_rust-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom-devel}"
SRC_URI[aarch64_rust-getrandom-devel.sha256sum] = "3c8cbe2d78f42eb4069fcc83c09d36d13b0eaa668e03c8b5698541965f828b74"
RPROVIDES:rust-getrandom-devel:aarch64 = "virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"

RDEPENDS:rust-getrandom+default-devel = " \
 cargo \
 rust-getrandom-devel \
 "
RDEPENDS:rust-getrandom+std-devel = " \
 cargo \
 rust-getrandom-devel \
 "
RDEPENDS:rust-getrandom+sys_rng-devel = " \
 cargo \
 rust-getrandom-devel \
 rust-rand_core+default-devel \
 "
RDEPENDS:rust-getrandom-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~ rpm/virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_getrandom/default__ge_0.3.0_with_crate_getrandom/default__lt_0.5.0~ rpm/virtual/crate_getrandom__ge_0.3.0_with_crate_getrandom__lt_0.5.0~"
