# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dkms"
PV = "3.4.3"
PR = "2.el10_2"
PACKAGES = " \
 dkms \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dkms-3.4.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a58cce1a5f6b13e94901ec7ddff80c0b97731573e608e018f8a1ddee3ecb6cb3"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - dkms: (kernel-64k-devel-matched if kernel-64k-core)
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dkms: (kernel-rt-debug-devel if kernel-rt-debug-core)
# - dkms: (kernel-rt-devel if kernel-rt-core)

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dkms-3.4.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dkms;unpack=0"
SRC_URI[x86_64_v2_dkms.sha256sum] = "f83203f0c54e55ca47cac25f72e70c0960b762762b77f77d4d319b3cc850e194"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dkms-3.4.3-2.el10_2.noarch.rpm;name=aarch64_dkms;unpack=0"
SRC_URI[aarch64_dkms.sha256sum] = "ba0534ffdac90637cd8aa44032e33a0e1509ed3b1789bd7c5c0797dc99d6ad2c"

RDEPENDS:dkms:x86_64_v2 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
RDEPENDS:dkms:aarch64 = " \
 bash \
 cpio \
 elfutils-libelf-devel \
 file \
 findutils \
 gawk \
 gcc \
 grep \
 gzip \
 kernel-64k-devel-matched \
 kernel-debug-devel-matched \
 kernel-devel-matched \
 kmod \
 make \
 patch \
 sed \
 tar \
 virtual/coreutils \
 which \
"
