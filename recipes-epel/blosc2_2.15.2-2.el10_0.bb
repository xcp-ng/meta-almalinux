# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blosc2"
PV = "2.15.2"
PR = "2.el10_0"
PACKAGES = " \
 blosc2 \
 blosc2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blosc2-2.15.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bee265bdd2bd0b2f98a2eab6937701704ab84103ca7cc320c0a76243980eeea7"

URI_x86_64_v2_blosc2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blosc2-2.15.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blosc2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blosc2}"
SRC_URI[x86_64_v2_blosc2.sha256sum] = "3a479f0d5b71685e22ae9fb4ed019ddc6dc6922b260d553c3c824bc005bf4e96"

URI_x86_64_v2_blosc2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blosc2-devel-2.15.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blosc2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blosc2-devel}"
SRC_URI[x86_64_v2_blosc2-devel.sha256sum] = "743959603e38e17300958aabb345d83e5687d2fc6399fe1448bee922d7fde5fd"

URI_aarch64_blosc2 = "${EPEL_MIRROR}/aarch64/Packages/b/blosc2-2.15.2-2.el10_0.aarch64.rpm;name=aarch64_blosc2;unpack=0"
SRC_URI:append = " ${URI_aarch64_blosc2}"
SRC_URI[aarch64_blosc2.sha256sum] = "7a4b819aea7b0101ffe7197c0340bdf3c2697bb18a6fc8c3adc0cba3b783c0fc"

URI_aarch64_blosc2-devel = "${EPEL_MIRROR}/aarch64/Packages/b/blosc2-devel-2.15.2-2.el10_0.aarch64.rpm;name=aarch64_blosc2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_blosc2-devel}"
SRC_URI[aarch64_blosc2-devel.sha256sum] = "9591dc196a38281bf77b704f8b27a5f40ae6d45d9038cdfed579f680cb0f7500"

RDEPENDS:blosc2 = " \
 glibc \
 libzstd \
 lz4-libs \
 zlib-ng \
 "
RDEPENDS:blosc2-devel = " \
 blosc2 \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
