# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amdsmi"
PV = "6.4.2"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 amdsmi \
 amdsmi-devel \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/amdsmi-6.4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3531c8c0c03294f62050b9617c159ca560359572c68a5fb0e52606f786e2aed0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amdsmi-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amdsmi;unpack=0"
SRC_URI[x86_64_v2_amdsmi.sha256sum] = "22f556f1b941097370b0191c3bad6e1445a20545c469a620adb35fecac719d92"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amdsmi-devel-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amdsmi-devel;unpack=0"
SRC_URI[x86_64_v2_amdsmi-devel.sha256sum] = "30a343753f4877f6b9de77edf32587a075c0d8deeef38e0a237cb87f37b633d7"

RDEPENDS:amdsmi = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-pyyaml \
 "
RDEPENDS:amdsmi-devel = " \
 amdsmi \
 cmake-filesystem \
 "
