# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vlc"
PE = "1"
PV = "3.0.24"
PR = "1.el10_2"
PACKAGES = " \
 vlc \
 vlc-cli \
 vlc-devel \
 vlc-gui-ncurses \
 vlc-gui-qt \
 vlc-gui-skins2 \
 vlc-libs \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pulseaudio \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-all \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vlc-3.0.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f4d2970a4dbbf18eb04da9e9773e5f9720d13a3672b2743c2dfeabbf7f0881da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc;unpack=0"
SRC_URI[x86_64_v2_vlc.sha256sum] = "c61d8dd78b71e0c8d6553f3bf1deba44bc523c49d5fc01dd0793e65746ff81ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-cli-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-cli;unpack=0"
SRC_URI[x86_64_v2_vlc-cli.sha256sum] = "5c5a8741d3f9df567ecf80db9b428603b8c3637cedc8f737d1b2229b37eb125e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-devel-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-devel;unpack=0"
SRC_URI[x86_64_v2_vlc-devel.sha256sum] = "a3a9a54547c40107c2b9f919fe3ddd9c4aaf3ef5f45c1efe8d4426efc4be22cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-ncurses-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-ncurses;unpack=0"
SRC_URI[x86_64_v2_vlc-gui-ncurses.sha256sum] = "f05c7007792cbc9831e219525e5132b26bf9a3ba42b83dd67242211ebfef65e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-qt-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-qt;unpack=0"
SRC_URI[x86_64_v2_vlc-gui-qt.sha256sum] = "92e401bdeeeff2a1e8c67b9ff9f5dfb86f69a90031c8f609fc68d0cb8ee7694d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-gui-skins2-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-gui-skins2;unpack=0"
SRC_URI[x86_64_v2_vlc-gui-skins2.sha256sum] = "ff6439d8944ecb7b7efcd226ac9ceb1adaebf50c1c7368669c457fe33a03d34d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-libs-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-libs;unpack=0"
SRC_URI[x86_64_v2_vlc-libs.sha256sum] = "f7dd1f583ad8613ebb06c9bfe0dd99aa6f1ca3ffe28a23b826d426b8968493ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ffmpeg-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ffmpeg;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-ffmpeg.sha256sum] = "c5d94394c43dac2b455ca94bb1ca0f90bf1d200addceb6d8b5be44a7756c8339"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-fluidsynth-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-fluidsynth;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-fluidsynth.sha256sum] = "bebb20d2d92909b03f03d2d6ac4a94ad1aeb992cfd27fb2b7006c0c8eb6b89c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gnome-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gnome;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-gnome.sha256sum] = "7849071947d42b501cf726aea3d58fe5eb6ca402bca53c700a44b65f11403c16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-gstreamer-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-gstreamer;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-gstreamer.sha256sum] = "481a6c76c5390ca7ef3835110058fab0831a58b2087f6ca75bb17f3a1a9f6889"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-ieee1394-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-ieee1394;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-ieee1394.sha256sum] = "27c0d54333085a984d5413aff9de5dc981fe8ae688ec2c7ec98d2a6372b15b09"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-jack-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-jack;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-jack.sha256sum] = "4f8136180b66f33574ce46dce6380a435d086bae3dfd1a9f7f41121a4f9ae9d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-kde-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-kde;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-kde.sha256sum] = "2f0ff93be93811a4d7defb8df1d086a2d165272438a92d5ffc94ba4fa061018b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-lua-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-lua;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-lua.sha256sum] = "38f438ce7604f76756858f2029376d66d487af9b16c727c8a9435df57742c6d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-notify-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-notify;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-notify.sha256sum] = "8a6b2b036375c3b8c6eba23beddefdac370330ad5d1d349f8cfe3b56f61bf559"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-pulseaudio-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-pulseaudio;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-pulseaudio.sha256sum] = "c30f0a99bf8d204dd7119fd39ac99f4d604d91f9c75dc50117a858f2371b001a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-samba-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-samba;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-samba.sha256sum] = "788cc05a55fa21e72bd299529056cde99c9959a990cae5fb02340c749fa5b0f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-svg-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-svg;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-svg.sha256sum] = "328ca74a41ad9ec7a86d61d7967199298daadf684d3c69bebcca5111840d3a7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-visualization-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-visualization;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-visualization.sha256sum] = "a0e90a281b4b9a1e03f97c4f530b3b49362a36915886f4841649f858548118c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugin-vnc-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugin-vnc;unpack=0"
SRC_URI[x86_64_v2_vlc-plugin-vnc.sha256sum] = "b8c21bace755d1df233a93de81c1effec881e50466c78a1b8d3a14f08e0e363f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-all-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-all;unpack=0"
SRC_URI[x86_64_v2_vlc-plugins-all.sha256sum] = "825927cb6ff84c72b35de0f71c547576cfbca908e36040c82274e694f4956bff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-base-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-base;unpack=0"
SRC_URI[x86_64_v2_vlc-plugins-base.sha256sum] = "53cc7e02e37165362f15e4d70e906a8da4c0c5b4fc108ab780d8a047d34c54a2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-extra-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-extra;unpack=0"
SRC_URI[x86_64_v2_vlc-plugins-extra.sha256sum] = "8b6496b62987770f2a8bcff724e7998c6c2845f27eaddfb1197f8284ed128352"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vlc-plugins-video-out-3.0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vlc-plugins-video-out;unpack=0"
SRC_URI[x86_64_v2_vlc-plugins-video-out.sha256sum] = "ce971c7a847fb4101d16e8392febaf67537e9b6a22e625cfa66dccff54a44358"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc;unpack=0"
SRC_URI[aarch64_vlc.sha256sum] = "d485f29ab2d87596f48420c86d4f398e30f78aa03276c4ae04926cb2f339592b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-cli-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-cli;unpack=0"
SRC_URI[aarch64_vlc-cli.sha256sum] = "b536b9c2d0288bf0827148e8ab6f49d40048a46d6aeb2df4598df9ace1ba1cab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-devel-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-devel;unpack=0"
SRC_URI[aarch64_vlc-devel.sha256sum] = "a44e8eb68847f7889eb6ea6d880e416d2bd9cd5f7a463d98e370d6720ab2aa4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-ncurses-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-gui-ncurses;unpack=0"
SRC_URI[aarch64_vlc-gui-ncurses.sha256sum] = "fca27d7c4abb412f7a9e4089dabae0b5a5eb6680331b0317082c9eeeb233e0bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-qt-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-gui-qt;unpack=0"
SRC_URI[aarch64_vlc-gui-qt.sha256sum] = "eb344ba8b4690e4102df80268a08f31ac35f0a787c063e8acf2ede79e579ae4c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-gui-skins2-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-gui-skins2;unpack=0"
SRC_URI[aarch64_vlc-gui-skins2.sha256sum] = "c6a6a5f2d344a46d573113b6e2f58852b6957333793ba5fc9d0777fd0713e317"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-libs-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-libs;unpack=0"
SRC_URI[aarch64_vlc-libs.sha256sum] = "b2d6c0d1a18faecb9d71123f4279754bc2b332396914cf4ea02552432f932589"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ffmpeg-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-ffmpeg;unpack=0"
SRC_URI[aarch64_vlc-plugin-ffmpeg.sha256sum] = "53f9b45f8c969c279fec94dd0f97fd20c2d63f236e0dfff1591d650215febeaf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-fluidsynth-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-fluidsynth;unpack=0"
SRC_URI[aarch64_vlc-plugin-fluidsynth.sha256sum] = "95f3221803f9811d11b6488ade773383ba65392c4ece84455d5f78710f9b16fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gnome-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-gnome;unpack=0"
SRC_URI[aarch64_vlc-plugin-gnome.sha256sum] = "e1079557e55849194b4b8f8a6566ec98a62e30442649f229c1d1a6a6128b644d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-gstreamer-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-gstreamer;unpack=0"
SRC_URI[aarch64_vlc-plugin-gstreamer.sha256sum] = "409b9e006a4ad7256d03aa764e14605ed87a797569d91cc1a90543be2abb4740"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-ieee1394-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-ieee1394;unpack=0"
SRC_URI[aarch64_vlc-plugin-ieee1394.sha256sum] = "a4c624272a6fac5c305c4dfc1eab32dad408a55fe68ca32e02410167d5bcbce6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-jack-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-jack;unpack=0"
SRC_URI[aarch64_vlc-plugin-jack.sha256sum] = "bedba11c44f4956e59a52e25b6c9254c0bd07779cecb3766e237520c85924369"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-kde-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-kde;unpack=0"
SRC_URI[aarch64_vlc-plugin-kde.sha256sum] = "655f23f42fb52e400abbacc9b2d6d931655aa00b4283f27aed959b3583560ff8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-lua-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-lua;unpack=0"
SRC_URI[aarch64_vlc-plugin-lua.sha256sum] = "1f8e03badf2bc20cb4e8faf00901784b4acc624aac7511901d6c1716dd757210"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-notify-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-notify;unpack=0"
SRC_URI[aarch64_vlc-plugin-notify.sha256sum] = "a4381ff7eb5849a54852f6f629a63e97e21654b323d13446391ebe902341929e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-pulseaudio-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-pulseaudio;unpack=0"
SRC_URI[aarch64_vlc-plugin-pulseaudio.sha256sum] = "65a5322e4cd4d7c397cfc07345e6623be9096f5134f68816d72f0563ea306868"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-samba-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-samba;unpack=0"
SRC_URI[aarch64_vlc-plugin-samba.sha256sum] = "32a664fc07366489320c99f6cd18344f2dbeffb92d8114bb07aba76d00e029e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-svg-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-svg;unpack=0"
SRC_URI[aarch64_vlc-plugin-svg.sha256sum] = "fc6d38a311be33fc73e4d2617a3747faf6ada609661abaf780b3ea59ca70992c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-visualization-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-visualization;unpack=0"
SRC_URI[aarch64_vlc-plugin-visualization.sha256sum] = "f4651eceb269798f3153f83e4d0250770ad2ccae60c5e4f3826f12f2efda8a09"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugin-vnc-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugin-vnc;unpack=0"
SRC_URI[aarch64_vlc-plugin-vnc.sha256sum] = "dd4d341bb5f01989aabe9f567ddc8875e2b20ab0e88b4fc8c862c8a783146ba4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-all-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugins-all;unpack=0"
SRC_URI[aarch64_vlc-plugins-all.sha256sum] = "1fae6dfec4d69f5bb15d004ad01b51d74753cde402522f4fb88d179a69af4c4d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-base-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugins-base;unpack=0"
SRC_URI[aarch64_vlc-plugins-base.sha256sum] = "eb092640670c6bb7c92105ee09a440c041901372d31c1a5e1cc85f7090634a18"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-extra-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugins-extra;unpack=0"
SRC_URI[aarch64_vlc-plugins-extra.sha256sum] = "2d47c4a0ce7940781d3e64147aba5e047f9ec24abef56c9a916023fb69527b37"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vlc-plugins-video-out-3.0.24-1.el10_2.aarch64.rpm;name=aarch64_vlc-plugins-video-out;unpack=0"
SRC_URI[aarch64_vlc-plugins-video-out.sha256sum] = "0326bd67cd72e000a43e0919029aaf6952bc981dc31ea293fe960016509f9be4"

RDEPENDS:vlc = " \
 bash \
 hicolor-icon-theme \
 kde-filesystem \
 vlc-gui-qt \
 "
RDEPENDS:vlc-cli = " \
 bash \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-devel = " \
 pkgconf-pkg-config \
 vlc-libs \
 "
RDEPENDS:vlc-gui-ncurses = " \
 bash \
 glibc \
 ncurses-libs \
 vlc-cli \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-gui-qt = " \
 bash \
 glibc \
 libX11 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 vlc-cli \
 vlc-libs \
 vlc-plugin-lua \
 vlc-plugin-pulseaudio \
 vlc-plugins-base \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-gui-skins2 = " \
 bash \
 freetype \
 fribidi \
 glibc \
 gnu-free-sans-fonts \
 libX11 \
 libXext \
 libXinerama \
 libXpm \
 libgcc \
 libstdc++ \
 vlc-cli \
 vlc-gui-qt \
 vlc-libs \
 "
RDEPENDS:vlc-libs = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libidn2 \
 "
RDEPENDS:vlc-plugin-ffmpeg = " \
 glibc \
 libX11 \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libchromaprint \
 libpostproc-free \
 libswscale-free \
 libva \
 vlc-libs \
 vlc-plugins-base \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-plugin-fluidsynth = " \
 fluidsynth-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gnome = " \
 glib2 \
 glibc \
 libsecret \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-ieee1394 = " \
 glibc \
 libavc1394 \
 libdc1394 \
 libgcc \
 libraw1394 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-jack = " \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-kde = " \
 dbus-libs \
 glibc \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-lua = " \
 glibc \
 libgcc \
 lua-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-notify = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libnotify \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-pulseaudio = " \
 glibc \
 pulseaudio-libs \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-samba = " \
 glibc \
 libsmbclient \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-svg = " \
 cairo \
 glib2 \
 glibc \
 librsvg2 \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-visualization = " \
 glibc \
 libglvnd-glx \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugin-vnc = " \
 glibc \
 libvncserver \
 vlc-libs \
 vlc-plugins-base \
 "
RDEPENDS:vlc-plugins-all = " \
 vlc-plugin-bittorrent \
 vlc-plugin-ffmpeg \
 vlc-plugin-fluidsynth \
 vlc-plugin-gnome \
 vlc-plugin-gstreamer \
 vlc-plugin-ieee1394 \
 vlc-plugin-jack \
 vlc-plugin-kde \
 vlc-plugin-lua \
 vlc-plugin-notify \
 vlc-plugin-pause-click \
 vlc-plugin-pipewire \
 vlc-plugin-pulseaudio \
 vlc-plugin-samba \
 vlc-plugin-svg \
 vlc-plugin-visualization \
 vlc-plugin-vnc \
 vlc-plugins-base \
 vlc-plugins-extra \
 vlc-plugins-video-out \
 "
RDEPENDS:vlc-plugins-base = " \
 alsa-lib \
 dbus-libs \
 faad2-libs \
 fdk-aac-free \
 flac-libs \
 glibc \
 gnutls \
 google-noto-sans-mono-vf-fonts \
 google-noto-serif-vf-fonts \
 libdav1d \
 libgcc \
 libgcrypt \
 libgpg-error \
 libjpeg-turbo \
 libogg \
 libpng \
 librist \
 libshout \
 libstdc++ \
 libtheora \
 libvorbis \
 libvpx \
 libxml2 \
 mpg123-libs \
 opus \
 speex \
 systemd-libs \
 taglib \
 twolame-libs \
 vlc-libs \
 zlib-ng-compat \
 "
RDEPENDS:vlc-plugins-extra:x86_64_v2 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 asdcplib \
 avahi-libs \
 daala-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libgpg-error \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libvpl \
 libxcb \
 lirc-libs \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-extra:aarch64 = " \
 aalib-libs \
 alsa-lib \
 aribb24 \
 aribb25 \
 asdcplib \
 avahi-libs \
 daala-libs \
 fontconfig \
 freetype \
 fribidi \
 game-music-emu \
 glibc \
 harfbuzz \
 libX11 \
 libaom \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcddb \
 libdvbpsi \
 libdvdnav \
 libdvdread \
 libebml \
 libgcc \
 libgcrypt \
 libgpg-error \
 libkate \
 libmad \
 libmatroska \
 libmicrodns \
 libmodplug \
 libmpcdec \
 libmtp \
 libnfs \
 libsamplerate \
 libspatialaudio \
 libssh2 \
 libstdc++ \
 libtiger \
 libupnp \
 libxcb \
 lirc-libs \
 live555 \
 pcsc-lite-libs \
 protobuf-lite \
 soxr \
 speexdsp \
 srt-libs \
 systemd-libs \
 vlc-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:vlc-plugins-video-out = " \
 glibc \
 libX11 \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libva \
 libwayland-client \
 libwayland-egl \
 libxcb \
 vlc-libs \
 vlc-plugins-base \
 xcb-util-keysyms \
 "
