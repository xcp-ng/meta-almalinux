# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tikv-jemallocator"
PV = "0.6.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tikv-jemallocator+alloc_trait-devel \
 rust-tikv-jemallocator+background_threads-devel \
 rust-tikv-jemallocator+background_threads_runtime_support-devel \
 rust-tikv-jemallocator+debug-devel \
 rust-tikv-jemallocator+default-devel \
 rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel \
 rust-tikv-jemallocator+profiling-devel \
 rust-tikv-jemallocator+stats-devel \
 rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemallocator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tikv-jemallocator-0.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cd9973e6d85a3fbcc6f70d9f80dd34b027ea091537b2b7bda34f10073a09646"

URI_x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+alloc_trait-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+alloc_trait-devel.sha256sum] = "7766d29bcba3baaaf8d121b072dcf4dfd444fdbc250110ec49d40e543ad4e9ab"

URI_x86_64_v2_rust-tikv-jemallocator+background_threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+background_threads-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+background_threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+background_threads-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+background_threads-devel.sha256sum] = "0bf3d4d1a960e3a24f120f46746fb2121dded7b4962919d5a93afd2aea4bdd3f"

URI_x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+background_threads_runtime_support-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+background_threads_runtime_support-devel.sha256sum] = "bb66191bdc6209ba1dac8d6bc64a8b4a2b86343bfc6aa846009a6ed930dfe053"

URI_x86_64_v2_rust-tikv-jemallocator+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+debug-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+debug-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+debug-devel.sha256sum] = "44828fe3ab03496efdce60b2be7da06628a6f6e49d5c2a6efadfc772e8246baf"

URI_x86_64_v2_rust-tikv-jemallocator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+default-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+default-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+default-devel.sha256sum] = "6e95860c317d95adfeb13a0ddff3fde83ed5ab868b74cc8f4b11856226716a36"

URI_x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel.sha256sum] = "47c6912441ba0284162114347d79eaa89ef0252d410e583158ed1d30896800e7"

URI_x86_64_v2_rust-tikv-jemallocator+profiling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+profiling-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+profiling-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+profiling-devel.sha256sum] = "6645a3d98e476124fd422f7cab13f4cbc9a6f7310e3e2b9864d4fd8d1146b441"

URI_x86_64_v2_rust-tikv-jemallocator+stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+stats-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+stats-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+stats-devel.sha256sum] = "a275bdc00e911ff2530dbe05e52dc4d1f6c1dd49263cd1a85892438aade46c1f"

URI_x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "d50b70fdba5efc44cf37002b123c49d837543da8da9e187c03174d8ea2dfc684"

URI_x86_64_v2_rust-tikv-jemallocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tikv-jemallocator-devel-0.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tikv-jemallocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tikv-jemallocator-devel}"
SRC_URI[x86_64_v2_rust-tikv-jemallocator-devel.sha256sum] = "01460ea569c53a85c1bf8cf0eddbbee6002e6eae419a35f0aadec608e4ebab87"

URI_aarch64_rust-tikv-jemallocator+alloc_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+alloc_trait-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator+alloc_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+alloc_trait-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+alloc_trait-devel.sha256sum] = "aab4240743950896b32f2a904e020d4f47942a7344a39fd98f8bb4f0bfc9491f"

URI_aarch64_rust-tikv-jemallocator+background_threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+background_threads-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator+background_threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+background_threads-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+background_threads-devel.sha256sum] = "7faa44d50f51901f09c58ab6879f5e91b86a4e839273b95cf706ea6f9edc0a51"

URI_aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+background_threads_runtime_support-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+background_threads_runtime_support-devel.sha256sum] = "2a834d628bfba0a412a64772d379135faac491e4df24222b353ec8291bb75dd7"

URI_aarch64_rust-tikv-jemallocator+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+debug-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+debug-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+debug-devel.sha256sum] = "a56a0c5029f0839c8e03bbb900826f6e406f58f83589b8829380efa194b91461"

URI_aarch64_rust-tikv-jemallocator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+default-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+default-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+default-devel.sha256sum] = "2d91216f04887ebaeb320a1d3d8a3aa491c78e59aa841fbb011f1856c79a090c"

URI_aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel.sha256sum] = "e3ff1ba01ffd443b7155ab0f83b2aa9591feb95ec9f7120b718466aa80935194"

URI_aarch64_rust-tikv-jemallocator+profiling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+profiling-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator+profiling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+profiling-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+profiling-devel.sha256sum] = "ec1f6c1f51c4381351b4d1addd2e040e850dd84e09463d84a45a790a7c6932bc"

URI_aarch64_rust-tikv-jemallocator+stats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+stats-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator+stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+stats-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+stats-devel.sha256sum] = "5650d0df4ded0829f30e81d96b6f7df13abc1ee99cdca1717ab585482f43d35e"

URI_aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel.sha256sum] = "30780ee6b3bd3067ad5a2dac2843fd3aa4f174becdb5e432fa215d3d4c16d3f7"

URI_aarch64_rust-tikv-jemallocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tikv-jemallocator-devel-0.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-tikv-jemallocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tikv-jemallocator-devel}"
SRC_URI[aarch64_rust-tikv-jemallocator-devel.sha256sum] = "5d0d55c69d86654d4232ac91f95d30c5b588aa161078f3a24b345b92a0f5fc7a"

RDEPENDS:rust-tikv-jemallocator+alloc_trait-devel = " \
 cargo \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+background_threads-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+background_threads_runtime_support-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+background_threads_runtime_support-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+debug-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+debug-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+default-devel = " \
 cargo \
 rust-tikv-jemallocator+background_threads_runtime_support-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+override_allocator_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+override_allocator_on_supported_platforms-devel \
 rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+profiling-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+profiling-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+stats-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+stats-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator+unprefixed_malloc_on_supported_platforms-devel = " \
 cargo \
 rust-tikv-jemalloc-sys+unprefixed_malloc_on_supported_platforms-devel \
 rust-tikv-jemallocator-devel \
 "
RDEPENDS:rust-tikv-jemallocator-devel = " \
 cargo \
 rust-libc-devel \
 rust-tikv-jemalloc-sys-devel \
 "
