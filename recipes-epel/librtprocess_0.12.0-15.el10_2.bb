# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "librtprocess"
PV = "0.12.0"
PR = "15.el10_2"
PACKAGES = " \
 librtprocess \
 librtprocess-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/librtprocess-0.12.0-15.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ea3b8e247bdcf87317b4ac95018b05099d20d0be6b00ed0f25c3b7093ed6bc9"

URI_x86_64_v2_librtprocess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librtprocess-0.12.0-15.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librtprocess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librtprocess}"
SRC_URI[x86_64_v2_librtprocess.sha256sum] = "85dbbabe148adb188a0cf763d261cfe379236fac5f184d6641fc2050a278ade7"

URI_x86_64_v2_librtprocess-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/librtprocess-devel-0.12.0-15.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_librtprocess-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_librtprocess-devel}"
SRC_URI[x86_64_v2_librtprocess-devel.sha256sum] = "13736b7b4eac02c011fa0e4f210ad7b6afa51292e319bcd486f2fad57cd35764"

URI_aarch64_librtprocess = "${EPEL_MIRROR}/aarch64/Packages/l/librtprocess-0.12.0-15.el10_2.aarch64.rpm;name=aarch64_librtprocess;unpack=0"
SRC_URI:append = " ${URI_aarch64_librtprocess}"
SRC_URI[aarch64_librtprocess.sha256sum] = "6a178893d68aa5e21b2d18c1a55bbd6091644e7d985f1854588e426dbe33f60a"

URI_aarch64_librtprocess-devel = "${EPEL_MIRROR}/aarch64/Packages/l/librtprocess-devel-0.12.0-15.el10_2.aarch64.rpm;name=aarch64_librtprocess-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_librtprocess-devel}"
SRC_URI[aarch64_librtprocess-devel.sha256sum] = "ac0d25c04c86a95f1d995719c75ec32bb0dffad113635ef8d7d9eca39eeb570d"

RDEPENDS:librtprocess = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 "
RDEPENDS:librtprocess-devel = " \
 cmake-filesystem \
 librtprocess \
 pkgconf-pkg-config \
 "
