# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is-macro"
PV = "0.3.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-is-macro+default-devel \
 rust-is-macro+small-panic-devel \
 rust-is-macro-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-is-macro-0.3.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b141d276b450ba1a0b388b88c1230076fad224e6384af25c543b061e4990db6d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-macro+default-devel-0.3.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-macro+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-is-macro+default-devel.sha256sum] = "d8f98e49b3d8a0b8ce4a3c92badcdb7156befff55f374db9dd2aa33ef5466a93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-macro+small-panic-devel-0.3.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-macro+small-panic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-is-macro+small-panic-devel.sha256sum] = "e8a943eb840e17394d235222256fb302a8baeee5fc46d37d15a5cf3cdc3d1e95"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-macro-devel-0.3.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-is-macro-devel.sha256sum] = "92c19c130944907ca80914ce84e651e5360a9143f79094f4302c3180833c8d3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-is-macro+default-devel-0.3.8-1.el10_3.noarch.rpm;name=aarch64_rust-is-macro+default-devel;unpack=0"
SRC_URI[aarch64_rust-is-macro+default-devel.sha256sum] = "59eb4c9249e769b15e124ecef1e9bc2f448a22befaa3462a2a37787ef6f146ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-is-macro+small-panic-devel-0.3.8-1.el10_3.noarch.rpm;name=aarch64_rust-is-macro+small-panic-devel;unpack=0"
SRC_URI[aarch64_rust-is-macro+small-panic-devel.sha256sum] = "e739e55e2ad9c00735d19a44748956027b5b8173cd68910e8feef027e4bc7267"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-is-macro-devel-0.3.8-1.el10_3.noarch.rpm;name=aarch64_rust-is-macro-devel;unpack=0"
SRC_URI[aarch64_rust-is-macro-devel.sha256sum] = "0a20450631322ada784a7ff161eda656853d1081686f530829aa12795a1a0148"

RDEPENDS:rust-is-macro+default-devel = " \
 cargo \
 rust-is-macro-devel \
 "
RDEPENDS:rust-is-macro+small-panic-devel = " \
 cargo \
 rust-is-macro-devel \
 "
RDEPENDS:rust-is-macro-devel = " \
 cargo \
 rust-heck+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+derive-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+fold-devel \
 rust-syn2+full-devel \
 "
