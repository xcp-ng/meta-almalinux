# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-binutils"
PV = "2.43.1"
PR = "2.el10"
PACKAGES = " \
 mingw-binutils-generic \
 mingw32-binutils \
 mingw64-binutils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-binutils-2.43.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d71368daa039e3a5a3c32dfe3e599bdfeac19ba3254d5a2108ea2ba778ad35b"

URI_x86_64_v2_mingw-binutils-generic = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw-binutils-generic-2.43.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_mingw-binutils-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw-binutils-generic}"
SRC_URI[x86_64_v2_mingw-binutils-generic.sha256sum] = "e29ff139cd012b81ffab08475aee5d37833f1a9a513aa5e6237dd974d56f4df0"

URI_x86_64_v2_mingw32-binutils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-binutils-2.43.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_mingw32-binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-binutils}"
SRC_URI[x86_64_v2_mingw32-binutils.sha256sum] = "fd797f7c1165fca22ebb3d964ad205bf5e43c7d8a176d93831db6eb31b4eb4c5"

URI_x86_64_v2_mingw64-binutils = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-binutils-2.43.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_mingw64-binutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-binutils}"
SRC_URI[x86_64_v2_mingw64-binutils.sha256sum] = "8adbc875f82e5d50b971c10cd85058efc74a02c8f664c1065cc9feea8478ca2e"

URI_aarch64_mingw-binutils-generic = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw-binutils-generic-2.43.1-2.el10.aarch64.rpm;name=aarch64_mingw-binutils-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw-binutils-generic}"
SRC_URI[aarch64_mingw-binutils-generic.sha256sum] = "e752f4e6c626096610e806fb6f349905f31bf0b330c9cdc4f99ba6c8cbacbe92"

URI_aarch64_mingw32-binutils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-binutils-2.43.1-2.el10.aarch64.rpm;name=aarch64_mingw32-binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-binutils}"
SRC_URI[aarch64_mingw32-binutils.sha256sum] = "a2d0ee088f38bf3bb83761ee2d363f8c30dc96b7ad8e214fda8c3e7370acec1a"

URI_aarch64_mingw64-binutils = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-binutils-2.43.1-2.el10.aarch64.rpm;name=aarch64_mingw64-binutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-binutils}"
SRC_URI[aarch64_mingw64-binutils.sha256sum] = "7c8499f8161750648d596bbd7129c4085e258e8b3c4eba3d0a3050e64afe79dd"

RDEPENDS:mingw-binutils-generic = " \
 glibc \
 "
RDEPENDS:mingw32-binutils = " \
 glibc \
 mingw-binutils-generic \
 mingw32-filesystem \
 "
RDEPENDS:mingw64-binutils = " \
 glibc \
 mingw-binutils-generic \
 mingw64-filesystem \
 "
