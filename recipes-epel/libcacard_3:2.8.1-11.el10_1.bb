# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcacard"
PE = "3"
PV = "2.8.1"
PR = "11.el10_1"
PACKAGES = " \
 libcacard \
 libcacard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcacard-2.8.1-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5d0ecbaed2e2451cc912da01999b9cf88344ddd983177b0d421615d14d1c718"

URI_x86_64_v2_libcacard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcacard-2.8.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcacard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcacard}"
SRC_URI[x86_64_v2_libcacard.sha256sum] = "0bd94f2184d1fce8763e93e882f7db56029b5720f0a303719786f2dd59a7f1d1"

URI_x86_64_v2_libcacard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcacard-devel-2.8.1-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcacard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcacard-devel}"
SRC_URI[x86_64_v2_libcacard-devel.sha256sum] = "7aa56523eed17259b8f24cc905e143c208e169b9846ca781e262647e67a5770e"

URI_aarch64_libcacard = "${EPEL_MIRROR}/aarch64/Packages/l/libcacard-2.8.1-11.el10_1.aarch64.rpm;name=aarch64_libcacard;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcacard}"
SRC_URI[aarch64_libcacard.sha256sum] = "d433c13eb72c6945494293625238448ad236ee4532b09a7ae7c31dec9ad0fe37"

URI_aarch64_libcacard-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcacard-devel-2.8.1-11.el10_1.aarch64.rpm;name=aarch64_libcacard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcacard-devel}"
SRC_URI[aarch64_libcacard-devel.sha256sum] = "66018d85b5bd19e4101ced99e5074721a5f547b00c9d10f7c440b079f0d5f6b2"

RDEPENDS:libcacard = " \
 glib2 \
 glibc \
 nspr \
 nss \
 pcsc-lite-libs \
 "
RDEPENDS:libcacard-devel = " \
 glib2-devel \
 libcacard \
 nss-devel \
 pcsc-lite-devel \
 pkgconf-pkg-config \
 "
