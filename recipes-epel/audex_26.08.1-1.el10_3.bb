# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audex"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 audex \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/audex-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "35783c183e8dae6017884a75528bc5a81f2d261eb5ae88fc9cf40c39eb0a0cca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audex-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audex;unpack=0"
SRC_URI[x86_64_v2_audex.sha256sum] = "6c21b8a00cc406a099f3d013c1fd39caddd6df8b0ff523abf21fd45ad9464989"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/audex-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_audex;unpack=0"
SRC_URI[aarch64_audex.sha256sum] = "b241787a27eb3427f9839ca194e52a17cebab50ea15edef8bac08ddfc89ce89b"

RDEPENDS:audex = " \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 libcdio-paranoia \
 libkcddb \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
