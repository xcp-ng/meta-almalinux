# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "webkitgtk"
PV = "2.50.4"
PR = "2.el10_2"
PACKAGES = " \
 javascriptcoregtk4.1 \
 javascriptcoregtk4.1-devel \
 javascriptcoregtk6.0 \
 javascriptcoregtk6.0-devel \
 webkit2gtk4.1 \
 webkit2gtk4.1-devel \
 webkit2gtk4.1-doc \
 webkitgtk6.0 \
 webkitgtk6.0-devel \
 webkitgtk6.0-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/webkitgtk-2.50.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c28aa6f4bea15bbb0b92af5ef379d6b1b1591b118ff2a485e9b818703612cabe"

URI_x86_64_v2_javascriptcoregtk4.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk4.1-2.50.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk4.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk4.1}"
SRC_URI[x86_64_v2_javascriptcoregtk4.1.sha256sum] = "b43e039a6b50520429fc59e066653a07ebc9ee787a69add81e0dd875510eddc0"

URI_x86_64_v2_javascriptcoregtk4.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk4.1-devel-2.50.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk4.1-devel}"
SRC_URI[x86_64_v2_javascriptcoregtk4.1-devel.sha256sum] = "065dde40e1779a613cf8a287d18eeabf8098cb8b0576a2b6409926480d72a78d"

URI_x86_64_v2_javascriptcoregtk6.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk6.0-2.50.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk6.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk6.0}"
SRC_URI[x86_64_v2_javascriptcoregtk6.0.sha256sum] = "3b5bb55cf1479addecd8abbe6b0c8905e63452295da04c8346a2c76db1cb5bf3"

URI_x86_64_v2_javascriptcoregtk6.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/javascriptcoregtk6.0-devel-2.50.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_javascriptcoregtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_javascriptcoregtk6.0-devel}"
SRC_URI[x86_64_v2_javascriptcoregtk6.0-devel.sha256sum] = "ead41afb3c709b24ad61925f1650eb8b2e1d87f92553de9183852e0e005a3045"

URI_x86_64_v2_webkit2gtk4.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-2.50.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkit2gtk4.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1}"
SRC_URI[x86_64_v2_webkit2gtk4.1.sha256sum] = "6328657394805130710283734ba2bae674bc7ff5338c97dd20fabbd7cf8cea88"

URI_x86_64_v2_webkit2gtk4.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-devel-2.50.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkit2gtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1-devel}"
SRC_URI[x86_64_v2_webkit2gtk4.1-devel.sha256sum] = "b7181f8cd714f7e5d898a3e2cee812d53766c9d2def3802c1b86a3d247d40f31"

URI_x86_64_v2_webkit2gtk4.1-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkit2gtk4.1-doc-2.50.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_webkit2gtk4.1-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkit2gtk4.1-doc}"
SRC_URI[x86_64_v2_webkit2gtk4.1-doc.sha256sum] = "19b2865b6beb119dc7e898a922d11a2c473be0e7913b5d4bea79fe2ca79a8198"

URI_x86_64_v2_webkitgtk6.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-2.50.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkitgtk6.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0}"
SRC_URI[x86_64_v2_webkitgtk6.0.sha256sum] = "d84da39e554f42dc7cc79b6eeb97d2fee6ab679deec2379ab98132337795fd9b"

URI_x86_64_v2_webkitgtk6.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-devel-2.50.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_webkitgtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0-devel}"
SRC_URI[x86_64_v2_webkitgtk6.0-devel.sha256sum] = "a6a8a969f4df759fceb3b4a0773233875cff3ee6285875f00dc411546282f728"

URI_x86_64_v2_webkitgtk6.0-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/webkitgtk6.0-doc-2.50.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_webkitgtk6.0-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webkitgtk6.0-doc}"
SRC_URI[x86_64_v2_webkitgtk6.0-doc.sha256sum] = "34dd24c19987252d2acfd5e65310027201bac6d900dd5c43dc266bdf026c8f66"

URI_aarch64_javascriptcoregtk4.1 = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk4.1-2.50.4-2.el10_2.aarch64.rpm;name=aarch64_javascriptcoregtk4.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk4.1}"
SRC_URI[aarch64_javascriptcoregtk4.1.sha256sum] = "81648029630261f62521db952150bbd0750a16edfcc4e635e36848230cadc855"

URI_aarch64_javascriptcoregtk4.1-devel = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk4.1-devel-2.50.4-2.el10_2.aarch64.rpm;name=aarch64_javascriptcoregtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk4.1-devel}"
SRC_URI[aarch64_javascriptcoregtk4.1-devel.sha256sum] = "5ceee32747602717d3e43620ae05bc3008e90e118da930c4483c665fdede7b3d"

URI_aarch64_javascriptcoregtk6.0 = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk6.0-2.50.4-2.el10_2.aarch64.rpm;name=aarch64_javascriptcoregtk6.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk6.0}"
SRC_URI[aarch64_javascriptcoregtk6.0.sha256sum] = "c30f6613f5e06e6ef46b5030c001de610f921fcc066325f374f0c86a836eac08"

URI_aarch64_javascriptcoregtk6.0-devel = "${EPEL_MIRROR}/aarch64/Packages/j/javascriptcoregtk6.0-devel-2.50.4-2.el10_2.aarch64.rpm;name=aarch64_javascriptcoregtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_javascriptcoregtk6.0-devel}"
SRC_URI[aarch64_javascriptcoregtk6.0-devel.sha256sum] = "c5e7e1fb427e09f1ce2baee3fd435b92b0f291a714fb3dbf3961741b09c69512"

URI_aarch64_webkit2gtk4.1 = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-2.50.4-2.el10_2.aarch64.rpm;name=aarch64_webkit2gtk4.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1}"
SRC_URI[aarch64_webkit2gtk4.1.sha256sum] = "1344b19f5e2e9ed3445797ffcf8fa5a6e0cb223d85f93fcbce56068d0c4af3d5"

URI_aarch64_webkit2gtk4.1-devel = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-devel-2.50.4-2.el10_2.aarch64.rpm;name=aarch64_webkit2gtk4.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1-devel}"
SRC_URI[aarch64_webkit2gtk4.1-devel.sha256sum] = "8a2cab6dc825301d46ae9ba5f918ee533bc011e1eb2f76ac48691b0987ec0db2"

URI_aarch64_webkit2gtk4.1-doc = "${EPEL_MIRROR}/aarch64/Packages/w/webkit2gtk4.1-doc-2.50.4-2.el10_2.noarch.rpm;name=aarch64_webkit2gtk4.1-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkit2gtk4.1-doc}"
SRC_URI[aarch64_webkit2gtk4.1-doc.sha256sum] = "19adc5693070c8d7aad8dc410a7994d6293b3f32514eaab1a9552ac1dfa12a25"

URI_aarch64_webkitgtk6.0 = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-2.50.4-2.el10_2.aarch64.rpm;name=aarch64_webkitgtk6.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0}"
SRC_URI[aarch64_webkitgtk6.0.sha256sum] = "dd1fc1688fb1734b09656048f62d715a6bc952cbdea66db94f742f25eca91520"

URI_aarch64_webkitgtk6.0-devel = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-devel-2.50.4-2.el10_2.aarch64.rpm;name=aarch64_webkitgtk6.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0-devel}"
SRC_URI[aarch64_webkitgtk6.0-devel.sha256sum] = "9925bcf10ca65f0fd2d5c2575762f48a0c91df9e0bfa0bd3e84c94657f880bfa"

URI_aarch64_webkitgtk6.0-doc = "${EPEL_MIRROR}/aarch64/Packages/w/webkitgtk6.0-doc-2.50.4-2.el10_2.noarch.rpm;name=aarch64_webkitgtk6.0-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_webkitgtk6.0-doc}"
SRC_URI[aarch64_webkitgtk6.0-doc.sha256sum] = "4824d3e8769e83d723d4980ebc1ea5e6a9c1e396799cee64c3b708ee0b6cf646"

RDEPENDS:javascriptcoregtk4.1 = " \
 glib2 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:javascriptcoregtk4.1-devel = " \
 glib2-devel \
 glibc \
 javascriptcoregtk4.1 \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:javascriptcoregtk6.0 = " \
 glib2 \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 systemd-libs \
 "
RDEPENDS:javascriptcoregtk6.0-devel = " \
 glib2-devel \
 glibc \
 javascriptcoregtk6.0 \
 libstdc++ \
 pkgconf-pkg-config \
 "
RDEPENDS:webkit2gtk4.1:x86_64_v2 = " \
 atk \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk3 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk4.1 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkit2gtk4.1:aarch64 = " \
 atk \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk3 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk4.1 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcc \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkit2gtk4.1-devel = " \
 cairo \
 glib2 \
 glib2-devel \
 glibc \
 gstreamer1 \
 gtk3 \
 gtk3-devel \
 javascriptcoregtk4.1 \
 javascriptcoregtk4.1-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 webkit2gtk4.1 \
 "
RDEPENDS:webkit2gtk4.1-doc = " \
 webkit2gtk4.1 \
 "
RDEPENDS:webkitgtk6.0:x86_64_v2 = " \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk4 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk6.0 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkitgtk6.0:aarch64 = " \
 bubblewrap \
 cairo \
 enchant2 \
 expat \
 flite \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gtk4 \
 harfbuzz \
 harfbuzz-icu \
 hyphen \
 javascriptcoregtk6.0 \
 lcms2 \
 libX11 \
 libavif \
 libdrm \
 libepoxy \
 libgcc \
 libgcrypt \
 libglvnd-gles \
 libicu \
 libjpeg-turbo \
 libjxl \
 libmanette \
 libpng \
 libseccomp \
 libsecret \
 libsoup3 \
 libstdc++ \
 libtasn1 \
 libwayland-client \
 libwayland-server \
 libwebp \
 libxml2 \
 libxslt \
 mesa-libgbm \
 pango \
 sqlite-libs \
 systemd-libs \
 woff2 \
 xdg-dbus-proxy \
 zlib-ng-compat \
"
RDEPENDS:webkitgtk6.0-devel = " \
 glib2 \
 glib2-devel \
 glibc \
 gstreamer1 \
 gtk4 \
 gtk4-devel \
 javascriptcoregtk6.0 \
 javascriptcoregtk6.0-devel \
 libsoup3-devel \
 pkgconf-pkg-config \
 webkitgtk6.0 \
 "
RDEPENDS:webkitgtk6.0-doc = " \
 webkitgtk6.0 \
 "
