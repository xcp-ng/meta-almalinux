# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Uniqid"
PV = "0.12"
PR = "39.el10_2"
PACKAGES = " \
 perl-Data-Uniqid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Uniqid-0.12-39.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2efe55998d235dbaf5fb614f20622fc0e4e3a4d06dccf39fcc666227b49f4e07"

URI_x86_64_v2_perl-Data-Uniqid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Uniqid-0.12-39.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Uniqid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Uniqid}"
SRC_URI[x86_64_v2_perl-Data-Uniqid.sha256sum] = "4e620d583430ef314b9970d452d3517bb88505bf6e9cd27c0eafbcb7678529ce"

URI_aarch64_perl-Data-Uniqid = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Uniqid-0.12-39.el10_2.noarch.rpm;name=aarch64_perl-Data-Uniqid;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Uniqid}"
SRC_URI[aarch64_perl-Data-Uniqid.sha256sum] = "61e4b4e82a7741cdade9253c9098ebedb2255bc03da70cac104bff3163d618ac"

RDEPENDS:perl-Data-Uniqid = " \
 perl-AutoLoader \
 perl-Exporter \
 perl-Math-BigInt \
 perl-Sys-Hostname \
 perl-Time-HiRes \
 perl-libs \
 "
