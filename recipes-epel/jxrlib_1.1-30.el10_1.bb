# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jxrlib"
PV = "1.1"
PR = "30.el10_1"
PACKAGES = " \
 jxrlib \
 jxrlib-devel \
 mingw32-jxrlib \
 mingw64-jxrlib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jxrlib-1.1-30.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e69a0693397bc45d85b14d7d13b9c523607ff03aeaf4bc911a91d38a396a5e6c"

URI_x86_64_v2_jxrlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jxrlib-1.1-30.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jxrlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jxrlib}"
SRC_URI[x86_64_v2_jxrlib.sha256sum] = "d88920157a2f4927a3bdad4796da7ce131df97e39df224e87da1804896592c6b"

URI_x86_64_v2_jxrlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jxrlib-devel-1.1-30.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jxrlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jxrlib-devel}"
SRC_URI[x86_64_v2_jxrlib-devel.sha256sum] = "cc66bdd0f113be0c63273ce2c96ce2e679451962a4ce12c37eb26340c784c96b"

URI_x86_64_v2_mingw32-jxrlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-jxrlib-1.1-30.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-jxrlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-jxrlib}"
SRC_URI[x86_64_v2_mingw32-jxrlib.sha256sum] = "9cfe69313004d14cf0004ae5cf01a32b5e28db0fbf37c013bff8bb1ee38385fb"

URI_x86_64_v2_mingw64-jxrlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-jxrlib-1.1-30.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-jxrlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-jxrlib}"
SRC_URI[x86_64_v2_mingw64-jxrlib.sha256sum] = "4f02a99944dd52f1385b9066b3678cd2e70a50ff55706fd1dded72d16cd16b9d"

URI_aarch64_jxrlib = "${EPEL_MIRROR}/aarch64/Packages/j/jxrlib-1.1-30.el10_1.aarch64.rpm;name=aarch64_jxrlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_jxrlib}"
SRC_URI[aarch64_jxrlib.sha256sum] = "c54d397a7fe76cf02de423c31ca5f78a3ebe1b7098a55a6ae319c396f372c035"

URI_aarch64_jxrlib-devel = "${EPEL_MIRROR}/aarch64/Packages/j/jxrlib-devel-1.1-30.el10_1.aarch64.rpm;name=aarch64_jxrlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_jxrlib-devel}"
SRC_URI[aarch64_jxrlib-devel.sha256sum] = "a9803db93b8fddce2ac5d9af4eb37afe5568dceda0be251b55f2b3043df365c2"

URI_aarch64_mingw32-jxrlib = "${EPEL_MIRROR}/aarch64/Packages/m/mingw32-jxrlib-1.1-30.el10_1.noarch.rpm;name=aarch64_mingw32-jxrlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-jxrlib}"
SRC_URI[aarch64_mingw32-jxrlib.sha256sum] = "48652f6bda2a3c95b141f6d14add0a757c57bd783dcc8afd61bb20c0d3f3a52e"

URI_aarch64_mingw64-jxrlib = "${EPEL_MIRROR}/aarch64/Packages/m/mingw64-jxrlib-1.1-30.el10_1.noarch.rpm;name=aarch64_mingw64-jxrlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-jxrlib}"
SRC_URI[aarch64_mingw64-jxrlib.sha256sum] = "e02a99576472595bc823162cd1adb4c5018161b7d1051cbf774ab063d900aa4f"

RDEPENDS:jxrlib = " \
 glibc \
 "
RDEPENDS:jxrlib-devel = " \
 jxrlib \
 "
RDEPENDS:mingw32-jxrlib = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libgcc \
 "
RDEPENDS:mingw64-jxrlib = " \
 mingw64-crt \
 mingw64-filesystem \
 "
