# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmag"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kmag \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kmag-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e8ac63e2d621f37bfb1d69c9a0a68e45692ac9386e32ac9c0193a39c655cd69"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmag-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmag;unpack=0"
SRC_URI[x86_64_v2_kmag.sha256sum] = "b9ce8c543fb792e8e8d9f6810c32c3e0233257ca307558f1c50ce8ee0a03e0a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kmag-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kmag;unpack=0"
SRC_URI[aarch64_kmag.sha256sum] = "389cd5bbeda09812fe7de6048f20893f01fdcc21c4d2cd9989050bfba5a61618"

RDEPENDS:kmag = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
