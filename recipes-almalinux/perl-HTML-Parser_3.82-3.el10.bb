# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-Parser"
PV = "3.82"
PR = "3.el10"
PACKAGES = " \
 perl-HTML-Parser \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-HTML-Parser-3.82-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b8ebd69e0bb7cdbdd7a42b8e9dcff6a239369aaa5259bdb725e3118b4788e8b"

URI_x86_64_v2_perl-HTML-Parser = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-HTML-Parser-3.82-3.el10.x86_64_v2.rpm;name=x86_64_v2_perl-HTML-Parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTML-Parser}"
SRC_URI[x86_64_v2_perl-HTML-Parser.sha256sum] = "088faafffa2c11b55980f6633365eee657f09547c0ff448d1498bacd053d1a71"

URI_aarch64_perl-HTML-Parser = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-HTML-Parser-3.82-3.el10.aarch64.rpm;name=aarch64_perl-HTML-Parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTML-Parser}"
SRC_URI[aarch64_perl-HTML-Parser.sha256sum] = "9fdd97fd5a8286eed58417ad8d7d779b6c629f78dfa511fd54ed6183b80108e1"

RDEPENDS:perl-HTML-Parser = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-HTML-Parser \
 perl-HTML-Tagset \
 perl-HTTP-Message \
 perl-IO \
 perl-URI \
 perl-libs \
 "
