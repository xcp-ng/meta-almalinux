# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install"
PV = "1.21"
PR = "6.el10"
PACKAGES = " \
 perl-Module-Install \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Module-Install-1.21-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f7af1dea2f370b7effdc8a1adc1422e42b05482c604eedc9c4fbcc8c90fce9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Module-Install-1.21-6.el10.noarch.rpm;name=x86_64_v2_perl-Module-Install;unpack=0"
SRC_URI[x86_64_v2_perl-Module-Install.sha256sum] = "f330f49849544d4c950a18adf8125e8de829ce3f15bab5a66ecee2f21363b268"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Module-Install-1.21-6.el10.noarch.rpm;name=aarch64_perl-Module-Install;unpack=0"
SRC_URI[aarch64_perl-Module-Install.sha256sum] = "f330f49849544d4c950a18adf8125e8de829ce3f15bab5a66ecee2f21363b268"

RDEPENDS:perl-Module-Install = " \
 perl-Archive-Zip \
 perl-CPAN \
 perl-CPAN-Meta \
 perl-Carp \
 perl-Devel-PPPort \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-Remove \
 perl-File-Temp \
 perl-FileHandle \
 perl-FindBin \
 perl-Module-Build \
 perl-Module-CoreList \
 perl-Module-Install \
 perl-Module-ScanDeps \
 perl-PathTools \
 perl-Socket \
 perl-YAML-Tiny \
 perl-libs \
 perl-vars \
 "
