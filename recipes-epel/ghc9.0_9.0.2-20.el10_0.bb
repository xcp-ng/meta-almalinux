# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.0"
PV = "9.0.2"
PR = "20.el10_0"
PACKAGES = " \
 ghc9.0 \
 ghc9.0-Cabal \
 ghc9.0-Cabal-devel \
 ghc9.0-Cabal-doc \
 ghc9.0-Cabal-prof \
 ghc9.0-array \
 ghc9.0-array-devel \
 ghc9.0-array-doc \
 ghc9.0-array-prof \
 ghc9.0-base \
 ghc9.0-base-devel \
 ghc9.0-base-doc \
 ghc9.0-base-prof \
 ghc9.0-binary \
 ghc9.0-binary-devel \
 ghc9.0-binary-doc \
 ghc9.0-binary-prof \
 ghc9.0-bytestring \
 ghc9.0-bytestring-devel \
 ghc9.0-bytestring-doc \
 ghc9.0-bytestring-prof \
 ghc9.0-compiler \
 ghc9.0-compiler-default \
 ghc9.0-containers \
 ghc9.0-containers-devel \
 ghc9.0-containers-doc \
 ghc9.0-containers-prof \
 ghc9.0-deepseq \
 ghc9.0-deepseq-devel \
 ghc9.0-deepseq-doc \
 ghc9.0-deepseq-prof \
 ghc9.0-devel \
 ghc9.0-directory \
 ghc9.0-directory-devel \
 ghc9.0-directory-doc \
 ghc9.0-directory-prof \
 ghc9.0-doc \
 ghc9.0-doc-index \
 ghc9.0-exceptions \
 ghc9.0-exceptions-devel \
 ghc9.0-exceptions-doc \
 ghc9.0-exceptions-prof \
 ghc9.0-filepath \
 ghc9.0-filepath-devel \
 ghc9.0-filepath-doc \
 ghc9.0-filepath-prof \
 ghc9.0-filesystem \
 ghc9.0-ghc \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-bignum-devel \
 ghc9.0-ghc-bignum-doc \
 ghc9.0-ghc-bignum-prof \
 ghc9.0-ghc-boot \
 ghc9.0-ghc-boot-devel \
 ghc9.0-ghc-boot-doc \
 ghc9.0-ghc-boot-prof \
 ghc9.0-ghc-boot-th \
 ghc9.0-ghc-boot-th-devel \
 ghc9.0-ghc-boot-th-doc \
 ghc9.0-ghc-boot-th-prof \
 ghc9.0-ghc-compact \
 ghc9.0-ghc-compact-devel \
 ghc9.0-ghc-compact-doc \
 ghc9.0-ghc-compact-prof \
 ghc9.0-ghc-devel \
 ghc9.0-ghc-doc \
 ghc9.0-ghc-heap \
 ghc9.0-ghc-heap-devel \
 ghc9.0-ghc-heap-doc \
 ghc9.0-ghc-heap-prof \
 ghc9.0-ghc-prof \
 ghc9.0-ghci \
 ghc9.0-ghci-devel \
 ghc9.0-ghci-doc \
 ghc9.0-ghci-prof \
 ghc9.0-haskeline \
 ghc9.0-haskeline-devel \
 ghc9.0-haskeline-doc \
 ghc9.0-haskeline-prof \
 ghc9.0-hpc \
 ghc9.0-hpc-devel \
 ghc9.0-hpc-doc \
 ghc9.0-hpc-prof \
 ghc9.0-libiserv \
 ghc9.0-libiserv-devel \
 ghc9.0-libiserv-doc \
 ghc9.0-libiserv-prof \
 ghc9.0-manual \
 ghc9.0-mtl \
 ghc9.0-mtl-devel \
 ghc9.0-mtl-doc \
 ghc9.0-mtl-prof \
 ghc9.0-parsec \
 ghc9.0-parsec-devel \
 ghc9.0-parsec-doc \
 ghc9.0-parsec-prof \
 ghc9.0-pretty \
 ghc9.0-pretty-devel \
 ghc9.0-pretty-doc \
 ghc9.0-pretty-prof \
 ghc9.0-process \
 ghc9.0-process-devel \
 ghc9.0-process-doc \
 ghc9.0-process-prof \
 ghc9.0-prof \
 ghc9.0-stm \
 ghc9.0-stm-devel \
 ghc9.0-stm-doc \
 ghc9.0-stm-prof \
 ghc9.0-template-haskell \
 ghc9.0-template-haskell-devel \
 ghc9.0-template-haskell-doc \
 ghc9.0-template-haskell-prof \
 ghc9.0-terminfo \
 ghc9.0-terminfo-devel \
 ghc9.0-terminfo-doc \
 ghc9.0-terminfo-prof \
 ghc9.0-text \
 ghc9.0-text-devel \
 ghc9.0-text-doc \
 ghc9.0-text-prof \
 ghc9.0-time \
 ghc9.0-time-devel \
 ghc9.0-time-doc \
 ghc9.0-time-prof \
 ghc9.0-transformers \
 ghc9.0-transformers-devel \
 ghc9.0-transformers-doc \
 ghc9.0-transformers-prof \
 ghc9.0-unix \
 ghc9.0-unix-devel \
 ghc9.0-unix-doc \
 ghc9.0-unix-prof \
 ghc9.0-xhtml \
 ghc9.0-xhtml-devel \
 ghc9.0-xhtml-doc \
 ghc9.0-xhtml-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.0-9.0.2-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ccb476f154346ab7fae57c84044eb8dc458646c6a5ba8d8ce55db85dc8f38d0"

URI_x86_64_v2_ghc9.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0}"
SRC_URI[x86_64_v2_ghc9.0.sha256sum] = "8d239f87c14a924e0873cad6a1f2291435829e096761a08bf0933d17c9af69be"

URI_x86_64_v2_ghc9.0-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-Cabal-3.4.1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-Cabal}"
SRC_URI[x86_64_v2_ghc9.0-Cabal.sha256sum] = "a84d6ac1b3e3c2903ef445e3c8660dde0f2154dcb038228757319d7aa4d7ec54"

URI_x86_64_v2_ghc9.0-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-Cabal-devel-3.4.1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.0-Cabal-devel.sha256sum] = "97494227fa76dfbd94f23acce437449752bf99ea1539ef8d9ed52c7b3c315c0a"

URI_x86_64_v2_ghc9.0-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-Cabal-doc-3.4.1.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.0-Cabal-doc.sha256sum] = "3ab44b92d897d2ad95bc9b1719faac1f6412b4ac7f7fbc27eed21eddc8c15378"

URI_x86_64_v2_ghc9.0-Cabal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-Cabal-prof-3.4.1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-Cabal-prof}"
SRC_URI[x86_64_v2_ghc9.0-Cabal-prof.sha256sum] = "442818e215cac39db9b8ffcace22a91d5ec41256eb9c1b4a94b76784081068fd"

URI_x86_64_v2_ghc9.0-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-array-0.5.4.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-array}"
SRC_URI[x86_64_v2_ghc9.0-array.sha256sum] = "b42b97803117124fb3bba2ce568141208da87cc65eecdbc9debca59584c72b1d"

URI_x86_64_v2_ghc9.0-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-array-devel-0.5.4.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-array-devel}"
SRC_URI[x86_64_v2_ghc9.0-array-devel.sha256sum] = "05eafb1372820733a09c229a747336b6a3b17ba9e739bc182b441097cf3814d4"

URI_x86_64_v2_ghc9.0-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-array-doc-0.5.4.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-array-doc}"
SRC_URI[x86_64_v2_ghc9.0-array-doc.sha256sum] = "46d4d22a1506d833792340a92a01546a0d7402b3907ab461638217e8b210e587"

URI_x86_64_v2_ghc9.0-array-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-array-prof-0.5.4.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-array-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-array-prof}"
SRC_URI[x86_64_v2_ghc9.0-array-prof.sha256sum] = "3f3eaee3e5784e1d660f73417263fd8d5c6ecec90ad078664863b8f30cbd74e2"

URI_x86_64_v2_ghc9.0-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-base-4.15.1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-base}"
SRC_URI[x86_64_v2_ghc9.0-base.sha256sum] = "30add34eb4846220c8f116553cff13222e5998ec080cfd63ec1850bbac71f445"

URI_x86_64_v2_ghc9.0-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-base-devel-4.15.1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-base-devel}"
SRC_URI[x86_64_v2_ghc9.0-base-devel.sha256sum] = "eee57e6adad479bda2601043a8cb15262537030385f1616a9d03641334be1980"

URI_x86_64_v2_ghc9.0-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-base-doc-4.15.1.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-base-doc}"
SRC_URI[x86_64_v2_ghc9.0-base-doc.sha256sum] = "f9b64824e1f276ab77972dfafc3e75cb2cfc4179e263e32a56426fc3860a1224"

URI_x86_64_v2_ghc9.0-base-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-base-prof-4.15.1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-base-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-base-prof}"
SRC_URI[x86_64_v2_ghc9.0-base-prof.sha256sum] = "c83c313d023b674fe0d660e6fc4f79fb8f02e8ed9d1baccafb29dcd332bb5445"

URI_x86_64_v2_ghc9.0-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-binary-0.8.8.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-binary}"
SRC_URI[x86_64_v2_ghc9.0-binary.sha256sum] = "ff386ba20d0b055e7c6769959529b2b4407ef50aecb9422ee4073d12e8437c16"

URI_x86_64_v2_ghc9.0-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-binary-devel-0.8.8.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-binary-devel}"
SRC_URI[x86_64_v2_ghc9.0-binary-devel.sha256sum] = "1c0e8e876b2b1754ab30852ac8c0123b316f24b42b3a3f61a717caf821e4dfbd"

URI_x86_64_v2_ghc9.0-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-binary-doc-0.8.8.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-binary-doc}"
SRC_URI[x86_64_v2_ghc9.0-binary-doc.sha256sum] = "2d369ff9e27d6db2ecd0134164a641793b418d9e5b91b585ac0dc2a97c61e783"

URI_x86_64_v2_ghc9.0-binary-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-binary-prof-0.8.8.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-binary-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-binary-prof}"
SRC_URI[x86_64_v2_ghc9.0-binary-prof.sha256sum] = "d49ec10090715ab7f25cf7c6abc48a55e11bf4895e5444ca2be83f492a03ff42"

URI_x86_64_v2_ghc9.0-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-bytestring-0.10.12.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-bytestring}"
SRC_URI[x86_64_v2_ghc9.0-bytestring.sha256sum] = "2dedc301df0d2a0254bc59e1c95f4d28a6a2dbfb0a70217a0a0f587e35b0eb75"

URI_x86_64_v2_ghc9.0-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-bytestring-devel-0.10.12.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.0-bytestring-devel.sha256sum] = "24bc441cea911f09433943fbd99b02df3f33877473291b132865bdee5b0e6fe7"

URI_x86_64_v2_ghc9.0-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-bytestring-doc-0.10.12.1-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.0-bytestring-doc.sha256sum] = "df20b707f39ff050a237d630589a6c00cf4cb1adf69a79961666e2ab238ab42d"

URI_x86_64_v2_ghc9.0-bytestring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-bytestring-prof-0.10.12.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-bytestring-prof}"
SRC_URI[x86_64_v2_ghc9.0-bytestring-prof.sha256sum] = "776b84564204d57fe9af1d2a2cad56c00c418db9cdf4d3fd40e5f451bd0a5a99"

URI_x86_64_v2_ghc9.0-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-compiler-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-compiler}"
SRC_URI[x86_64_v2_ghc9.0-compiler.sha256sum] = "4ff1e297e0184e806455113e67d485b937f0570dfeffe7e75d21153b656da4c8"

URI_x86_64_v2_ghc9.0-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-compiler-default-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-compiler-default}"
SRC_URI[x86_64_v2_ghc9.0-compiler-default.sha256sum] = "1c3edcef062eb0c59a15308342cd321828c2d94b2f931e3882dec6acc4f209a0"

URI_x86_64_v2_ghc9.0-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-containers-0.6.4.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-containers}"
SRC_URI[x86_64_v2_ghc9.0-containers.sha256sum] = "12671190daf5d0ff535437ccb9105268f57a7f20204c57f8a20adb9183b6a973"

URI_x86_64_v2_ghc9.0-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-containers-devel-0.6.4.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-containers-devel}"
SRC_URI[x86_64_v2_ghc9.0-containers-devel.sha256sum] = "aa8dd0886f9f1d9302751b5a9d9a6069111a8a110af342066a0752c33c278c12"

URI_x86_64_v2_ghc9.0-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-containers-doc-0.6.4.1-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-containers-doc}"
SRC_URI[x86_64_v2_ghc9.0-containers-doc.sha256sum] = "47ddd9103de9df2b9a02e18e937f682a61e553e27f29e292cc915dec1d373613"

URI_x86_64_v2_ghc9.0-containers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-containers-prof-0.6.4.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-containers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-containers-prof}"
SRC_URI[x86_64_v2_ghc9.0-containers-prof.sha256sum] = "ed364c4eccddca1c7bfd0068547cd9e2ac474057deb4548743f6b97a9bf00e0b"

URI_x86_64_v2_ghc9.0-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-deepseq-1.4.5.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-deepseq}"
SRC_URI[x86_64_v2_ghc9.0-deepseq.sha256sum] = "8d31dcc21c60d71a78299973afd71974f53a5dd231f3c690f7a19a1e12917668"

URI_x86_64_v2_ghc9.0-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-deepseq-devel-1.4.5.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.0-deepseq-devel.sha256sum] = "a62ba5a23019457ad4a446e3152b0016d284e70c90c6dbe7affd23d7760a7710"

URI_x86_64_v2_ghc9.0-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-deepseq-doc-1.4.5.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.0-deepseq-doc.sha256sum] = "0a4686762e22c78ef15743b3fadf6144bbe671be964da16bf0e0ec00f764a8c7"

URI_x86_64_v2_ghc9.0-deepseq-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-deepseq-prof-1.4.5.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-deepseq-prof}"
SRC_URI[x86_64_v2_ghc9.0-deepseq-prof.sha256sum] = "a4921f733df2fe0bef60770025cac4fdf3052140cd15dbee3399bf3de0ef1846"

URI_x86_64_v2_ghc9.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-devel-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-devel}"
SRC_URI[x86_64_v2_ghc9.0-devel.sha256sum] = "eec5e16099a037607775f60f4d85c77884c90b838be2d5f214dea4b3e65f56e7"

URI_x86_64_v2_ghc9.0-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-directory-1.3.6.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-directory}"
SRC_URI[x86_64_v2_ghc9.0-directory.sha256sum] = "a50fe0916af556652c02f5168262bd4a3af837160ee796d1f0efad87b452b131"

URI_x86_64_v2_ghc9.0-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-directory-devel-1.3.6.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-directory-devel}"
SRC_URI[x86_64_v2_ghc9.0-directory-devel.sha256sum] = "2016bde2ac7a608a7d5beac09eee54b5bada0ef21d106edd644c101985f5e27a"

URI_x86_64_v2_ghc9.0-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-directory-doc-1.3.6.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-directory-doc}"
SRC_URI[x86_64_v2_ghc9.0-directory-doc.sha256sum] = "acf990e3b6380f1fb0afb8df3867fcf8496a4a2826b766c3dae443405274bc94"

URI_x86_64_v2_ghc9.0-directory-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-directory-prof-1.3.6.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-directory-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-directory-prof}"
SRC_URI[x86_64_v2_ghc9.0-directory-prof.sha256sum] = "f368c936298d7e5ed3c986ea5b84e6dcff6ad8e1bc25ae879f977c6f0304f1fc"

URI_x86_64_v2_ghc9.0-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-doc-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-doc}"
SRC_URI[x86_64_v2_ghc9.0-doc.sha256sum] = "f57fa0e056ea18c1fd4ac5dc87165cc882307e0ea2505b0c370328302517bbb0"

URI_x86_64_v2_ghc9.0-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-doc-index-9.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-doc-index}"
SRC_URI[x86_64_v2_ghc9.0-doc-index.sha256sum] = "cfe693e8f998b494e374bd0381cdce1beb2fc9d834977d743b0ba67144b441f0"

URI_x86_64_v2_ghc9.0-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-exceptions-0.10.4-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-exceptions}"
SRC_URI[x86_64_v2_ghc9.0-exceptions.sha256sum] = "1758b6c096879918c10b46c702605019736600d9c4593b86e7abc04983b83dbd"

URI_x86_64_v2_ghc9.0-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-exceptions-devel-0.10.4-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.0-exceptions-devel.sha256sum] = "7ec4728d1970407c4eb050b763f9d0ecae21efd0f32e5239e753007d6cd9ed4c"

URI_x86_64_v2_ghc9.0-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-exceptions-doc-0.10.4-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.0-exceptions-doc.sha256sum] = "adc327ee519ad85b8d095e9008c6091534e98033a86936a13c6b356aa4370a13"

URI_x86_64_v2_ghc9.0-exceptions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-exceptions-prof-0.10.4-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-exceptions-prof}"
SRC_URI[x86_64_v2_ghc9.0-exceptions-prof.sha256sum] = "49ee016c4b21e31271fdcca767e37fed96e10ffabac1e5f93333567b82f6d4b4"

URI_x86_64_v2_ghc9.0-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-filepath-1.4.2.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-filepath}"
SRC_URI[x86_64_v2_ghc9.0-filepath.sha256sum] = "86076a9ed0ffd5e0ff2c314e32e643dbca584b5e26af4a758d4c29bce7c26c66"

URI_x86_64_v2_ghc9.0-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-filepath-devel-1.4.2.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.0-filepath-devel.sha256sum] = "52f7cfc8bf8b8d5147a400613efb9a07d0eaa4b7cfca927a3df8193b5bc56e93"

URI_x86_64_v2_ghc9.0-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-filepath-doc-1.4.2.1-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.0-filepath-doc.sha256sum] = "dcba21b8ff35c8b8fe3e2c8499e617e555e2ca700d52927169f48513d3320df7"

URI_x86_64_v2_ghc9.0-filepath-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-filepath-prof-1.4.2.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-filepath-prof}"
SRC_URI[x86_64_v2_ghc9.0-filepath-prof.sha256sum] = "11b92e2da7a74cd54b81e7ba9f1664c6cbca1933d5580cb334edfb029e7c4ca1"

URI_x86_64_v2_ghc9.0-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-filesystem-9.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-filesystem}"
SRC_URI[x86_64_v2_ghc9.0-filesystem.sha256sum] = "254bf91fe7be3de93e28fb28e72a40eb76532483153d579822498b9424dd7fad"

URI_x86_64_v2_ghc9.0-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc}"
SRC_URI[x86_64_v2_ghc9.0-ghc.sha256sum] = "2bb3252891a441565690449b1e1640b5d73151d5b66ccccca8536d0f1ea7e9b7"

URI_x86_64_v2_ghc9.0-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-bignum-1.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.0-ghc-bignum.sha256sum] = "8d37d3dde5ed30af306b43965cf748204638e33ebf3c911223ad00ac5e99d535"

URI_x86_64_v2_ghc9.0-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-bignum-devel-1.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.0-ghc-bignum-devel.sha256sum] = "098940a802b7834d83a6fb88fda7834e6906ad246f8b0bbba1000a11a165f539"

URI_x86_64_v2_ghc9.0-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-bignum-doc-1.1-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.0-ghc-bignum-doc.sha256sum] = "612f30dbb2a357a6056b45ac25e7c66e88e5fde4fcc9f9e5eeeb8d46eacaef74"

URI_x86_64_v2_ghc9.0-ghc-bignum-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-bignum-prof-1.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-bignum-prof}"
SRC_URI[x86_64_v2_ghc9.0-ghc-bignum-prof.sha256sum] = "920e9c541edd7d4bf281dafcb7e970217de567143cf6b74c2ed79969053e1155"

URI_x86_64_v2_ghc9.0-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-boot-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.0-ghc-boot.sha256sum] = "2db1e2b5a4322045628e7141c0dc40dfa9a4cfe4afd56b3a2e297e8947af7162"

URI_x86_64_v2_ghc9.0-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-boot-devel-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.0-ghc-boot-devel.sha256sum] = "16485c9296de11b160b3260307d565b2b2d9923d73b63b7403bdbf8be7e88e57"

URI_x86_64_v2_ghc9.0-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-boot-doc-9.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.0-ghc-boot-doc.sha256sum] = "89de5e47bce3d552428fef5a5c6129ac3b29b49908bbd68b5cf4f6bd66d452d5"

URI_x86_64_v2_ghc9.0-ghc-boot-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-boot-prof-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-boot-prof}"
SRC_URI[x86_64_v2_ghc9.0-ghc-boot-prof.sha256sum] = "95518e4f8ea1bb7ec42e058897d5bdacdf9f25a4f7601183236793c9665555b9"

URI_x86_64_v2_ghc9.0-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-boot-th-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.0-ghc-boot-th.sha256sum] = "7dbb857aa283a9bb0f02c26e18dc395db532c171a93043e5c13cf9730ef0c789"

URI_x86_64_v2_ghc9.0-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-boot-th-devel-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.0-ghc-boot-th-devel.sha256sum] = "548216cfb86793ae7b9ae75aac0c8d85003336536cf69901c3a8686ccbb14994"

URI_x86_64_v2_ghc9.0-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-boot-th-doc-9.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.0-ghc-boot-th-doc.sha256sum] = "48ac7e63eccd00b3c41ebb014f724df9cef1b01df152d89aa9adbc52da4ec763"

URI_x86_64_v2_ghc9.0-ghc-boot-th-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-boot-th-prof-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-boot-th-prof}"
SRC_URI[x86_64_v2_ghc9.0-ghc-boot-th-prof.sha256sum] = "926f7fe215294b33e12affc65b15cf45ed3562f8dd9d34fb608a56eaa453e7ec"

URI_x86_64_v2_ghc9.0-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-compact-0.1.0.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.0-ghc-compact.sha256sum] = "a5be99ba6fdbeb7f05790141bf14e512e5598b01b616d6649d705f74255ca7ef"

URI_x86_64_v2_ghc9.0-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-compact-devel-0.1.0.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.0-ghc-compact-devel.sha256sum] = "21738c7b1c248cc190e231c9bbd0570c1dafa74a3d73ac3e787156e9cdd14429"

URI_x86_64_v2_ghc9.0-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-compact-doc-0.1.0.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.0-ghc-compact-doc.sha256sum] = "1e01b62271c4898778c5c8d05420ab22a67c2e57e186b7e73295373fb552dd9b"

URI_x86_64_v2_ghc9.0-ghc-compact-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-compact-prof-0.1.0.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-compact-prof}"
SRC_URI[x86_64_v2_ghc9.0-ghc-compact-prof.sha256sum] = "58117136f25eace477e0339f9e4e9586862d151b6e0a65c304da1ea6243a2c54"

URI_x86_64_v2_ghc9.0-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-devel-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.0-ghc-devel.sha256sum] = "e7c799fce97d94c472c8ed8418b03ef14308e9479af6f35959fd0a9aa6324992"

URI_x86_64_v2_ghc9.0-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-doc-9.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.0-ghc-doc.sha256sum] = "3433e617de025226efcc349fefebcc77c15079c0c854d7887e2ff5ba03981dd3"

URI_x86_64_v2_ghc9.0-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-heap-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.0-ghc-heap.sha256sum] = "833a0991cea5de58e2dc78d4098fe6976e19ba2350cd672c5fd106c15c5ab0d2"

URI_x86_64_v2_ghc9.0-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-heap-devel-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.0-ghc-heap-devel.sha256sum] = "88d8a734735769d99cc39ead3bee08199c05725a277c76f848cf88f1c9db3690"

URI_x86_64_v2_ghc9.0-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-heap-doc-9.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.0-ghc-heap-doc.sha256sum] = "950570a21a26f6fa8e30040357ec0afda70a1433a4629ba8251a2425febf16e0"

URI_x86_64_v2_ghc9.0-ghc-heap-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-heap-prof-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-heap-prof}"
SRC_URI[x86_64_v2_ghc9.0-ghc-heap-prof.sha256sum] = "66f13352c8d1b8435e19dcc7e70eb0b4215a72610d31f300b2c773eeaeeab159"

URI_x86_64_v2_ghc9.0-ghc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghc-prof-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghc-prof}"
SRC_URI[x86_64_v2_ghc9.0-ghc-prof.sha256sum] = "63776efcd14447a7f5dd6928179d9e32dae3e365f9f2612d76d724bd2c33ea66"

URI_x86_64_v2_ghc9.0-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghci-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghci}"
SRC_URI[x86_64_v2_ghc9.0-ghci.sha256sum] = "144f282a5acb88ef6a2a836c9d91e835e33da41dff8bbf877ce2112640ac5747"

URI_x86_64_v2_ghc9.0-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghci-devel-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.0-ghci-devel.sha256sum] = "72a4edfe7cdf1fa3a3f63d2db8bb3063ee02471cb77505d0eab161c54dd89226"

URI_x86_64_v2_ghc9.0-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghci-doc-9.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.0-ghci-doc.sha256sum] = "f60aea3acba0fca4be3daa2459b711c08ea4ad2d82cd6c0e64b72ca62e9e1978"

URI_x86_64_v2_ghc9.0-ghci-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-ghci-prof-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-ghci-prof}"
SRC_URI[x86_64_v2_ghc9.0-ghci-prof.sha256sum] = "e308ec1f59f7bd076348146aaaded4bd952de02529fa3d90cb4e6603653374d2"

URI_x86_64_v2_ghc9.0-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-haskeline-0.8.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-haskeline}"
SRC_URI[x86_64_v2_ghc9.0-haskeline.sha256sum] = "a6d58bfb258a5090400cccd587332321c0db828bf591592f8dd68c4b0d65830c"

URI_x86_64_v2_ghc9.0-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-haskeline-devel-0.8.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.0-haskeline-devel.sha256sum] = "fa8cc8cccc1dacb227cd6dad1eef6b7deb6022c7ead824010965658fc2bdb672"

URI_x86_64_v2_ghc9.0-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-haskeline-doc-0.8.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.0-haskeline-doc.sha256sum] = "eb6d49054d39174b907b390b4999977bdef2a28a9334983055474f9bd1f78b9c"

URI_x86_64_v2_ghc9.0-haskeline-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-haskeline-prof-0.8.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-haskeline-prof}"
SRC_URI[x86_64_v2_ghc9.0-haskeline-prof.sha256sum] = "b035f4cf8854b71fd563c8f84bf7c5d713e4c45182abe9c5b7976d59895ece25"

URI_x86_64_v2_ghc9.0-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-hpc-0.6.1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-hpc}"
SRC_URI[x86_64_v2_ghc9.0-hpc.sha256sum] = "2647da62ef234147c17ee4fcaccb70767900d51f817658f32de9f340964445ea"

URI_x86_64_v2_ghc9.0-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-hpc-devel-0.6.1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.0-hpc-devel.sha256sum] = "96f65fe204766aabbbed41f3a54d0188a435d3b3cae59946dd6b50e8d6e398e0"

URI_x86_64_v2_ghc9.0-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-hpc-doc-0.6.1.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.0-hpc-doc.sha256sum] = "281ed2a165500dc868a61efd73342352c896df913c3c00a05cef6299ffb35bfa"

URI_x86_64_v2_ghc9.0-hpc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-hpc-prof-0.6.1.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-hpc-prof}"
SRC_URI[x86_64_v2_ghc9.0-hpc-prof.sha256sum] = "ed53ebe1592b8bb57932d538c76200cd55cdfedc9a50b452cae0ccbb54a548a5"

URI_x86_64_v2_ghc9.0-libiserv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-libiserv-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-libiserv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-libiserv}"
SRC_URI[x86_64_v2_ghc9.0-libiserv.sha256sum] = "936d32905e4ddfca0f0d2c0635ef4a162a5eaf209593289f3e9158059aec6a6b"

URI_x86_64_v2_ghc9.0-libiserv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-libiserv-devel-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-libiserv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-libiserv-devel}"
SRC_URI[x86_64_v2_ghc9.0-libiserv-devel.sha256sum] = "994f753544750d9734a78ab2f3f635c0fd4ca38370cf3a706519dddd6092ae06"

URI_x86_64_v2_ghc9.0-libiserv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-libiserv-doc-9.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-libiserv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-libiserv-doc}"
SRC_URI[x86_64_v2_ghc9.0-libiserv-doc.sha256sum] = "70951ca21e93bd7a314e820d96f15f4dcd91486ee82f5ed49193c2ea2d1b8096"

URI_x86_64_v2_ghc9.0-libiserv-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-libiserv-prof-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-libiserv-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-libiserv-prof}"
SRC_URI[x86_64_v2_ghc9.0-libiserv-prof.sha256sum] = "c1246263858354c59389bf2e0567bad6b56026313977cb31ae39e48ca837503a"

URI_x86_64_v2_ghc9.0-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-manual-9.0.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-manual}"
SRC_URI[x86_64_v2_ghc9.0-manual.sha256sum] = "7a36e11792b80de046150c2d2d7b9d6be6f1ef57fd22855fa6dd7155841d360c"

URI_x86_64_v2_ghc9.0-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-mtl-2.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-mtl}"
SRC_URI[x86_64_v2_ghc9.0-mtl.sha256sum] = "e9dd61c2eec16b0c0c99e60c2b23445bd24d527115c84eac8f9e25535c12e5ed"

URI_x86_64_v2_ghc9.0-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-mtl-devel-2.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.0-mtl-devel.sha256sum] = "3e4fef226ef57bd42de19ac1ec8c2e34676d7e3e7829c9a1b3fa85aa16027540"

URI_x86_64_v2_ghc9.0-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-mtl-doc-2.2.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.0-mtl-doc.sha256sum] = "67225c413f073fc2512d8cacde774308a7c4ca1de1c9d48cf4bf1db01797404e"

URI_x86_64_v2_ghc9.0-mtl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-mtl-prof-2.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-mtl-prof}"
SRC_URI[x86_64_v2_ghc9.0-mtl-prof.sha256sum] = "3806c9671963454219f844eb95f517f66c741b8c0c5fc3f83cd1ea5cd63b4d59"

URI_x86_64_v2_ghc9.0-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-parsec-3.1.14.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-parsec}"
SRC_URI[x86_64_v2_ghc9.0-parsec.sha256sum] = "669954a9574b1f1a00573cc3b157dc16bf9b7ced08629d48ef5e6bd0601c08c9"

URI_x86_64_v2_ghc9.0-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-parsec-devel-3.1.14.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.0-parsec-devel.sha256sum] = "c159d9ede5eb3d2649b99f8c44e486445b9e00ca71715c324a80e26d3b6cc84f"

URI_x86_64_v2_ghc9.0-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-parsec-doc-3.1.14.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.0-parsec-doc.sha256sum] = "a22aed98092bcd0c0c84008f5c96df718ed1f36886cecdce909dd84f0f806bcc"

URI_x86_64_v2_ghc9.0-parsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-parsec-prof-3.1.14.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-parsec-prof}"
SRC_URI[x86_64_v2_ghc9.0-parsec-prof.sha256sum] = "d353c9ffc06499f8aae5eed49e9d4e6bf6ae484ea1b92ab4b625fa76722dc61e"

URI_x86_64_v2_ghc9.0-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-pretty-1.1.3.6-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-pretty}"
SRC_URI[x86_64_v2_ghc9.0-pretty.sha256sum] = "5b06df02b75e72c2f24d7def86e77d80e7742cd3430a584298e833f1e79e9912"

URI_x86_64_v2_ghc9.0-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-pretty-devel-1.1.3.6-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.0-pretty-devel.sha256sum] = "1d35f5fda1fc2891f3754bdf1f772d556b0021339c5282d5eb581436435557c5"

URI_x86_64_v2_ghc9.0-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-pretty-doc-1.1.3.6-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.0-pretty-doc.sha256sum] = "0c89102c636a82e8bcab99e4361358ece5e703d382ca1309b39235c28f2a32f8"

URI_x86_64_v2_ghc9.0-pretty-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-pretty-prof-1.1.3.6-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-pretty-prof}"
SRC_URI[x86_64_v2_ghc9.0-pretty-prof.sha256sum] = "b1bbc63b8c81eb77d88e38fda72d34e66c1969de213f1c0f932955ce9d2cb445"

URI_x86_64_v2_ghc9.0-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-process-1.6.13.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-process}"
SRC_URI[x86_64_v2_ghc9.0-process.sha256sum] = "2b899b744dab3249fbeab6328f522d9ae6a18f3aed89b3754ecaf99ce028059e"

URI_x86_64_v2_ghc9.0-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-process-devel-1.6.13.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-process-devel}"
SRC_URI[x86_64_v2_ghc9.0-process-devel.sha256sum] = "e49d551ac758d69200963f4a299241d751a44290962eef34c8d4866ecee9f377"

URI_x86_64_v2_ghc9.0-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-process-doc-1.6.13.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-process-doc}"
SRC_URI[x86_64_v2_ghc9.0-process-doc.sha256sum] = "b46b4c761c13e59e3abf3e338b3fd456ffcdd1381ae4a58fd187c5c6e5a0edc1"

URI_x86_64_v2_ghc9.0-process-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-process-prof-1.6.13.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-process-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-process-prof}"
SRC_URI[x86_64_v2_ghc9.0-process-prof.sha256sum] = "1653e0f7a050dd47df42b5457d2841a597f8f9ea58633944856fdc1cf434f96d"

URI_x86_64_v2_ghc9.0-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-prof-9.0.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-prof}"
SRC_URI[x86_64_v2_ghc9.0-prof.sha256sum] = "f1367ce6659d5a1505e8582edebbf95c6dbb72a3804c36d75f4f838eaa7bd89e"

URI_x86_64_v2_ghc9.0-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-stm-2.5.0.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-stm}"
SRC_URI[x86_64_v2_ghc9.0-stm.sha256sum] = "c29ab8764fd640a52680aa64d24d9b741cce9e999e751beeed4a2c3ae537e956"

URI_x86_64_v2_ghc9.0-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-stm-devel-2.5.0.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-stm-devel}"
SRC_URI[x86_64_v2_ghc9.0-stm-devel.sha256sum] = "ad968a1382fee59cbc3ebeca08b614692d29288907f6fad9695e89bdbbd6f4d2"

URI_x86_64_v2_ghc9.0-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-stm-doc-2.5.0.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-stm-doc}"
SRC_URI[x86_64_v2_ghc9.0-stm-doc.sha256sum] = "3bd6d8c6b1d9cb870aa778f8ccaf3dbad637e67b7535127a698954a62e61b3d7"

URI_x86_64_v2_ghc9.0-stm-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-stm-prof-2.5.0.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-stm-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-stm-prof}"
SRC_URI[x86_64_v2_ghc9.0-stm-prof.sha256sum] = "72ef08cb3591c49f9872f0ca4f5b56a64550d7273cd417702ede9c4d826aba37"

URI_x86_64_v2_ghc9.0-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-template-haskell-2.17.0.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-template-haskell}"
SRC_URI[x86_64_v2_ghc9.0-template-haskell.sha256sum] = "627a19fb98a8fda786a8c209ea2a29543630ccbea3b113f6b8a37d6a8e28bffb"

URI_x86_64_v2_ghc9.0-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-template-haskell-devel-2.17.0.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.0-template-haskell-devel.sha256sum] = "492d4f2eff75e09cdc8962f48cd38a8df0e63eec8c66a979e55df8723518d79f"

URI_x86_64_v2_ghc9.0-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-template-haskell-doc-2.17.0.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.0-template-haskell-doc.sha256sum] = "f540bb2954644f5fd7a94e16c31e37fbd20b4ee6bca7e6c8835661fdf45e0c9a"

URI_x86_64_v2_ghc9.0-template-haskell-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-template-haskell-prof-2.17.0.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-template-haskell-prof}"
SRC_URI[x86_64_v2_ghc9.0-template-haskell-prof.sha256sum] = "cf256c2b602cc566c613506826c007bc8e3cba40b2f0139aa88452df090a3074"

URI_x86_64_v2_ghc9.0-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-terminfo-0.4.1.5-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-terminfo}"
SRC_URI[x86_64_v2_ghc9.0-terminfo.sha256sum] = "373790a7fa071a45ec782021d69a904c80acc425c1a2a103aced6b12af94a6fb"

URI_x86_64_v2_ghc9.0-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-terminfo-devel-0.4.1.5-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.0-terminfo-devel.sha256sum] = "05efc7c9b8c0608ab0cbd44b15eaa86f110d07730a25f4aac1b878c90bd3fe1c"

URI_x86_64_v2_ghc9.0-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-terminfo-doc-0.4.1.5-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.0-terminfo-doc.sha256sum] = "62ec7f406fdc32e74cde44c6fed0ac3c0868baec1e4fe239bf6687ed7032ef0f"

URI_x86_64_v2_ghc9.0-terminfo-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-terminfo-prof-0.4.1.5-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-terminfo-prof}"
SRC_URI[x86_64_v2_ghc9.0-terminfo-prof.sha256sum] = "62587190039d0890880e231b6268239c049f638561ed3b4cc9f50c98e79a5b48"

URI_x86_64_v2_ghc9.0-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-text-1.2.5.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-text}"
SRC_URI[x86_64_v2_ghc9.0-text.sha256sum] = "43f29aa697c8894c7475fce8d789c98bb13ca7b2c5371be1d8441a22de6119ed"

URI_x86_64_v2_ghc9.0-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-text-devel-1.2.5.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-text-devel}"
SRC_URI[x86_64_v2_ghc9.0-text-devel.sha256sum] = "91f5edd45eca878f6768aeeec8aaf58a8d637d3ee971b61ab2372f1aa6c9839d"

URI_x86_64_v2_ghc9.0-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-text-doc-1.2.5.0-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-text-doc}"
SRC_URI[x86_64_v2_ghc9.0-text-doc.sha256sum] = "73895d682ce89ac3e31c3f6df10bdb8a785e49a8c3c9f17f136595ee6ace894d"

URI_x86_64_v2_ghc9.0-text-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-text-prof-1.2.5.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-text-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-text-prof}"
SRC_URI[x86_64_v2_ghc9.0-text-prof.sha256sum] = "03d42b8c4756c224cd5db07be41299afcb94209c757d72b55db848664aaa0e68"

URI_x86_64_v2_ghc9.0-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-time-1.9.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-time}"
SRC_URI[x86_64_v2_ghc9.0-time.sha256sum] = "72450118a87eb4a5c4a2b50f1773b1f3ac044e19b08310aa0d89c057fd55d4f4"

URI_x86_64_v2_ghc9.0-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-time-devel-1.9.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-time-devel}"
SRC_URI[x86_64_v2_ghc9.0-time-devel.sha256sum] = "9be23bb1b314b130c7085634577dd4db8e6139c6c574e7a18195c6676cdb6f5e"

URI_x86_64_v2_ghc9.0-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-time-doc-1.9.3-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-time-doc}"
SRC_URI[x86_64_v2_ghc9.0-time-doc.sha256sum] = "a73aa6ed4b63b4cec474823aba98d702c4ab8845550b307552403613c7797657"

URI_x86_64_v2_ghc9.0-time-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-time-prof-1.9.3-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-time-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-time-prof}"
SRC_URI[x86_64_v2_ghc9.0-time-prof.sha256sum] = "51f3ed06f72ad4d6ec04b68c7d75e0596453d22ff3cabede594c688efc4bacd4"

URI_x86_64_v2_ghc9.0-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-transformers-0.5.6.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-transformers}"
SRC_URI[x86_64_v2_ghc9.0-transformers.sha256sum] = "5b702f73eb469d8354bffe33b11808fafc2d2b219980ed9097e4bd7e551f6175"

URI_x86_64_v2_ghc9.0-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-transformers-devel-0.5.6.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.0-transformers-devel.sha256sum] = "a886f8fb9056592c7f361700644b36db96b4863db9719324b1db7f3388e2218f"

URI_x86_64_v2_ghc9.0-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-transformers-doc-0.5.6.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.0-transformers-doc.sha256sum] = "7be5ca107711a82ce374037ba7479d2d8e263635a93912db7aa196452a94a64a"

URI_x86_64_v2_ghc9.0-transformers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-transformers-prof-0.5.6.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-transformers-prof}"
SRC_URI[x86_64_v2_ghc9.0-transformers-prof.sha256sum] = "ebaf8891577b2e3f7fb42de51564f2bdbec61a1e68ca2f601c287052ba071de3"

URI_x86_64_v2_ghc9.0-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-unix-2.7.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-unix}"
SRC_URI[x86_64_v2_ghc9.0-unix.sha256sum] = "6e7c28ceabcf2cea3ebd37326ed1bd10bbab3a4de36310fe40a58b3e87547ae2"

URI_x86_64_v2_ghc9.0-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-unix-devel-2.7.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-unix-devel}"
SRC_URI[x86_64_v2_ghc9.0-unix-devel.sha256sum] = "2840ca50802dcaf1b4381ed509566e24cf3200dfba4e192b1f7a6ee738457b88"

URI_x86_64_v2_ghc9.0-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-unix-doc-2.7.2.2-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-unix-doc}"
SRC_URI[x86_64_v2_ghc9.0-unix-doc.sha256sum] = "cacc7d7bf43ebc6176a711d0e87d567b190e4d7b7f07bc5aa243f4930ddacaea"

URI_x86_64_v2_ghc9.0-unix-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-unix-prof-2.7.2.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-unix-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-unix-prof}"
SRC_URI[x86_64_v2_ghc9.0-unix-prof.sha256sum] = "4ad31cba708c69d562bd275c787a2e459f20cc400d7de5ea74c03ac86a04bb5e"

URI_x86_64_v2_ghc9.0-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-xhtml-3000.2.2.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-xhtml}"
SRC_URI[x86_64_v2_ghc9.0-xhtml.sha256sum] = "26de28b626cf40a827b91f895228edbc8fdec3806e0d2c1eacdda4fe067d1b55"

URI_x86_64_v2_ghc9.0-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-xhtml-devel-3000.2.2.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.0-xhtml-devel.sha256sum] = "ab3d41a3f60562cb806cb3d69b16dd03342e25c9a50738fafcb863815934d1d0"

URI_x86_64_v2_ghc9.0-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-xhtml-doc-3000.2.2.1-20.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.0-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.0-xhtml-doc.sha256sum] = "5c8cb653f9b730e20f89b4f6a362054eada8c7fb308ffabcbc278d792c222bcf"

URI_x86_64_v2_ghc9.0-xhtml-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.0-xhtml-prof-3000.2.2.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.0-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.0-xhtml-prof}"
SRC_URI[x86_64_v2_ghc9.0-xhtml-prof.sha256sum] = "02c2323fd6f38c56af4a599f495bfaf02f07f12f55f92b9b8df9db423eac384b"

URI_aarch64_ghc9.0 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0}"
SRC_URI[aarch64_ghc9.0.sha256sum] = "3f02beb1063e0d02e4842a0d73409f0b9431d1371dc3dd7529f938552993502f"

URI_aarch64_ghc9.0-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-Cabal-3.4.1.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-Cabal}"
SRC_URI[aarch64_ghc9.0-Cabal.sha256sum] = "5151051ce7eebcd351f924002c12b5030560415221f2cbede8209407be48a1e3"

URI_aarch64_ghc9.0-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-Cabal-devel-3.4.1.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-Cabal-devel}"
SRC_URI[aarch64_ghc9.0-Cabal-devel.sha256sum] = "ebbae74c7c6d6928793773856dda9beb63966e7d4775ce4180e5905ed45f97f4"

URI_aarch64_ghc9.0-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-Cabal-doc-3.4.1.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-Cabal-doc}"
SRC_URI[aarch64_ghc9.0-Cabal-doc.sha256sum] = "51faf7236d75e74fb08cb5516c584e1cc28ef7e5e856ae26caea8334c0ad1316"

URI_aarch64_ghc9.0-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-Cabal-prof-3.4.1.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-Cabal-prof}"
SRC_URI[aarch64_ghc9.0-Cabal-prof.sha256sum] = "bdb648a4fec3234c7d8562f5795b75b6227e04f04424f6d610407eea5b81376f"

URI_aarch64_ghc9.0-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-array-0.5.4.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-array}"
SRC_URI[aarch64_ghc9.0-array.sha256sum] = "b1b03b3f667531ce616a933b97c7c854e8d51b2e5490f621fdc827a207a0512c"

URI_aarch64_ghc9.0-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-array-devel-0.5.4.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-array-devel}"
SRC_URI[aarch64_ghc9.0-array-devel.sha256sum] = "ae91b50809f443a62032d17acde836b800751a6ba62ebf7337b6422ff22e02d7"

URI_aarch64_ghc9.0-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-array-doc-0.5.4.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-array-doc}"
SRC_URI[aarch64_ghc9.0-array-doc.sha256sum] = "765a532e76e61a6516ec08d5a20be8746667b7ed249e985e89b1b4aebf4a7361"

URI_aarch64_ghc9.0-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-array-prof-0.5.4.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-array-prof}"
SRC_URI[aarch64_ghc9.0-array-prof.sha256sum] = "92c380f073f65cce0827164b6abb5d6d10c64155b85b177943fd7ec0d98180d2"

URI_aarch64_ghc9.0-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-base-4.15.1.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-base}"
SRC_URI[aarch64_ghc9.0-base.sha256sum] = "178b94bf2f331d5dfcc8ce3f9494332ada9afc9e40a7c830d130ede62fcd878c"

URI_aarch64_ghc9.0-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-base-devel-4.15.1.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-base-devel}"
SRC_URI[aarch64_ghc9.0-base-devel.sha256sum] = "a43271094f31d0517258773507a988cf57c4c1826d6077bd6017f3145993cb2d"

URI_aarch64_ghc9.0-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-base-doc-4.15.1.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-base-doc}"
SRC_URI[aarch64_ghc9.0-base-doc.sha256sum] = "22de79f71aef816912c5fd399f78485e0b0b962b96a125ed089ee4bcd89b3d6f"

URI_aarch64_ghc9.0-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-base-prof-4.15.1.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-base-prof}"
SRC_URI[aarch64_ghc9.0-base-prof.sha256sum] = "71c5cbc46e3e3cf6e0a88aedc0633236c0783bdbb8f3db51a6a9dd7da89732ce"

URI_aarch64_ghc9.0-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-binary-0.8.8.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-binary}"
SRC_URI[aarch64_ghc9.0-binary.sha256sum] = "57aa7b3edeae6aa2c7023da077dd88ecc912cbe26637fea4dcefd1110920fe40"

URI_aarch64_ghc9.0-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-binary-devel-0.8.8.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-binary-devel}"
SRC_URI[aarch64_ghc9.0-binary-devel.sha256sum] = "f557cb2d954f200c67d6d148f190b7303fd784a0d9e52c46a1674ba40c1d42d2"

URI_aarch64_ghc9.0-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-binary-doc-0.8.8.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-binary-doc}"
SRC_URI[aarch64_ghc9.0-binary-doc.sha256sum] = "f80d7fd83f96812a077a44dd0b3da42f736f6a2a2b1eef79908db072de1b4b77"

URI_aarch64_ghc9.0-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-binary-prof-0.8.8.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-binary-prof}"
SRC_URI[aarch64_ghc9.0-binary-prof.sha256sum] = "cf8396ddaa60235c4ba4449c0ae6d687c03c6ab97bb7286effef1e1c51cd4171"

URI_aarch64_ghc9.0-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-bytestring-0.10.12.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-bytestring}"
SRC_URI[aarch64_ghc9.0-bytestring.sha256sum] = "fef4040ac30acd8987b9294e24d46b9c04db6c705cda5d0dd1eda2165d0f5cc7"

URI_aarch64_ghc9.0-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-bytestring-devel-0.10.12.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-bytestring-devel}"
SRC_URI[aarch64_ghc9.0-bytestring-devel.sha256sum] = "c0e15f687be16adf4326cb8adf4b81ead3d1121f0ac2de2620ba5970da4b17a6"

URI_aarch64_ghc9.0-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-bytestring-doc-0.10.12.1-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-bytestring-doc}"
SRC_URI[aarch64_ghc9.0-bytestring-doc.sha256sum] = "f316be715032b11d28f2dfa034cadd4f83fea9d0191c6c3cd573e13ba95b8d4e"

URI_aarch64_ghc9.0-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-bytestring-prof-0.10.12.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-bytestring-prof}"
SRC_URI[aarch64_ghc9.0-bytestring-prof.sha256sum] = "17b162220b77815d2e6b98e134b6ec33cb7a9bcbbe72cd581b8e40bfc4f7d326"

URI_aarch64_ghc9.0-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-compiler-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-compiler}"
SRC_URI[aarch64_ghc9.0-compiler.sha256sum] = "6c64eb1019021436eb518718ade0a8a07b96e0888ef7a4888c050e028d6a850f"

URI_aarch64_ghc9.0-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-compiler-default-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-compiler-default}"
SRC_URI[aarch64_ghc9.0-compiler-default.sha256sum] = "377c8775d8d29d68582aeec9af1587966b678041159813a6c9d521c253042354"

URI_aarch64_ghc9.0-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-containers-0.6.4.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-containers}"
SRC_URI[aarch64_ghc9.0-containers.sha256sum] = "2f9461c182985b815aa408d12fa137a1d5c5ab0ea0578f98a82bfa3f0a0aeee7"

URI_aarch64_ghc9.0-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-containers-devel-0.6.4.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-containers-devel}"
SRC_URI[aarch64_ghc9.0-containers-devel.sha256sum] = "234899d15df9bfba00c9582178c1a2eb43f1cefb58a469491f8074d001fff52a"

URI_aarch64_ghc9.0-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-containers-doc-0.6.4.1-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-containers-doc}"
SRC_URI[aarch64_ghc9.0-containers-doc.sha256sum] = "1748bbcf50a973947b678f0bc8f4180db90a780fb2caaba92e5ef487e5fc1bf7"

URI_aarch64_ghc9.0-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-containers-prof-0.6.4.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-containers-prof}"
SRC_URI[aarch64_ghc9.0-containers-prof.sha256sum] = "2b8149d28261b6166a3c73148eb95f2dd9688c697a1abeaacc60baa4e5b2e3e7"

URI_aarch64_ghc9.0-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-deepseq-1.4.5.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-deepseq}"
SRC_URI[aarch64_ghc9.0-deepseq.sha256sum] = "a354900ef41426035a2f3ef58d03550a95f8182332a9f8b15d1ef4432f1ac21c"

URI_aarch64_ghc9.0-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-deepseq-devel-1.4.5.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-deepseq-devel}"
SRC_URI[aarch64_ghc9.0-deepseq-devel.sha256sum] = "2df8f6094b3a75f04e7b139b503ac7e58a4af3a74c84f85b52555e6dbff42ead"

URI_aarch64_ghc9.0-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-deepseq-doc-1.4.5.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-deepseq-doc}"
SRC_URI[aarch64_ghc9.0-deepseq-doc.sha256sum] = "eecf096123d27f7f4f1b5f567fb38cc7df0d473ab6e74f7af94f30a86fa70cf1"

URI_aarch64_ghc9.0-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-deepseq-prof-1.4.5.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-deepseq-prof}"
SRC_URI[aarch64_ghc9.0-deepseq-prof.sha256sum] = "cf164d2f45c0aa4665faffb7b372f5e8acca127eef14b4cfd41fde2517e245e5"

URI_aarch64_ghc9.0-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-devel-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-devel}"
SRC_URI[aarch64_ghc9.0-devel.sha256sum] = "813a3210a97a23067c3f5adc46fc53b8ce7f703901a7f40e86a766df6c316315"

URI_aarch64_ghc9.0-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-directory-1.3.6.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-directory}"
SRC_URI[aarch64_ghc9.0-directory.sha256sum] = "0b220a37f71fef7ab9097fbcbd3422e6a3ff8c7ab601df6658945220be2b5792"

URI_aarch64_ghc9.0-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-directory-devel-1.3.6.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-directory-devel}"
SRC_URI[aarch64_ghc9.0-directory-devel.sha256sum] = "c62dc58a1a6b3107c54aba7625744660ea2c6c0a1f8f90fe4761e5b81ed012ab"

URI_aarch64_ghc9.0-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-directory-doc-1.3.6.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-directory-doc}"
SRC_URI[aarch64_ghc9.0-directory-doc.sha256sum] = "a73e3fec5227a70711b09d12f324115d46d18bf8fb82a885ea1ee5b9ed15ee6f"

URI_aarch64_ghc9.0-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-directory-prof-1.3.6.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-directory-prof}"
SRC_URI[aarch64_ghc9.0-directory-prof.sha256sum] = "e69aa4203b37714bd19237fd89a9814fbed0acf6bc628177efa559b76d7737b1"

URI_aarch64_ghc9.0-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-doc-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-doc}"
SRC_URI[aarch64_ghc9.0-doc.sha256sum] = "3aeb956268cc0564332c67dfbe8bd6107422b28801d1294c7733c47a06e643b4"

URI_aarch64_ghc9.0-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-doc-index-9.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-doc-index}"
SRC_URI[aarch64_ghc9.0-doc-index.sha256sum] = "9abb7c1cdec1ef4e82e5e9e2604dbc0e3b6bc857877438f11f72ba07819ebf9a"

URI_aarch64_ghc9.0-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-exceptions-0.10.4-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-exceptions}"
SRC_URI[aarch64_ghc9.0-exceptions.sha256sum] = "35dff94c3cfe5e61e67ff9bca7508a036bdeaa964ff8973d22749e4cba6e9db4"

URI_aarch64_ghc9.0-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-exceptions-devel-0.10.4-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-exceptions-devel}"
SRC_URI[aarch64_ghc9.0-exceptions-devel.sha256sum] = "5ccf15c4926d9a89483a44cf9600c5640af432d4e7bb152ede5d19a4d07b8575"

URI_aarch64_ghc9.0-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-exceptions-doc-0.10.4-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-exceptions-doc}"
SRC_URI[aarch64_ghc9.0-exceptions-doc.sha256sum] = "f833b46ca9e07f74955bb6939fc1233279b7db82444eb0379662e844aa40a8e5"

URI_aarch64_ghc9.0-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-exceptions-prof-0.10.4-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-exceptions-prof}"
SRC_URI[aarch64_ghc9.0-exceptions-prof.sha256sum] = "5fd2fd9c2ae3878be875a76037be5889b68a7279d27507b532218834172a80e3"

URI_aarch64_ghc9.0-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-filepath-1.4.2.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-filepath}"
SRC_URI[aarch64_ghc9.0-filepath.sha256sum] = "6c51881ca19e7a249cff668ebd2f1303b88d709a0292c21c1da22dc2da99b75f"

URI_aarch64_ghc9.0-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-filepath-devel-1.4.2.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-filepath-devel}"
SRC_URI[aarch64_ghc9.0-filepath-devel.sha256sum] = "17669db0878220c1c083a1089d068594ffd072180b8df14e1a7cf212daa875e3"

URI_aarch64_ghc9.0-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-filepath-doc-1.4.2.1-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-filepath-doc}"
SRC_URI[aarch64_ghc9.0-filepath-doc.sha256sum] = "5525cde9e50c462a1318c260f153aa3712d5d439f3c9e767050d6a3cd95c2449"

URI_aarch64_ghc9.0-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-filepath-prof-1.4.2.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-filepath-prof}"
SRC_URI[aarch64_ghc9.0-filepath-prof.sha256sum] = "d70b040e6edaf92ec9a1372a8d46b766346dbc41e522287d768bac6e6ee97b37"

URI_aarch64_ghc9.0-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-filesystem-9.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-filesystem}"
SRC_URI[aarch64_ghc9.0-filesystem.sha256sum] = "2b1662ba1ee6282afda51b4962893bd5894b94d913d1d9e722919aa3a12ac9b7"

URI_aarch64_ghc9.0-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc}"
SRC_URI[aarch64_ghc9.0-ghc.sha256sum] = "b215de5d9c35aff14e59d39cf9617ddee8545e5398350a9b9ccaa4566ebc133c"

URI_aarch64_ghc9.0-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-bignum-1.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-bignum}"
SRC_URI[aarch64_ghc9.0-ghc-bignum.sha256sum] = "9c1a8b8d5e631ec33037a1b72f3cbeca10ee42c57a8b82e25c857776edcf9356"

URI_aarch64_ghc9.0-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-bignum-devel-1.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.0-ghc-bignum-devel.sha256sum] = "992b84886bc63b6ee51d7698bac79eebdf3d29d6842cfdc0be1bf97e750227d7"

URI_aarch64_ghc9.0-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-bignum-doc-1.1-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.0-ghc-bignum-doc.sha256sum] = "2ad5aa521a6eb61e9a8df6c7ec384625c0920a902eb504b9554d6012337dd4c4"

URI_aarch64_ghc9.0-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-bignum-prof-1.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.0-ghc-bignum-prof.sha256sum] = "66bff622ff15a3bff5217cbf3769d548ac7a2dc7dad763eba63b3ebe16b651ad"

URI_aarch64_ghc9.0-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-boot-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-boot}"
SRC_URI[aarch64_ghc9.0-ghc-boot.sha256sum] = "c516c3916a9440037753d70c9549f6e862be863febee49d5a7100d16772e7ded"

URI_aarch64_ghc9.0-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-boot-devel-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.0-ghc-boot-devel.sha256sum] = "b8633a5d744c510b6323ce1220d0e9cf3c80e4472a46f5323238e01b6515f651"

URI_aarch64_ghc9.0-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-boot-doc-9.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.0-ghc-boot-doc.sha256sum] = "7440f024b59218c395922095bed222959e23ace29f222925a38eb8e9a6b75d43"

URI_aarch64_ghc9.0-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-boot-prof-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.0-ghc-boot-prof.sha256sum] = "720423edcc1a97dafc97e1f49c184d6fab1d4d68c0056dbfa0e7afa32bd41310"

URI_aarch64_ghc9.0-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-boot-th-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-boot-th}"
SRC_URI[aarch64_ghc9.0-ghc-boot-th.sha256sum] = "f7b19d9fe84ad0836c5c17449677197b0b0f7b557c1fa9f40a05c7a3dfc6c857"

URI_aarch64_ghc9.0-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-boot-th-devel-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.0-ghc-boot-th-devel.sha256sum] = "6428dd614b9a6391fd08addfac49315ff915483d92f9f657ec0000a1ef23ccdf"

URI_aarch64_ghc9.0-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-boot-th-doc-9.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.0-ghc-boot-th-doc.sha256sum] = "59d0acb1c2bf90c8ad27b18639c42af1aeddbc1cbf2961cd5f1033341b847ae3"

URI_aarch64_ghc9.0-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-boot-th-prof-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.0-ghc-boot-th-prof.sha256sum] = "f3f8f92b9408927a469907a7b0e86dd5688c3dc33191d7682f0bca167fd8445d"

URI_aarch64_ghc9.0-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-compact-0.1.0.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-compact}"
SRC_URI[aarch64_ghc9.0-ghc-compact.sha256sum] = "a76b1c7c7539512e2510ad62b83d1d9879b4fcb9385d8fe8a23a19c2e8192f07"

URI_aarch64_ghc9.0-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-compact-devel-0.1.0.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.0-ghc-compact-devel.sha256sum] = "d93f31ba19914fdba75753e8c55b71d26830433419d2fcf347ff595c77466196"

URI_aarch64_ghc9.0-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-compact-doc-0.1.0.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.0-ghc-compact-doc.sha256sum] = "b878dce9456123b0ac1474e750688605914cd0a13501aa0b41b417ad116d9668"

URI_aarch64_ghc9.0-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-compact-prof-0.1.0.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.0-ghc-compact-prof.sha256sum] = "6f8562d3ab8d9d9c18632755445e8b5ae7a9731ab84f718dcf43ca35fbe4f78f"

URI_aarch64_ghc9.0-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-devel-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-devel}"
SRC_URI[aarch64_ghc9.0-ghc-devel.sha256sum] = "8789c884160e657bc57c68cf361dba09c020d5a1ff8037544978c09c5df7168a"

URI_aarch64_ghc9.0-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-doc-9.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-doc}"
SRC_URI[aarch64_ghc9.0-ghc-doc.sha256sum] = "b2e14495d3128674a8489ae3d6cf2432feb397151c4a25a5e970a92163616e17"

URI_aarch64_ghc9.0-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-heap-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-heap}"
SRC_URI[aarch64_ghc9.0-ghc-heap.sha256sum] = "27981a2127f3ce73d53d7bac154479a751682843b2ece6a93cef778a45fd6729"

URI_aarch64_ghc9.0-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-heap-devel-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.0-ghc-heap-devel.sha256sum] = "25788af6c3098f09d9f824def5ba51d1582b0dd812408909dd0eb37510e36c32"

URI_aarch64_ghc9.0-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-heap-doc-9.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.0-ghc-heap-doc.sha256sum] = "9cbd9c6ce597d3ca83730d2c2c7b215483c2fdcf2e3581b918a3be1187528dce"

URI_aarch64_ghc9.0-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-heap-prof-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.0-ghc-heap-prof.sha256sum] = "190fb6fc80be659ebe794637c91bbbce73952ac006da248127b49c9dbd80c0fc"

URI_aarch64_ghc9.0-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghc-prof-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghc-prof}"
SRC_URI[aarch64_ghc9.0-ghc-prof.sha256sum] = "b5be72f8d49d78a8977cb17627f65abcfcd47be14fda652f7e0d6a379fe8e724"

URI_aarch64_ghc9.0-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghci-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghci}"
SRC_URI[aarch64_ghc9.0-ghci.sha256sum] = "9fdf5861e1a6fe66cf26527c721c5ed1e931d819e1b9c9d0baa35c5ed92f10b6"

URI_aarch64_ghc9.0-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghci-devel-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghci-devel}"
SRC_URI[aarch64_ghc9.0-ghci-devel.sha256sum] = "ba4b24a7276a4e04307efd1282bad61ea0c715227e7dbb4fe62fc0af172ca0b1"

URI_aarch64_ghc9.0-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghci-doc-9.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghci-doc}"
SRC_URI[aarch64_ghc9.0-ghci-doc.sha256sum] = "ecf8ffba04c8e56620780a9d0c7c26dec8ce9b07974300b070f09ff30e727a84"

URI_aarch64_ghc9.0-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-ghci-prof-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-ghci-prof}"
SRC_URI[aarch64_ghc9.0-ghci-prof.sha256sum] = "c9427db774627f9945c4164a62af785a64f6b96910d7fbb2c6f1214a52dfa1b5"

URI_aarch64_ghc9.0-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-haskeline-0.8.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-haskeline}"
SRC_URI[aarch64_ghc9.0-haskeline.sha256sum] = "ff9b95593e3829d48e2719ae3d2d94a3571dc94ff40abeef73256ddd25e29d2f"

URI_aarch64_ghc9.0-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-haskeline-devel-0.8.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-haskeline-devel}"
SRC_URI[aarch64_ghc9.0-haskeline-devel.sha256sum] = "5dd6a375030da4b3a590a239b1ef9be8ba51b7aa67332fc00af8641bc216f230"

URI_aarch64_ghc9.0-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-haskeline-doc-0.8.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-haskeline-doc}"
SRC_URI[aarch64_ghc9.0-haskeline-doc.sha256sum] = "e875b691fb50b88a180bcd24aa27e760cd35b2f5f7a96caaf1ad3a13fc3b6530"

URI_aarch64_ghc9.0-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-haskeline-prof-0.8.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-haskeline-prof}"
SRC_URI[aarch64_ghc9.0-haskeline-prof.sha256sum] = "c40dcd46181350a6014c67074d750a7b311cd16d59abc48610eb55976a1da612"

URI_aarch64_ghc9.0-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-hpc-0.6.1.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-hpc}"
SRC_URI[aarch64_ghc9.0-hpc.sha256sum] = "dcbb5996bdcdd103366f6ba7ecbd6d6c61a9a44abc5e55e2d5148afd0476071d"

URI_aarch64_ghc9.0-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-hpc-devel-0.6.1.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-hpc-devel}"
SRC_URI[aarch64_ghc9.0-hpc-devel.sha256sum] = "569cf33739578ef320b03f89141f70ed82a303e78b866d6109afa7d6b7a2a252"

URI_aarch64_ghc9.0-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-hpc-doc-0.6.1.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-hpc-doc}"
SRC_URI[aarch64_ghc9.0-hpc-doc.sha256sum] = "5f210acce7945413492d4549d5f160a5c688b453ae06919bf61a16ea1c9e200f"

URI_aarch64_ghc9.0-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-hpc-prof-0.6.1.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-hpc-prof}"
SRC_URI[aarch64_ghc9.0-hpc-prof.sha256sum] = "300ddcbfc8ef226d627446e0bd4c9a8472c926335eb9c7d6a08885777e8111d9"

URI_aarch64_ghc9.0-libiserv = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-libiserv-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-libiserv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-libiserv}"
SRC_URI[aarch64_ghc9.0-libiserv.sha256sum] = "640f7c8b7a790752bf1703eedb0a119bfb8f75ea89dd750890e0957108ad0d87"

URI_aarch64_ghc9.0-libiserv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-libiserv-devel-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-libiserv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-libiserv-devel}"
SRC_URI[aarch64_ghc9.0-libiserv-devel.sha256sum] = "f07eb1dff9adb538c65949d7b6f5c6b7078995280dd8359725936c575d70f181"

URI_aarch64_ghc9.0-libiserv-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-libiserv-doc-9.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-libiserv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-libiserv-doc}"
SRC_URI[aarch64_ghc9.0-libiserv-doc.sha256sum] = "68b2ef52f22373182f222c5c8eb409e37033fe296342f999ea06b915d92bdc82"

URI_aarch64_ghc9.0-libiserv-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-libiserv-prof-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-libiserv-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-libiserv-prof}"
SRC_URI[aarch64_ghc9.0-libiserv-prof.sha256sum] = "b6be487d5bec9c9260487a1e994b6a06d487934378ba036b8488c5f14363ece2"

URI_aarch64_ghc9.0-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-manual-9.0.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-manual}"
SRC_URI[aarch64_ghc9.0-manual.sha256sum] = "4443e4df2ae8b7fff1f84c5a8b296e4ea6ed2410f0c4880fd3de1bd4526a86f7"

URI_aarch64_ghc9.0-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-mtl-2.2.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-mtl}"
SRC_URI[aarch64_ghc9.0-mtl.sha256sum] = "22e7bc7e8ca4b037694882409596c8c34abd8b5bcdd3dfdf4771dd8616604cc1"

URI_aarch64_ghc9.0-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-mtl-devel-2.2.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-mtl-devel}"
SRC_URI[aarch64_ghc9.0-mtl-devel.sha256sum] = "540ea9eeb76a150ebb78a32ac8bd899e0e672f7e3e493211aa2e3b5defb459c5"

URI_aarch64_ghc9.0-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-mtl-doc-2.2.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-mtl-doc}"
SRC_URI[aarch64_ghc9.0-mtl-doc.sha256sum] = "071c8a86a5f480e4768d0bc38ca6aff9d31c8e1e52203fe985929cc3a24fb5de"

URI_aarch64_ghc9.0-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-mtl-prof-2.2.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-mtl-prof}"
SRC_URI[aarch64_ghc9.0-mtl-prof.sha256sum] = "960af92c2cac90155308b1029d7bfac375f615e874e0d9d49280fd7571abf58d"

URI_aarch64_ghc9.0-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-parsec-3.1.14.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-parsec}"
SRC_URI[aarch64_ghc9.0-parsec.sha256sum] = "cec099881dc666b4e230c4c3dc35cd59166244427505f41b35f4101bf7e04fa0"

URI_aarch64_ghc9.0-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-parsec-devel-3.1.14.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-parsec-devel}"
SRC_URI[aarch64_ghc9.0-parsec-devel.sha256sum] = "dd2af97cd0906d1fc725c8b2028d46e6d8d4a5245732f067053a4a84fbdf30f1"

URI_aarch64_ghc9.0-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-parsec-doc-3.1.14.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-parsec-doc}"
SRC_URI[aarch64_ghc9.0-parsec-doc.sha256sum] = "9a46a4f837a650f6fa7108af6f5a3e32a156ac2e79d0f08caa1b3c8546a7ac9d"

URI_aarch64_ghc9.0-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-parsec-prof-3.1.14.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-parsec-prof}"
SRC_URI[aarch64_ghc9.0-parsec-prof.sha256sum] = "006f4ae16a8efde4d2cde351518e8a15bf6d82f3b78f91548c3a7d17f58737b4"

URI_aarch64_ghc9.0-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-pretty-1.1.3.6-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-pretty}"
SRC_URI[aarch64_ghc9.0-pretty.sha256sum] = "0b57562752d7f70f81d28513fcf87faaf2508ef385f7dd9b924615e1f1ce1231"

URI_aarch64_ghc9.0-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-pretty-devel-1.1.3.6-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-pretty-devel}"
SRC_URI[aarch64_ghc9.0-pretty-devel.sha256sum] = "c2b40a1842ab2d41010b880e484b4e39da72cefa7e41a218f2a5b8ae3fbdb397"

URI_aarch64_ghc9.0-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-pretty-doc-1.1.3.6-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-pretty-doc}"
SRC_URI[aarch64_ghc9.0-pretty-doc.sha256sum] = "b02faa83c3df33e41981fb48c866323c3297687085ea424e048dd2b8381cf840"

URI_aarch64_ghc9.0-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-pretty-prof-1.1.3.6-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-pretty-prof}"
SRC_URI[aarch64_ghc9.0-pretty-prof.sha256sum] = "ff179df4501734e2f5b316dbeca80100c8deb37d4c0df1f2c055ed54455100f5"

URI_aarch64_ghc9.0-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-process-1.6.13.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-process}"
SRC_URI[aarch64_ghc9.0-process.sha256sum] = "92f0c22d54649640d476ac1bf84ac4e1078bc2a54eae1f5c69f23236df6ec724"

URI_aarch64_ghc9.0-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-process-devel-1.6.13.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-process-devel}"
SRC_URI[aarch64_ghc9.0-process-devel.sha256sum] = "4a58055e221650b234350b56d72c4a9f7e44a9a582c9c7e68301006d36b3f6b5"

URI_aarch64_ghc9.0-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-process-doc-1.6.13.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-process-doc}"
SRC_URI[aarch64_ghc9.0-process-doc.sha256sum] = "7bb45b4034132e26ac94811f0cafeb19a9e3e4c60e4a5df331ef4d80ab5fecba"

URI_aarch64_ghc9.0-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-process-prof-1.6.13.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-process-prof}"
SRC_URI[aarch64_ghc9.0-process-prof.sha256sum] = "7f213df7ccfe3b440e7291d6586274fc89198791fc744fcb3658b6dce726f730"

URI_aarch64_ghc9.0-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-prof-9.0.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-prof}"
SRC_URI[aarch64_ghc9.0-prof.sha256sum] = "cb16f00459e17611bdfae53991b2b78ddf95f7a08710a8fa316d2c2f2db023f2"

URI_aarch64_ghc9.0-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-stm-2.5.0.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-stm}"
SRC_URI[aarch64_ghc9.0-stm.sha256sum] = "5fb4b97e151cb7368b66fa973654db4faca0cf33586bbb9be2ef4681784f0c83"

URI_aarch64_ghc9.0-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-stm-devel-2.5.0.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-stm-devel}"
SRC_URI[aarch64_ghc9.0-stm-devel.sha256sum] = "f7d00b37c64d87462b47f9691f4933466f9ff2da9af2396a26022bb91225726a"

URI_aarch64_ghc9.0-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-stm-doc-2.5.0.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-stm-doc}"
SRC_URI[aarch64_ghc9.0-stm-doc.sha256sum] = "445e42c156d18bbdf0a9d75e2e5f599195d5b07bd612709f9dabeed2b39c348f"

URI_aarch64_ghc9.0-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-stm-prof-2.5.0.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-stm-prof}"
SRC_URI[aarch64_ghc9.0-stm-prof.sha256sum] = "b3cbed4594a68f219cc0f6a78678f894f5a7f04ae2d9ca754994f2c2a8e2c6cb"

URI_aarch64_ghc9.0-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-template-haskell-2.17.0.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-template-haskell}"
SRC_URI[aarch64_ghc9.0-template-haskell.sha256sum] = "b10a8d2b54a5ed4191ea7aa88059e63539de0e0f42420fb859ec0f0888b45328"

URI_aarch64_ghc9.0-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-template-haskell-devel-2.17.0.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-template-haskell-devel}"
SRC_URI[aarch64_ghc9.0-template-haskell-devel.sha256sum] = "173b8b7db01732c66727485766015e4384082664ac2e6bec1e475f24a083e471"

URI_aarch64_ghc9.0-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-template-haskell-doc-2.17.0.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-template-haskell-doc}"
SRC_URI[aarch64_ghc9.0-template-haskell-doc.sha256sum] = "00546c8a7bd35e519e3c71ca5df9b8180a7d49576c22708df677f421204b30a2"

URI_aarch64_ghc9.0-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-template-haskell-prof-2.17.0.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-template-haskell-prof}"
SRC_URI[aarch64_ghc9.0-template-haskell-prof.sha256sum] = "54ea41b9447af0e6c9ed24ee828aab822cad865f5d3841b4cd21934392d22cbc"

URI_aarch64_ghc9.0-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-terminfo-0.4.1.5-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-terminfo}"
SRC_URI[aarch64_ghc9.0-terminfo.sha256sum] = "2134ebb6648a1f36ad957160a13ece95cc53710fe20658b93114c4601a29ae59"

URI_aarch64_ghc9.0-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-terminfo-devel-0.4.1.5-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-terminfo-devel}"
SRC_URI[aarch64_ghc9.0-terminfo-devel.sha256sum] = "02c95cb75b73dbb4f4d98e6bb587f1ab7560727467ef958578d3df6bc7454f4d"

URI_aarch64_ghc9.0-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-terminfo-doc-0.4.1.5-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-terminfo-doc}"
SRC_URI[aarch64_ghc9.0-terminfo-doc.sha256sum] = "3482345ff771b2095dd5bb991df1e11b071eba8292a49e456de60bb3c363df24"

URI_aarch64_ghc9.0-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-terminfo-prof-0.4.1.5-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-terminfo-prof}"
SRC_URI[aarch64_ghc9.0-terminfo-prof.sha256sum] = "ce9f1e960d2ff161edc432ca1c8b7af969b2650156e7ad98b207034204ab2884"

URI_aarch64_ghc9.0-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-text-1.2.5.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-text}"
SRC_URI[aarch64_ghc9.0-text.sha256sum] = "2181affd154c507d8aba323aefa786e0b5dc7a780ad053cd40a2047b40fc6b73"

URI_aarch64_ghc9.0-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-text-devel-1.2.5.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-text-devel}"
SRC_URI[aarch64_ghc9.0-text-devel.sha256sum] = "372f96b0ab7f892f826dde885e332ad53784500c8d681a1f968e6efbba59303e"

URI_aarch64_ghc9.0-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-text-doc-1.2.5.0-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-text-doc}"
SRC_URI[aarch64_ghc9.0-text-doc.sha256sum] = "05ee18e609f1d231f9959557dff0a6213936fe8c4ff4b7d2477a8f4745c19468"

URI_aarch64_ghc9.0-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-text-prof-1.2.5.0-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-text-prof}"
SRC_URI[aarch64_ghc9.0-text-prof.sha256sum] = "c1b4c22ad38e5bbe8c036cf6bcb86ac35e9ecb1a499e93a02f6e94937ee3565a"

URI_aarch64_ghc9.0-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-time-1.9.3-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-time}"
SRC_URI[aarch64_ghc9.0-time.sha256sum] = "c6599ae1c7456d92545399e12b0c66f7ef9f7a4c70fa7aeeea7287b4a5f5b97d"

URI_aarch64_ghc9.0-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-time-devel-1.9.3-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-time-devel}"
SRC_URI[aarch64_ghc9.0-time-devel.sha256sum] = "86d35997bfe91e180338a7e8d241941a9e736ff0d0caa5a917c194300cc9b9fd"

URI_aarch64_ghc9.0-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-time-doc-1.9.3-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-time-doc}"
SRC_URI[aarch64_ghc9.0-time-doc.sha256sum] = "d912c4a0e45d5a63106ce547bfd7c76172a3f25ac51700f29622c3fc76bfae0f"

URI_aarch64_ghc9.0-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-time-prof-1.9.3-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-time-prof}"
SRC_URI[aarch64_ghc9.0-time-prof.sha256sum] = "d226c47901a2c13a0f21d15953defa49b94bee3e435820dd0d6f09c518f6c32b"

URI_aarch64_ghc9.0-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-transformers-0.5.6.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-transformers}"
SRC_URI[aarch64_ghc9.0-transformers.sha256sum] = "505b1a8835311fa9dbd8960c100172052b32f2a4373e12a482fc8f6c8d13760d"

URI_aarch64_ghc9.0-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-transformers-devel-0.5.6.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-transformers-devel}"
SRC_URI[aarch64_ghc9.0-transformers-devel.sha256sum] = "e808d2249812e5254264efa8ec272ca37e9de175d4cc438a41e85156f3f44228"

URI_aarch64_ghc9.0-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-transformers-doc-0.5.6.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-transformers-doc}"
SRC_URI[aarch64_ghc9.0-transformers-doc.sha256sum] = "e8124b7c11977293335ec21cfff7d58efdda619e2207fb50db667ae348d7ef95"

URI_aarch64_ghc9.0-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-transformers-prof-0.5.6.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-transformers-prof}"
SRC_URI[aarch64_ghc9.0-transformers-prof.sha256sum] = "f821badf9e418e5dc10d10ce8c4c4fd4ca9f78588b86fe777e2a7ae3ff6027c6"

URI_aarch64_ghc9.0-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-unix-2.7.2.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-unix}"
SRC_URI[aarch64_ghc9.0-unix.sha256sum] = "354829754822749daa25edc6d5e3fd770c8cb874523a7d1e71f977b18aa118c1"

URI_aarch64_ghc9.0-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-unix-devel-2.7.2.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-unix-devel}"
SRC_URI[aarch64_ghc9.0-unix-devel.sha256sum] = "bb98ae7d1f8c99a4b62d929100c6d4b61aa9c7381e07bd841719dfde4703c685"

URI_aarch64_ghc9.0-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-unix-doc-2.7.2.2-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-unix-doc}"
SRC_URI[aarch64_ghc9.0-unix-doc.sha256sum] = "0f7788a2cbf18761f21fe4a53acca7e7510eb8c7e6b44fb27f03e28a0401c7ff"

URI_aarch64_ghc9.0-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-unix-prof-2.7.2.2-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-unix-prof}"
SRC_URI[aarch64_ghc9.0-unix-prof.sha256sum] = "4f8e9b7ccfef6eda99aff455e2446fc41cafe14a39c4b7bcb321c6d8ff978102"

URI_aarch64_ghc9.0-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-xhtml-3000.2.2.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-xhtml}"
SRC_URI[aarch64_ghc9.0-xhtml.sha256sum] = "885f770bc32cb030117995a11b15d31be782dad51ed49c439d1804e6cef37c71"

URI_aarch64_ghc9.0-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-xhtml-devel-3000.2.2.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-xhtml-devel}"
SRC_URI[aarch64_ghc9.0-xhtml-devel.sha256sum] = "3e3163bad7892f0f9b5bab9ad70b7c6fde05e4d987e2a20918a1730e0d2f4340"

URI_aarch64_ghc9.0-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-xhtml-doc-3000.2.2.1-20.el10_0.noarch.rpm;name=aarch64_ghc9.0-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-xhtml-doc}"
SRC_URI[aarch64_ghc9.0-xhtml-doc.sha256sum] = "b6006ef7b7784b3ece7c5f7426f359bdccc2a25651a12c0ce6d59455bff8acae"

URI_aarch64_ghc9.0-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.0-xhtml-prof-3000.2.2.1-20.el10_0.aarch64.rpm;name=aarch64_ghc9.0-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.0-xhtml-prof}"
SRC_URI[aarch64_ghc9.0-xhtml-prof.sha256sum] = "f2aa6c9af0814ce1ea397401d1d38078d237ea4860f24ad474e564c40f105381"

RDEPENDS:ghc9.0 = " \
 ghc9.0-compiler \
 ghc9.0-devel \
 ghc9.0-ghc-boot-devel \
 ghc9.0-ghc-compact-devel \
 ghc9.0-ghc-devel \
 ghc9.0-ghc-heap-devel \
 ghc9.0-ghci-devel \
 ghc9.0-hpc-devel \
 ghc9.0-libiserv-devel \
 "
RDEPENDS:ghc9.0-Cabal = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-binary \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-filepath \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot-th \
 ghc9.0-mtl \
 ghc9.0-parsec \
 ghc9.0-pretty \
 ghc9.0-process \
 ghc9.0-template-haskell \
 ghc9.0-text \
 ghc9.0-time \
 ghc9.0-transformers \
 ghc9.0-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-Cabal-devel = " \
 ghc9.0-Cabal \
 ghc9.0-array-devel \
 ghc9.0-base-devel \
 ghc9.0-binary-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-containers-devel \
 ghc9.0-deepseq-devel \
 ghc9.0-directory-devel \
 ghc9.0-filepath-devel \
 ghc9.0-mtl-devel \
 ghc9.0-parsec-devel \
 ghc9.0-pretty-devel \
 ghc9.0-process-devel \
 ghc9.0-text-devel \
 ghc9.0-time-devel \
 ghc9.0-transformers-devel \
 ghc9.0-unix-devel \
 "
RDEPENDS:ghc9.0-Cabal-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-Cabal-prof = " \
 ghc9.0-Cabal-devel \
 ghc9.0-array-prof \
 ghc9.0-base-prof \
 ghc9.0-binary-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-containers-prof \
 ghc9.0-deepseq-prof \
 ghc9.0-directory-prof \
 ghc9.0-filepath-prof \
 ghc9.0-mtl-prof \
 ghc9.0-parsec-prof \
 ghc9.0-pretty-prof \
 ghc9.0-process-prof \
 ghc9.0-text-prof \
 ghc9.0-time-prof \
 ghc9.0-transformers-prof \
 ghc9.0-unix-prof \
 "
RDEPENDS:ghc9.0-array = " \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-array-devel = " \
 ghc9.0-array \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 "
RDEPENDS:ghc9.0-array-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-array-prof = " \
 ghc9.0-array-devel \
 ghc9.0-base-prof \
 "
RDEPENDS:ghc9.0-base = " \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.0-base-devel = " \
 ghc9.0-base \
 ghc9.0-compiler \
 ghc9.0-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 "
RDEPENDS:ghc9.0-base-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-base-prof = " \
 ghc9.0-base-devel \
 ghc9.0-ghc-bignum-prof \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.0-binary = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-binary-devel = " \
 ghc9.0-array-devel \
 ghc9.0-base-devel \
 ghc9.0-binary \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-containers-devel \
 "
RDEPENDS:ghc9.0-binary-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-binary-prof = " \
 ghc9.0-array-prof \
 ghc9.0-base-prof \
 ghc9.0-binary-devel \
 ghc9.0-bytestring-prof \
 ghc9.0-containers-prof \
 "
RDEPENDS:ghc9.0-bytestring = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-bytestring-devel = " \
 ghc9.0-base-devel \
 ghc9.0-bytestring \
 ghc9.0-compiler \
 ghc9.0-deepseq-devel \
 ghc9.0-ghc-bignum-devel \
 "
RDEPENDS:ghc9.0-bytestring-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-bytestring-prof = " \
 ghc9.0-base-prof \
 ghc9.0-bytestring-devel \
 ghc9.0-deepseq-prof \
 ghc9.0-ghc-bignum-prof \
 "
RDEPENDS:ghc9.0-compiler:x86_64_v2 = " \
 bash \
 binutils-gold \
 gcc \
 ghc9.0-Cabal \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-base-devel \
 ghc9.0-binary \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-exceptions \
 ghc9.0-filepath \
 ghc9.0-filesystem \
 ghc9.0-ghc \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot \
 ghc9.0-ghc-boot-th \
 ghc9.0-ghc-heap \
 ghc9.0-ghci \
 ghc9.0-haskeline \
 ghc9.0-hpc \
 ghc9.0-libiserv \
 ghc9.0-mtl \
 ghc9.0-parsec \
 ghc9.0-pretty \
 ghc9.0-process \
 ghc9.0-stm \
 ghc9.0-template-haskell \
 ghc9.0-terminfo \
 ghc9.0-text \
 ghc9.0-time \
 ghc9.0-transformers \
 ghc9.0-unix \
 ghc9.0-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
"
RDEPENDS:ghc9.0-compiler:aarch64 = " \
 bash \
 binutils-gold \
 gcc \
 ghc9.0-Cabal \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-base-devel \
 ghc9.0-binary \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-exceptions \
 ghc9.0-filepath \
 ghc9.0-filesystem \
 ghc9.0-ghc \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot \
 ghc9.0-ghc-boot-th \
 ghc9.0-ghc-heap \
 ghc9.0-ghci \
 ghc9.0-haskeline \
 ghc9.0-hpc \
 ghc9.0-libiserv \
 ghc9.0-mtl \
 ghc9.0-parsec \
 ghc9.0-pretty \
 ghc9.0-process \
 ghc9.0-stm \
 ghc9.0-template-haskell \
 ghc9.0-terminfo \
 ghc9.0-text \
 ghc9.0-time \
 ghc9.0-transformers \
 ghc9.0-unix \
 ghc9.0-xhtml \
 glibc \
 gmp \
 libffi \
 llvm12 \
 ncurses-libs \
"
RDEPENDS:ghc9.0-compiler-default = " \
 ghc9.0-compiler \
 "
RDEPENDS:ghc9.0-containers = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-containers-devel = " \
 ghc9.0-array-devel \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-containers \
 ghc9.0-deepseq-devel \
 "
RDEPENDS:ghc9.0-containers-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-containers-prof = " \
 ghc9.0-array-prof \
 ghc9.0-base-prof \
 ghc9.0-containers-devel \
 ghc9.0-deepseq-prof \
 "
RDEPENDS:ghc9.0-deepseq = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-deepseq-devel = " \
 ghc9.0-array-devel \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-deepseq \
 "
RDEPENDS:ghc9.0-deepseq-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-deepseq-prof = " \
 ghc9.0-array-prof \
 ghc9.0-base-prof \
 ghc9.0-deepseq-devel \
 "
RDEPENDS:ghc9.0-devel = " \
 ghc9.0-Cabal-devel \
 ghc9.0-array-devel \
 ghc9.0-base-devel \
 ghc9.0-binary-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-containers-devel \
 ghc9.0-deepseq-devel \
 ghc9.0-directory-devel \
 ghc9.0-exceptions-devel \
 ghc9.0-filepath-devel \
 ghc9.0-ghc-boot-th-devel \
 ghc9.0-haskeline-devel \
 ghc9.0-mtl-devel \
 ghc9.0-parsec-devel \
 ghc9.0-pretty-devel \
 ghc9.0-process-devel \
 ghc9.0-stm-devel \
 ghc9.0-template-haskell-devel \
 ghc9.0-terminfo-devel \
 ghc9.0-text-devel \
 ghc9.0-time-devel \
 ghc9.0-transformers-devel \
 ghc9.0-unix-devel \
 ghc9.0-xhtml-devel \
 "
RDEPENDS:ghc9.0-directory = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-bytestring \
 ghc9.0-deepseq \
 ghc9.0-filepath \
 ghc9.0-ghc-bignum \
 ghc9.0-time \
 ghc9.0-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-directory-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-directory \
 ghc9.0-filepath-devel \
 ghc9.0-time-devel \
 ghc9.0-unix-devel \
 "
RDEPENDS:ghc9.0-directory-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-directory-prof = " \
 ghc9.0-base-prof \
 ghc9.0-directory-devel \
 ghc9.0-filepath-prof \
 ghc9.0-time-prof \
 ghc9.0-unix-prof \
 "
RDEPENDS:ghc9.0-doc = " \
 "
RDEPENDS:ghc9.0-doc-index = " \
 bash \
 ghc9.0-compiler \
 "
RDEPENDS:ghc9.0-exceptions = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot-th \
 ghc9.0-mtl \
 ghc9.0-pretty \
 ghc9.0-stm \
 ghc9.0-template-haskell \
 ghc9.0-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-exceptions-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-exceptions \
 ghc9.0-mtl-devel \
 ghc9.0-stm-devel \
 ghc9.0-template-haskell-devel \
 ghc9.0-transformers-devel \
 "
RDEPENDS:ghc9.0-exceptions-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-exceptions-prof = " \
 ghc9.0-base-prof \
 ghc9.0-exceptions-devel \
 ghc9.0-mtl-prof \
 ghc9.0-stm-prof \
 ghc9.0-template-haskell-prof \
 ghc9.0-transformers-prof \
 "
RDEPENDS:ghc9.0-filepath = " \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-filepath-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-filepath \
 "
RDEPENDS:ghc9.0-filepath-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-filepath-prof = " \
 ghc9.0-base-prof \
 ghc9.0-filepath-devel \
 "
RDEPENDS:ghc9.0-filesystem = " \
 "
RDEPENDS:ghc9.0-ghc = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-binary \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-exceptions \
 ghc9.0-filepath \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot \
 ghc9.0-ghc-boot-th \
 ghc9.0-ghc-heap \
 ghc9.0-ghci \
 ghc9.0-hpc \
 ghc9.0-mtl \
 ghc9.0-pretty \
 ghc9.0-process \
 ghc9.0-stm \
 ghc9.0-template-haskell \
 ghc9.0-terminfo \
 ghc9.0-time \
 ghc9.0-transformers \
 ghc9.0-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.0-ghc-bignum = " \
 ghc9.0-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-ghc-bignum-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-ghc-bignum \
 "
RDEPENDS:ghc9.0-ghc-bignum-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-ghc-bignum-prof = " \
 ghc9.0-base-prof \
 ghc9.0-ghc-bignum-devel \
 "
RDEPENDS:ghc9.0-ghc-boot = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-binary \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-filepath \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot-th \
 ghc9.0-time \
 ghc9.0-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-ghc-boot-devel = " \
 ghc9.0-base-devel \
 ghc9.0-binary-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-containers-devel \
 ghc9.0-directory-devel \
 ghc9.0-filepath-devel \
 ghc9.0-ghc-boot \
 ghc9.0-ghc-boot-th-devel \
 "
RDEPENDS:ghc9.0-ghc-boot-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-ghc-boot-prof = " \
 ghc9.0-base-prof \
 ghc9.0-binary-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-containers-prof \
 ghc9.0-directory-prof \
 ghc9.0-filepath-prof \
 ghc9.0-ghc-boot-devel \
 ghc9.0-ghc-boot-th-prof \
 "
RDEPENDS:ghc9.0-ghc-boot-th = " \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-ghc-boot-th-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-ghc-boot-th \
 "
RDEPENDS:ghc9.0-ghc-boot-th-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-ghc-boot-th-prof = " \
 ghc9.0-base-prof \
 ghc9.0-ghc-boot-th-devel \
 "
RDEPENDS:ghc9.0-ghc-compact = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-bytestring \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-ghc-compact-devel = " \
 ghc9.0-base-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-ghc-compact \
 "
RDEPENDS:ghc9.0-ghc-compact-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-ghc-compact-prof = " \
 ghc9.0-base-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-ghc-compact-devel \
 "
RDEPENDS:ghc9.0-ghc-devel = " \
 ghc9.0-array-devel \
 ghc9.0-base-devel \
 ghc9.0-binary-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-containers-devel \
 ghc9.0-deepseq-devel \
 ghc9.0-directory-devel \
 ghc9.0-exceptions-devel \
 ghc9.0-filepath-devel \
 ghc9.0-ghc \
 ghc9.0-ghc-boot-devel \
 ghc9.0-ghc-boot-th-devel \
 ghc9.0-ghc-heap-devel \
 ghc9.0-ghci-devel \
 ghc9.0-hpc-devel \
 ghc9.0-process-devel \
 ghc9.0-template-haskell-devel \
 ghc9.0-terminfo-devel \
 ghc9.0-time-devel \
 ghc9.0-transformers-devel \
 ghc9.0-unix-devel \
 "
RDEPENDS:ghc9.0-ghc-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-ghc-heap = " \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-ghc-heap-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-ghc-heap \
 "
RDEPENDS:ghc9.0-ghc-heap-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-ghc-heap-prof = " \
 ghc9.0-base-prof \
 ghc9.0-ghc-heap-devel \
 "
RDEPENDS:ghc9.0-ghc-prof = " \
 ghc9.0-array-prof \
 ghc9.0-base-prof \
 ghc9.0-binary-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-containers-prof \
 ghc9.0-deepseq-prof \
 ghc9.0-directory-prof \
 ghc9.0-exceptions-prof \
 ghc9.0-filepath-prof \
 ghc9.0-ghc-boot-prof \
 ghc9.0-ghc-boot-th-prof \
 ghc9.0-ghc-devel \
 ghc9.0-ghc-heap-prof \
 ghc9.0-ghci-prof \
 ghc9.0-hpc-prof \
 ghc9.0-process-prof \
 ghc9.0-template-haskell-prof \
 ghc9.0-terminfo-prof \
 ghc9.0-time-prof \
 ghc9.0-transformers-prof \
 ghc9.0-unix-prof \
 "
RDEPENDS:ghc9.0-ghci = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-binary \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-filepath \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot \
 ghc9.0-ghc-boot-th \
 ghc9.0-ghc-heap \
 ghc9.0-pretty \
 ghc9.0-template-haskell \
 ghc9.0-time \
 ghc9.0-transformers \
 ghc9.0-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-ghci-devel = " \
 ghc9.0-array-devel \
 ghc9.0-base-devel \
 ghc9.0-binary-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-containers-devel \
 ghc9.0-deepseq-devel \
 ghc9.0-filepath-devel \
 ghc9.0-ghc-boot-devel \
 ghc9.0-ghc-boot-th-devel \
 ghc9.0-ghc-heap-devel \
 ghc9.0-ghci \
 ghc9.0-template-haskell-devel \
 ghc9.0-transformers-devel \
 ghc9.0-unix-devel \
 "
RDEPENDS:ghc9.0-ghci-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-ghci-prof = " \
 ghc9.0-array-prof \
 ghc9.0-base-prof \
 ghc9.0-binary-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-containers-prof \
 ghc9.0-deepseq-prof \
 ghc9.0-filepath-prof \
 ghc9.0-ghc-boot-prof \
 ghc9.0-ghc-boot-th-prof \
 ghc9.0-ghc-heap-prof \
 ghc9.0-ghci-devel \
 ghc9.0-template-haskell-prof \
 ghc9.0-transformers-prof \
 ghc9.0-unix-prof \
 "
RDEPENDS:ghc9.0-haskeline = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-exceptions \
 ghc9.0-filepath \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot-th \
 ghc9.0-mtl \
 ghc9.0-pretty \
 ghc9.0-process \
 ghc9.0-stm \
 ghc9.0-template-haskell \
 ghc9.0-terminfo \
 ghc9.0-time \
 ghc9.0-transformers \
 ghc9.0-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.0-haskeline-devel = " \
 ghc9.0-base-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-containers-devel \
 ghc9.0-directory-devel \
 ghc9.0-exceptions-devel \
 ghc9.0-filepath-devel \
 ghc9.0-haskeline \
 ghc9.0-process-devel \
 ghc9.0-stm-devel \
 ghc9.0-terminfo-devel \
 ghc9.0-transformers-devel \
 ghc9.0-unix-devel \
 "
RDEPENDS:ghc9.0-haskeline-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-haskeline-prof = " \
 ghc9.0-base-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-containers-prof \
 ghc9.0-directory-prof \
 ghc9.0-exceptions-prof \
 ghc9.0-filepath-prof \
 ghc9.0-haskeline-devel \
 ghc9.0-process-prof \
 ghc9.0-stm-prof \
 ghc9.0-terminfo-prof \
 ghc9.0-transformers-prof \
 ghc9.0-unix-prof \
 "
RDEPENDS:ghc9.0-hpc = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-filepath \
 ghc9.0-ghc-bignum \
 ghc9.0-time \
 ghc9.0-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-hpc-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-containers-devel \
 ghc9.0-deepseq-devel \
 ghc9.0-directory-devel \
 ghc9.0-filepath-devel \
 ghc9.0-hpc \
 ghc9.0-time-devel \
 "
RDEPENDS:ghc9.0-hpc-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-hpc-prof = " \
 ghc9.0-base-prof \
 ghc9.0-containers-prof \
 ghc9.0-deepseq-prof \
 ghc9.0-directory-prof \
 ghc9.0-filepath-prof \
 ghc9.0-hpc-devel \
 ghc9.0-time-prof \
 "
RDEPENDS:ghc9.0-libiserv = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-binary \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-filepath \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot \
 ghc9.0-ghc-boot-th \
 ghc9.0-ghc-heap \
 ghc9.0-ghci \
 ghc9.0-pretty \
 ghc9.0-template-haskell \
 ghc9.0-time \
 ghc9.0-transformers \
 ghc9.0-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-libiserv-devel = " \
 ghc9.0-base-devel \
 ghc9.0-binary-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-containers-devel \
 ghc9.0-deepseq-devel \
 ghc9.0-ghci-devel \
 ghc9.0-libiserv \
 ghc9.0-unix-devel \
 "
RDEPENDS:ghc9.0-libiserv-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-libiserv-prof = " \
 ghc9.0-base-prof \
 ghc9.0-binary-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-containers-prof \
 ghc9.0-deepseq-prof \
 ghc9.0-ghci-prof \
 ghc9.0-libiserv-devel \
 ghc9.0-unix-prof \
 "
RDEPENDS:ghc9.0-manual = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-mtl = " \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 ghc9.0-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-mtl-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-mtl \
 ghc9.0-transformers-devel \
 "
RDEPENDS:ghc9.0-mtl-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-mtl-prof = " \
 ghc9.0-base-prof \
 ghc9.0-mtl-devel \
 ghc9.0-transformers-prof \
 "
RDEPENDS:ghc9.0-parsec = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-binary \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot-th \
 ghc9.0-mtl \
 ghc9.0-pretty \
 ghc9.0-template-haskell \
 ghc9.0-text \
 ghc9.0-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-parsec-devel = " \
 ghc9.0-base-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-mtl-devel \
 ghc9.0-parsec \
 ghc9.0-text-devel \
 "
RDEPENDS:ghc9.0-parsec-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-parsec-prof = " \
 ghc9.0-base-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-mtl-prof \
 ghc9.0-parsec-devel \
 ghc9.0-text-prof \
 "
RDEPENDS:ghc9.0-pretty = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-pretty-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-deepseq-devel \
 ghc9.0-pretty \
 "
RDEPENDS:ghc9.0-pretty-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-pretty-prof = " \
 ghc9.0-base-prof \
 ghc9.0-deepseq-prof \
 ghc9.0-pretty-devel \
 "
RDEPENDS:ghc9.0-process = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-bytestring \
 ghc9.0-deepseq \
 ghc9.0-directory \
 ghc9.0-filepath \
 ghc9.0-ghc-bignum \
 ghc9.0-time \
 ghc9.0-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-process-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-deepseq-devel \
 ghc9.0-directory-devel \
 ghc9.0-filepath-devel \
 ghc9.0-process \
 ghc9.0-unix-devel \
 "
RDEPENDS:ghc9.0-process-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-process-prof = " \
 ghc9.0-base-prof \
 ghc9.0-deepseq-prof \
 ghc9.0-directory-prof \
 ghc9.0-filepath-prof \
 ghc9.0-process-devel \
 ghc9.0-unix-prof \
 "
RDEPENDS:ghc9.0-prof = " \
 ghc9.0-compiler \
 "
RDEPENDS:ghc9.0-stm = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-stm-devel = " \
 ghc9.0-array-devel \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-stm \
 "
RDEPENDS:ghc9.0-stm-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-stm-prof = " \
 ghc9.0-array-prof \
 ghc9.0-base-prof \
 ghc9.0-stm-devel \
 "
RDEPENDS:ghc9.0-template-haskell = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot-th \
 ghc9.0-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-template-haskell-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-ghc-boot-th-devel \
 ghc9.0-pretty-devel \
 ghc9.0-template-haskell \
 "
RDEPENDS:ghc9.0-template-haskell-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-template-haskell-prof = " \
 ghc9.0-base-prof \
 ghc9.0-ghc-boot-th-prof \
 ghc9.0-pretty-prof \
 ghc9.0-template-haskell-devel \
 "
RDEPENDS:ghc9.0-terminfo = " \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.0-terminfo-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.0-terminfo-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-terminfo-prof = " \
 ghc9.0-base-prof \
 ghc9.0-terminfo-devel \
 "
RDEPENDS:ghc9.0-text = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-binary \
 ghc9.0-bytestring \
 ghc9.0-containers \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 ghc9.0-ghc-boot-th \
 ghc9.0-pretty \
 ghc9.0-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-text-devel = " \
 ghc9.0-array-devel \
 ghc9.0-base-devel \
 ghc9.0-binary-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-deepseq-devel \
 ghc9.0-template-haskell-devel \
 ghc9.0-text \
 "
RDEPENDS:ghc9.0-text-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-text-prof = " \
 ghc9.0-array-prof \
 ghc9.0-base-prof \
 ghc9.0-binary-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-deepseq-prof \
 ghc9.0-template-haskell-prof \
 ghc9.0-text-devel \
 "
RDEPENDS:ghc9.0-time = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-time-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-deepseq-devel \
 ghc9.0-time \
 "
RDEPENDS:ghc9.0-time-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-time-prof = " \
 ghc9.0-base-prof \
 ghc9.0-deepseq-prof \
 ghc9.0-time-devel \
 "
RDEPENDS:ghc9.0-transformers = " \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-transformers-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-transformers \
 "
RDEPENDS:ghc9.0-transformers-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-transformers-prof = " \
 ghc9.0-base-prof \
 ghc9.0-transformers-devel \
 "
RDEPENDS:ghc9.0-unix = " \
 ghc9.0-array \
 ghc9.0-base \
 ghc9.0-bytestring \
 ghc9.0-deepseq \
 ghc9.0-ghc-bignum \
 ghc9.0-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-unix-devel = " \
 ghc9.0-base-devel \
 ghc9.0-bytestring-devel \
 ghc9.0-compiler \
 ghc9.0-time-devel \
 ghc9.0-unix \
 "
RDEPENDS:ghc9.0-unix-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-unix-prof = " \
 ghc9.0-base-prof \
 ghc9.0-bytestring-prof \
 ghc9.0-time-prof \
 ghc9.0-unix-devel \
 "
RDEPENDS:ghc9.0-xhtml = " \
 ghc9.0-base \
 ghc9.0-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.0-xhtml-devel = " \
 ghc9.0-base-devel \
 ghc9.0-compiler \
 ghc9.0-xhtml \
 "
RDEPENDS:ghc9.0-xhtml-doc = " \
 ghc9.0-filesystem \
 "
RDEPENDS:ghc9.0-xhtml-prof = " \
 ghc9.0-base-prof \
 ghc9.0-xhtml-devel \
 "
