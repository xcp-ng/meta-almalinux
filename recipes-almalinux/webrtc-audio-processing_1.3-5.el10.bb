# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "webrtc-audio-processing"
PV = "1.3"
PR = "5.el10"
PACKAGES = " \
 webrtc-audio-processing \
 webrtc-audio-processing-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/webrtc-audio-processing-1.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a7ae227a5e30c20ed91da48a95bfff8523e5f9276f15fb6ba36383b4885b716"

URI_x86_64_v2_webrtc-audio-processing = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/webrtc-audio-processing-1.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_webrtc-audio-processing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webrtc-audio-processing}"
SRC_URI[x86_64_v2_webrtc-audio-processing.sha256sum] = "b967141b374c22126a895fdd9b6de9b0a66be9ae9283f1c12df3e974da347bdc"

URI_x86_64_v2_webrtc-audio-processing-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/webrtc-audio-processing-devel-1.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_webrtc-audio-processing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_webrtc-audio-processing-devel}"
SRC_URI[x86_64_v2_webrtc-audio-processing-devel.sha256sum] = "8cb5d4375b0dba17db4252999558c037992cdb04ea9e9cf21339b9d240fdedbd"

URI_aarch64_webrtc-audio-processing = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/webrtc-audio-processing-1.3-5.el10.aarch64.rpm;name=aarch64_webrtc-audio-processing;unpack=0"
SRC_URI:append = " ${URI_aarch64_webrtc-audio-processing}"
SRC_URI[aarch64_webrtc-audio-processing.sha256sum] = "6884311fe7aae20d4a19d143299f49ccb007a239b05d0b52dfddcf16a989dff0"

URI_aarch64_webrtc-audio-processing-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/webrtc-audio-processing-devel-1.3-5.el10.aarch64.rpm;name=aarch64_webrtc-audio-processing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_webrtc-audio-processing-devel}"
SRC_URI[aarch64_webrtc-audio-processing-devel.sha256sum] = "8336851335e5f9700b243216d2254ffd8813ad507fd6577f0fa6e4406459e79d"

RDEPENDS:webrtc-audio-processing = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:webrtc-audio-processing-devel = " \
 pkgconf-pkg-config \
 webrtc-audio-processing \
 "
