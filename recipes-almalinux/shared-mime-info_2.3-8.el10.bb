# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shared-mime-info"
PV = "2.3"
PR = "8.el10"
PACKAGES = " \
 shared-mime-info \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/shared-mime-info-2.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9bac0969617bcb8792bba437ee867b5c1e134f5a6b3c8c2337f355510d02ae02"

URI_x86_64_v2_shared-mime-info = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shared-mime-info-2.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_shared-mime-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shared-mime-info}"
SRC_URI[x86_64_v2_shared-mime-info.sha256sum] = "8295f8ec223ac62f2dcc6065a5d6485bc0a2f3ce848611977659ebc9e314f43a"

URI_aarch64_shared-mime-info = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shared-mime-info-2.3-8.el10.aarch64.rpm;name=aarch64_shared-mime-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_shared-mime-info}"
SRC_URI[aarch64_shared-mime-info.sha256sum] = "643cc71d86e510238226bd6939032481129e2ead3bf200e5d0a8cbc82e710b46"

RDEPENDS:shared-mime-info = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 "
