# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_repr"
PV = "0.1.20"
PR = "1.el10_0"
PACKAGES = " \
 rust-serde_repr+default-devel \
 rust-serde_repr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_repr-0.1.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "089710cbdcde06e05a369ea086fcc61397f16a0e562c0ba39457aced22d4598d"

URI_x86_64_v2_rust-serde_repr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_repr+default-devel-0.1.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_repr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_repr+default-devel}"
SRC_URI[x86_64_v2_rust-serde_repr+default-devel.sha256sum] = "63a36e4957d6c6b2a7b0e3cbfd814748948e602125b777cde6922f8b6d9d2ed8"

URI_x86_64_v2_rust-serde_repr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_repr-devel-0.1.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_repr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_repr-devel}"
SRC_URI[x86_64_v2_rust-serde_repr-devel.sha256sum] = "e471b7ef2753bcf6d1b4b448c5273d9403fda1970114eae2ca7b7d8b6a3e66d4"

URI_aarch64_rust-serde_repr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_repr+default-devel-0.1.20-1.el10_0.noarch.rpm;name=aarch64_rust-serde_repr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_repr+default-devel}"
SRC_URI[aarch64_rust-serde_repr+default-devel.sha256sum] = "319e8b62684a46aa48294a0e64645ec0200620b590bef53bed9c81c881e76cd3"

URI_aarch64_rust-serde_repr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_repr-devel-0.1.20-1.el10_0.noarch.rpm;name=aarch64_rust-serde_repr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_repr-devel}"
SRC_URI[aarch64_rust-serde_repr-devel.sha256sum] = "7197ae8c68a327a58a2826a2eeffd8d6ae876b558a8ecc1f7f23d5e20d411b63"

RDEPENDS:rust-serde_repr+default-devel = " \
 cargo \
 rust-serde_repr-devel \
 "
RDEPENDS:rust-serde_repr-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
