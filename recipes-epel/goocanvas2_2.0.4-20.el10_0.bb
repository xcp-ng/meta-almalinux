# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goocanvas2"
PV = "2.0.4"
PR = "20.el10_0"
PACKAGES = " \
 goocanvas2 \
 goocanvas2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/goocanvas2-2.0.4-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "672bd1c94443aee995da08beac67d0ad74acc5a908ac6b12ea059ea5cb31a9c8"

URI_x86_64_v2_goocanvas2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goocanvas2-2.0.4-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goocanvas2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goocanvas2}"
SRC_URI[x86_64_v2_goocanvas2.sha256sum] = "41cd50f2030eefac5f31ffd241f4d6d1b687534493086b00fb5706995f18c2e3"

URI_x86_64_v2_goocanvas2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goocanvas2-devel-2.0.4-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goocanvas2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goocanvas2-devel}"
SRC_URI[x86_64_v2_goocanvas2-devel.sha256sum] = "a46d3f7d109d3199341f75a3b8d6844e6d337c1b0c40e3cdecdd64ac76bda04a"

URI_aarch64_goocanvas2 = "${EPEL_MIRROR}/aarch64/Packages/g/goocanvas2-2.0.4-20.el10_0.aarch64.rpm;name=aarch64_goocanvas2;unpack=0"
SRC_URI:append = " ${URI_aarch64_goocanvas2}"
SRC_URI[aarch64_goocanvas2.sha256sum] = "3f147549c8c0d3c6d653155a09ee59256dcea8d0363c500c700e1852f046d1c4"

URI_aarch64_goocanvas2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/goocanvas2-devel-2.0.4-20.el10_0.aarch64.rpm;name=aarch64_goocanvas2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_goocanvas2-devel}"
SRC_URI[aarch64_goocanvas2-devel.sha256sum] = "034a4874167331b03b30430c641774129ad4067b3846ae72dd8bfb8716ffadfe"

RDEPENDS:goocanvas2 = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 pango \
 "
RDEPENDS:goocanvas2-devel = " \
 cairo-devel \
 goocanvas2 \
 gtk3-devel \
 pkgconf-pkg-config \
 "
