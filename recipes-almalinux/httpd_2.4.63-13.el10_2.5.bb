# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "httpd"
PV = "2.4.63"
PR = "13.el10_2.5"
PACKAGES = " \
 httpd \
 httpd-core \
 httpd-devel \
 httpd-filesystem \
 httpd-manual \
 httpd-tools \
 mod_ldap \
 mod_lua \
 mod_proxy_html \
 mod_session \
 mod_ssl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/httpd-2.4.63-13.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f8b7cff4140d82fa5d6c940ba4c23565e676120cc496dd3f6dacb9e698d0595"

URI_x86_64_v2_httpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-2.4.63-13.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd}"
SRC_URI[x86_64_v2_httpd.sha256sum] = "79172fd61b2f6680e9923fec8b0fb020fe011c7d065403b7b6ecc778e47feb5c"
RPROVIDES:httpd:x86_64_v2 = "virtual/httpd_or_nginx virtual/webserver"

URI_x86_64_v2_httpd-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-core-2.4.63-13.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_httpd-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-core}"
SRC_URI[x86_64_v2_httpd-core.sha256sum] = "66871a78918f700e31cf9372c9027259cc8416ace89dc089df3e3bd17484b6b7"

URI_x86_64_v2_httpd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-devel-2.4.63-13.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_httpd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-devel}"
SRC_URI[x86_64_v2_httpd-devel.sha256sum] = "3e4c748556f9a53561987c0a368caf1acc1114defc9dd4f1d2ff1ac38800d6a0"

URI_x86_64_v2_httpd-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-filesystem-2.4.63-13.el10_2.5.noarch.rpm;name=x86_64_v2_httpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-filesystem}"
SRC_URI[x86_64_v2_httpd-filesystem.sha256sum] = "aa01e523e20af21fe0d9f4ae5d82065643e6eb5bcbd1693ef03a4b4434d2f7c7"

URI_x86_64_v2_httpd-manual = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-manual-2.4.63-13.el10_2.5.noarch.rpm;name=x86_64_v2_httpd-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-manual}"
SRC_URI[x86_64_v2_httpd-manual.sha256sum] = "d1229f2e96ba760a0d3e53066454eddf2ee82f101539aed0d01737fe82be5cae"

URI_x86_64_v2_httpd-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-tools-2.4.63-13.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_httpd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-tools}"
SRC_URI[x86_64_v2_httpd-tools.sha256sum] = "bb4d8b9e564ff2b1394f1bf9fd90a4451aa2fcf07eb546076f765690e4887291"

URI_x86_64_v2_mod_ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ldap-2.4.63-13.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_mod_ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_ldap}"
SRC_URI[x86_64_v2_mod_ldap.sha256sum] = "1b891e09f2906307447cce34a7fd6a03fad7d10823b26b33c71746f6058b2346"

URI_x86_64_v2_mod_lua = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_lua-2.4.63-13.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_mod_lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_lua}"
SRC_URI[x86_64_v2_mod_lua.sha256sum] = "ff4836e655234320834457829de2f9592081d3ee769d8bf8b9ffa3f5942687ea"

URI_x86_64_v2_mod_proxy_html = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_proxy_html-2.4.63-13.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_mod_proxy_html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_proxy_html}"
SRC_URI[x86_64_v2_mod_proxy_html.sha256sum] = "2eba52ea70fe39d794d140a4e40cfe9543b0ffd6c7ea78f6ecc83e6ecd33c93c"

URI_x86_64_v2_mod_session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_session-2.4.63-13.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_mod_session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_session}"
SRC_URI[x86_64_v2_mod_session.sha256sum] = "c969bb13c0674169ee24ec23c424f8357f63a182f9b600805086fda1ceaff9f1"

URI_x86_64_v2_mod_ssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ssl-2.4.63-13.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_mod_ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_ssl}"
SRC_URI[x86_64_v2_mod_ssl.sha256sum] = "40a118418b7588c539e7b58c6c70847ed46884770409f01b0486b2e2dba38b19"

URI_aarch64_httpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-2.4.63-13.el10_2.5.aarch64.rpm;name=aarch64_httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd}"
SRC_URI[aarch64_httpd.sha256sum] = "291698d21692c42e825ec49c901fc69150b57ea0ec153d2ef11df1fbc2732450"
RPROVIDES:httpd:aarch64 = "virtual/httpd_or_nginx virtual/webserver"

URI_aarch64_httpd-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-core-2.4.63-13.el10_2.5.aarch64.rpm;name=aarch64_httpd-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-core}"
SRC_URI[aarch64_httpd-core.sha256sum] = "eed6b51f729cb58912c7301627b5cab485c16e7da049735137daadc97420399f"

URI_aarch64_httpd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-devel-2.4.63-13.el10_2.5.aarch64.rpm;name=aarch64_httpd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-devel}"
SRC_URI[aarch64_httpd-devel.sha256sum] = "124e1c2796e47efeca10600b1dc08a98d716eb2e01e70eafeebcdfeb4b22fa76"

URI_aarch64_httpd-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-filesystem-2.4.63-13.el10_2.5.noarch.rpm;name=aarch64_httpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-filesystem}"
SRC_URI[aarch64_httpd-filesystem.sha256sum] = "aa01e523e20af21fe0d9f4ae5d82065643e6eb5bcbd1693ef03a4b4434d2f7c7"

URI_aarch64_httpd-manual = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-manual-2.4.63-13.el10_2.5.noarch.rpm;name=aarch64_httpd-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-manual}"
SRC_URI[aarch64_httpd-manual.sha256sum] = "d1229f2e96ba760a0d3e53066454eddf2ee82f101539aed0d01737fe82be5cae"

URI_aarch64_httpd-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-tools-2.4.63-13.el10_2.5.aarch64.rpm;name=aarch64_httpd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-tools}"
SRC_URI[aarch64_httpd-tools.sha256sum] = "a4eccf6f191760bc57d89f7b1b64c824f733e5f1f4bd26a1faf776fe8e8f8fb7"

URI_aarch64_mod_ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ldap-2.4.63-13.el10_2.5.aarch64.rpm;name=aarch64_mod_ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_ldap}"
SRC_URI[aarch64_mod_ldap.sha256sum] = "909cb682379c09763dbfab1735ffa372616a172c6934227ba4dc1866986296a8"

URI_aarch64_mod_lua = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_lua-2.4.63-13.el10_2.5.aarch64.rpm;name=aarch64_mod_lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_lua}"
SRC_URI[aarch64_mod_lua.sha256sum] = "ff34d5b81b7aa3588ece4bdbb1c33a9153787a38cb71c827cc046d5b8807a731"

URI_aarch64_mod_proxy_html = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_proxy_html-2.4.63-13.el10_2.5.aarch64.rpm;name=aarch64_mod_proxy_html;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_proxy_html}"
SRC_URI[aarch64_mod_proxy_html.sha256sum] = "a647483760e56f6b518e5c8b62da038d4759ce34fbbdabc4f81e32596b37c674"

URI_aarch64_mod_session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_session-2.4.63-13.el10_2.5.aarch64.rpm;name=aarch64_mod_session;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_session}"
SRC_URI[aarch64_mod_session.sha256sum] = "5905f9c343e41cd34e2283020079957387d979f538b698821cf62c6867e01bcc"

URI_aarch64_mod_ssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ssl-2.4.63-13.el10_2.5.aarch64.rpm;name=aarch64_mod_ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_ssl}"
SRC_URI[aarch64_mod_ssl.sha256sum] = "4c03d0511ebca595ea5ba06661c759ce3c03f13e4878096dcf11ca55705ca504"

RDEPENDS:httpd = " \
 almalinux-logos-httpd \
 bash \
 glibc \
 httpd-core \
 libbrotli \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:httpd-core = " \
 apr \
 apr-util \
 apr-util-lmdb \
 bash \
 glibc \
 httpd-filesystem \
 httpd-tools \
 mailcap \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:httpd-devel = " \
 apr-devel \
 apr-util-devel \
 bash \
 httpd-core \
 libtool \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:httpd-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:httpd-manual = " \
 httpd-core \
 "
RDEPENDS:httpd-tools = " \
 apr \
 apr-util \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:mod_ldap = " \
 apr-util-ldap \
 glibc \
 httpd-core \
 openldap \
 "
RDEPENDS:mod_lua = " \
 glibc \
 httpd-core \
 libxcrypt \
 lua-libs \
 "
RDEPENDS:mod_proxy_html = " \
 glibc \
 httpd-core \
 libxml2 \
 "
RDEPENDS:mod_session = " \
 glibc \
 httpd-core \
 "
RDEPENDS:mod_ssl = " \
 bash \
 glibc \
 hostname \
 httpd-core \
 httpd-filesystem \
 openssl-libs \
 sscg \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"

PROVIDES:append:aarch64 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"
