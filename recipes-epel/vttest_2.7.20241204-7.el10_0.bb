# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vttest"
PV = "2.7.20241204"
PR = "7.el10_0"
PACKAGES = " \
 vttest \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/v/vttest-2.7.20241204-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91c2f62ceb2b1cca665bbcc8d805e87d705bcad525970c403cd5f5082ca5ba69"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vttest-2.7.20241204-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vttest;unpack=0"
SRC_URI[x86_64_v2_vttest.sha256sum] = "7ccad66ec7429270e51148e5feb1942328b75ef4083596696285ed214dcf516a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/v/vttest-2.7.20241204-7.el10_0.aarch64.rpm;name=aarch64_vttest;unpack=0"
SRC_URI[aarch64_vttest.sha256sum] = "9d10ffcb1183e49a763cd3a4acf610285fc7c0c8da4e4bc71ddd8da544b2b54d"

RDEPENDS:vttest = " \
 glibc \
 "
