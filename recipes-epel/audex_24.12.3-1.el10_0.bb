# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audex"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 audex \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audex-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdc058705669038b3e9a63b8cf364018eff68b480238f78008509c2987b063df"

URI_x86_64_v2_audex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audex-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audex}"
SRC_URI[x86_64_v2_audex.sha256sum] = "f017f7987530f796d5a510ad131c907bafa019bdb922958020d6f84412ae1f6c"

URI_aarch64_audex = "${EPEL_MIRROR}/aarch64/Packages/a/audex-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_audex;unpack=0"
SRC_URI:append = " ${URI_aarch64_audex}"
SRC_URI[aarch64_audex.sha256sum] = "2dfe23c7c66393462750721c41629a0b2b71f084f532788023c90f1431d44e70"

RDEPENDS:audex = " \
 glibc \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 libcdio \
 libcdio-paranoia \
 libkcddb \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
