# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audit"
PV = "4.2.1"
PR = "3.el10"
PACKAGES = " \
 audispd-plugins \
 audispd-plugins-zos \
 audit \
 audit-libs \
 audit-libs-devel \
 audit-rules \
 python3-audit \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/audit-4.2.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b60470e9b934ffa4019d190997a145097c6fae663ffc04d1d07224aaecf0c3fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audispd-plugins-4.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_audispd-plugins;unpack=0"
SRC_URI[x86_64_v2_audispd-plugins.sha256sum] = "b2f4181a47a977f4584ff1284244a29eec8b2cc8a9cc5f7130f3d24a835339ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audispd-plugins-zos-4.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_audispd-plugins-zos;unpack=0"
SRC_URI[x86_64_v2_audispd-plugins-zos.sha256sum] = "b49923574313eb4f1ff9a3feca9c88f8d05adb2ff5b23b365181d07c78343c56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-4.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_audit;unpack=0"
SRC_URI[x86_64_v2_audit.sha256sum] = "152c730cbb81aa88430510a04ebd2d5da53df114e76a47850e6487d3545f4af8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-libs-4.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_audit-libs;unpack=0"
SRC_URI[x86_64_v2_audit-libs.sha256sum] = "cb6bb40cb3e238034183e3600598ec1d912f27fcbb1fd2903feb4d06c68c186e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/audit-libs-devel-4.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_audit-libs-devel;unpack=0"
SRC_URI[x86_64_v2_audit-libs-devel.sha256sum] = "c503d0c2c950f7994a88e53dd9821a1e654c3e348022e7bfa9faf1a2a3c06a66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/audit-rules-4.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_audit-rules;unpack=0"
SRC_URI[x86_64_v2_audit-rules.sha256sum] = "3f6c824b530cc2f54496f8d287aaff7a7489fadbaa150d4e4b4fe1ef20cf1008"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-audit-4.2.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-audit;unpack=0"
SRC_URI[x86_64_v2_python3-audit.sha256sum] = "237c8003bbbc2581f95e51a5cf047c790a835782b7bd7b462672fc60bcef322f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audispd-plugins-4.2.1-3.el10.aarch64.rpm;name=aarch64_audispd-plugins;unpack=0"
SRC_URI[aarch64_audispd-plugins.sha256sum] = "de4a9cd55c23a289e965578a2fefe8aaded2ac1deadedd0fd39d6a69d0361edb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audispd-plugins-zos-4.2.1-3.el10.aarch64.rpm;name=aarch64_audispd-plugins-zos;unpack=0"
SRC_URI[aarch64_audispd-plugins-zos.sha256sum] = "92d49023bca9d0db19d6f7e6dc220a3f97b482b2b6a6a9dd5bc1fde1174fafef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-4.2.1-3.el10.aarch64.rpm;name=aarch64_audit;unpack=0"
SRC_URI[aarch64_audit.sha256sum] = "f7933676c6d8eb53c9a8f0255ce81322942f3246a68e092005cc575e21650e2e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-libs-4.2.1-3.el10.aarch64.rpm;name=aarch64_audit-libs;unpack=0"
SRC_URI[aarch64_audit-libs.sha256sum] = "96d99d8b0f36613e4f2054d36355d9ec7af30007bbb8ca114144dcc396e4478f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/audit-libs-devel-4.2.1-3.el10.aarch64.rpm;name=aarch64_audit-libs-devel;unpack=0"
SRC_URI[aarch64_audit-libs-devel.sha256sum] = "4898a5297c08d4a2956d8181e749338e3ff1f0ad6682286ebeebfd2e52c5392b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/audit-rules-4.2.1-3.el10.aarch64.rpm;name=aarch64_audit-rules;unpack=0"
SRC_URI[aarch64_audit-rules.sha256sum] = "23ea786f3e7366b7f2bbb19b055bb3b6092d017c782ef555e07092660c3a01e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-audit-4.2.1-3.el10.aarch64.rpm;name=aarch64_python3-audit;unpack=0"
SRC_URI[aarch64_python3-audit.sha256sum] = "a313ec670124e50a191894c51419659ff96a59148ef487f43833687db7cffbb9"

RDEPENDS:audispd-plugins = " \
 audit \
 audit-libs \
 glibc \
 krb5-libs \
 libcap-ng \
 openssl-libs \
 "
RDEPENDS:audispd-plugins-zos = " \
 audit \
 audit-libs \
 glibc \
 libcap-ng \
 openldap \
 "
RDEPENDS:audit = " \
 audit-libs \
 bash \
 glibc \
 krb5-libs \
 openssl-libs \
 systemd \
 virtual/coreutils \
 "
RDEPENDS:audit-libs = " \
 glibc \
 libcap-ng \
 "
RDEPENDS:audit-libs-devel = " \
 audit-libs \
 kernel-headers \
 libcap-ng-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:audit-rules = " \
 audit-libs \
 bash \
 gawk \
 glibc \
 grep \
 virtual/coreutils \
 "
RDEPENDS:python3-audit = " \
 audit-libs \
 glibc \
 libcap-ng \
 python3 \
 "
