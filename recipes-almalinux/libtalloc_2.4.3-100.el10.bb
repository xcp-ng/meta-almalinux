# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtalloc"
PV = "2.4.3"
PR = "100.el10"
PACKAGES = " \
 libtalloc \
 libtalloc-devel \
 python3-talloc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtalloc-2.4.3-100.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22e10b203afac34743b278226279be17c28a58c73b82bde3482ceaf767439c38"

URI_x86_64_v2_libtalloc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtalloc-2.4.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libtalloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtalloc}"
SRC_URI[x86_64_v2_libtalloc.sha256sum] = "2029cdb930a9fc4649a8806bf1bf80484a7812f70c030f21de633b274ea86b23"

URI_x86_64_v2_libtalloc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libtalloc-devel-2.4.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libtalloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtalloc-devel}"
SRC_URI[x86_64_v2_libtalloc-devel.sha256sum] = "703d060b777ed58f9729aa46ebb6acd0c93d04aaf5fd41851db5c71525f6083c"

URI_x86_64_v2_python3-talloc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-talloc-2.4.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_python3-talloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-talloc}"
SRC_URI[x86_64_v2_python3-talloc.sha256sum] = "35b8918172aaccd3f78b8909e0e43b5a5971eb6c65a27a01c1d80de9ba9766ff"

URI_aarch64_libtalloc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtalloc-2.4.3-100.el10.aarch64.rpm;name=aarch64_libtalloc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtalloc}"
SRC_URI[aarch64_libtalloc.sha256sum] = "218e4c3687c30a7707f45cf45b3dffd9e044ad694f96322a9b1fcc8823fad1a4"

URI_aarch64_libtalloc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libtalloc-devel-2.4.3-100.el10.aarch64.rpm;name=aarch64_libtalloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtalloc-devel}"
SRC_URI[aarch64_libtalloc-devel.sha256sum] = "6c093fd992b686dd7940b9de3a19bb7f681e8825847e7cced9831899dae71801"

URI_aarch64_python3-talloc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-talloc-2.4.3-100.el10.aarch64.rpm;name=aarch64_python3-talloc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-talloc}"
SRC_URI[aarch64_python3-talloc.sha256sum] = "bda4aa73671473c57c8ffd68968db6cd659618f067a9768c683ee8233f93ade1"

RDEPENDS:libtalloc = " \
 glibc \
 "
RDEPENDS:libtalloc-devel = " \
 libtalloc \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-talloc = " \
 glibc \
 libtalloc \
 python3 \
 python3-libs \
 "
