# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsconfd"
PV = "1.7.3"
PR = "2.el10"
PACKAGES = " \
 dnsconfd \
 dnsconfd-dracut \
 dnsconfd-micro \
 dnsconfd-selinux \
 dnsconfd-unbound \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dnsconfd-1.7.3-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e78c7010021524db688b0e2eb712e80ee6dd953dea0a7e5b5b8a3207176ea935"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-1.7.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_dnsconfd;unpack=0"
SRC_URI[x86_64_v2_dnsconfd.sha256sum] = "3256479f16ce2c17bd44afc1ad9d43b22ee873bc63a421506e1ef5651efb06e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-dracut-1.7.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_dnsconfd-dracut;unpack=0"
SRC_URI[x86_64_v2_dnsconfd-dracut.sha256sum] = "ff4a1ded6ac13cb6755414c33fca66998474a400cb8c58b62e862d6fc98dbd3b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-micro-1.7.3-2.el10.x86_64_v2.rpm;name=x86_64_v2_dnsconfd-micro;unpack=0"
SRC_URI[x86_64_v2_dnsconfd-micro.sha256sum] = "0b57715f45157f41221a67757647695fe0f1c814d7936c181235f98ff6aedb65"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-selinux-1.7.3-2.el10.noarch.rpm;name=x86_64_v2_dnsconfd-selinux;unpack=0"
SRC_URI[x86_64_v2_dnsconfd-selinux.sha256sum] = "e299fdb9627e6c2546350d10d3a7d0e7352b274d930ef37736a524cf2f53421b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsconfd-unbound-1.7.3-2.el10.noarch.rpm;name=x86_64_v2_dnsconfd-unbound;unpack=0"
SRC_URI[x86_64_v2_dnsconfd-unbound.sha256sum] = "e00333ac12314b9af0e466ca48b9ae51eb07403038ab0e82e0c3ef4076cdceaf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-1.7.3-2.el10.aarch64.rpm;name=aarch64_dnsconfd;unpack=0"
SRC_URI[aarch64_dnsconfd.sha256sum] = "e5032235c1c897f649b094ed84c5c6274f6961fdb1599b5cd89afb6450362863"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-dracut-1.7.3-2.el10.aarch64.rpm;name=aarch64_dnsconfd-dracut;unpack=0"
SRC_URI[aarch64_dnsconfd-dracut.sha256sum] = "fa4d4da0d3c6a0f3ce3624f7db3131bd534788da122bf0b86966f1b777bc2fdf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-micro-1.7.3-2.el10.aarch64.rpm;name=aarch64_dnsconfd-micro;unpack=0"
SRC_URI[aarch64_dnsconfd-micro.sha256sum] = "05235bf03849911e7d435f2d74e7d902041cd10265f90a03860829cc83cfe37c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-selinux-1.7.3-2.el10.noarch.rpm;name=aarch64_dnsconfd-selinux;unpack=0"
SRC_URI[aarch64_dnsconfd-selinux.sha256sum] = "e299fdb9627e6c2546350d10d3a7d0e7352b274d930ef37736a524cf2f53421b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsconfd-unbound-1.7.3-2.el10.noarch.rpm;name=aarch64_dnsconfd-unbound;unpack=0"
SRC_URI[aarch64_dnsconfd-unbound.sha256sum] = "e00333ac12314b9af0e466ca48b9ae51eb07403038ab0e82e0c3ef4076cdceaf"

RDEPENDS:dnsconfd = " \
 bash \
 dbus-common \
 dnsconfd-selinux \
 dnsconfd-unbound \
 polkit \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-pyyaml \
 python3-systemd \
 shadow-utils \
 "
RDEPENDS:dnsconfd-dracut = " \
 bash \
 dnsconfd-micro \
 dracut \
 dracut-network \
 unbound \
 "
RDEPENDS:dnsconfd-micro = " \
 dnsconfd \
 dnsconfd-selinux \
 glib2 \
 glibc \
 systemd-libs \
 unbound-dracut \
 virtual/libcurl \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:dnsconfd-selinux = " \
 bash \
 dnsconfd \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:dnsconfd-unbound = " \
 bash \
 dnsconfd \
 unbound \
 "
