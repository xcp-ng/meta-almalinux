# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gi-docgen"
PV = "2025.5"
PR = "1.el10_2"
PACKAGES = " \
 gi-docgen \
 gi-docgen-doc \
 gi-docgen-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gi-docgen-2025.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0da3aaef9574d2d864beb0c521d7b239dd47fb066d5332c486bc8033035e5da"

URI_x86_64_v2_gi-docgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gi-docgen-2025.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gi-docgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gi-docgen}"
SRC_URI[x86_64_v2_gi-docgen.sha256sum] = "685dc7de13ba97aa3373c589006bf460400fe6593f39bec3f0d9750f6b0ff58a"

URI_x86_64_v2_gi-docgen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gi-docgen-doc-2025.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gi-docgen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gi-docgen-doc}"
SRC_URI[x86_64_v2_gi-docgen-doc.sha256sum] = "3acd4049e58f49e8b62c0429af89af0ab535fff092bdfebe0aa18f253683ce78"

URI_x86_64_v2_gi-docgen-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gi-docgen-fonts-2025.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gi-docgen-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gi-docgen-fonts}"
SRC_URI[x86_64_v2_gi-docgen-fonts.sha256sum] = "de0e7f79f058bd4a2eb7cbb31cf7caedaab3df29d2ded3114d46d280fde2fcf3"

URI_aarch64_gi-docgen = "${EPEL_MIRROR}/aarch64/Packages/g/gi-docgen-2025.5-1.el10_2.noarch.rpm;name=aarch64_gi-docgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_gi-docgen}"
SRC_URI[aarch64_gi-docgen.sha256sum] = "37da4434791794f0be1c77a6793864b772a8c8fb34e87ae7ac813b6abd433551"

URI_aarch64_gi-docgen-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gi-docgen-doc-2025.5-1.el10_2.noarch.rpm;name=aarch64_gi-docgen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gi-docgen-doc}"
SRC_URI[aarch64_gi-docgen-doc.sha256sum] = "d90549fceb625058fc9e6722b0d8a5e76d4b29dfb45caf10219676a85a191a9a"

URI_aarch64_gi-docgen-fonts = "${EPEL_MIRROR}/aarch64/Packages/g/gi-docgen-fonts-2025.5-1.el10_2.noarch.rpm;name=aarch64_gi-docgen-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gi-docgen-fonts}"
SRC_URI[aarch64_gi-docgen-fonts.sha256sum] = "277a0c9b42f4ebb2a032c2cefbc8978186679318f30c844d1ac425a7737c820f"

RDEPENDS:gi-docgen = " \
 gi-docgen-fonts \
 pkgconf-pkg-config \
 python3 \
 python3-jinja2 \
 python3-markdown \
 python3-markupsafe \
 python3-packaging \
 python3-pygments \
 python3-typogrify \
 "
RDEPENDS:gi-docgen-doc = " \
 "
RDEPENDS:gi-docgen-fonts = " \
 redhat-display-fonts \
 redhat-mono-vf-fonts \
 redhat-text-fonts \
 virtual/font_redhatdisplay_ \
 virtual/font_redhattext_ \
 "
