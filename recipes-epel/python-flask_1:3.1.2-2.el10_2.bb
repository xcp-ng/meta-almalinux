# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-flask"
PE = "1"
PV = "3.1.2"
PR = "2.el10_2"
PACKAGES = " \
 python3-flask \
 python3-flask+async \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-flask-3.1.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3507d9cb9cc871605a56fefd1d3716282707fc73af2ce1a9f6df92c108d401f"

URI_x86_64_v2_python3-flask = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flask-3.1.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flask;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flask}"
SRC_URI[x86_64_v2_python3-flask.sha256sum] = "4c26a5447352051bf833ca501540973a49d818eac5b436c2f8603ffccbbff09f"

URI_x86_64_v2_python3-flask+async = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-flask+async-3.1.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-flask+async;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-flask+async}"
SRC_URI[x86_64_v2_python3-flask+async.sha256sum] = "d35040f7dde6b7c34721445a7594a9f7bb02cb2049d5cb84af11e83e2c924f3d"

URI_aarch64_python3-flask = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flask-3.1.2-2.el10_2.noarch.rpm;name=aarch64_python3-flask;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flask}"
SRC_URI[aarch64_python3-flask.sha256sum] = "a4524c5b141b746d31161580e882c541d5ecc246aa8c038bf046b1f784efffe9"

URI_aarch64_python3-flask+async = "${EPEL_MIRROR}/aarch64/Packages/p/python3-flask+async-3.1.2-2.el10_2.noarch.rpm;name=aarch64_python3-flask+async;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-flask+async}"
SRC_URI[aarch64_python3-flask+async.sha256sum] = "7e70450559e27beaae461c304e11b25fc6880f5f498a8b0bbf2f2d47b5bf9e20"

RDEPENDS:python3-flask = " \
 python3 \
 python3-blinker \
 python3-click \
 python3-itsdangerous \
 python3-jinja2 \
 python3-markupsafe \
 python3-werkzeug \
 "
RDEPENDS:python3-flask+async = " \
 python3 \
 python3-asgiref \
 python3-flask \
 "
