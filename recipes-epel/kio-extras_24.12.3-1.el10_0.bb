# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kio-extras"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kio-extras \
 kio-extras-devel \
 kio-extras-info \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kio-extras-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bc5a835ad00ec9116681ba52963b3e7e0ea383544a84c060d751e60fe0b6bdb"

URI_x86_64_v2_kio-extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-extras}"
SRC_URI[x86_64_v2_kio-extras.sha256sum] = "67c8d6363ec5ffb7760e96b3a6602200925eb6ed651fd56d0f36aadcf150669c"

URI_x86_64_v2_kio-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-extras-devel}"
SRC_URI[x86_64_v2_kio-extras-devel.sha256sum] = "b953116244e42b00d05150613755b65612e2b9c76c98963a5c1d6e93b30f8b90"

URI_x86_64_v2_kio-extras-info = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kio-extras-info-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kio-extras-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kio-extras-info}"
SRC_URI[x86_64_v2_kio-extras-info.sha256sum] = "4b0fa22302462ebf0bd8f354ffe4d19fff81e3a2ac5afb2efb9fb326bb611257"

URI_aarch64_kio-extras = "${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kio-extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-extras}"
SRC_URI[aarch64_kio-extras.sha256sum] = "f9057225e4351d3f33ea1e565f62008ebc791235aa29ecce968a8e244cc92032"

URI_aarch64_kio-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kio-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-extras-devel}"
SRC_URI[aarch64_kio-extras-devel.sha256sum] = "9aedd23ddd93538f34de99a542f613db7bf27589798d19d5625a4a3cc5adc3fe"

URI_aarch64_kio-extras-info = "${EPEL_MIRROR}/aarch64/Packages/k/kio-extras-info-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kio-extras-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_kio-extras-info}"
SRC_URI[aarch64_kio-extras-info.sha256sum] = "ca9992d158cd117250a026fc339df21b8536616dd124c96ef3d78493dc3a2756"

RDEPENDS:kio-extras = " \
 bash \
 glibc \
 kdsoap-ws-discovery-client \
 kdsoap6 \
 kf6-karchive \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-solid \
 kf6-syntax-highlighting \
 libXcursor \
 libgcc \
 libimobiledevice \
 libkexiv2-qt6 \
 libmtp \
 libplist \
 libsmbclient \
 libssh \
 libstdc++ \
 openexr-libs \
 phonon-qt6 \
 plasma-activities \
 plasma-activities-stats \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 taglib \
 "
RDEPENDS:kio-extras-devel = " \
 cmake-filesystem \
 kio-extras \
 "
RDEPENDS:kio-extras-info = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 perl-interpreter \
 perl-libs \
 qt6-qtbase \
 "
