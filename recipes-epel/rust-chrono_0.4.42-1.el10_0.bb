# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono"
PV = "0.4.42"
PR = "1.el10_0"
PACKAGES = " \
 rust-chrono+alloc-devel \
 rust-chrono+arbitrary-devel \
 rust-chrono+clock-devel \
 rust-chrono+core-error-devel \
 rust-chrono+default-devel \
 rust-chrono+iana-time-zone-devel \
 rust-chrono+libc-devel \
 rust-chrono+now-devel \
 rust-chrono+oldtime-devel \
 rust-chrono+pure-rust-locales-devel \
 rust-chrono+rkyv-16-devel \
 rust-chrono+rkyv-32-devel \
 rust-chrono+rkyv-64-devel \
 rust-chrono+rkyv-devel \
 rust-chrono+rkyv-validation-devel \
 rust-chrono+serde-devel \
 rust-chrono+std-devel \
 rust-chrono+unstable-locales-devel \
 rust-chrono-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-0.4.42-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bf7dc063b88d321463a4128a279c7d4f7bae9128ada2fcb163ca05a16d1db0c"

URI_x86_64_v2_rust-chrono+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+alloc-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+alloc-devel}"
SRC_URI[x86_64_v2_rust-chrono+alloc-devel.sha256sum] = "a16239445bc9ed8975b29df3b80c374e39bc83c778f1c86568498f0c66cbffbc"

URI_x86_64_v2_rust-chrono+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+arbitrary-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-chrono+arbitrary-devel.sha256sum] = "79a6fbb078cb0fbaf5b6308a7de84838024880641a3a807ae24bc0ca1971bc24"

URI_x86_64_v2_rust-chrono+clock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+clock-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+clock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+clock-devel}"
SRC_URI[x86_64_v2_rust-chrono+clock-devel.sha256sum] = "987c9f1d8bb2922d046164372f74b80ec0b20709272548dcdf2c74f77d24cef3"

URI_x86_64_v2_rust-chrono+core-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+core-error-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+core-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+core-error-devel}"
SRC_URI[x86_64_v2_rust-chrono+core-error-devel.sha256sum] = "1a9af7da994651339206439fb61055910b89ab36972f854a408aea9f31422332"

URI_x86_64_v2_rust-chrono+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+default-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+default-devel}"
SRC_URI[x86_64_v2_rust-chrono+default-devel.sha256sum] = "f0edd444d21d4cfd3c7592c0edc24848b2891b24718833ef3f62853c4bfedf39"

URI_x86_64_v2_rust-chrono+iana-time-zone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+iana-time-zone-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+iana-time-zone-devel}"
SRC_URI[x86_64_v2_rust-chrono+iana-time-zone-devel.sha256sum] = "da78f735e53d85cbdb76124885905866a391311a9e6f47f0de8242fce2a5c65e"

URI_x86_64_v2_rust-chrono+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+libc-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+libc-devel}"
SRC_URI[x86_64_v2_rust-chrono+libc-devel.sha256sum] = "6c37dd321d293b423f180694c8d6a06be438380f08a648c95d0dd747a1d2bfb9"

URI_x86_64_v2_rust-chrono+now-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+now-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+now-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+now-devel}"
SRC_URI[x86_64_v2_rust-chrono+now-devel.sha256sum] = "45cb116c51734c2f1b529e158eb78c16403efa530850a039ff672a75dc084a73"

URI_x86_64_v2_rust-chrono+oldtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+oldtime-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+oldtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+oldtime-devel}"
SRC_URI[x86_64_v2_rust-chrono+oldtime-devel.sha256sum] = "5b0b2cd79334f5a6a58aa2a340f3a551e33de78391ba9bb954d39a81837cfd5b"

URI_x86_64_v2_rust-chrono+pure-rust-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+pure-rust-locales-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+pure-rust-locales-devel}"
SRC_URI[x86_64_v2_rust-chrono+pure-rust-locales-devel.sha256sum] = "dad438480682f9f11d972397320f05d7d9c35ad7bade1432e7fb0b2286fc24c4"

URI_x86_64_v2_rust-chrono+rkyv-16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-16-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-16-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-16-devel.sha256sum] = "6b68db7576f92aa6276a13b85b0b246fce6c1330f009d06cc32ad6c6399f944c"

URI_x86_64_v2_rust-chrono+rkyv-32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-32-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-32-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-32-devel.sha256sum] = "51a153346bed1567eea2fd6cf2f9e95c3b3d6abcd27cba6da08cb786342fa477"

URI_x86_64_v2_rust-chrono+rkyv-64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-64-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-64-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-64-devel.sha256sum] = "da0f7922d7ea84ea0727ebcb95faec6eafb51cf355be83d8ba12ad607ddcb750"

URI_x86_64_v2_rust-chrono+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-devel.sha256sum] = "174e6ce625bcb49d09696e78bfef60617c81598d3981b792d3469839e56e7eb4"

URI_x86_64_v2_rust-chrono+rkyv-validation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+rkyv-validation-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+rkyv-validation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+rkyv-validation-devel}"
SRC_URI[x86_64_v2_rust-chrono+rkyv-validation-devel.sha256sum] = "03dae645faef6f1dc6248df5f41a7b034d1d77d81d18d2b1ad6302d729b94e90"

URI_x86_64_v2_rust-chrono+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+serde-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+serde-devel}"
SRC_URI[x86_64_v2_rust-chrono+serde-devel.sha256sum] = "b62bad4e266e0e2298279783021fed27ba3e7cbde266c1123bd7cddfe0e6be37"

URI_x86_64_v2_rust-chrono+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+std-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+std-devel}"
SRC_URI[x86_64_v2_rust-chrono+std-devel.sha256sum] = "51b414552c4cd30919302c23d81dc5fb8e2d606c5a062c1bcb2da82c0d192ffc"

URI_x86_64_v2_rust-chrono+unstable-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono+unstable-locales-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono+unstable-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono+unstable-locales-devel}"
SRC_URI[x86_64_v2_rust-chrono+unstable-locales-devel.sha256sum] = "8431ee7197acb672e11c453078dde6b0ffb45a5031a64f27a8fcfa7d11941a29"

URI_x86_64_v2_rust-chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-devel-0.4.42-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-devel}"
SRC_URI[x86_64_v2_rust-chrono-devel.sha256sum] = "46336f95ce8f68d42f81b513486326131821c08fbf5982ce3faeb5362a3dcfcd"

URI_aarch64_rust-chrono+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+alloc-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+alloc-devel}"
SRC_URI[aarch64_rust-chrono+alloc-devel.sha256sum] = "bd385a5d6def733d757d68e24801d43f2b0f9a0820ced323c1f87aa6f4998641"

URI_aarch64_rust-chrono+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+arbitrary-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+arbitrary-devel}"
SRC_URI[aarch64_rust-chrono+arbitrary-devel.sha256sum] = "822921a5bf32f5a40c182c008c3ae99cb9ab6156d8ab3dd8fed4931a3e743e12"

URI_aarch64_rust-chrono+clock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+clock-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+clock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+clock-devel}"
SRC_URI[aarch64_rust-chrono+clock-devel.sha256sum] = "f6ecbde4587877ef3451af02582ce6ea04363ea516887bb135cf3644acc652d0"

URI_aarch64_rust-chrono+core-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+core-error-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+core-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+core-error-devel}"
SRC_URI[aarch64_rust-chrono+core-error-devel.sha256sum] = "c8f29749c178870325bccf0b127b60b0196d61b1ae71c779b2c5020b96e42d33"

URI_aarch64_rust-chrono+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+default-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+default-devel}"
SRC_URI[aarch64_rust-chrono+default-devel.sha256sum] = "cc75cc526128938f51eff7b98a86c28020adf87091ae8f146c71a3d5c7cfdc25"

URI_aarch64_rust-chrono+iana-time-zone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+iana-time-zone-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+iana-time-zone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+iana-time-zone-devel}"
SRC_URI[aarch64_rust-chrono+iana-time-zone-devel.sha256sum] = "a62d86ff8f37b06800de58e34a76c0367ea3d1b3cafbeb6e211db76e0e1a8214"

URI_aarch64_rust-chrono+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+libc-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+libc-devel}"
SRC_URI[aarch64_rust-chrono+libc-devel.sha256sum] = "252eb895520c9c704ecefaa436095d17de87b3f9f794cbdaf29b06e62885beff"

URI_aarch64_rust-chrono+now-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+now-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+now-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+now-devel}"
SRC_URI[aarch64_rust-chrono+now-devel.sha256sum] = "200832276905641201f8dcdf2b469e16b7b553875b6a28c6d3ca538f051446db"

URI_aarch64_rust-chrono+oldtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+oldtime-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+oldtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+oldtime-devel}"
SRC_URI[aarch64_rust-chrono+oldtime-devel.sha256sum] = "8505032f4f9d77c20ecda19b18ef44be28a1c18d839cfe0f75cb1599a86cdbc8"

URI_aarch64_rust-chrono+pure-rust-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+pure-rust-locales-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+pure-rust-locales-devel}"
SRC_URI[aarch64_rust-chrono+pure-rust-locales-devel.sha256sum] = "0db16f9ba36f4afd45726a6f6ee16346acadb4d254292decee5159b63b977892"

URI_aarch64_rust-chrono+rkyv-16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-16-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+rkyv-16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-16-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-16-devel.sha256sum] = "fe2a15e171b92f75205158fe6277858423bef1e20292b88a7d70c1dc63ddd7df"

URI_aarch64_rust-chrono+rkyv-32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-32-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+rkyv-32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-32-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-32-devel.sha256sum] = "83538d638bad004f02e31a5a051957a69918a21cd3fa96674fa309c53e0f4db7"

URI_aarch64_rust-chrono+rkyv-64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-64-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+rkyv-64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-64-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-64-devel.sha256sum] = "49a01c68087d8ceee5d69ce8d3ec099fa6e47409f09de739181a982928a6a022"

URI_aarch64_rust-chrono+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-devel.sha256sum] = "cb14668d18c27903a57ea49c5ec3003199ab4b48e14fd1ebceb3ea679cc48906"

URI_aarch64_rust-chrono+rkyv-validation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+rkyv-validation-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+rkyv-validation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+rkyv-validation-devel}"
SRC_URI[aarch64_rust-chrono+rkyv-validation-devel.sha256sum] = "76e8a5afad7d84ca6b30d85de3e40ba9ddfa2f276c2aa79629acafb282a5d9b0"

URI_aarch64_rust-chrono+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+serde-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+serde-devel}"
SRC_URI[aarch64_rust-chrono+serde-devel.sha256sum] = "8b52232d9989e307be440ef32185ddc78be6d86254a0307bcea11ef532e5dae2"

URI_aarch64_rust-chrono+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+std-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+std-devel}"
SRC_URI[aarch64_rust-chrono+std-devel.sha256sum] = "f1982e3bb3f21dddf1b623e02e917f3526f188b813b25dce85b95949838272d8"

URI_aarch64_rust-chrono+unstable-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono+unstable-locales-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono+unstable-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono+unstable-locales-devel}"
SRC_URI[aarch64_rust-chrono+unstable-locales-devel.sha256sum] = "2a7898720c0e838fb3ffb1e59db5e5448ad7babd6976a2d083cbd824c79ad9be"

URI_aarch64_rust-chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-devel-0.4.42-1.el10_0.noarch.rpm;name=aarch64_rust-chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-devel}"
SRC_URI[aarch64_rust-chrono-devel.sha256sum] = "51dab0502646d1dcfb76c18aa4a3a0a976787c6fbb7e5119ef3af64605372c2b"

RDEPENDS:rust-chrono+alloc-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+clock-devel = " \
 cargo \
 rust-chrono+iana-time-zone-devel \
 rust-chrono+now-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+core-error-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+default-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+oldtime-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+iana-time-zone-devel = " \
 cargo \
 rust-chrono-devel \
 rust-iana-time-zone+default-devel \
 rust-iana-time-zone+fallback-devel \
 "
RDEPENDS:rust-chrono+libc-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+now-devel = " \
 cargo \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+oldtime-devel = " \
 cargo \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+pure-rust-locales-devel = " \
 cargo \
 rust-chrono-devel \
 rust-pure-rust-locales+default-devel \
 "
RDEPENDS:rust-chrono+rkyv-16-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_16-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-32-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-64-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_64-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+rkyv-validation-devel = " \
 cargo \
 rust-chrono-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-chrono+serde-devel = " \
 cargo \
 rust-chrono-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-chrono+std-devel = " \
 cargo \
 rust-chrono+alloc-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono+unstable-locales-devel = " \
 cargo \
 rust-chrono+pure-rust-locales-devel \
 rust-chrono-devel \
 "
RDEPENDS:rust-chrono-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
