# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lru0.12"
PV = "0.12.5"
PR = "2.el10_1"
PACKAGES = " \
 rust-lru0.12+default-devel \
 rust-lru0.12+hashbrown-devel \
 rust-lru0.12-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lru0.12-0.12.5-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "729bbb1be810674c6936289750dd3cefd96d3260f6b4fa5dc3e878a82b559eb9"

URI_x86_64_v2_rust-lru0.12+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru0.12+default-devel-0.12.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru0.12+default-devel}"
SRC_URI[x86_64_v2_rust-lru0.12+default-devel.sha256sum] = "39667121a852bc4b7d32ed7f6b186cf13b0681ce9e5178127c7c8d2cc654f3e2"

URI_x86_64_v2_rust-lru0.12+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru0.12+hashbrown-devel-0.12.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru0.12+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru0.12+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-lru0.12+hashbrown-devel.sha256sum] = "b494601c90ce4519836e8496b68643aea8c735ef33dcbc488ee275c1b1beb244"

URI_x86_64_v2_rust-lru0.12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lru0.12-devel-0.12.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lru0.12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lru0.12-devel}"
SRC_URI[x86_64_v2_rust-lru0.12-devel.sha256sum] = "ca2936c82ac64ae28a7ce1997931feb4e3a10252efe1f8e0865a5939fc83df2a"

URI_aarch64_rust-lru0.12+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru0.12+default-devel-0.12.5-2.el10_1.noarch.rpm;name=aarch64_rust-lru0.12+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru0.12+default-devel}"
SRC_URI[aarch64_rust-lru0.12+default-devel.sha256sum] = "3d06cebde59d732fdb82c0f751a9f8e8dbba1758211fcb94448b0a780704fcdf"

URI_aarch64_rust-lru0.12+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru0.12+hashbrown-devel-0.12.5-2.el10_1.noarch.rpm;name=aarch64_rust-lru0.12+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru0.12+hashbrown-devel}"
SRC_URI[aarch64_rust-lru0.12+hashbrown-devel.sha256sum] = "589a82fa7507a8b2cd59aa04029909d398a8df0c29988e38c81890fc390825e9"

URI_aarch64_rust-lru0.12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lru0.12-devel-0.12.5-2.el10_1.noarch.rpm;name=aarch64_rust-lru0.12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lru0.12-devel}"
SRC_URI[aarch64_rust-lru0.12-devel.sha256sum] = "aabc1deb030a045428defeb46d0c8d9744fd0ae860d4dbdba008718dca6eb583"

RDEPENDS:rust-lru0.12+default-devel = " \
 cargo \
 rust-lru0.12+hashbrown-devel \
 rust-lru0.12-devel \
 "
RDEPENDS:rust-lru0.12+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.15+default-devel \
 rust-lru0.12-devel \
 "
RDEPENDS:rust-lru0.12-devel = " \
 cargo \
 "
