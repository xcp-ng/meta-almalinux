# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipmitool"
PV = "1.8.19"
PR = "9.el10"
PACKAGES = " \
 bmc-snmp-proxy \
 exchange-bmc-os-info \
 ipmievd \
 ipmitool \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipmitool-1.8.19-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abbfb88001390d89401a16dd8420aef23bd947b57ceb00ee798ecf83e791c928"

URI_x86_64_v2_bmc-snmp-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bmc-snmp-proxy-1.8.19-9.el10.noarch.rpm;name=x86_64_v2_bmc-snmp-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bmc-snmp-proxy}"
SRC_URI[x86_64_v2_bmc-snmp-proxy.sha256sum] = "869dfbe458519302abd94a313028ad02afac53060d71a5fcbe7930ba87ca29e4"

URI_x86_64_v2_exchange-bmc-os-info = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/exchange-bmc-os-info-1.8.19-9.el10.noarch.rpm;name=x86_64_v2_exchange-bmc-os-info;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exchange-bmc-os-info}"
SRC_URI[x86_64_v2_exchange-bmc-os-info.sha256sum] = "1354c2e759f1be3e1428978ec02a6236bb1796070291bfd899bbc1819e4ade64"

URI_x86_64_v2_ipmievd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipmievd-1.8.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_ipmievd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipmievd}"
SRC_URI[x86_64_v2_ipmievd.sha256sum] = "2729532a4ec5dc841779697acd8ab6ee4fd5a6162b5dd96f876a0d6a4ee5aca5"

URI_x86_64_v2_ipmitool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipmitool-1.8.19-9.el10.x86_64_v2.rpm;name=x86_64_v2_ipmitool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipmitool}"
SRC_URI[x86_64_v2_ipmitool.sha256sum] = "1d8bbb3c49465718af3b05f5f7a6e610f2cc5f9838aa0d0acde4bfa78bc8721c"

URI_aarch64_bmc-snmp-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bmc-snmp-proxy-1.8.19-9.el10.noarch.rpm;name=aarch64_bmc-snmp-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_bmc-snmp-proxy}"
SRC_URI[aarch64_bmc-snmp-proxy.sha256sum] = "869dfbe458519302abd94a313028ad02afac53060d71a5fcbe7930ba87ca29e4"

URI_aarch64_exchange-bmc-os-info = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/exchange-bmc-os-info-1.8.19-9.el10.noarch.rpm;name=aarch64_exchange-bmc-os-info;unpack=0"
SRC_URI:append = " ${URI_aarch64_exchange-bmc-os-info}"
SRC_URI[aarch64_exchange-bmc-os-info.sha256sum] = "1354c2e759f1be3e1428978ec02a6236bb1796070291bfd899bbc1819e4ade64"

URI_aarch64_ipmievd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipmievd-1.8.19-9.el10.aarch64.rpm;name=aarch64_ipmievd;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipmievd}"
SRC_URI[aarch64_ipmievd.sha256sum] = "b22b90dc8d78ef82591c425369729a07ccddf201973fcd0ac1adccc9e35a521f"

URI_aarch64_ipmitool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipmitool-1.8.19-9.el10.aarch64.rpm;name=aarch64_ipmitool;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipmitool}"
SRC_URI[aarch64_ipmitool.sha256sum] = "1ae46e257dbf8990662342a398f00906efe5af2a705049ddbbb4d272908ff049"

RDEPENDS:bmc-snmp-proxy = " \
 bash \
 exchange-bmc-os-info \
 net-snmp \
 "
RDEPENDS:exchange-bmc-os-info = " \
 bash \
 hostname \
 ipmitool \
 systemd \
 "
RDEPENDS:ipmievd = " \
 bash \
 glibc \
 ipmitool \
 openssl-libs \
 systemd \
 "
RDEPENDS:ipmitool = " \
 bash \
 glibc \
 openssl-libs \
 readline \
 systemd \
 "
