# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liburing"
PV = "2.5"
PR = "5.el10"
PACKAGES = " \
 liburing \
 liburing-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/liburing-2.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5aaea52eb4900a4fbcb8222b91d40d2c0fa65ffb04d3039e8ce371e7a3dd7a84"

URI_x86_64_v2_liburing = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/liburing-2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_liburing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liburing}"
SRC_URI[x86_64_v2_liburing.sha256sum] = "52fa69fd43296e9e33dc743b546397ac9c4daa5dc334495020f33c0be9acce29"

URI_x86_64_v2_liburing-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liburing-devel-2.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_liburing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liburing-devel}"
SRC_URI[x86_64_v2_liburing-devel.sha256sum] = "7d071830adc6d4da4fa09aca215c86be87ad26a9b6cab5437993c2b814f4aeb3"

URI_aarch64_liburing = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/liburing-2.5-5.el10.aarch64.rpm;name=aarch64_liburing;unpack=0"
SRC_URI:append = " ${URI_aarch64_liburing}"
SRC_URI[aarch64_liburing.sha256sum] = "445ae3c084664fe9949cf89be8cec2817988b310c34a96f1dc4cd0a872d11d91"

URI_aarch64_liburing-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liburing-devel-2.5-5.el10.aarch64.rpm;name=aarch64_liburing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liburing-devel}"
SRC_URI[aarch64_liburing-devel.sha256sum] = "9ffac7e51cf1d793d7d5dac86cd18729e40d019229d1630677f88585f8920e88"

RDEPENDS:liburing = " \
 glibc \
 "
RDEPENDS:liburing-devel = " \
 liburing \
 pkgconf-pkg-config \
 "
