# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cinfo"
PV = "0.5.10"
PR = "1.el10_0"
PACKAGES = " \
 cinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cinfo-0.5.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4c0eed11f13feaf4b2f151f1756a308e73ba986b6b6f323b4c102f216c84cfe"

URI_x86_64_v2_cinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cinfo-0.5.10-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cinfo}"
SRC_URI[x86_64_v2_cinfo.sha256sum] = "4d3cf0f231db141791cee2b08b91598b52595e0c87f8b5162681392187081201"

URI_aarch64_cinfo = "${EPEL_MIRROR}/aarch64/Packages/c/cinfo-0.5.10-1.el10_0.aarch64.rpm;name=aarch64_cinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_cinfo}"
SRC_URI[aarch64_cinfo.sha256sum] = "e9826779eb1201a9aa29d6c1dc2d25a4ac6b90dfe1f7a94a86c36e5d6f85b7f7"

RDEPENDS:cinfo = " \
 glibc \
 "
