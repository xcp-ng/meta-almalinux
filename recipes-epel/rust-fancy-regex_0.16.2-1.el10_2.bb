# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fancy-regex"
PV = "0.16.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-fancy-regex+default-devel \
 rust-fancy-regex+perf-devel \
 rust-fancy-regex+std-devel \
 rust-fancy-regex+track_caller-devel \
 rust-fancy-regex+unicode-devel \
 rust-fancy-regex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fancy-regex-0.16.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4672f90f7a01ed1005c4943929663d41040cc94c05494b13e4a1c7161093f74"

URI_x86_64_v2_rust-fancy-regex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex+default-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex+default-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex+default-devel.sha256sum] = "5c38502f25b40b50b4c41bf88a66d27a332a761b32350fe96e69d8e97625094c"

URI_x86_64_v2_rust-fancy-regex+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex+perf-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex+perf-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex+perf-devel.sha256sum] = "620f3729323839770590cf7c36486738384f2aaa28978ad599475ee23ae2b081"

URI_x86_64_v2_rust-fancy-regex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex+std-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex+std-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex+std-devel.sha256sum] = "75730e811b16c04238cadcec29807785401925bc631e9aeb83fba2341b1b68cb"

URI_x86_64_v2_rust-fancy-regex+track_caller-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex+track_caller-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex+track_caller-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex+track_caller-devel.sha256sum] = "f0e66cd821d1054a35ce511110dbdfe746449cc7bff381a1386e9c137f1f2650"

URI_x86_64_v2_rust-fancy-regex+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex+unicode-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex+unicode-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex+unicode-devel.sha256sum] = "f9440dfad9ac7c6a08eaf8d9a6f21e4e526ec3f01774ad866f3f62a6c964cbbb"

URI_x86_64_v2_rust-fancy-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fancy-regex-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fancy-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fancy-regex-devel}"
SRC_URI[x86_64_v2_rust-fancy-regex-devel.sha256sum] = "15a93967fa83faeea1341429fe17936a33e589dd43187b5f55acc8f2f793ec89"

URI_aarch64_rust-fancy-regex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex+default-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-fancy-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex+default-devel}"
SRC_URI[aarch64_rust-fancy-regex+default-devel.sha256sum] = "ddfc7ff9deea2364c3da40b7ccee727f4590398223870cd2da0775976a124da5"

URI_aarch64_rust-fancy-regex+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex+perf-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-fancy-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex+perf-devel}"
SRC_URI[aarch64_rust-fancy-regex+perf-devel.sha256sum] = "ed0047eafe2bd25f4a50b34b026cbd7117c18558328af3beab5e1e1823a52a4a"

URI_aarch64_rust-fancy-regex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex+std-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-fancy-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex+std-devel}"
SRC_URI[aarch64_rust-fancy-regex+std-devel.sha256sum] = "b6dac939f92244ae7b2c645f46547f3a869484b2227b178e9f504c2c3abc667a"

URI_aarch64_rust-fancy-regex+track_caller-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex+track_caller-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-fancy-regex+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex+track_caller-devel}"
SRC_URI[aarch64_rust-fancy-regex+track_caller-devel.sha256sum] = "05244e9042c7a2811ad67613c8ba9b7e336959d1fe281f44f000fa76afaffb3b"

URI_aarch64_rust-fancy-regex+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex+unicode-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-fancy-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex+unicode-devel}"
SRC_URI[aarch64_rust-fancy-regex+unicode-devel.sha256sum] = "8a55bfa169942a727063cf0ea5d1e4a19e9e784fd07c4b5e25528c0510b8d4db"

URI_aarch64_rust-fancy-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fancy-regex-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-fancy-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fancy-regex-devel}"
SRC_URI[aarch64_rust-fancy-regex-devel.sha256sum] = "6d470250a955195350f94eb4de27ae3c71a94cd4f5268b4d9dd7325ca3f68b5a"

RDEPENDS:rust-fancy-regex+default-devel = " \
 cargo \
 rust-fancy-regex+perf-devel \
 rust-fancy-regex+std-devel \
 rust-fancy-regex+unicode-devel \
 rust-fancy-regex-devel \
 "
RDEPENDS:rust-fancy-regex+perf-devel = " \
 cargo \
 rust-fancy-regex-devel \
 rust-regex-automata+perf-devel \
 "
RDEPENDS:rust-fancy-regex+std-devel = " \
 cargo \
 rust-bit-set+std-devel \
 rust-fancy-regex-devel \
 rust-regex-automata+std-devel \
 rust-regex-syntax+std-devel \
 "
RDEPENDS:rust-fancy-regex+track_caller-devel = " \
 cargo \
 rust-fancy-regex-devel \
 "
RDEPENDS:rust-fancy-regex+unicode-devel = " \
 cargo \
 rust-fancy-regex-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-syntax+unicode-devel \
 "
RDEPENDS:rust-fancy-regex-devel = " \
 cargo \
 rust \
 rust-bit-set-devel \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+dfa-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-regex-syntax-devel \
 "
