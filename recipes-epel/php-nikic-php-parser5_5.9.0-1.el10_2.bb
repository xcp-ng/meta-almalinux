# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-nikic-php-parser5"
PV = "5.9.0"
PR = "1.el10_2"
PACKAGES = " \
 php-nikic-php-parser5 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php-nikic-php-parser5-5.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f048b4774aa6c0373974f97cc24250a8ce394853c862ac023fd134159496e20"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-nikic-php-parser5-5.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_php-nikic-php-parser5;unpack=0"
SRC_URI[x86_64_v2_php-nikic-php-parser5.sha256sum] = "4bba09102ab56332de87dd721da2a8708f213801ba95109d2f71137770f98919"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php-nikic-php-parser5-5.9.0-1.el10_2.noarch.rpm;name=aarch64_php-nikic-php-parser5;unpack=0"
SRC_URI[aarch64_php-nikic-php-parser5.sha256sum] = "95dba6b8f428262fd676ce95ed7d201c67f201896a623bf3b272aace21da3a0c"

RDEPENDS:php-nikic-php-parser5 = " \
 php-fedora-autoloader \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-json \
 virtual/php-tokenizer \
 virtual/php_language__ge_7.4 \
 "
