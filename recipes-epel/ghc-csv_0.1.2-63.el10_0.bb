# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-csv"
PV = "0.1.2"
PR = "63.el10_0"
PACKAGES = " \
 ghc-csv \
 ghc-csv-devel \
 ghc-csv-doc \
 ghc-csv-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-csv-0.1.2-63.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3e2a60ad6afcf09189a9dfedb686b0d67be304e4e39d6743338bde5c2bbc27b"

URI_x86_64_v2_ghc-csv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-csv-0.1.2-63.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-csv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-csv}"
SRC_URI[x86_64_v2_ghc-csv.sha256sum] = "5a0386c8b44ae809968c998aec50fde05e0ee7cda5df968adc0f2d89a78c2bc3"

URI_x86_64_v2_ghc-csv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-csv-devel-0.1.2-63.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-csv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-csv-devel}"
SRC_URI[x86_64_v2_ghc-csv-devel.sha256sum] = "d92146645d39dea85eb855669ea82915ee3b6672b64101077a1cb9d866041ce3"

URI_x86_64_v2_ghc-csv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-csv-doc-0.1.2-63.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-csv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-csv-doc}"
SRC_URI[x86_64_v2_ghc-csv-doc.sha256sum] = "2a3f960596c2732fa975bda0e0f97105abde2cb67fff7f44dfde20c429fc7a64"

URI_x86_64_v2_ghc-csv-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-csv-prof-0.1.2-63.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-csv-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-csv-prof}"
SRC_URI[x86_64_v2_ghc-csv-prof.sha256sum] = "9926d758c967f95dd88858a2f24261d060d7d061c1a5a9d2943c8311b3e2dc24"

URI_aarch64_ghc-csv = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-csv-0.1.2-63.el10_0.aarch64.rpm;name=aarch64_ghc-csv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-csv}"
SRC_URI[aarch64_ghc-csv.sha256sum] = "7e1404fbd451ffb12ca4e67e02c020efd4f0a6e042fb09a5e5d915a0850e20ba"

URI_aarch64_ghc-csv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-csv-devel-0.1.2-63.el10_0.aarch64.rpm;name=aarch64_ghc-csv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-csv-devel}"
SRC_URI[aarch64_ghc-csv-devel.sha256sum] = "50b5273faae7ec9d9a2005870afd7c20a2c393ef2de3b578d5f1b3c993170e0d"

URI_aarch64_ghc-csv-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-csv-doc-0.1.2-63.el10_0.noarch.rpm;name=aarch64_ghc-csv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-csv-doc}"
SRC_URI[aarch64_ghc-csv-doc.sha256sum] = "d652a9aa6ca0bb5b538cd8638b979f34b255896c3d08c5add1bde2b4138c804c"

URI_aarch64_ghc-csv-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-csv-prof-0.1.2-63.el10_0.aarch64.rpm;name=aarch64_ghc-csv-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-csv-prof}"
SRC_URI[aarch64_ghc-csv-prof.sha256sum] = "1b601d21ba9371456e1026102ae61cd89610420eb4b1f94f9233524aef7df8d2"

RDEPENDS:ghc-csv = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-csv-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-csv \
 ghc-filepath-devel \
 ghc-parsec-devel \
 "
RDEPENDS:ghc-csv-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-csv-prof = " \
 ghc-base-prof \
 ghc-csv-devel \
 ghc-filepath-prof \
 ghc-parsec-prof \
 "
