# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "expected"
PV = "1.1.0"
PR = "1.el10_0"
PACKAGES = " \
 expected-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/expected-1.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3e0a48f215db6eb675b3eed99ac2d8d36e2fccf71af03ad0394503935ef21864"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/expected-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_expected-devel;unpack=0"
SRC_URI[x86_64_v2_expected-devel.sha256sum] = "244a4982038ac09ce64d1f8674bd8579838336bf60c113278d9c4e91f99b74ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/expected-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_expected-devel;unpack=0"
SRC_URI[aarch64_expected-devel.sha256sum] = "63bd141ecb28cc6f655ae1133eac96cad6909d526f6736bb951b5ddc75138ea7"

RDEPENDS:expected-devel = " \
 cmake-filesystem \
 "
