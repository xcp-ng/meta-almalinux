# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-daemonize"
PV = "0.5.0"
PR = "5.el10_0"
PACKAGES = " \
 rust-daemonize+default-devel \
 rust-daemonize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-daemonize-0.5.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44867677edf52530c3c3c9c3288e6e2708064e440f9dcc39c0315497632ca441"

URI_x86_64_v2_rust-daemonize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-daemonize+default-devel-0.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-daemonize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-daemonize+default-devel}"
SRC_URI[x86_64_v2_rust-daemonize+default-devel.sha256sum] = "f717d177867ed05b44aba38edde2603c068bd8f48463ac30a15b887824f250e9"

URI_x86_64_v2_rust-daemonize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-daemonize-devel-0.5.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-daemonize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-daemonize-devel}"
SRC_URI[x86_64_v2_rust-daemonize-devel.sha256sum] = "c533e73bbbe5f8460061eedea9014d06cfa85a61d54262529aa479dc2211625b"

URI_aarch64_rust-daemonize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-daemonize+default-devel-0.5.0-5.el10_0.noarch.rpm;name=aarch64_rust-daemonize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-daemonize+default-devel}"
SRC_URI[aarch64_rust-daemonize+default-devel.sha256sum] = "702daa8813e66c1603a6ad67034f664f7e5768e81baee8a16a9685c692efcb8f"

URI_aarch64_rust-daemonize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-daemonize-devel-0.5.0-5.el10_0.noarch.rpm;name=aarch64_rust-daemonize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-daemonize-devel}"
SRC_URI[aarch64_rust-daemonize-devel.sha256sum] = "e5e5fe3c597bfb61bca30bcce1d310ce93fb6e3c0bf2886eea16023dc88a6462"

RDEPENDS:rust-daemonize+default-devel = " \
 cargo \
 rust-daemonize-devel \
 "
RDEPENDS:rust-daemonize-devel = " \
 cargo \
 rust-libc+default-devel \
 "
