# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar-tools"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 akonadi-calendar-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-tools-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d49041c2ff1ea447431fdee4764bc726e7a4d1e233fd92d82910adb9698b6eb6"

URI_x86_64_v2_akonadi-calendar-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-tools-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-tools}"
SRC_URI[x86_64_v2_akonadi-calendar-tools.sha256sum] = "75909a1115b4eb4c83b2d02bd777305abe531dff647bbbfc4eb3564fc54423be"

URI_aarch64_akonadi-calendar-tools = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-tools-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_akonadi-calendar-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-tools}"
SRC_URI[aarch64_akonadi-calendar-tools.sha256sum] = "030d9ad12f23fae19f76dad9de9fb1e643cf080fdf25d1d9ecfa21f86ed0cf33"

RDEPENDS:akonadi-calendar-tools = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kf6-kcalendarcore \
 kf6-kcoreaddons \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
