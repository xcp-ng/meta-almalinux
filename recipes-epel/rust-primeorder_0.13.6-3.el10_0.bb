# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-primeorder"
PV = "0.13.6"
PR = "3.el10_0"
PACKAGES = " \
 rust-primeorder+alloc-devel \
 rust-primeorder+default-devel \
 rust-primeorder+dev-devel \
 rust-primeorder+serde-devel \
 rust-primeorder+serdect-devel \
 rust-primeorder+std-devel \
 rust-primeorder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-primeorder-0.13.6-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9bee00e7f773c8438bc86b75d09ea56a43a9c876d936d1596c2951954106f31"

URI_x86_64_v2_rust-primeorder+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primeorder+alloc-devel-0.13.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primeorder+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primeorder+alloc-devel}"
SRC_URI[x86_64_v2_rust-primeorder+alloc-devel.sha256sum] = "1a0b0d816e18078104b26505c782a57eff248e70bef738ccc995d158e8c0b914"

URI_x86_64_v2_rust-primeorder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primeorder+default-devel-0.13.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primeorder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primeorder+default-devel}"
SRC_URI[x86_64_v2_rust-primeorder+default-devel.sha256sum] = "ae0b44bc655605f90ce24b61f2dd1458941f0d5f2e1e6331ad506fda1f14b761"

URI_x86_64_v2_rust-primeorder+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primeorder+dev-devel-0.13.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primeorder+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primeorder+dev-devel}"
SRC_URI[x86_64_v2_rust-primeorder+dev-devel.sha256sum] = "b6493d086afcb4f208b93030a54c929e5f3f43b963e1296e46bcbe41c9b82a14"

URI_x86_64_v2_rust-primeorder+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primeorder+serde-devel-0.13.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primeorder+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primeorder+serde-devel}"
SRC_URI[x86_64_v2_rust-primeorder+serde-devel.sha256sum] = "533315f824e6d378e7d81e4195fd28e75312d922368def0863dc4324065331d8"

URI_x86_64_v2_rust-primeorder+serdect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primeorder+serdect-devel-0.13.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primeorder+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primeorder+serdect-devel}"
SRC_URI[x86_64_v2_rust-primeorder+serdect-devel.sha256sum] = "cd6b93712a13a058687cfe42122ea7b4b8747db53feb83ef18aa72f9dfe2070d"

URI_x86_64_v2_rust-primeorder+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primeorder+std-devel-0.13.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primeorder+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primeorder+std-devel}"
SRC_URI[x86_64_v2_rust-primeorder+std-devel.sha256sum] = "3c4e3cc2c0174a63690e05118d7793d94669101df7be01d4691421600944d87d"

URI_x86_64_v2_rust-primeorder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primeorder-devel-0.13.6-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primeorder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primeorder-devel}"
SRC_URI[x86_64_v2_rust-primeorder-devel.sha256sum] = "f4a37d192f6cb73bcee1325d12d579678dc97126e7e3062914a37a1b3ee136fd"

URI_aarch64_rust-primeorder+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primeorder+alloc-devel-0.13.6-3.el10_0.noarch.rpm;name=aarch64_rust-primeorder+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primeorder+alloc-devel}"
SRC_URI[aarch64_rust-primeorder+alloc-devel.sha256sum] = "376ca1ab3801453ccc602e74962dc787537b7e9d8d64f9376455f706fb55d3cc"

URI_aarch64_rust-primeorder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primeorder+default-devel-0.13.6-3.el10_0.noarch.rpm;name=aarch64_rust-primeorder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primeorder+default-devel}"
SRC_URI[aarch64_rust-primeorder+default-devel.sha256sum] = "0d99bf1d4f68d74444f956bf24fe7ac0067c8c49f75671d351c8bcf90ecfb917"

URI_aarch64_rust-primeorder+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primeorder+dev-devel-0.13.6-3.el10_0.noarch.rpm;name=aarch64_rust-primeorder+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primeorder+dev-devel}"
SRC_URI[aarch64_rust-primeorder+dev-devel.sha256sum] = "95818ddb5b4e2e63af8d41abe52768116724ce3bcfce9e062927b7e813ec0a4c"

URI_aarch64_rust-primeorder+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primeorder+serde-devel-0.13.6-3.el10_0.noarch.rpm;name=aarch64_rust-primeorder+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primeorder+serde-devel}"
SRC_URI[aarch64_rust-primeorder+serde-devel.sha256sum] = "a1b55b1a359d3f99fbad8f06548007dd74f58da026d5bee55c3a825e4802d695"

URI_aarch64_rust-primeorder+serdect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primeorder+serdect-devel-0.13.6-3.el10_0.noarch.rpm;name=aarch64_rust-primeorder+serdect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primeorder+serdect-devel}"
SRC_URI[aarch64_rust-primeorder+serdect-devel.sha256sum] = "74dfe45b381e19e776f04ac947c6895fa6be7f6d55f5a94569be613f09c5b1be"

URI_aarch64_rust-primeorder+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primeorder+std-devel-0.13.6-3.el10_0.noarch.rpm;name=aarch64_rust-primeorder+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primeorder+std-devel}"
SRC_URI[aarch64_rust-primeorder+std-devel.sha256sum] = "7b0c3d2ac18472aeaad7e3d72ef32d098b0b0140b43756223e95c7a4c5fc7ca1"

URI_aarch64_rust-primeorder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primeorder-devel-0.13.6-3.el10_0.noarch.rpm;name=aarch64_rust-primeorder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primeorder-devel}"
SRC_URI[aarch64_rust-primeorder-devel.sha256sum] = "e8688e4832625a1e77f09d3a6408bcccdcfdf9a0c58fd14bfe45fa9cfedc9615"

RDEPENDS:rust-primeorder+alloc-devel = " \
 cargo \
 rust-elliptic-curve+alloc-devel \
 rust-primeorder-devel \
 "
RDEPENDS:rust-primeorder+default-devel = " \
 cargo \
 rust-primeorder-devel \
 "
RDEPENDS:rust-primeorder+dev-devel = " \
 cargo \
 rust-primeorder-devel \
 "
RDEPENDS:rust-primeorder+serde-devel = " \
 cargo \
 rust-elliptic-curve+serde-devel \
 rust-primeorder+serdect-devel \
 rust-primeorder-devel \
 "
RDEPENDS:rust-primeorder+serdect-devel = " \
 cargo \
 rust-primeorder-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-primeorder+std-devel = " \
 cargo \
 rust-elliptic-curve+std-devel \
 rust-primeorder+alloc-devel \
 rust-primeorder-devel \
 "
RDEPENDS:rust-primeorder-devel = " \
 cargo \
 rust \
 rust-elliptic-curve+arithmetic-devel \
 rust-elliptic-curve+sec1-devel \
 rust-elliptic-curve-devel \
 "
