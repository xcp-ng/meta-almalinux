# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Lingua-EN-Inflect"
PV = "1.905"
PR = "8.el10_0"
PACKAGES = " \
 perl-Lingua-EN-Inflect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Lingua-EN-Inflect-1.905-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "426eb5e180add996c0d73b2ec1cea76a70af980f31d7f3b442e13d730e289a6b"

URI_x86_64_v2_perl-Lingua-EN-Inflect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lingua-EN-Inflect-1.905-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Lingua-EN-Inflect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Lingua-EN-Inflect}"
SRC_URI[x86_64_v2_perl-Lingua-EN-Inflect.sha256sum] = "b01739ac374daeff31bb04ab57bd85fbf6e1f752715b1f8dfe4465df3fbfb46e"

URI_aarch64_perl-Lingua-EN-Inflect = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Lingua-EN-Inflect-1.905-8.el10_0.noarch.rpm;name=aarch64_perl-Lingua-EN-Inflect;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Lingua-EN-Inflect}"
SRC_URI[aarch64_perl-Lingua-EN-Inflect.sha256sum] = "4c098a46cbda4d643a42e7c3c7b9d616bf12c8305828dcb522e469a33f4834c4"

RDEPENDS:perl-Lingua-EN-Inflect = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
