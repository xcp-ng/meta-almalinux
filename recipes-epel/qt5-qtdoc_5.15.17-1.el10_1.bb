# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtdoc"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtdoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtdoc-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77a70de7f66ffddf5daf7febaf350ed7938dcd11f847d1306fa9fa8fbc02a1c7"

URI_x86_64_v2_qt5-qtdoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdoc-5.15.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdoc}"
SRC_URI[x86_64_v2_qt5-qtdoc.sha256sum] = "99550c5a334a8d0d17470c7c75213dfd19d903211ce01ed06b8820d94dd2006e"

URI_aarch64_qt5-qtdoc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdoc-5.15.17-1.el10_1.noarch.rpm;name=aarch64_qt5-qtdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdoc}"
SRC_URI[aarch64_qt5-qtdoc.sha256sum] = "6ef9dd6054e53379dfb98cddaadfb657037b240c50cccd5a14ad44dd65fad9bd"

RDEPENDS:qt5-qtdoc = " \
 "
