# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mstflint"
PV = "4.32.0^20250517git48a1454"
PR = "1.el10"
PACKAGES = " \
 mstflint \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mstflint-4.32.0^20250517git48a1454-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7237be3b0bab6189fbd733aeefe8fce47752b880e9cc7b07e7ab879969838056"

URI_x86_64_v2_mstflint = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mstflint-4.32.0^20250517git48a1454-1.el10.x86_64_v2.rpm;name=x86_64_v2_mstflint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mstflint}"
SRC_URI[x86_64_v2_mstflint.sha256sum] = "8fb9aec0dfd6442f10bc715ea2f271abd421bf7935075a6f33ee844fe2336e4c"

URI_aarch64_mstflint = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mstflint-4.32.0^20250517git48a1454-1.el10.aarch64.rpm;name=aarch64_mstflint;unpack=0"
SRC_URI:append = " ${URI_aarch64_mstflint}"
SRC_URI[aarch64_mstflint.sha256sum] = "8a0932918e3d31dabdb0c80648f09a801c7374fb489bd65ab76ceb3412728227"

RDEPENDS:mstflint = " \
 bash \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 openssl-libs \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
 "
