# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libidn"
PV = "1.44"
PR = "1.el10_3"
PACKAGES = " \
 libidn \
 libidn-devel \
 libidn-java \
 libidn-javadoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libidn-1.44-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37ee2e29596bdfbdb396a983d9c99d0c6f9b0a9b3cfd659ef12b30f4881ce9e3"

URI_x86_64_v2_libidn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libidn-1.44-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libidn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn}"
SRC_URI[x86_64_v2_libidn.sha256sum] = "5c4aa89a0310a46dd3ced3ff56eb3e2525236a69b624589dde90a84986450858"

URI_x86_64_v2_libidn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libidn-devel-1.44-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libidn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn-devel}"
SRC_URI[x86_64_v2_libidn-devel.sha256sum] = "59315ee2111dbc633c325b39b833a7ea4ecf7ed17e9b0439d4507e41bfc4714d"

URI_x86_64_v2_libidn-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libidn-java-1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libidn-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn-java}"
SRC_URI[x86_64_v2_libidn-java.sha256sum] = "c88a7cbe799b6fce8245b17d600b3488948a629d15efa1b1b59e4ec98c8186bd"

URI_x86_64_v2_libidn-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libidn-javadoc-1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libidn-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libidn-javadoc}"
SRC_URI[x86_64_v2_libidn-javadoc.sha256sum] = "eb26d61f23fc514b4f06370e123d63c4f82285261666935405e3bb8290793a2a"

URI_aarch64_libidn = "${EPEL_MIRROR}/aarch64/Packages/l/libidn-1.44-1.el10_3.aarch64.rpm;name=aarch64_libidn;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn}"
SRC_URI[aarch64_libidn.sha256sum] = "04a65f2f3c172e720a570de6fb1cfec2d36e1ae8b2a3cad55701455fccc2f0fb"

URI_aarch64_libidn-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libidn-devel-1.44-1.el10_3.aarch64.rpm;name=aarch64_libidn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn-devel}"
SRC_URI[aarch64_libidn-devel.sha256sum] = "ef3be79cea8b6a45200f64e0c8142f56d6d6ca512cc8d751abfb179fdbf14c8a"

URI_aarch64_libidn-java = "${EPEL_MIRROR}/aarch64/Packages/l/libidn-java-1.44-1.el10_3.noarch.rpm;name=aarch64_libidn-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn-java}"
SRC_URI[aarch64_libidn-java.sha256sum] = "d7f1fca00bcd08c71acf2c05c830aa51b6274636cbde08024675cfe65c8a5c74"

URI_aarch64_libidn-javadoc = "${EPEL_MIRROR}/aarch64/Packages/l/libidn-javadoc-1.44-1.el10_3.noarch.rpm;name=aarch64_libidn-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libidn-javadoc}"
SRC_URI[aarch64_libidn-javadoc.sha256sum] = "733e6d0e205ae8ad55911cd8bfad6693697ad8079cbb42a2ae8b7d386f674313"

RDEPENDS:libidn = " \
 emacs-filesystem \
 glibc \
 "
RDEPENDS:libidn-devel = " \
 libidn \
 pkgconf-pkg-config \
 "
RDEPENDS:libidn-java = " \
 javapackages-filesystem \
 "
RDEPENDS:libidn-javadoc = " \
 javapackages-filesystem \
 "
