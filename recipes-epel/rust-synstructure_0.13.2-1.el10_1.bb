# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-synstructure"
PV = "0.13.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-synstructure+default-devel \
 rust-synstructure+proc-macro-devel \
 rust-synstructure-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-synstructure-0.13.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbd72b3e2e3d374333fc51319a61ed402bc6d94ef8b7c086bd0f9bdbd8baaabe"

URI_x86_64_v2_rust-synstructure+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-synstructure+default-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-synstructure+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-synstructure+default-devel}"
SRC_URI[x86_64_v2_rust-synstructure+default-devel.sha256sum] = "7cbbcee30cff51492166e6c31328db85d50ee9a1b0f533400b6053e8cc809163"

URI_x86_64_v2_rust-synstructure+proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-synstructure+proc-macro-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-synstructure+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-synstructure+proc-macro-devel}"
SRC_URI[x86_64_v2_rust-synstructure+proc-macro-devel.sha256sum] = "78d12fd0e1ac55b3ab32dd979b2db4576186857671c6f0b190b290df3d6def65"

URI_x86_64_v2_rust-synstructure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-synstructure-devel-0.13.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-synstructure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-synstructure-devel}"
SRC_URI[x86_64_v2_rust-synstructure-devel.sha256sum] = "d76407a37d8f8e385eb606489dbb9af44af5186c25cfae99a0ecf025f0bd764f"

URI_aarch64_rust-synstructure+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-synstructure+default-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-synstructure+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-synstructure+default-devel}"
SRC_URI[aarch64_rust-synstructure+default-devel.sha256sum] = "1da3502acffd33971f6cbf3bd063855ba78b5512f22bb894e31a2df3d850a98d"

URI_aarch64_rust-synstructure+proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-synstructure+proc-macro-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-synstructure+proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-synstructure+proc-macro-devel}"
SRC_URI[aarch64_rust-synstructure+proc-macro-devel.sha256sum] = "cf2f0064644ca32695b9db6df6ce4b6e6916c35ea65c42a5ec9a6c828bc4202a"

URI_aarch64_rust-synstructure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-synstructure-devel-0.13.2-1.el10_1.noarch.rpm;name=aarch64_rust-synstructure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-synstructure-devel}"
SRC_URI[aarch64_rust-synstructure-devel.sha256sum] = "5530bc4a7bde8df1be062a6331cba9725bc5f3f9eed41c5330f4f33d0166ba32"

RDEPENDS:rust-synstructure+default-devel = " \
 cargo \
 rust-synstructure+proc-macro-devel \
 rust-synstructure-devel \
 "
RDEPENDS:rust-synstructure+proc-macro-devel = " \
 cargo \
 rust-proc-macro2+proc-macro-devel \
 rust-quote+proc-macro-devel \
 rust-syn+proc-macro-devel \
 rust-synstructure-devel \
 "
RDEPENDS:rust-synstructure-devel = " \
 cargo \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+visit-devel \
 rust-syn-devel \
 "
