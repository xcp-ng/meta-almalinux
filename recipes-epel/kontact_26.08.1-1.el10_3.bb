# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontact"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kontact \
 kontact-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kontact-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df6b6eaae9502eeec4a2559595fb8ac13c081b7bac68a099669512c7e2bf4218"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontact-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontact;unpack=0"
SRC_URI[x86_64_v2_kontact.sha256sum] = "8290a21861c9e0119da3e0206a7e9fee3ca9159c8e7f96726f532d0151d9e3a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontact-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontact-libs;unpack=0"
SRC_URI[x86_64_v2_kontact-libs.sha256sum] = "a6c630469188bb55811f10d77124ba1735241028327f23652e5f445556cdde79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kontact-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kontact;unpack=0"
SRC_URI[aarch64_kontact.sha256sum] = "2eaef2ac492fba5c205ec2d0937dfd1d59883f557792d1ff2a68d82150983d94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kontact-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kontact-libs;unpack=0"
SRC_URI[aarch64_kontact-libs.sha256sum] = "431c703078d0323bdf65c54cc23ecb0c13773e085efa1bdfd78659ac6820317a"

RDEPENDS:kontact = " \
 glibc \
 kaddressbook \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kxmlgui \
 kmail \
 kontact-libs \
 kontactinterface \
 korganizer \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kontact-libs = " \
 glibc \
 grantleetheme \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontact \
 kontactinterface \
 ktextaddons-qt6 \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
