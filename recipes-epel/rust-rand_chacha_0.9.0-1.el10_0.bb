# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_chacha"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand_chacha+default-devel \
 rust-rand_chacha+os_rng-devel \
 rust-rand_chacha+serde-devel \
 rust-rand_chacha+std-devel \
 rust-rand_chacha-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_chacha-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47ac56ed7cb507c512f60aaa17c4a408ec47e417501a679f015dd5953802ee29"

URI_x86_64_v2_rust-rand_chacha+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha+default-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha+default-devel.sha256sum] = "05ce2fd412771e8ffdb2b79e088246ec9eaa596c690681a2649810201cd7e0b6"

URI_x86_64_v2_rust-rand_chacha+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha+os_rng-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha+os_rng-devel.sha256sum] = "d1c6a3bfbc4dce00581b6b66eef4252401e33c70ca84d247c7e09348ef68f2ae"

URI_x86_64_v2_rust-rand_chacha+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha+serde-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha+serde-devel.sha256sum] = "ee8ee47d25e7c647261105387e7f324f71b085d8b764e4316cc66b163e04059f"

URI_x86_64_v2_rust-rand_chacha+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha+std-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha+std-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha+std-devel.sha256sum] = "81b031fcf6d93f94044417abf0c9ffea5ae2cb56a6f9ad23464af18471049fd0"

URI_x86_64_v2_rust-rand_chacha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha-devel.sha256sum] = "7a851045e34e4ead2c6ff7cabe619526c89931965104050e8b798f2290d4e70b"

URI_aarch64_rust-rand_chacha+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha+default-devel}"
SRC_URI[aarch64_rust-rand_chacha+default-devel.sha256sum] = "ca2f7ab42297de60f8beecedc8c0925bb6a66f6f0484a1ec300c10f70d0472b6"

URI_aarch64_rust-rand_chacha+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha+os_rng-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha+os_rng-devel}"
SRC_URI[aarch64_rust-rand_chacha+os_rng-devel.sha256sum] = "7c52dd3cb5efca35c0a72f29eca6c09948ca0a4c8423e4edb01256548f976041"

URI_aarch64_rust-rand_chacha+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha+serde-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha+serde-devel}"
SRC_URI[aarch64_rust-rand_chacha+serde-devel.sha256sum] = "20002c22855daa00a6e0f329343a362d5c956533050c267235d1e4435762ac36"

URI_aarch64_rust-rand_chacha+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha+std-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha+std-devel}"
SRC_URI[aarch64_rust-rand_chacha+std-devel.sha256sum] = "75415719621de19d88246f7e2abb5d24b7872ad54371eab20ce9b2ad7268b406"

URI_aarch64_rust-rand_chacha-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-rand_chacha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha-devel}"
SRC_URI[aarch64_rust-rand_chacha-devel.sha256sum] = "2054325bc40784c77994674d64517a41afe77124cb9d7a2c0e79ca2d0df827b1"

RDEPENDS:rust-rand_chacha+default-devel = " \
 cargo \
 rust-rand_chacha+std-devel \
 rust-rand_chacha-devel \
 "
RDEPENDS:rust-rand_chacha+os_rng-devel = " \
 cargo \
 rust-rand_chacha-devel \
 rust-rand_core+os_rng-devel \
 "
RDEPENDS:rust-rand_chacha+serde-devel = " \
 cargo \
 rust-rand_chacha-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_chacha+std-devel = " \
 cargo \
 rust-ppv-lite86+std-devel \
 rust-rand_chacha-devel \
 rust-rand_core+std-devel \
 "
RDEPENDS:rust-rand_chacha-devel = " \
 cargo \
 rust \
 rust-ppv-lite86+simd-devel \
 rust-ppv-lite86-devel \
 rust-rand_core+default-devel \
 "
