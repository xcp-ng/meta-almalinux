# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indicatif"
PV = "0.17.11"
PR = "1.el10_0"
PACKAGES = " \
 rust-indicatif+default-devel \
 rust-indicatif+futures-devel \
 rust-indicatif+improved_unicode-devel \
 rust-indicatif+in_memory-devel \
 rust-indicatif+rayon-devel \
 rust-indicatif+tokio-devel \
 rust-indicatif+unicode-segmentation-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif+vt100-devel \
 rust-indicatif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indicatif-0.17.11-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0c301bf5448470030990f27873ba6479ef6139c170f406416150538e1929102"

URI_x86_64_v2_rust-indicatif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+default-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+default-devel}"
SRC_URI[x86_64_v2_rust-indicatif+default-devel.sha256sum] = "d8ef9f49ae9b3bb910706a890770f649965e799f480f5f2543e11e4779e80b54"

URI_x86_64_v2_rust-indicatif+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+futures-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+futures-devel}"
SRC_URI[x86_64_v2_rust-indicatif+futures-devel.sha256sum] = "1dc5f5bf419aa1806039ccf7d2de9f2154b5b34128a3f72ba77743db995721f8"

URI_x86_64_v2_rust-indicatif+improved_unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+improved_unicode-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+improved_unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+improved_unicode-devel}"
SRC_URI[x86_64_v2_rust-indicatif+improved_unicode-devel.sha256sum] = "34a5a20edef12d9c72f1f0b3ad90180bd7504a423a1b17959eb5b52edb36d277"

URI_x86_64_v2_rust-indicatif+in_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+in_memory-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+in_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+in_memory-devel}"
SRC_URI[x86_64_v2_rust-indicatif+in_memory-devel.sha256sum] = "ce42bcaf6a9b42b7daa22a9c6e68d3a14c76a448ddf1c37567b9f63f0939d0a7"

URI_x86_64_v2_rust-indicatif+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+rayon-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+rayon-devel}"
SRC_URI[x86_64_v2_rust-indicatif+rayon-devel.sha256sum] = "3a8bec9f5d03a77eb704ed73bc469b6f95479c5959c82afb5187404b2b84b828"

URI_x86_64_v2_rust-indicatif+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+tokio-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+tokio-devel}"
SRC_URI[x86_64_v2_rust-indicatif+tokio-devel.sha256sum] = "ce5a8a5990371c362de44838f34e53fce2293cfaa5516cdca4bfd326924bd6b2"

URI_x86_64_v2_rust-indicatif+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+unicode-segmentation-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-indicatif+unicode-segmentation-devel.sha256sum] = "d3361587a3cb99bbadad0b5b93b481ccfe1721aa8ed8c3d95641ed7e44eeae49"

URI_x86_64_v2_rust-indicatif+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+unicode-width-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-indicatif+unicode-width-devel.sha256sum] = "6eb63fab9105bd8748093766f29897a129602880d0e879f3071c44bd28ba3283"

URI_x86_64_v2_rust-indicatif+vt100-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+vt100-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+vt100-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+vt100-devel}"
SRC_URI[x86_64_v2_rust-indicatif+vt100-devel.sha256sum] = "b59932d3bbc02c90e802f8b04feb32e4dda3ee9582d2cbb01c01be8fbeaa2de4"

URI_x86_64_v2_rust-indicatif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif-devel-0.17.11-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif-devel}"
SRC_URI[x86_64_v2_rust-indicatif-devel.sha256sum] = "f4402339007c4d8b029ce44b24489e8e5b46ab67766732d44752663dc28afec7"

URI_aarch64_rust-indicatif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+default-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+default-devel}"
SRC_URI[aarch64_rust-indicatif+default-devel.sha256sum] = "4723fbbcbd3f06d27daa6220c41e6b10c0f85746e2cc9f190510ceffb6eccbf8"

URI_aarch64_rust-indicatif+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+futures-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+futures-devel}"
SRC_URI[aarch64_rust-indicatif+futures-devel.sha256sum] = "0a07d1f78f6d6ff2214bdc0194c6fb9a2ffa23490710037f2861a484c103db43"

URI_aarch64_rust-indicatif+improved_unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+improved_unicode-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif+improved_unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+improved_unicode-devel}"
SRC_URI[aarch64_rust-indicatif+improved_unicode-devel.sha256sum] = "25e25ce38b809f549cf15dbf700fe72d7f3ee055f9f9a3a8d5ba204de7440d38"

URI_aarch64_rust-indicatif+in_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+in_memory-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif+in_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+in_memory-devel}"
SRC_URI[aarch64_rust-indicatif+in_memory-devel.sha256sum] = "4d2a9a8bc4b1a38c010914d9d260151c2790ee6b126872ffa54c7ebd90c53cd4"

URI_aarch64_rust-indicatif+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+rayon-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+rayon-devel}"
SRC_URI[aarch64_rust-indicatif+rayon-devel.sha256sum] = "fee2f13b3c83e0d090adbf2b603ccb643fac78a4b93403178cfac0e3172994ce"

URI_aarch64_rust-indicatif+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+tokio-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+tokio-devel}"
SRC_URI[aarch64_rust-indicatif+tokio-devel.sha256sum] = "3b1331e7c345c9a69b710f1b9fe7967090544484138adb16c9460dd527afef61"

URI_aarch64_rust-indicatif+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+unicode-segmentation-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-indicatif+unicode-segmentation-devel.sha256sum] = "3aa5e3f2f8f20ccd8c18f772099640b751d20eff152ed0bd5f8adb70f9bc55de"

URI_aarch64_rust-indicatif+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+unicode-width-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+unicode-width-devel}"
SRC_URI[aarch64_rust-indicatif+unicode-width-devel.sha256sum] = "69de8dc967b9076bfdbb5914a719bbf6698afcaa6a3a79f8e052c52c76568275"

URI_aarch64_rust-indicatif+vt100-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+vt100-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif+vt100-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+vt100-devel}"
SRC_URI[aarch64_rust-indicatif+vt100-devel.sha256sum] = "fe0cde46a33d92791bdb8414a9948a4df16b91f262b7bcb900ab783d6e040fd5"

URI_aarch64_rust-indicatif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif-devel-0.17.11-1.el10_0.noarch.rpm;name=aarch64_rust-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif-devel}"
SRC_URI[aarch64_rust-indicatif-devel.sha256sum] = "947abb6b5c64bd1671860a7a20c8100fa8f178888b7ce6ee98a0ae309339d1be"

RDEPENDS:rust-indicatif+default-devel = " \
 cargo \
 rust-console+unicode-width-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+futures-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+improved_unicode-devel = " \
 cargo \
 rust-console+unicode-width-devel \
 rust-indicatif+unicode-segmentation-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+in_memory-devel = " \
 cargo \
 rust-indicatif+vt100-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+rayon-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indicatif+tokio-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-indicatif+unicode-segmentation-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-indicatif+unicode-width-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-indicatif+vt100-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-vt100+default-devel \
 "
RDEPENDS:rust-indicatif-devel = " \
 cargo \
 rust \
 rust-console+ansi-parsing-devel \
 rust-console-devel \
 rust-number_prefix+default-devel \
 rust-portable-atomic+default-devel \
 "
