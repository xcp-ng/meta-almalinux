# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Daemon"
PV = "6.16"
PR = "8.el10"
PACKAGES = " \
 perl-HTTP-Daemon \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-HTTP-Daemon-6.16-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "83bf964d0b571c0917dab4da5f94379bc83b1c46f6ebae079a097b1d2a648929"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-HTTP-Daemon-6.16-8.el10.noarch.rpm;name=x86_64_v2_perl-HTTP-Daemon;unpack=0"
SRC_URI[x86_64_v2_perl-HTTP-Daemon.sha256sum] = "4b90e21473fd801368c739a6e81e40621d2064405b029fe996f4ee2e204bf7dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-HTTP-Daemon-6.16-8.el10.noarch.rpm;name=aarch64_perl-HTTP-Daemon;unpack=0"
SRC_URI[aarch64_perl-HTTP-Daemon.sha256sum] = "4b90e21473fd801368c739a6e81e40621d2064405b029fe996f4ee2e204bf7dc"

RDEPENDS:perl-HTTP-Daemon = " \
 perl-Carp \
 perl-HTTP-Date \
 perl-HTTP-Message \
 perl-IO-Socket-IP \
 perl-LWP-MediaTypes \
 perl-Socket \
 perl-libs \
 "
