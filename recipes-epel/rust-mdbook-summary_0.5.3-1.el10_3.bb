# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mdbook-summary"
PV = "0.5.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-mdbook-summary+default-devel \
 rust-mdbook-summary-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mdbook-summary-0.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3905ea8b22d838c9b6e112317e4ce1347f618111f0204b4a4ac874ab52050cf"

URI_x86_64_v2_rust-mdbook-summary+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-summary+default-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-summary+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-summary+default-devel}"
SRC_URI[x86_64_v2_rust-mdbook-summary+default-devel.sha256sum] = "34715302acd8cfb04bf25c6d111b80b546f130a9f948c94fba1049a2a657fb65"

URI_x86_64_v2_rust-mdbook-summary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mdbook-summary-devel-0.5.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mdbook-summary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mdbook-summary-devel}"
SRC_URI[x86_64_v2_rust-mdbook-summary-devel.sha256sum] = "a24e7b88a5ce9a0036a00c32e50f030ab22316db4dd89c20cd293f8446743fc4"

URI_aarch64_rust-mdbook-summary+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-summary+default-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-summary+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-summary+default-devel}"
SRC_URI[aarch64_rust-mdbook-summary+default-devel.sha256sum] = "7533664128ee43b6d3024e8cbc75b19d47a2e4118002dec826946cecaaa6ae18"

URI_aarch64_rust-mdbook-summary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mdbook-summary-devel-0.5.3-1.el10_3.noarch.rpm;name=aarch64_rust-mdbook-summary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mdbook-summary-devel}"
SRC_URI[aarch64_rust-mdbook-summary-devel.sha256sum] = "b76e84b425ea3702a2d586e76cb0e897dcaf412cd86da2002d5def871bf174e0"

RDEPENDS:rust-mdbook-summary+default-devel = " \
 cargo \
 rust-mdbook-summary-devel \
 "
RDEPENDS:rust-mdbook-summary-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-mdbook-core+default-devel \
 rust-memchr+default-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-tracing+default-devel \
 "
