# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "krb5"
PV = "1.21.3"
PR = "9.el10_1"
PACKAGES = " \
 krb5-devel \
 krb5-libs \
 krb5-pkinit \
 krb5-server \
 krb5-server-ldap \
 krb5-workstation \
 libkadm5 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/krb5-1.21.3-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f5f6aa5f93c209b494d54ea31fde4ea5bf94e7e3bd21603e1751d018aabe73b"

URI_x86_64_v2_krb5-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/krb5-devel-1.21.3-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_krb5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-devel}"
SRC_URI[x86_64_v2_krb5-devel.sha256sum] = "416525c541ffb7364bb79f41746216d4b76270160509cd0a34df15b5c87af95d"

URI_x86_64_v2_krb5-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-libs-1.21.3-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_krb5-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-libs}"
SRC_URI[x86_64_v2_krb5-libs.sha256sum] = "b4b6fcbc91fef09bd35f3f06123c220e36bebe443bb202eb46eeb13c0e080d7d"

URI_x86_64_v2_krb5-pkinit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-pkinit-1.21.3-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_krb5-pkinit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-pkinit}"
SRC_URI[x86_64_v2_krb5-pkinit.sha256sum] = "1634e70147705b0f37873e4aae7aab4cd643aef9f4c7480caa47f94aeba08ec8"

URI_x86_64_v2_krb5-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-server-1.21.3-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_krb5-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-server}"
SRC_URI[x86_64_v2_krb5-server.sha256sum] = "0fd9fdb3e7dc34e3d1fbe6ff3d95fb057ca65fdda9840a96f6090d3288981391"

URI_x86_64_v2_krb5-server-ldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-server-ldap-1.21.3-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_krb5-server-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-server-ldap}"
SRC_URI[x86_64_v2_krb5-server-ldap.sha256sum] = "b8cd805b91f4d3e40ffea3329af713ea4541cd6d6804b982301fb65c79475269"

URI_x86_64_v2_krb5-workstation = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/krb5-workstation-1.21.3-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_krb5-workstation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_krb5-workstation}"
SRC_URI[x86_64_v2_krb5-workstation.sha256sum] = "d3876b7759dbe15bc15904afd019cc508aeef2d42e375c87265504e54b31feb1"

URI_x86_64_v2_libkadm5 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libkadm5-1.21.3-9.el10_1.x86_64_v2.rpm;name=x86_64_v2_libkadm5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkadm5}"
SRC_URI[x86_64_v2_libkadm5.sha256sum] = "200463473c22220e2d0e97d11c3ba5b8fd4af3563b3ce7ac8ccbf68e13330321"

URI_aarch64_krb5-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/krb5-devel-1.21.3-9.el10_1.aarch64.rpm;name=aarch64_krb5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-devel}"
SRC_URI[aarch64_krb5-devel.sha256sum] = "a218c51cf1684fcb8c111a9715952d07ccfaa89bc4e2227823854bfba6d2218e"

URI_aarch64_krb5-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-libs-1.21.3-9.el10_1.aarch64.rpm;name=aarch64_krb5-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-libs}"
SRC_URI[aarch64_krb5-libs.sha256sum] = "2290cdbb09699fa41fc3a2d33582dbb6e9f85838602787a47c9bb84ea2ac0d0d"

URI_aarch64_krb5-pkinit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-pkinit-1.21.3-9.el10_1.aarch64.rpm;name=aarch64_krb5-pkinit;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-pkinit}"
SRC_URI[aarch64_krb5-pkinit.sha256sum] = "2cada5ada73b5be72d46a777f063a0caa349e08b13b81004425182360ccd5b32"

URI_aarch64_krb5-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-server-1.21.3-9.el10_1.aarch64.rpm;name=aarch64_krb5-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-server}"
SRC_URI[aarch64_krb5-server.sha256sum] = "ecc7a0984a12c98db0ae9f56541e1c7a6f042fac7bad66c4d8cb1a0931887d81"

URI_aarch64_krb5-server-ldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-server-ldap-1.21.3-9.el10_1.aarch64.rpm;name=aarch64_krb5-server-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-server-ldap}"
SRC_URI[aarch64_krb5-server-ldap.sha256sum] = "74f72720cd9017c3da64bdd7326be4562a66e8f84eaf5a20bee8cc4de7617fa5"

URI_aarch64_krb5-workstation = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/krb5-workstation-1.21.3-9.el10_1.aarch64.rpm;name=aarch64_krb5-workstation;unpack=0"
SRC_URI:append = " ${URI_aarch64_krb5-workstation}"
SRC_URI[aarch64_krb5-workstation.sha256sum] = "95896262d3d11ad2c9852fc2fa906ef051ae1f56896023c678f384e06d31409f"

URI_aarch64_libkadm5 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libkadm5-1.21.3-9.el10_1.aarch64.rpm;name=aarch64_libkadm5;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkadm5}"
SRC_URI[aarch64_libkadm5.sha256sum] = "70c4464074ebdd99cf7a9cbb61db7005a42bbec589d0bca04407e2983ac54d88"

RDEPENDS:krb5-devel = " \
 bash \
 keyutils-libs-devel \
 krb5-devel \
 krb5-libs \
 libcom_err-devel \
 libkadm5 \
 libselinux-devel \
 libverto-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:krb5-libs = " \
 crypto-policies \
 gawk \
 glibc \
 keyutils-libs \
 libcom_err \
 libselinux \
 libverto \
 openssl-libs \
 sed \
 virtual/coreutils \
 "
RDEPENDS:krb5-pkinit = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 openssl-libs \
 "
RDEPENDS:krb5-server = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 krb5-pkinit \
 libcom_err \
 libkadm5 \
 libselinux \
 libss \
 libverto \
 libverto-libev \
 lmdb-libs \
 logrotate \
 openssl-libs \
 systemd \
 words \
 "
RDEPENDS:krb5-server-ldap = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 krb5-server \
 libcom_err \
 libkadm5 \
 openldap \
 openssl-libs \
 "
RDEPENDS:krb5-workstation = " \
 bash \
 glibc \
 krb5-libs \
 krb5-pkinit \
 libcom_err \
 libkadm5 \
 libss \
 pam-libs \
 "
RDEPENDS:libkadm5 = " \
 glibc \
 keyutils-libs \
 krb5-libs \
 libcom_err \
 openssl-libs \
 "
