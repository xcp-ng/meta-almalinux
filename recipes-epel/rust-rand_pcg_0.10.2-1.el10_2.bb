# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_pcg"
PV = "0.10.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_pcg+default-devel \
 rust-rand_pcg+serde-devel \
 rust-rand_pcg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_pcg-0.10.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28239f589e1046d5656881861e7dcbd14145fc98bf14fe0584372c066fc3af6c"

URI_x86_64_v2_rust-rand_pcg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg+default-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg+default-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg+default-devel.sha256sum] = "6eabe6ee6d3b815c8139a6f16058991385cda0fa81b0c9757a9f1e856cf1a066"

URI_x86_64_v2_rust-rand_pcg+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg+serde-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg+serde-devel.sha256sum] = "f7363f396432b64d27e77c68953d1587595554e6dbeac983f0f469db8b7e40cd"

URI_x86_64_v2_rust-rand_pcg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg-devel.sha256sum] = "796d645cda65975fd38d407eeb0f09a94d472f53ba83f7cd36ddc87dc17c1412"

URI_aarch64_rust-rand_pcg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg+default-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand_pcg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg+default-devel}"
SRC_URI[aarch64_rust-rand_pcg+default-devel.sha256sum] = "d8d473dce343c3189dbde00a395401e632415519e71b6b5baf17679862157dee"

URI_aarch64_rust-rand_pcg+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg+serde-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand_pcg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg+serde-devel}"
SRC_URI[aarch64_rust-rand_pcg+serde-devel.sha256sum] = "0df83152140a425ce7a5b6de11d8e50a1a89293fca2c86546c5981372e2c0b64"

URI_aarch64_rust-rand_pcg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-rand_pcg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg-devel}"
SRC_URI[aarch64_rust-rand_pcg-devel.sha256sum] = "f8590b71909fcc9ff6b79b3647d288cddbd893d79f0d66b957f7bc85528c2190"

RDEPENDS:rust-rand_pcg+default-devel = " \
 cargo \
 rust-rand_pcg-devel \
 "
RDEPENDS:rust-rand_pcg+serde-devel = " \
 cargo \
 rust-rand_pcg-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_pcg-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
