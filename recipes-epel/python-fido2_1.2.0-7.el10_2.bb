# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fido2"
PV = "1.2.0"
PR = "7.el10_2"
PACKAGES = " \
 python3-fido2 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-fido2-1.2.0-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "07007fb47c179f971712b65bdab36713749b62d8d1b96630bbbe9b4c08114fa5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fido2-1.2.0-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fido2;unpack=0"
SRC_URI[x86_64_v2_python3-fido2.sha256sum] = "1ed53f72f52da3ff45b6a1620e98da03286df0c6095d520c885ed89293754a2c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-fido2-1.2.0-7.el10_2.noarch.rpm;name=aarch64_python3-fido2;unpack=0"
SRC_URI[aarch64_python3-fido2.sha256sum] = "5b1ad887f6f34068b0b0daec65016882af8d788116d94f385f3f386d1c53e89c"

RDEPENDS:python3-fido2 = " \
 python3 \
 python3-cryptography \
 "
