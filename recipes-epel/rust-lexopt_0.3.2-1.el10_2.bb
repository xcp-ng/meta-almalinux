# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexopt"
PV = "0.3.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-lexopt+default-devel \
 rust-lexopt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexopt-0.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7444146bc7fab90f45c45b95d0867d5888b9fd7cf9b5a9564b9570657a983dd5"

URI_x86_64_v2_rust-lexopt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexopt+default-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexopt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexopt+default-devel}"
SRC_URI[x86_64_v2_rust-lexopt+default-devel.sha256sum] = "21f8590f92e8c04517194af6b035f2170138a942e5751e7daca620ca798d6d5c"

URI_x86_64_v2_rust-lexopt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexopt-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexopt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexopt-devel}"
SRC_URI[x86_64_v2_rust-lexopt-devel.sha256sum] = "e6afe0c9a55a90a661091cbee4c0e1ac2f33a707b7da0508f25272fd8fc2cd45"

URI_aarch64_rust-lexopt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexopt+default-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-lexopt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexopt+default-devel}"
SRC_URI[aarch64_rust-lexopt+default-devel.sha256sum] = "05af3243da1e687349d87805aa2232398a5d36ddc6392a5223d9386b52a1a776"

URI_aarch64_rust-lexopt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexopt-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-lexopt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexopt-devel}"
SRC_URI[aarch64_rust-lexopt-devel.sha256sum] = "97e95106519782f295a3acb7a7e07dae8522919018c0b15996492cd79f0c67d3"

RDEPENDS:rust-lexopt+default-devel = " \
 cargo \
 rust-lexopt-devel \
 "
RDEPENDS:rust-lexopt-devel = " \
 cargo \
 "
