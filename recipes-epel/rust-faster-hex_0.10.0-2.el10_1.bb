# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-faster-hex"
PV = "0.10.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-faster-hex+alloc-devel \
 rust-faster-hex+default-devel \
 rust-faster-hex+serde-devel \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-faster-hex-0.10.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd0d23d76eecfe02a740318ca10f6e4e028427a4cc29173e00b84d3bed537534"

URI_x86_64_v2_rust-faster-hex+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex+alloc-devel-0.10.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex+alloc-devel}"
SRC_URI[x86_64_v2_rust-faster-hex+alloc-devel.sha256sum] = "3a5a4545ae7cfafa291ad101775b2aae5d37bac70026021baa6f8661d60f1aad"

URI_x86_64_v2_rust-faster-hex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex+default-devel-0.10.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex+default-devel}"
SRC_URI[x86_64_v2_rust-faster-hex+default-devel.sha256sum] = "582ee306633bc737d3ed3710b513024cf29243da389bac7b037acb95cc67b547"

URI_x86_64_v2_rust-faster-hex+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex+serde-devel-0.10.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex+serde-devel}"
SRC_URI[x86_64_v2_rust-faster-hex+serde-devel.sha256sum] = "babc101e638eb65f4fba5db78d098d4ccc076adb946e636e0d3a850ccc29be44"

URI_x86_64_v2_rust-faster-hex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex+std-devel-0.10.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex+std-devel}"
SRC_URI[x86_64_v2_rust-faster-hex+std-devel.sha256sum] = "b0847c10e4452445e5050eb252df56ea19cb8dd90f82e48a153389c1396fe3bb"

URI_x86_64_v2_rust-faster-hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-faster-hex-devel-0.10.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-faster-hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-faster-hex-devel}"
SRC_URI[x86_64_v2_rust-faster-hex-devel.sha256sum] = "b00c6b1841f96d9f9f25b103e6ade4a632bfa979668d95758d1a6e06a1dc456e"

URI_aarch64_rust-faster-hex+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex+alloc-devel-0.10.0-2.el10_1.noarch.rpm;name=aarch64_rust-faster-hex+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex+alloc-devel}"
SRC_URI[aarch64_rust-faster-hex+alloc-devel.sha256sum] = "e90f7a7739fe047501baf2bc5cafc6d03beefd86c04ab6863965e7046db765b6"

URI_aarch64_rust-faster-hex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex+default-devel-0.10.0-2.el10_1.noarch.rpm;name=aarch64_rust-faster-hex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex+default-devel}"
SRC_URI[aarch64_rust-faster-hex+default-devel.sha256sum] = "61dbc5fab35cd1a7cbbb2d1ff14bd820561347d35103e2e8a5cda377226becb7"

URI_aarch64_rust-faster-hex+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex+serde-devel-0.10.0-2.el10_1.noarch.rpm;name=aarch64_rust-faster-hex+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex+serde-devel}"
SRC_URI[aarch64_rust-faster-hex+serde-devel.sha256sum] = "0462c8dc098e587476a3efce4aae94079a8c691ae537e5f285f6dfa037bb8c34"

URI_aarch64_rust-faster-hex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex+std-devel-0.10.0-2.el10_1.noarch.rpm;name=aarch64_rust-faster-hex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex+std-devel}"
SRC_URI[aarch64_rust-faster-hex+std-devel.sha256sum] = "089afc7288a37953b772730a3c4e2a1ee29979a435e8a7bb594fb0a6161443b8"

URI_aarch64_rust-faster-hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-faster-hex-devel-0.10.0-2.el10_1.noarch.rpm;name=aarch64_rust-faster-hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-faster-hex-devel}"
SRC_URI[aarch64_rust-faster-hex-devel.sha256sum] = "5dc4dbed476928a12709f6ddc4cd5d2a4f4fbe40fa4fbdf08ba78246181ee0dc"

RDEPENDS:rust-faster-hex+alloc-devel = " \
 cargo \
 rust-faster-hex-devel \
 "
RDEPENDS:rust-faster-hex+default-devel = " \
 cargo \
 rust-faster-hex+serde-devel \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 "
RDEPENDS:rust-faster-hex+serde-devel = " \
 cargo \
 rust-faster-hex+alloc-devel \
 rust-faster-hex-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-faster-hex+std-devel = " \
 cargo \
 rust-faster-hex+alloc-devel \
 rust-faster-hex-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-faster-hex-devel = " \
 cargo \
 rust-heapless+default-devel \
 "
