# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squidclamav"
PV = "7.4"
PR = "1.el10_0"
PACKAGES = " \
 squidclamav \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/squidclamav-7.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1f7862a9f591fda66c17996622ebc663163f3b9197e555c6da234746eff3f32"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squidclamav-7.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squidclamav;unpack=0"
SRC_URI[x86_64_v2_squidclamav.sha256sum] = "36b3d0573d6875c2e6ab6cebcb978eb07d43c42c5bde7d76592a48d976074460"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/squidclamav-7.4-1.el10_0.aarch64.rpm;name=aarch64_squidclamav;unpack=0"
SRC_URI[aarch64_squidclamav.sha256sum] = "6498f0d178d8e76bbf2676fa918f1fcb08bba49cace1421bb0d67fd6078c8026"

RDEPENDS:squidclamav = " \
 bzip2-libs \
 c-icap \
 glibc \
 httpd-filesystem \
 libarchive \
 perl-interpreter \
 squid \
 zlib-ng-compat \
 "
