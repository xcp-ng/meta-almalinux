# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyvmomi"
PV = "9.0.0.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-pyvmomi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyvmomi-9.0.0.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e066dd3947267398cf49ada4f86855987f7ac40fc32cd22c9a0e9f2f8ec8582"

URI_x86_64_v2_python3-pyvmomi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyvmomi-9.0.0.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyvmomi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyvmomi}"
SRC_URI[x86_64_v2_python3-pyvmomi.sha256sum] = "277f7b80f101fa350bf560dc2b27127c150d3f25326045876ce5a9f5d474e71e"

URI_aarch64_python3-pyvmomi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyvmomi-9.0.0.0-1.el10_2.noarch.rpm;name=aarch64_python3-pyvmomi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyvmomi}"
SRC_URI[aarch64_python3-pyvmomi.sha256sum] = "63f2436c2cb040442849c6fe5edf67cbd064a450b6491c27ea3bf751dff23bfc"

RDEPENDS:python3-pyvmomi = " \
 python3 \
 "
