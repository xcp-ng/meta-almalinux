# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distgen"
PV = "2.4"
PR = "1.el10_3"
PACKAGES = " \
 distgen \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/distgen-2.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c1df64d95120401ce9cea64ab733082ea463ef852408cbc8bb1059284af614b8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distgen-2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_distgen;unpack=0"
SRC_URI[x86_64_v2_distgen.sha256sum] = "12edb76c3aafc774602ac020d4b1108a1de8b7c2e8ce4e57ac0c362635835e3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/distgen-2.4-1.el10_3.noarch.rpm;name=aarch64_distgen;unpack=0"
SRC_URI[aarch64_distgen.sha256sum] = "46453af2d88c755e55db80247a5a7f13a9d7e19121a7d668e1966dfc1ee808f5"

RDEPENDS:distgen = " \
 python3 \
 python3-distro \
 python3-jinja2 \
 python3-pyyaml \
 python3-setuptools \
 "
