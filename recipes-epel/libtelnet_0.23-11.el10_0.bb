# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtelnet"
PV = "0.23"
PR = "11.el10_0"
PACKAGES = " \
 libtelnet \
 libtelnet-devel \
 libtelnet-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libtelnet-0.23-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9bb018427119571f62f8acf7494269f0cb85da6ad22406174b79d3d5de467f63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtelnet-0.23-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtelnet;unpack=0"
SRC_URI[x86_64_v2_libtelnet.sha256sum] = "5539f8bb33fedec149578601b49821155422ea3e180a4c06911d2069ecd35c4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtelnet-devel-0.23-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtelnet-devel;unpack=0"
SRC_URI[x86_64_v2_libtelnet-devel.sha256sum] = "d2225084f9aab821cd90c9ef49a00c88eb8277dfd67f52828080b43535f73e93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtelnet-utils-0.23-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtelnet-utils;unpack=0"
SRC_URI[x86_64_v2_libtelnet-utils.sha256sum] = "83d00b575291c3ae225bbbd0f7922835d980095abb47868bdc274f58a81d4dd9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libtelnet-0.23-11.el10_0.aarch64.rpm;name=aarch64_libtelnet;unpack=0"
SRC_URI[aarch64_libtelnet.sha256sum] = "be61031080c71d4ea5b7d88bab9046dd5a8d152e388dd2b97fd00e3bd02a6596"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libtelnet-devel-0.23-11.el10_0.aarch64.rpm;name=aarch64_libtelnet-devel;unpack=0"
SRC_URI[aarch64_libtelnet-devel.sha256sum] = "5caa828974db04e2d40dbb7ba3c050dae2d6a7ddf35662fe382f7ee383f011c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libtelnet-utils-0.23-11.el10_0.aarch64.rpm;name=aarch64_libtelnet-utils;unpack=0"
SRC_URI[aarch64_libtelnet-utils.sha256sum] = "fc2741dbb7544ee28965dcebfc3313c4952442dbd0d696c5e4bc32ef893a7b6d"

RDEPENDS:libtelnet = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libtelnet-devel = " \
 libtelnet \
 pkgconf-pkg-config \
 "
RDEPENDS:libtelnet-utils = " \
 glibc \
 libtelnet \
 "
