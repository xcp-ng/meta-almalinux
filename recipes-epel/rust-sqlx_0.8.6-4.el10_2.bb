# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sqlx"
PV = "0.8.6"
PR = "4.el10_2"
PACKAGES = " \
 rust-sqlx+_rt-tokio-devel \
 rust-sqlx+_sqlite-devel \
 rust-sqlx+_unstable-all-types-devel \
 rust-sqlx+all-databases-devel \
 rust-sqlx+any-devel \
 rust-sqlx+bigdecimal-devel \
 rust-sqlx+bit-vec-devel \
 rust-sqlx+bstr-devel \
 rust-sqlx+chrono-devel \
 rust-sqlx+default-devel \
 rust-sqlx+derive-devel \
 rust-sqlx+ipnet-devel \
 rust-sqlx+ipnetwork-devel \
 rust-sqlx+json-devel \
 rust-sqlx+mac_address-devel \
 rust-sqlx+macros-devel \
 rust-sqlx+migrate-devel \
 rust-sqlx+mysql-devel \
 rust-sqlx+postgres-devel \
 rust-sqlx+regexp-devel \
 rust-sqlx+runtime-tokio-devel \
 rust-sqlx+runtime-tokio-native-tls-devel \
 rust-sqlx+runtime-tokio-rustls-devel \
 rust-sqlx+rust_decimal-devel \
 rust-sqlx+sqlite-devel \
 rust-sqlx+sqlite-preupdate-hook-devel \
 rust-sqlx+sqlite-unbundled-devel \
 rust-sqlx+sqlx-macros-devel \
 rust-sqlx+sqlx-mysql-devel \
 rust-sqlx+sqlx-postgres-devel \
 rust-sqlx+sqlx-sqlite-devel \
 rust-sqlx+time-devel \
 rust-sqlx+tls-native-tls-devel \
 rust-sqlx+tls-none-devel \
 rust-sqlx+tls-rustls-devel \
 rust-sqlx+tls-rustls-ring-devel \
 rust-sqlx+tls-rustls-ring-native-roots-devel \
 rust-sqlx+tls-rustls-ring-webpki-devel \
 rust-sqlx+uuid-devel \
 rust-sqlx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sqlx-0.8.6-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e97ffeb9edc50ee5b3d63b00947a3c9a99d2505400907423f4b4c563c2fc0c8a"

URI_x86_64_v2_rust-sqlx+_rt-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+_rt-tokio-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+_rt-tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx+_rt-tokio-devel.sha256sum] = "a6c3a0e7796200e4646f91a29eecabbf234971770fe46992aa00e0dbac186128"

URI_x86_64_v2_rust-sqlx+_sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+_sqlite-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+_sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx+_sqlite-devel.sha256sum] = "77341d933810d4ec1baabbb45d2d691171ebd2b98cb00e19c190528397267266"

URI_x86_64_v2_rust-sqlx+_unstable-all-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+_unstable-all-types-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+_unstable-all-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+_unstable-all-types-devel}"
SRC_URI[x86_64_v2_rust-sqlx+_unstable-all-types-devel.sha256sum] = "df1e7493111ca9152efdd7b37e352f9d49e2780603d5bebf14f56d4d60e10bdc"

URI_x86_64_v2_rust-sqlx+all-databases-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+all-databases-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+all-databases-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+all-databases-devel}"
SRC_URI[x86_64_v2_rust-sqlx+all-databases-devel.sha256sum] = "9ddff41b8d676018c8ccfaab31fa003be58b0723d94077c47e1637240fe6b46a"

URI_x86_64_v2_rust-sqlx+any-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+any-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+any-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+any-devel}"
SRC_URI[x86_64_v2_rust-sqlx+any-devel.sha256sum] = "2575a6bb8d24c2cd7f278556559b995407cb7da61eb65c2d37ced500557890b8"

URI_x86_64_v2_rust-sqlx+bigdecimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+bigdecimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+bigdecimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx+bigdecimal-devel.sha256sum] = "501dbbda8bb23fb5d9d36d0374d00f2f848c9cb2eb5ebe263696ff8757058817"

URI_x86_64_v2_rust-sqlx+bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+bit-vec-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+bit-vec-devel}"
SRC_URI[x86_64_v2_rust-sqlx+bit-vec-devel.sha256sum] = "ff330eefc69a9fdb669437e6a661495b9dd16b79e3a0c7fd329027b2b46d7cb1"

URI_x86_64_v2_rust-sqlx+bstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+bstr-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+bstr-devel}"
SRC_URI[x86_64_v2_rust-sqlx+bstr-devel.sha256sum] = "914ee7b34619c7e3a85727598f18c77361bf4ea3428c17369bfd1dd657943771"

URI_x86_64_v2_rust-sqlx+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+chrono-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+chrono-devel}"
SRC_URI[x86_64_v2_rust-sqlx+chrono-devel.sha256sum] = "fd0c189a490a3e68314be5e99d6ed6e39555fd36792b92b9a269f63818b3d47a"

URI_x86_64_v2_rust-sqlx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+default-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+default-devel}"
SRC_URI[x86_64_v2_rust-sqlx+default-devel.sha256sum] = "d6349e6e41a3b92330ca5b97b67f1ecd652038312e21b1bb98fffb0136004439"

URI_x86_64_v2_rust-sqlx+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+derive-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+derive-devel}"
SRC_URI[x86_64_v2_rust-sqlx+derive-devel.sha256sum] = "7141360513d4fe41cecf204016fe61c2cf41006461283742d88181dd9cb7a736"

URI_x86_64_v2_rust-sqlx+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+ipnet-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+ipnet-devel}"
SRC_URI[x86_64_v2_rust-sqlx+ipnet-devel.sha256sum] = "46087cc425129cb487feb742eecb9da2307850a56d983c9b4963f26879ac7964"

URI_x86_64_v2_rust-sqlx+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+ipnetwork-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-sqlx+ipnetwork-devel.sha256sum] = "af0fa8bc0e215131523e3e1b17b12d78f7c099480756ae2a6bd9aa0814b1922b"

URI_x86_64_v2_rust-sqlx+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+json-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+json-devel}"
SRC_URI[x86_64_v2_rust-sqlx+json-devel.sha256sum] = "5f77033e1d7876f6f4e20862c95fafd9d16f05b12e0e1797b2de55c65f4d92a3"

URI_x86_64_v2_rust-sqlx+mac_address-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+mac_address-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+mac_address-devel}"
SRC_URI[x86_64_v2_rust-sqlx+mac_address-devel.sha256sum] = "e5f52c1b68eba1fc821b1e52b62cdc53fba284d4fea71b5cedae96726c58798f"

URI_x86_64_v2_rust-sqlx+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+macros-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+macros-devel}"
SRC_URI[x86_64_v2_rust-sqlx+macros-devel.sha256sum] = "f8a6dff8e700a4575959cffccad2ebe91329eb8d2f6776bec273e7d864762431"

URI_x86_64_v2_rust-sqlx+migrate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+migrate-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+migrate-devel}"
SRC_URI[x86_64_v2_rust-sqlx+migrate-devel.sha256sum] = "09edb34a7c82152715cb671a6fb4361d57364ceaa684637a88c3c2adf298fc86"

URI_x86_64_v2_rust-sqlx+mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+mysql-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx+mysql-devel.sha256sum] = "702512b231bbb3059ea547f05f2eeac3a8ecd0cd5f56f7b544e33183e9939a61"

URI_x86_64_v2_rust-sqlx+postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+postgres-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx+postgres-devel.sha256sum] = "86c19523904c2376d9be18303981cfc3a068f4783d2cb00a581ccd271009caaf"

URI_x86_64_v2_rust-sqlx+regexp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+regexp-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+regexp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+regexp-devel}"
SRC_URI[x86_64_v2_rust-sqlx+regexp-devel.sha256sum] = "bf1eeb6d8439e005ab05e7f2fe6a732dbaf4402bbf91fc5005a58c9d9e468027"

URI_x86_64_v2_rust-sqlx+runtime-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+runtime-tokio-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+runtime-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+runtime-tokio-devel}"
SRC_URI[x86_64_v2_rust-sqlx+runtime-tokio-devel.sha256sum] = "80dc6a6321bf6efff0e51e2890932ea448126b1403211706b91f5c16d16f3032"

URI_x86_64_v2_rust-sqlx+runtime-tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+runtime-tokio-native-tls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+runtime-tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+runtime-tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx+runtime-tokio-native-tls-devel.sha256sum] = "01735ee4264b800fe9795812a751046699c651f1aeb16c61a486bd90ec861e06"

URI_x86_64_v2_rust-sqlx+runtime-tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+runtime-tokio-rustls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+runtime-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+runtime-tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-sqlx+runtime-tokio-rustls-devel.sha256sum] = "d886af069069cc1d2e2124a0d16bb552c62b673346c151b70597162044d40970"

URI_x86_64_v2_rust-sqlx+rust_decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+rust_decimal-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+rust_decimal-devel}"
SRC_URI[x86_64_v2_rust-sqlx+rust_decimal-devel.sha256sum] = "02ed9326600091559396e812ae98d69ee2e0e6a4daae795d7308ad5514a7637e"

URI_x86_64_v2_rust-sqlx+sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlite-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlite-devel.sha256sum] = "8bc7b27787bf3506661b5e45f6ba73c1e734fd89e69f86f781956c2dadd9568e"

URI_x86_64_v2_rust-sqlx+sqlite-preupdate-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlite-preupdate-hook-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlite-preupdate-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlite-preupdate-hook-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlite-preupdate-hook-devel.sha256sum] = "722461b49f47adb856daf6c582397bdb4d9f12b7955fa33eb2f3de376f3607e7"

URI_x86_64_v2_rust-sqlx+sqlite-unbundled-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlite-unbundled-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlite-unbundled-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlite-unbundled-devel.sha256sum] = "8f6a40273c4c43e4608be47abd4a71c1e8f3668616de561cf4269794172be352"

URI_x86_64_v2_rust-sqlx+sqlx-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlx-macros-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlx-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlx-macros-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlx-macros-devel.sha256sum] = "7db678ca6a4febfa6208c7fe0850f0205cca5a39ad6777d13aada0364124226d"

URI_x86_64_v2_rust-sqlx+sqlx-mysql-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlx-mysql-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlx-mysql-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlx-mysql-devel.sha256sum] = "9117825b1aef2050cb39be27b3236246c9cdda5ce75954edb59a07b9932bdd9b"

URI_x86_64_v2_rust-sqlx+sqlx-postgres-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlx-postgres-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlx-postgres-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlx-postgres-devel.sha256sum] = "e4cb272e61463d9bcdc0b285dcf9958f0a678b1b9687b46cf6579a0a5e26bdc0"

URI_x86_64_v2_rust-sqlx+sqlx-sqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+sqlx-sqlite-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+sqlx-sqlite-devel}"
SRC_URI[x86_64_v2_rust-sqlx+sqlx-sqlite-devel.sha256sum] = "d02dde4c5c8fd360152387c32cd2ca2a2bc6cfd9a9986921f618373abb32162a"

URI_x86_64_v2_rust-sqlx+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+time-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+time-devel}"
SRC_URI[x86_64_v2_rust-sqlx+time-devel.sha256sum] = "4919011fbe47c76db4ff82a1f2bd1f0f5f1b80bce36c86164d84f140a94288e3"

URI_x86_64_v2_rust-sqlx+tls-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-native-tls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-native-tls-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-native-tls-devel.sha256sum] = "ebe21f876805652abc559be3dd00e71a57ef2b6ea08490f48cfaf404e205ec99"

URI_x86_64_v2_rust-sqlx+tls-none-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-none-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-none-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-none-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-none-devel.sha256sum] = "b658114c900726628586e13847676656392bdbc788834c314ce76913eec9658a"

URI_x86_64_v2_rust-sqlx+tls-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-rustls-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-rustls-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-rustls-devel.sha256sum] = "0eff302f60fcff788f768f660d17ba0ea9ad9cc45cc2304c80bfdc0bba8b2ea7"

URI_x86_64_v2_rust-sqlx+tls-rustls-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-rustls-ring-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-rustls-ring-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-rustls-ring-devel.sha256sum] = "a5e2acd05a6905537246e454e34c01e2dcd8ddffb86361a9e90a814d76d7b0bc"

URI_x86_64_v2_rust-sqlx+tls-rustls-ring-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-rustls-ring-native-roots-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-rustls-ring-native-roots-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-rustls-ring-native-roots-devel.sha256sum] = "b81b47675317f1d160be680647997b7d4e4c97886c65ba6da84d8c57a9646dc3"

URI_x86_64_v2_rust-sqlx+tls-rustls-ring-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+tls-rustls-ring-webpki-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+tls-rustls-ring-webpki-devel}"
SRC_URI[x86_64_v2_rust-sqlx+tls-rustls-ring-webpki-devel.sha256sum] = "8287605ba052eb5fde697da4216864c47a58b696afdf284fb9f391414fd08e54"

URI_x86_64_v2_rust-sqlx+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx+uuid-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx+uuid-devel}"
SRC_URI[x86_64_v2_rust-sqlx+uuid-devel.sha256sum] = "60d8e2c4a14fe71606f77c2e849fb3a873a04afbae560a4ddebb37ad73711405"

URI_x86_64_v2_rust-sqlx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sqlx-devel-0.8.6-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sqlx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sqlx-devel}"
SRC_URI[x86_64_v2_rust-sqlx-devel.sha256sum] = "c2b9fd5733856b127f9af463b9f211ea98c57ad3f94763eba927b422b7840e20"

URI_aarch64_rust-sqlx+_rt-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+_rt-tokio-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+_rt-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+_rt-tokio-devel}"
SRC_URI[aarch64_rust-sqlx+_rt-tokio-devel.sha256sum] = "71754534c17322a0b52bcbf1562bcc92b4a89fef88d1faecbd78a9a3a033bf6c"

URI_aarch64_rust-sqlx+_sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+_sqlite-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+_sqlite-devel}"
SRC_URI[aarch64_rust-sqlx+_sqlite-devel.sha256sum] = "afd9a9ef044a4b7ced1718e5572e3dd6f1078cd489b3af2a5382f2de84159255"

URI_aarch64_rust-sqlx+_unstable-all-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+_unstable-all-types-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+_unstable-all-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+_unstable-all-types-devel}"
SRC_URI[aarch64_rust-sqlx+_unstable-all-types-devel.sha256sum] = "c823b207e478f7bb3cb196636f1a2d7e6bf5a9435731a1cdf7ad8ab951f454c9"

URI_aarch64_rust-sqlx+all-databases-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+all-databases-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+all-databases-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+all-databases-devel}"
SRC_URI[aarch64_rust-sqlx+all-databases-devel.sha256sum] = "5fb1720e5f321eca136c236381d163874ed198891716a2b796510ab9f16889f2"

URI_aarch64_rust-sqlx+any-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+any-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+any-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+any-devel}"
SRC_URI[aarch64_rust-sqlx+any-devel.sha256sum] = "dc55f1b10514c174cb08c07f17951016c8d5748a330527e2e57bdd5b518d092f"

URI_aarch64_rust-sqlx+bigdecimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+bigdecimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+bigdecimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+bigdecimal-devel}"
SRC_URI[aarch64_rust-sqlx+bigdecimal-devel.sha256sum] = "ac35fe9bdf8ce1af8f02babee411bac2404fbdc7d44f7757b6f9e47bb08375e0"

URI_aarch64_rust-sqlx+bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+bit-vec-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+bit-vec-devel}"
SRC_URI[aarch64_rust-sqlx+bit-vec-devel.sha256sum] = "905faedcd1cc83d3178bb5e195587a7905c1d7a46750167a0edd46a9cbc292ab"

URI_aarch64_rust-sqlx+bstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+bstr-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+bstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+bstr-devel}"
SRC_URI[aarch64_rust-sqlx+bstr-devel.sha256sum] = "1ca12e0fcff08e178a8b8f61c8288af20c8c1fd4a8a139862774682f835e01a6"

URI_aarch64_rust-sqlx+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+chrono-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+chrono-devel}"
SRC_URI[aarch64_rust-sqlx+chrono-devel.sha256sum] = "0f51cd6e049cdb4d663d81b7e87d6679aaee8b4de40baee834b1a08bd2f2c67a"

URI_aarch64_rust-sqlx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+default-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+default-devel}"
SRC_URI[aarch64_rust-sqlx+default-devel.sha256sum] = "88e9076f333617620e2f4152c46ada7edfe2cb929c218e58306fac30b51db72e"

URI_aarch64_rust-sqlx+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+derive-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+derive-devel}"
SRC_URI[aarch64_rust-sqlx+derive-devel.sha256sum] = "153905be131ad2ade230f54142998f99b9589fbd2b986c8c14ff676f6e2a9728"

URI_aarch64_rust-sqlx+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+ipnet-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+ipnet-devel}"
SRC_URI[aarch64_rust-sqlx+ipnet-devel.sha256sum] = "2a7082d3b712a4038a9eee2a49f034ea921c8a155f1d6b64cbdbec3a0d9522e2"

URI_aarch64_rust-sqlx+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+ipnetwork-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+ipnetwork-devel}"
SRC_URI[aarch64_rust-sqlx+ipnetwork-devel.sha256sum] = "de9ae99fe93f34294de8741187080126694dffcfb878bbe60fd1815434d36a57"

URI_aarch64_rust-sqlx+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+json-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+json-devel}"
SRC_URI[aarch64_rust-sqlx+json-devel.sha256sum] = "d0fbdd90d313c23d814b30a0f952247c605635b686a2d9ebb9a5bf42550d8212"

URI_aarch64_rust-sqlx+mac_address-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+mac_address-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+mac_address-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+mac_address-devel}"
SRC_URI[aarch64_rust-sqlx+mac_address-devel.sha256sum] = "dc3cd9e61f75633bbd4a2f9d0445a3689c97c91b84896a74f1bdeeb982eb9f77"

URI_aarch64_rust-sqlx+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+macros-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+macros-devel}"
SRC_URI[aarch64_rust-sqlx+macros-devel.sha256sum] = "828ebef83d50166d5e50cffbaeb08489a192609c3a90b4df124394bc1558bf27"

URI_aarch64_rust-sqlx+migrate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+migrate-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+migrate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+migrate-devel}"
SRC_URI[aarch64_rust-sqlx+migrate-devel.sha256sum] = "a9e14f9d8d53ad466a7a54c3df6da5032e5c90badbfe05b13ad70fa871da3ab1"

URI_aarch64_rust-sqlx+mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+mysql-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+mysql-devel}"
SRC_URI[aarch64_rust-sqlx+mysql-devel.sha256sum] = "05fae73d8f3802a49bf45c95cbba77c787413a55061452ce2b43c990b4a96aa7"

URI_aarch64_rust-sqlx+postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+postgres-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+postgres-devel}"
SRC_URI[aarch64_rust-sqlx+postgres-devel.sha256sum] = "3995f604c2fdae42f1ce0ef48cf1d466cc9ef96754564d816bcd25252374d12a"

URI_aarch64_rust-sqlx+regexp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+regexp-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+regexp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+regexp-devel}"
SRC_URI[aarch64_rust-sqlx+regexp-devel.sha256sum] = "4e7ab8566b6c43f2395c672f10cfceccd930649cc727160203de9629d3ef8d9f"

URI_aarch64_rust-sqlx+runtime-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+runtime-tokio-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+runtime-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+runtime-tokio-devel}"
SRC_URI[aarch64_rust-sqlx+runtime-tokio-devel.sha256sum] = "c6bb47e70f62f2b0d540879aa9fe502b5a67159cb6650725fee4f19fd1cc17f9"

URI_aarch64_rust-sqlx+runtime-tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+runtime-tokio-native-tls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+runtime-tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+runtime-tokio-native-tls-devel}"
SRC_URI[aarch64_rust-sqlx+runtime-tokio-native-tls-devel.sha256sum] = "76088257f6cab647f8902666cac60e8c8d6453435ecff8303fc53770e76df7f5"

URI_aarch64_rust-sqlx+runtime-tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+runtime-tokio-rustls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+runtime-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+runtime-tokio-rustls-devel}"
SRC_URI[aarch64_rust-sqlx+runtime-tokio-rustls-devel.sha256sum] = "298f62cb5fdfd15b86fcd687ada42b4dc3280eaece6776f646c0a1f09a42c5fb"

URI_aarch64_rust-sqlx+rust_decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+rust_decimal-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+rust_decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+rust_decimal-devel}"
SRC_URI[aarch64_rust-sqlx+rust_decimal-devel.sha256sum] = "3e805525ffade8329972dc8427751469c1b50c78cdd63b65add93ee700664ce6"

URI_aarch64_rust-sqlx+sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlite-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlite-devel}"
SRC_URI[aarch64_rust-sqlx+sqlite-devel.sha256sum] = "9f8b687bf82afe860210bf9890220ac7f2fa454c220ce45296245b299cc2cc31"

URI_aarch64_rust-sqlx+sqlite-preupdate-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlite-preupdate-hook-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+sqlite-preupdate-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlite-preupdate-hook-devel}"
SRC_URI[aarch64_rust-sqlx+sqlite-preupdate-hook-devel.sha256sum] = "c0c82734b14d1a028d6bdf97c71910ee02d372997c7089404d17c479e8d2ee59"

URI_aarch64_rust-sqlx+sqlite-unbundled-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlite-unbundled-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+sqlite-unbundled-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlite-unbundled-devel}"
SRC_URI[aarch64_rust-sqlx+sqlite-unbundled-devel.sha256sum] = "a54e8d7d59a34b272de458ca1e92894bab579daa54618239eab2bbd4624e77d3"

URI_aarch64_rust-sqlx+sqlx-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlx-macros-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+sqlx-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlx-macros-devel}"
SRC_URI[aarch64_rust-sqlx+sqlx-macros-devel.sha256sum] = "cd2a97e16b89bc87e2e5fdb04e940ac48118d8cfce19d2396fb4129586412ea0"

URI_aarch64_rust-sqlx+sqlx-mysql-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlx-mysql-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+sqlx-mysql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlx-mysql-devel}"
SRC_URI[aarch64_rust-sqlx+sqlx-mysql-devel.sha256sum] = "c1457455f09521b2ddfd374df81f8d7106de7b1c618f82d211a889e3630d117c"

URI_aarch64_rust-sqlx+sqlx-postgres-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlx-postgres-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+sqlx-postgres-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlx-postgres-devel}"
SRC_URI[aarch64_rust-sqlx+sqlx-postgres-devel.sha256sum] = "e7958c4eee66650f797c7ebdab9be3bd6e915e0b57b073fae71cf4817a002fef"

URI_aarch64_rust-sqlx+sqlx-sqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+sqlx-sqlite-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+sqlx-sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+sqlx-sqlite-devel}"
SRC_URI[aarch64_rust-sqlx+sqlx-sqlite-devel.sha256sum] = "bd346f2460a8885c051ecbd1b1239811365f55f91f1fa96223975e7d5961f81c"

URI_aarch64_rust-sqlx+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+time-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+time-devel}"
SRC_URI[aarch64_rust-sqlx+time-devel.sha256sum] = "c63b56476245cf5375e2578a3f448c6c1ea5c654b852cc688db6bc78ac7d77b4"

URI_aarch64_rust-sqlx+tls-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-native-tls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+tls-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-native-tls-devel}"
SRC_URI[aarch64_rust-sqlx+tls-native-tls-devel.sha256sum] = "756e5c62b993323a37d16f45d5753426208b205617bec0a814b6f16ea86a68ec"

URI_aarch64_rust-sqlx+tls-none-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-none-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+tls-none-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-none-devel}"
SRC_URI[aarch64_rust-sqlx+tls-none-devel.sha256sum] = "645b3ef57b1264ca1d2c40f03d28789e3a566426cb10541bc34c7b3bd1767619"

URI_aarch64_rust-sqlx+tls-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-rustls-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+tls-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-rustls-devel}"
SRC_URI[aarch64_rust-sqlx+tls-rustls-devel.sha256sum] = "9a67a183c33a7f6536eaf5b4e0551ce77ceee1e23b46d20f21c0a295501340e0"

URI_aarch64_rust-sqlx+tls-rustls-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-rustls-ring-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+tls-rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-rustls-ring-devel}"
SRC_URI[aarch64_rust-sqlx+tls-rustls-ring-devel.sha256sum] = "72ace536bfac25464bcaceba7eb36af4ee7873a4247dc9dfa22144cd85e382bd"

URI_aarch64_rust-sqlx+tls-rustls-ring-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-rustls-ring-native-roots-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+tls-rustls-ring-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-rustls-ring-native-roots-devel}"
SRC_URI[aarch64_rust-sqlx+tls-rustls-ring-native-roots-devel.sha256sum] = "063551886963aec02a6696079f36f9bb59478dbc4cedcd5963051eceb23b9ae4"

URI_aarch64_rust-sqlx+tls-rustls-ring-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+tls-rustls-ring-webpki-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+tls-rustls-ring-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+tls-rustls-ring-webpki-devel}"
SRC_URI[aarch64_rust-sqlx+tls-rustls-ring-webpki-devel.sha256sum] = "24a8c7fb2c2df19b6db1775ced14b054ea75d97d1393c2b5be16907cdf3d6909"

URI_aarch64_rust-sqlx+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx+uuid-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx+uuid-devel}"
SRC_URI[aarch64_rust-sqlx+uuid-devel.sha256sum] = "1e7b5a5bc05400747bc990d371539174c55c6fbc680483aff64c74d34ce96ef7"

URI_aarch64_rust-sqlx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sqlx-devel-0.8.6-4.el10_2.noarch.rpm;name=aarch64_rust-sqlx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sqlx-devel}"
SRC_URI[aarch64_rust-sqlx-devel.sha256sum] = "05ea0324d1f3e3037d0daa4fb430f49602d58ae30ac4da081690470ba7bc9184"

RDEPENDS:rust-sqlx+_rt-tokio-devel = " \
 cargo \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+_sqlite-devel = " \
 cargo \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+_unstable-all-types-devel = " \
 cargo \
 rust-sqlx+bigdecimal-devel \
 rust-sqlx+bit-vec-devel \
 rust-sqlx+bstr-devel \
 rust-sqlx+chrono-devel \
 rust-sqlx+ipnet-devel \
 rust-sqlx+ipnetwork-devel \
 rust-sqlx+json-devel \
 rust-sqlx+mac_address-devel \
 rust-sqlx+rust_decimal-devel \
 rust-sqlx+time-devel \
 rust-sqlx+uuid-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+all-databases-devel = " \
 cargo \
 rust-sqlx+any-devel \
 rust-sqlx+mysql-devel \
 rust-sqlx+postgres-devel \
 rust-sqlx+sqlite-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+any-devel = " \
 cargo \
 rust-sqlx-core+any-devel \
 rust-sqlx-devel \
 rust-sqlx-mysql+any-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-postgres+any-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-sqlite+any-devel \
 rust-sqlx-sqlite+default-devel \
 "
RDEPENDS:rust-sqlx+bigdecimal-devel = " \
 cargo \
 rust-sqlx-core+bigdecimal-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+bigdecimal-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-mysql+bigdecimal-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-postgres+bigdecimal-devel \
 rust-sqlx-postgres+default-devel \
 "
RDEPENDS:rust-sqlx+bit-vec-devel = " \
 cargo \
 rust-sqlx-core+bit-vec-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+bit-vec-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-postgres+bit-vec-devel \
 rust-sqlx-postgres+default-devel \
 "
RDEPENDS:rust-sqlx+bstr-devel = " \
 cargo \
 rust-sqlx-core+bstr-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+chrono-devel = " \
 cargo \
 rust-sqlx-core+chrono-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+chrono-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-mysql+chrono-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-postgres+chrono-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-sqlite+chrono-devel \
 rust-sqlx-sqlite+default-devel \
 "
RDEPENDS:rust-sqlx+default-devel = " \
 cargo \
 rust-sqlx+any-devel \
 rust-sqlx+json-devel \
 rust-sqlx+macros-devel \
 rust-sqlx+migrate-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+derive-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+derive-devel \
 "
RDEPENDS:rust-sqlx+ipnet-devel = " \
 cargo \
 rust-sqlx-core+ipnet-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+ipnet-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+ipnet-devel \
 "
RDEPENDS:rust-sqlx+ipnetwork-devel = " \
 cargo \
 rust-sqlx-core+ipnetwork-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+ipnetwork-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+ipnetwork-devel \
 "
RDEPENDS:rust-sqlx+json-devel = " \
 cargo \
 rust-sqlx-core+json-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+json-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+json-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+json-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+json-devel \
 "
RDEPENDS:rust-sqlx+mac_address-devel = " \
 cargo \
 rust-sqlx-core+mac_address-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+mac_address-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+mac_address-devel \
 "
RDEPENDS:rust-sqlx+macros-devel = " \
 cargo \
 rust-sqlx+derive-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+macros-devel \
 "
RDEPENDS:rust-sqlx+migrate-devel = " \
 cargo \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+migrate-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+migrate-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+migrate-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+migrate-devel \
 "
RDEPENDS:rust-sqlx+mysql-devel = " \
 cargo \
 rust-sqlx+sqlx-mysql-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+mysql-devel \
 "
RDEPENDS:rust-sqlx+postgres-devel = " \
 cargo \
 rust-sqlx+sqlx-postgres-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+postgres-devel \
 "
RDEPENDS:rust-sqlx+regexp-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+regexp-devel \
 "
RDEPENDS:rust-sqlx+runtime-tokio-devel = " \
 cargo \
 rust-sqlx+_rt-tokio-devel \
 rust-sqlx-core+_rt-tokio-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+_rt-tokio-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+runtime-tokio-native-tls-devel = " \
 cargo \
 rust-sqlx+runtime-tokio-devel \
 rust-sqlx+tls-native-tls-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+runtime-tokio-rustls-devel = " \
 cargo \
 rust-sqlx+runtime-tokio-devel \
 rust-sqlx+tls-rustls-ring-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+rust_decimal-devel = " \
 cargo \
 rust-sqlx-core+rust_decimal-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+rust_decimal-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+rust_decimal-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+rust_decimal-devel \
 "
RDEPENDS:rust-sqlx+sqlite-devel = " \
 cargo \
 rust-sqlx+sqlite-unbundled-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+sqlite-preupdate-hook-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+preupdate-hook-devel \
 "
RDEPENDS:rust-sqlx+sqlite-unbundled-devel = " \
 cargo \
 rust-sqlx+_sqlite-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+sqlite-unbundled-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+unbundled-devel \
 "
RDEPENDS:rust-sqlx+sqlx-macros-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+sqlx-mysql-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-mysql+default-devel \
 "
RDEPENDS:rust-sqlx+sqlx-postgres-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-postgres+default-devel \
 "
RDEPENDS:rust-sqlx+sqlx-sqlite-devel = " \
 cargo \
 rust-sqlx-devel \
 rust-sqlx-sqlite+default-devel \
 "
RDEPENDS:rust-sqlx+time-devel = " \
 cargo \
 rust-sqlx-core+time-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+time-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+time-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+time-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+time-devel \
 "
RDEPENDS:rust-sqlx+tls-native-tls-devel = " \
 cargo \
 rust-sqlx-core+_tls-native-tls-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+_tls-native-tls-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+tls-none-devel = " \
 cargo \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+tls-rustls-devel = " \
 cargo \
 rust-sqlx+tls-rustls-ring-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+tls-rustls-ring-devel = " \
 cargo \
 rust-sqlx+tls-rustls-ring-webpki-devel \
 rust-sqlx-devel \
 "
RDEPENDS:rust-sqlx+tls-rustls-ring-native-roots-devel = " \
 cargo \
 rust-sqlx-core+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+_tls-rustls-ring-native-roots-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+tls-rustls-ring-webpki-devel = " \
 cargo \
 rust-sqlx-core+_tls-rustls-ring-webpki-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+_tls-rustls-ring-webpki-devel \
 rust-sqlx-macros+default-devel \
 "
RDEPENDS:rust-sqlx+uuid-devel = " \
 cargo \
 rust-sqlx-core+uuid-devel \
 rust-sqlx-devel \
 rust-sqlx-macros+default-devel \
 rust-sqlx-macros+uuid-devel \
 rust-sqlx-mysql+default-devel \
 rust-sqlx-mysql+uuid-devel \
 rust-sqlx-postgres+default-devel \
 rust-sqlx-postgres+uuid-devel \
 rust-sqlx-sqlite+default-devel \
 rust-sqlx-sqlite+uuid-devel \
 "
RDEPENDS:rust-sqlx-devel = " \
 cargo \
 rust-sqlx-core+default-devel \
 rust-sqlx-core+migrate-devel \
 rust-sqlx-core+offline-devel \
 "
