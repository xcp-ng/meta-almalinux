# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mockito"
PV = "1.7.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-mockito+color-devel \
 rust-mockito+colored-devel \
 rust-mockito+default-devel \
 rust-mockito+parking_lot-devel \
 rust-mockito-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mockito-1.7.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5470a69f71b2084263a33f223768d7a4011d83ff1e3fc1d4938c30906e472874"

URI_x86_64_v2_rust-mockito+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito+color-devel-1.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito+color-devel}"
SRC_URI[x86_64_v2_rust-mockito+color-devel.sha256sum] = "8bb61ee57a233ccb6d8e83ef292f26ef3606a7b666f4379fe35e8336103155d4"

URI_x86_64_v2_rust-mockito+colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito+colored-devel-1.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito+colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito+colored-devel}"
SRC_URI[x86_64_v2_rust-mockito+colored-devel.sha256sum] = "e08526efecc713eafb908989afc637f11af4bd8cfc16c52fec97694d56e2745f"

URI_x86_64_v2_rust-mockito+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito+default-devel-1.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito+default-devel}"
SRC_URI[x86_64_v2_rust-mockito+default-devel.sha256sum] = "167bf04471740ef573fe5061bd2bad47414fffa39fc98c45a9fedf86ae5627a4"

URI_x86_64_v2_rust-mockito+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito+parking_lot-devel-1.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-mockito+parking_lot-devel.sha256sum] = "5fe1d45a55be7a1b842ca742ee3999f50ba55a7bb0efc8c5c0139b0aba71478e"

URI_x86_64_v2_rust-mockito-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockito-devel-1.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockito-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockito-devel}"
SRC_URI[x86_64_v2_rust-mockito-devel.sha256sum] = "c1c194fce8a24f265c8e60e880ad6bf8421aedbc884567903b658ea92a8487ca"

URI_aarch64_rust-mockito+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito+color-devel-1.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-mockito+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito+color-devel}"
SRC_URI[aarch64_rust-mockito+color-devel.sha256sum] = "0cfde9a7546563c2f6f9ac9835e4e1edd7575692e3214034abd69731a1874648"

URI_aarch64_rust-mockito+colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito+colored-devel-1.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-mockito+colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito+colored-devel}"
SRC_URI[aarch64_rust-mockito+colored-devel.sha256sum] = "63d51ee68559267528a7cb65b94ba69738a399951f3548d546862b1e50c5e963"

URI_aarch64_rust-mockito+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito+default-devel-1.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-mockito+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito+default-devel}"
SRC_URI[aarch64_rust-mockito+default-devel.sha256sum] = "9d05b1e206c5799e089134219af68b5f56eb16bcb6bf71899bf243c8bb4d4215"

URI_aarch64_rust-mockito+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito+parking_lot-devel-1.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-mockito+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito+parking_lot-devel}"
SRC_URI[aarch64_rust-mockito+parking_lot-devel.sha256sum] = "3a4092c4d58a863a7b237453567f7dd20e4f5c350c7f418361bfda3d7ca2870f"

URI_aarch64_rust-mockito-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockito-devel-1.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-mockito-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockito-devel}"
SRC_URI[aarch64_rust-mockito-devel.sha256sum] = "608a9858b1c55ce2f052bc622fbabf5bfdb2af987d3b98b3de5fd83f059f05b6"

RDEPENDS:rust-mockito+color-devel = " \
 cargo \
 rust-mockito+colored-devel \
 rust-mockito-devel \
 "
RDEPENDS:rust-mockito+colored-devel = " \
 cargo \
 rust-mockito-devel \
 virtual/crate_colored/default__ge_2.0.0_with_crate_colored/default__lt_4.0.0~ \
 "
RDEPENDS:rust-mockito+default-devel = " \
 cargo \
 rust-mockito+color-devel \
 rust-mockito+parking_lot-devel \
 rust-mockito-devel \
 "
RDEPENDS:rust-mockito+parking_lot-devel = " \
 cargo \
 rust-mockito-devel \
 rust-tokio+parking_lot-devel \
 "
RDEPENDS:rust-mockito-devel = " \
 cargo \
 rust \
 rust-assert-json-diff+default-devel \
 rust-bytes+default-devel \
 rust-futures-core+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+default-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+tokio-devel \
 rust-log+default-devel \
 rust-pin-project-lite+default-devel \
 rust-rand0.9+default-devel \
 rust-regex+default-devel \
 rust-serde_json+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-similar2+default-devel \
 rust-tokio+default-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 "
