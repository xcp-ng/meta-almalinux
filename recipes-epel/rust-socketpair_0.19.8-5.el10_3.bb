# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-socketpair"
PV = "0.19.8"
PR = "5.el10_3"
PACKAGES = " \
 rust-socketpair+async-std-devel \
 rust-socketpair+default-devel \
 rust-socketpair+tokio-devel \
 rust-socketpair+use_async_std-devel \
 rust-socketpair+use_tokio-devel \
 rust-socketpair-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-socketpair-0.19.8-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a4b089d9d3701328e4c19a51ab62ba07cb4adac5b022425c3c6366e66c43c65"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+async-std-devel-0.19.8-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+async-std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-socketpair+async-std-devel.sha256sum] = "04ef92b2e43a18879fd8bf701e925e8dd10e168e51b8160ce5ada78fe52e2b13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+default-devel-0.19.8-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-socketpair+default-devel.sha256sum] = "ba1cc4e3e30047a390db5fe7f39208a62f330247897d34b78f4430d0ca4af074"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+tokio-devel-0.19.8-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-socketpair+tokio-devel.sha256sum] = "aff3919795c6f70aaf4d0236f1179786a322a2b1393f17fa02870e03f9d599d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+use_async_std-devel-0.19.8-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+use_async_std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-socketpair+use_async_std-devel.sha256sum] = "32ed1bbb35e7964c2e4a55d44f029e473cd154596cddcc16da64c6333dfd8d7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair+use_tokio-devel-0.19.8-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair+use_tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-socketpair+use_tokio-devel.sha256sum] = "b9b4a2a23d9e6437cbf43ad462150f70a62da91f0e958eda3e1fbe1a890efd51"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socketpair-devel-0.19.8-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socketpair-devel;unpack=0"
SRC_URI[x86_64_v2_rust-socketpair-devel.sha256sum] = "1e302c0f53cc9696c0280c685fa1a4528324837a54d54a7191e7262f451a75e5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+async-std-devel-0.19.8-5.el10_3.noarch.rpm;name=aarch64_rust-socketpair+async-std-devel;unpack=0"
SRC_URI[aarch64_rust-socketpair+async-std-devel.sha256sum] = "84373444f662d73bdb8163c46194b2a099ebf442766354160af6914932ae2c10"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+default-devel-0.19.8-5.el10_3.noarch.rpm;name=aarch64_rust-socketpair+default-devel;unpack=0"
SRC_URI[aarch64_rust-socketpair+default-devel.sha256sum] = "3f685bd106ccaab5a7cc50eacf5217c8021ffadab14c3947795a0baf71139f96"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+tokio-devel-0.19.8-5.el10_3.noarch.rpm;name=aarch64_rust-socketpair+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-socketpair+tokio-devel.sha256sum] = "2555d26d10574de987e8b1642b31035319eb7a0c4eb656e456af6a8e85781e69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+use_async_std-devel-0.19.8-5.el10_3.noarch.rpm;name=aarch64_rust-socketpair+use_async_std-devel;unpack=0"
SRC_URI[aarch64_rust-socketpair+use_async_std-devel.sha256sum] = "c590929881c40a827f45f29e66bc3e2168017a5c270da6ac86bf5a1d8ca3c641"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair+use_tokio-devel-0.19.8-5.el10_3.noarch.rpm;name=aarch64_rust-socketpair+use_tokio-devel;unpack=0"
SRC_URI[aarch64_rust-socketpair+use_tokio-devel.sha256sum] = "364a3ff2492b4653c31b16aa86ae378d90124fae73c9498b1a7a87f578f8cbb8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-socketpair-devel-0.19.8-5.el10_3.noarch.rpm;name=aarch64_rust-socketpair-devel;unpack=0"
SRC_URI[aarch64_rust-socketpair-devel.sha256sum] = "14f4c4642ba189c6beeb3e072e5503dc8c98ce3e8a8fae55bea08fe00fdfaf1c"

RDEPENDS:rust-socketpair+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-async-std+io_safety-devel \
 rust-socketpair-devel \
 "
RDEPENDS:rust-socketpair+default-devel = " \
 cargo \
 rust-socketpair-devel \
 "
RDEPENDS:rust-socketpair+tokio-devel = " \
 cargo \
 rust-socketpair-devel \
 rust-tokio+default-devel \
 "
RDEPENDS:rust-socketpair+use_async_std-devel = " \
 cargo \
 rust-io-extras+async-std-devel \
 rust-socketpair+async-std-devel \
 rust-socketpair-devel \
 "
RDEPENDS:rust-socketpair+use_tokio-devel = " \
 cargo \
 rust-io-extras+tokio-devel \
 rust-socketpair+tokio-devel \
 rust-socketpair-devel \
 "
RDEPENDS:rust-socketpair-devel = " \
 cargo \
 rust-io-extras+default-devel \
 rust-io-lifetimes-devel \
 rust-rustix+default-devel \
 rust-rustix+net-devel \
 "
