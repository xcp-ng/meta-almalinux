# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apptainer"
PV = "1.5.3"
PR = "1.el10_3"
PACKAGES = " \
 apptainer \
 apptainer-suid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apptainer-1.5.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e224aee8c99c58915d60d274310ecbcfc5dd4a573388b3780e11e03a18cd564"

URI_x86_64_v2_apptainer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-1.5.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apptainer}"
SRC_URI[x86_64_v2_apptainer.sha256sum] = "7b3bf42bdd065be123e8c40fbcd93f897ec8b566cfa60d2fb3c244e9b85cab35"

URI_x86_64_v2_apptainer-suid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-suid-1.5.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer-suid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apptainer-suid}"
SRC_URI[x86_64_v2_apptainer-suid.sha256sum] = "b407f2ffbf794c275738067da1d76492a48d7d5c0c3b87d37484a17c1f7a0930"

URI_aarch64_apptainer = "${EPEL_MIRROR}/aarch64/Packages/a/apptainer-1.5.3-1.el10_3.aarch64.rpm;name=aarch64_apptainer;unpack=0"
SRC_URI:append = " ${URI_aarch64_apptainer}"
SRC_URI[aarch64_apptainer.sha256sum] = "8d9e269414d7cbf65ee29ba0a67ff3227949fb235e88ec334b7cea8d1f11b714"

URI_aarch64_apptainer-suid = "${EPEL_MIRROR}/aarch64/Packages/a/apptainer-suid-1.5.3-1.el10_3.aarch64.rpm;name=aarch64_apptainer-suid;unpack=0"
SRC_URI:append = " ${URI_aarch64_apptainer-suid}"
SRC_URI[aarch64_apptainer-suid.sha256sum] = "a4fbceb69da5381120b4ccb95bde24c4dcefc2573b93eaa828f85185a90f28e3"

RDEPENDS:apptainer = " \
 bash \
 fakeroot \
 fuse3-libs \
 glibc \
 libgcc \
 libseccomp \
 libtalloc \
 libzstd \
 lz4-libs \
 lzo \
 protobuf-c \
 shadow-utils-subid \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apptainer-suid = " \
 apptainer \
 fuse3-libs \
 glibc \
 libseccomp \
 shadow-utils-subid \
 "
