# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-config-value"
PV = "0.15.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-config-value+default-devel \
 rust-gix-config-value+document-features-devel \
 rust-gix-config-value+serde-devel \
 rust-gix-config-value-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-config-value-0.15.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8e77d91a58674e3244139f351e35d8ee9e5d88a24ebd8544a5615dedc7f6c41"

URI_x86_64_v2_rust-gix-config-value+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+default-devel-0.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+default-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+default-devel.sha256sum] = "82c1b3d337481bc546a47826ac4add2ab7f9a03ae1f5afaa0f3e701c7565a7a4"

URI_x86_64_v2_rust-gix-config-value+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+document-features-devel-0.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+document-features-devel.sha256sum] = "1c997b055a7057fa65196c886c456e4d6a119bc53c56ce1231c168ead5d63eae"

URI_x86_64_v2_rust-gix-config-value+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value+serde-devel-0.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value+serde-devel.sha256sum] = "11402cf12d101b1ccb7462caad3c79b0c835e45cc27fe26c2126bb1652b63f04"

URI_x86_64_v2_rust-gix-config-value-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-value-devel-0.15.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-value-devel}"
SRC_URI[x86_64_v2_rust-gix-config-value-devel.sha256sum] = "4607810dcfc90934589b59ac03ea275c099ffc7e567152b3adfb786420a2e167"

URI_aarch64_rust-gix-config-value+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+default-devel-0.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-config-value+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+default-devel}"
SRC_URI[aarch64_rust-gix-config-value+default-devel.sha256sum] = "564b36471d731068229bcfe95587e61247db5cc0e8ac56a646c0de3a3433d53a"

URI_aarch64_rust-gix-config-value+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+document-features-devel-0.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-config-value+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+document-features-devel}"
SRC_URI[aarch64_rust-gix-config-value+document-features-devel.sha256sum] = "5d26ad254ec5d4d723cc9292d3253ac1b28284349c0bada6839161e38638add9"

URI_aarch64_rust-gix-config-value+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value+serde-devel-0.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-config-value+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value+serde-devel}"
SRC_URI[aarch64_rust-gix-config-value+serde-devel.sha256sum] = "1028a0f061c10b69efcd0e3ee75c9d74eb00a52e941aef41b55ae14278146a7e"

URI_aarch64_rust-gix-config-value-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-value-devel-0.15.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-config-value-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-value-devel}"
SRC_URI[aarch64_rust-gix-config-value-devel.sha256sum] = "d635e33b60130cbdf50f5862296058401f837cfea3243678be4a31a8f3fb4cef"

RDEPENDS:rust-gix-config-value+default-devel = " \
 cargo \
 rust-gix-config-value-devel \
 "
RDEPENDS:rust-gix-config-value+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-config-value-devel \
 "
RDEPENDS:rust-gix-config-value+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-config-value-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-config-value-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-path+default-devel \
 rust-libc+default-devel \
 rust-thiserror+default-devel \
 "
