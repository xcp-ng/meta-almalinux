# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-utf16_iter"
PV = "1.0.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-utf16_iter+default-devel \
 rust-utf16_iter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-utf16_iter-1.0.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5eaf392cb30bfb21d216f95467b16919201306359d7997ea88216fe164ab9622"

URI_x86_64_v2_rust-utf16_iter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf16_iter+default-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf16_iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf16_iter+default-devel}"
SRC_URI[x86_64_v2_rust-utf16_iter+default-devel.sha256sum] = "ef0b6748669bf64d3d1f8ba44a70837888594f332a489e9eafacd51c613d5eba"

URI_x86_64_v2_rust-utf16_iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-utf16_iter-devel-1.0.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-utf16_iter-devel}"
SRC_URI[x86_64_v2_rust-utf16_iter-devel.sha256sum] = "aa6b6487b1aa5f907ad23714a2e9fdee60065ae76f92592d8423fcfe420ac349"

URI_aarch64_rust-utf16_iter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf16_iter+default-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-utf16_iter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf16_iter+default-devel}"
SRC_URI[aarch64_rust-utf16_iter+default-devel.sha256sum] = "6d040643cb4c09e2fe8c432d9c86977a420e5d56ec82796fdb1d5a707a343978"

URI_aarch64_rust-utf16_iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-utf16_iter-devel-1.0.5-1.el10_0.noarch.rpm;name=aarch64_rust-utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-utf16_iter-devel}"
SRC_URI[aarch64_rust-utf16_iter-devel.sha256sum] = "ebcba07cc474db8d4c1cc2c7005825bf497875a5830ec8852a46acff305ebab3"

RDEPENDS:rust-utf16_iter+default-devel = " \
 cargo \
 rust-utf16_iter-devel \
 "
RDEPENDS:rust-utf16_iter-devel = " \
 cargo \
 "
