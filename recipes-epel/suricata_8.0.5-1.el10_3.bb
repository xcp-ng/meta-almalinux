# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "suricata"
PV = "8.0.5"
PR = "1.el10_3"
PACKAGES = " \
 suricata \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/suricata-8.0.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76caf7763eb0bf4525d23ee30c4669895c30f4fe0023c22bf7140fb902aac0df"

URI_x86_64_v2_suricata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/suricata-8.0.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_suricata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_suricata}"
SRC_URI[x86_64_v2_suricata.sha256sum] = "d7dffcea3992d10f2d610734a15e6adababb38928e47b86a564c6b642306194c"

URI_aarch64_suricata = "${EPEL_MIRROR}/aarch64/Packages/s/suricata-8.0.5-1.el10_3.aarch64.rpm;name=aarch64_suricata;unpack=0"
SRC_URI:append = " ${URI_aarch64_suricata}"
SRC_URI[aarch64_suricata.sha256sum] = "1e30757c16567508eed51be9c4b46e8da61687bac382496377c96616e0534a36"

RDEPENDS:suricata:x86_64_v2 = " \
 bash \
 file-libs \
 glibc \
 hiredis \
 jansson \
 libcap-ng \
 libevent \
 libgcc \
 libmaxminddb \
 libnet \
 libnetfilter_queue \
 libnfnetlink \
 libpcap \
 libyaml \
 lz4-libs \
 pcre2 \
 python3 \
 python3-pyyaml \
 shadow-utils \
 systemd \
 vectorscan \
 zlib-ng-compat \
"
RDEPENDS:suricata:aarch64 = " \
 bash \
 file-libs \
 glibc \
 hiredis \
 jansson \
 libcap-ng \
 libevent \
 libgcc \
 libmaxminddb \
 libnet \
 libnetfilter_queue \
 libnfnetlink \
 libpcap \
 libyaml \
 lz4-libs \
 pcre2 \
 python3 \
 python3-pyyaml \
 shadow-utils \
 systemd \
 zlib-ng-compat \
"
