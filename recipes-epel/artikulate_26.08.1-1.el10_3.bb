# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "artikulate"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 artikulate \
 artikulate-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/artikulate-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e68162ce13866e0841e535ed89687c7d0116b58025c72b177b4beed83d3141c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artikulate-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_artikulate;unpack=0"
SRC_URI[x86_64_v2_artikulate.sha256sum] = "e95cda49c878da871f94b8f7b31b4c7d994bc862a82331d34997d6cb34fb2e7c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artikulate-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_artikulate-libs;unpack=0"
SRC_URI[x86_64_v2_artikulate-libs.sha256sum] = "7f33d880194f9d092416d70db85ccc0024abf35f9f2540ca41aad5ce375f234a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/artikulate-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_artikulate;unpack=0"
SRC_URI[aarch64_artikulate.sha256sum] = "e354cfd6551baa04f0e809c405bb0db6dbfa5cc255fcf1faa39d26d843c9adeb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/artikulate-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_artikulate-libs;unpack=0"
SRC_URI[aarch64_artikulate-libs.sha256sum] = "49cd4b0a88b24bbaceea548f7f31b06cb74fc8daf35a54215decf385c7b309d9"

RDEPENDS:artikulate = " \
 artikulate-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemmodels \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:artikulate-libs = " \
 artikulate \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-ki18n \
 libstdc++ \
 libxml2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
