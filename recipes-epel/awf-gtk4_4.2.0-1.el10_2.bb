# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awf-gtk4"
PV = "4.2.0"
PR = "1.el10_2"
PACKAGES = " \
 awf-gtk4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awf-gtk4-4.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d3492aaf6e4e1530fe4627f3321e6f26df444a03cdee0a5ff0202c6f3e55f6b"

URI_x86_64_v2_awf-gtk4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awf-gtk4-4.2.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_awf-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awf-gtk4}"
SRC_URI[x86_64_v2_awf-gtk4.sha256sum] = "f295399a7f04f5306cfbb745c8cbfc011de55166bbbf09d2b0e47e3385d021f1"

URI_aarch64_awf-gtk4 = "${EPEL_MIRROR}/aarch64/Packages/a/awf-gtk4-4.2.0-1.el10_2.aarch64.rpm;name=aarch64_awf-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_awf-gtk4}"
SRC_URI[aarch64_awf-gtk4.sha256sum] = "1348fd9058f9e84fab211a68e484d731b42b52ffcf38ba6c189230a247418153"

RDEPENDS:awf-gtk4 = " \
 glib2 \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 libnotify \
 pango \
 "
