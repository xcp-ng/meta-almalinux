# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmnl"
PV = "1.0.5"
PR = "7.el10"
PACKAGES = " \
 libmnl \
 libmnl-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libmnl-1.0.5-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0adfe737ee998116dacf99551dedda831cfee689cc33c9c15325439b982f38ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libmnl-1.0.5-7.el10.x86_64_v2.rpm;name=x86_64_v2_libmnl;unpack=0"
SRC_URI[x86_64_v2_libmnl.sha256sum] = "972ffae5b746addc46f61f79700ef1a716d257ecc226ec8e77bb9bbdee3671e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libmnl-devel-1.0.5-7.el10.x86_64_v2.rpm;name=x86_64_v2_libmnl-devel;unpack=0"
SRC_URI[x86_64_v2_libmnl-devel.sha256sum] = "82c6169d3ac4fa162143118a11959257fb3c9b08f2efb0eadeda2ce210b94413"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libmnl-1.0.5-7.el10.aarch64.rpm;name=aarch64_libmnl;unpack=0"
SRC_URI[aarch64_libmnl.sha256sum] = "ce9c444a2834aab6a1c390415f6a4ec3a553d0cd4561178c5e0f15d8db29bc9e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libmnl-devel-1.0.5-7.el10.aarch64.rpm;name=aarch64_libmnl-devel;unpack=0"
SRC_URI[aarch64_libmnl-devel.sha256sum] = "22bc57cb5986e41a60f2ee08ee0cf51d916a253549dca44e4d9d33e480b078d1"

RDEPENDS:libmnl = " \
 glibc \
 "
RDEPENDS:libmnl-devel = " \
 libmnl \
 pkgconf-pkg-config \
 "
