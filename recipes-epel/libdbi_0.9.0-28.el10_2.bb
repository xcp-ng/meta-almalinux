# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdbi"
PV = "0.9.0"
PR = "28.el10_2"
PACKAGES = " \
 libdbi \
 libdbi-devel \
 libdbi-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdbi-0.9.0-28.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8ac6e57746a03cecd9522898f2ed00a263aae9b895dac2d7c3249538534d4fc"

URI_x86_64_v2_libdbi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdbi-0.9.0-28.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbi}"
SRC_URI[x86_64_v2_libdbi.sha256sum] = "5936d79b7320a896f1aa6c48daa9100b8fad8ba3afcf08c914404531f5a2ce57"

URI_x86_64_v2_libdbi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdbi-devel-0.9.0-28.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdbi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbi-devel}"
SRC_URI[x86_64_v2_libdbi-devel.sha256sum] = "5cdebab64cfa1801269ea217ef3c04582d46439839ac5ab476bf98713b9ba4ee"

URI_x86_64_v2_libdbi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdbi-doc-0.9.0-28.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libdbi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdbi-doc}"
SRC_URI[x86_64_v2_libdbi-doc.sha256sum] = "405c924ef5c116ffcb8fdc510e9076b9a2f46cfefe8577aeeda7649e78639715"

URI_aarch64_libdbi = "${EPEL_MIRROR}/aarch64/Packages/l/libdbi-0.9.0-28.el10_2.aarch64.rpm;name=aarch64_libdbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbi}"
SRC_URI[aarch64_libdbi.sha256sum] = "df8426ffc2168d0c6d0295dc531e29d6ab5cd069742533e8c7de5224721504c2"

URI_aarch64_libdbi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdbi-devel-0.9.0-28.el10_2.aarch64.rpm;name=aarch64_libdbi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbi-devel}"
SRC_URI[aarch64_libdbi-devel.sha256sum] = "e9b9199f31075d6963c0efceb68c5041b1cab458358f4c5bafba72f879330163"

URI_aarch64_libdbi-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libdbi-doc-0.9.0-28.el10_2.noarch.rpm;name=aarch64_libdbi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdbi-doc}"
SRC_URI[aarch64_libdbi-doc.sha256sum] = "399e53c621a8ceabd61a5eef3be1000428128e304190dab77d35b82174b8b132"

RDEPENDS:libdbi = " \
 glibc \
 "
RDEPENDS:libdbi-devel = " \
 libdbi \
 pkgconf-pkg-config \
 "
RDEPENDS:libdbi-doc = " \
 "
