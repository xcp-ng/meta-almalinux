# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-munge"
PV = "0.4.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-munge+default-devel \
 rust-munge-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-munge-0.4.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4c85f6556d55fcdccf2402fe9e1539b6d26a10edab4dfd0a9b8532a79f76f059"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge+default-devel-0.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-munge+default-devel.sha256sum] = "1b59b5e9bd9b357ceb4ab533f6162546ff843d5f6d0abef8aa9bfdc509bc8894"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-munge-devel-0.4.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-munge-devel;unpack=0"
SRC_URI[x86_64_v2_rust-munge-devel.sha256sum] = "5dd8682735167e42b08e5fe60b51218a688d697e13063134c62bb181e806cdf0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-munge+default-devel-0.4.7-1.el10_0.noarch.rpm;name=aarch64_rust-munge+default-devel;unpack=0"
SRC_URI[aarch64_rust-munge+default-devel.sha256sum] = "1e9fe7f05771242bf27c0780f13b1656895dd24ea745c7098aa449a65b22950c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-munge-devel-0.4.7-1.el10_0.noarch.rpm;name=aarch64_rust-munge-devel;unpack=0"
SRC_URI[aarch64_rust-munge-devel.sha256sum] = "9d905aa392f95a900c08195e0f5460a91ce9dfc108eb4409d7a2c23f0e6c2623"

RDEPENDS:rust-munge+default-devel = " \
 cargo \
 rust-munge-devel \
 "
RDEPENDS:rust-munge-devel = " \
 cargo \
 rust \
 rust-munge_macro-devel \
 "
