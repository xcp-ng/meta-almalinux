# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete_nushell"
PV = "4.5.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap_complete_nushell+default-devel \
 rust-clap_complete_nushell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete_nushell-4.5.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87c038db58e85dd2f831ac8bc77e0396f4ee34492e3c1cb05ce7f13b00e5f2cc"

URI_x86_64_v2_rust-clap_complete_nushell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_nushell+default-devel-4.5.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_nushell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_nushell+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_nushell+default-devel.sha256sum] = "12dfab5bc17cc2af4b210803571fcf8076b67a741759c87d53b3d6cbbe41b4d5"

URI_x86_64_v2_rust-clap_complete_nushell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_nushell-devel-4.5.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_nushell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_nushell-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_nushell-devel.sha256sum] = "558e3a2103111b0a7b2ac5c47ae24114465fd2c2a1779ed3dbff942cd43aaccb"

URI_aarch64_rust-clap_complete_nushell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_nushell+default-devel-4.5.10-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete_nushell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_nushell+default-devel}"
SRC_URI[aarch64_rust-clap_complete_nushell+default-devel.sha256sum] = "682348781b3b0bf5945180587474c60245e21612b1a426d65593a85bc5bdba11"

URI_aarch64_rust-clap_complete_nushell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_nushell-devel-4.5.10-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete_nushell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_nushell-devel}"
SRC_URI[aarch64_rust-clap_complete_nushell-devel.sha256sum] = "ad2100e644327b886fce27a08f243778a75af687ad12b78756a32a22981d4dfa"

RDEPENDS:rust-clap_complete_nushell+default-devel = " \
 cargo \
 rust-clap_complete_nushell-devel \
 "
RDEPENDS:rust-clap_complete_nushell-devel = " \
 cargo \
 rust \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-clap_complete+default-devel \
 "
