# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhall-json"
PV = "1.7.12"
PR = "1.el10_0"
PACKAGES = " \
 dhall-json \
 ghc-dhall-json \
 ghc-dhall-json-devel \
 ghc-dhall-json-doc \
 ghc-dhall-json-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dhall-json-1.7.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22c0123e80181df1e011628dbb9da62db71290d356ff1d4222dec10ce91cc642"

URI_x86_64_v2_dhall-json = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dhall-json-1.7.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dhall-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhall-json}"
SRC_URI[x86_64_v2_dhall-json.sha256sum] = "90e117ca67a582bed6d5e649a5f6567d11a83bb27a34048e7ab4bc3d843909a8"

URI_x86_64_v2_ghc-dhall-json = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dhall-json-1.7.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dhall-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dhall-json}"
SRC_URI[x86_64_v2_ghc-dhall-json.sha256sum] = "e8518ae3c1d5d12c2a0a4882a6046076f52a8b2086707cc4863e5036c28161e9"

URI_x86_64_v2_ghc-dhall-json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dhall-json-devel-1.7.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dhall-json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dhall-json-devel}"
SRC_URI[x86_64_v2_ghc-dhall-json-devel.sha256sum] = "d0f5e82cb5379dfa0ef0de652fc4c1bf6ab930ef33edd73752a2eb66dded55bb"

URI_x86_64_v2_ghc-dhall-json-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dhall-json-doc-1.7.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-dhall-json-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dhall-json-doc}"
SRC_URI[x86_64_v2_ghc-dhall-json-doc.sha256sum] = "f68c9894cb8c752e9a80edefb51d1f6cc741384ec59448fc71e8438c3a56b6c2"

URI_x86_64_v2_ghc-dhall-json-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-dhall-json-prof-1.7.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-dhall-json-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-dhall-json-prof}"
SRC_URI[x86_64_v2_ghc-dhall-json-prof.sha256sum] = "ed07dbfa230fff0cba844b208e4f8c37f659256415d2c530d7b7ec11ba63a533"

URI_aarch64_dhall-json = "${EPEL_MIRROR}/aarch64/Packages/d/dhall-json-1.7.12-1.el10_0.aarch64.rpm;name=aarch64_dhall-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhall-json}"
SRC_URI[aarch64_dhall-json.sha256sum] = "6a97b94031f03772629facdf7d2b42417c0c8b61b823c4911baa53531a7e1520"

URI_aarch64_ghc-dhall-json = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dhall-json-1.7.12-1.el10_0.aarch64.rpm;name=aarch64_ghc-dhall-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dhall-json}"
SRC_URI[aarch64_ghc-dhall-json.sha256sum] = "ebb73a864e31a24762be10050c56f1045f284ce1a13177a6b89f02f52e521693"

URI_aarch64_ghc-dhall-json-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dhall-json-devel-1.7.12-1.el10_0.aarch64.rpm;name=aarch64_ghc-dhall-json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dhall-json-devel}"
SRC_URI[aarch64_ghc-dhall-json-devel.sha256sum] = "4860911c761b104d92c6b10a80fe05fa4d49ef262c3724ded357f1006f642622"

URI_aarch64_ghc-dhall-json-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dhall-json-doc-1.7.12-1.el10_0.noarch.rpm;name=aarch64_ghc-dhall-json-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dhall-json-doc}"
SRC_URI[aarch64_ghc-dhall-json-doc.sha256sum] = "89cb80c028c7eefdb3a875e603cfd30e559febdb48c99cf0aca7d0a8deabb74e"

URI_aarch64_ghc-dhall-json-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-dhall-json-prof-1.7.12-1.el10_0.aarch64.rpm;name=aarch64_ghc-dhall-json-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-dhall-json-prof}"
SRC_URI[aarch64_ghc-dhall-json-prof.sha256sum] = "09b686de710203d4bce689c587db99342328c67bec74f6387ae0afd930c71407"

RDEPENDS:dhall-json = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-dhall-json = " \
 ghc-Diff \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-aeson-pretty \
 ghc-aeson-yaml \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-atomic-write \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base16-bytestring \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cborg \
 ghc-cborg-json \
 ghc-cereal \
 ghc-charset \
 ghc-colour \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-cryptohash-sha256 \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-dhall \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-dotgen \
 ghc-either \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-half \
 ghc-hashable \
 ghc-haskeline \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-lens-family-core \
 ghc-megaparsec \
 ghc-memory \
 ghc-mime-types \
 ghc-mmorph \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-optparse-applicative \
 ghc-os-string \
 ghc-parsec \
 ghc-parser-combinators \
 ghc-parsers \
 ghc-pem \
 ghc-pretty \
 ghc-pretty-simple \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-primitive \
 ghc-process \
 ghc-profunctors \
 ghc-random \
 ghc-repline \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-serialise \
 ghc-socks \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-temporary \
 ghc-terminfo \
 ghc-text \
 ghc-text-manipulate \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unix-compat \
 ghc-unix-time \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 ncurses-libs \
 zlib-ng-compat \
 "
RDEPENDS:ghc-dhall-json-devel = " \
 ghc-aeson-devel \
 ghc-aeson-pretty-devel \
 ghc-aeson-yaml-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-dhall-devel \
 ghc-dhall-json \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-lens-family-core-devel \
 ghc-optparse-applicative-devel \
 ghc-prettyprinter-devel \
 ghc-scientific-devel \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-dhall-json-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-dhall-json-prof = " \
 ghc-aeson-pretty-prof \
 ghc-aeson-prof \
 ghc-aeson-yaml-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-dhall-json-devel \
 ghc-dhall-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-lens-family-core-prof \
 ghc-optparse-applicative-prof \
 ghc-prettyprinter-prof \
 ghc-scientific-prof \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
