# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syslog"
PV = "7.0.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-syslog+default-devel \
 rust-syslog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syslog-7.0.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2f4729fa5489158b63534ce5620d5112d9ccb9f1d05382f32e0a9b81f3fa070"

URI_x86_64_v2_rust-syslog+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syslog+default-devel-7.0.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syslog+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syslog+default-devel}"
SRC_URI[x86_64_v2_rust-syslog+default-devel.sha256sum] = "f6075fed23cb15ac1cd7f15ec189d73592598a6ba970cfb4164cf27cff63920d"

URI_x86_64_v2_rust-syslog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syslog-devel-7.0.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syslog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syslog-devel}"
SRC_URI[x86_64_v2_rust-syslog-devel.sha256sum] = "4f9aea9dec0b94b5cfacdc61462b4249ed16af70278d8385d0098ee945dbdebf"

URI_aarch64_rust-syslog+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syslog+default-devel-7.0.0-2.el10_3.noarch.rpm;name=aarch64_rust-syslog+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syslog+default-devel}"
SRC_URI[aarch64_rust-syslog+default-devel.sha256sum] = "ca61fb59cb75b712e7a42d1b3256b4df6537d86a36cc07127d317704695aa37e"

URI_aarch64_rust-syslog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syslog-devel-7.0.0-2.el10_3.noarch.rpm;name=aarch64_rust-syslog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syslog-devel}"
SRC_URI[aarch64_rust-syslog-devel.sha256sum] = "5ef3803838f3261b2c456db90ed6fc48d6b59242f3ca4bbdfdbbd7af45ca7673"

RDEPENDS:rust-syslog+default-devel = " \
 cargo \
 rust-syslog-devel \
 "
RDEPENDS:rust-syslog-devel = " \
 cargo \
 rust-hostname+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 "
