# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinyvec"
PV = "1.11.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+arbitrary-devel \
 rust-tinyvec+default-devel \
 rust-tinyvec+experimental_write_impl-devel \
 rust-tinyvec+grab_spare_slice-devel \
 rust-tinyvec+nightly_slice_partition_dedup-devel \
 rust-tinyvec+rustc_1_40-devel \
 rust-tinyvec+rustc_1_55-devel \
 rust-tinyvec+rustc_1_57-devel \
 rust-tinyvec+rustc_1_61-devel \
 rust-tinyvec+serde-devel \
 rust-tinyvec+std-devel \
 rust-tinyvec+tinyvec_macros-devel \
 rust-tinyvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tinyvec-1.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56ebd0f8de589d8cd82afbaa775c2c6b32ba6ec6869a53cfbe79a2268c39527a"

URI_x86_64_v2_rust-tinyvec+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+alloc-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+alloc-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+alloc-devel.sha256sum] = "c60b40f943ca7535bb84a361d11ca8552f6d1cfef76cf4d5c5a67f17c4c070d0"

URI_x86_64_v2_rust-tinyvec+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+arbitrary-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+arbitrary-devel.sha256sum] = "fa2e92d63145933346c9ac98d954a220487d4597f4aeb2dd149a4fcbfe84b497"

URI_x86_64_v2_rust-tinyvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+default-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+default-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+default-devel.sha256sum] = "fce09862ef77103bee18ae3860db2f1c1f9ebe3c8cd0a0813560c172f3fce8ab"

URI_x86_64_v2_rust-tinyvec+experimental_write_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+experimental_write_impl-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+experimental_write_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+experimental_write_impl-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+experimental_write_impl-devel.sha256sum] = "2904f1993e8902bbd9c76d884de757d7454fa71935390b13a7da27738a805050"

URI_x86_64_v2_rust-tinyvec+grab_spare_slice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+grab_spare_slice-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+grab_spare_slice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+grab_spare_slice-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+grab_spare_slice-devel.sha256sum] = "6f2013e240c7ab0dfef126403c6262c9d7d1270f497f826cf8a4f8611b00d575"

URI_x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+nightly_slice_partition_dedup-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+nightly_slice_partition_dedup-devel.sha256sum] = "55f842d514b4696362509a5345c888a5bdae31b4e7e74c2bf97d01e3ae071d23"

URI_x86_64_v2_rust-tinyvec+rustc_1_40-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_40-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_40-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_40-devel.sha256sum] = "86c969c5c14de88f66ceae845245330fc5880be4e064ba378f895d1960b1d1ba"

URI_x86_64_v2_rust-tinyvec+rustc_1_55-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_55-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_55-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_55-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_55-devel.sha256sum] = "768e269cc446563868451cf2aa05e999efa966eda2f52a93e6c7488d2ddc82b8"

URI_x86_64_v2_rust-tinyvec+rustc_1_57-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_57-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_57-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_57-devel.sha256sum] = "5e880067090962773bff3cba60343f45f9ad56d2949d6892e85186de0c0a1607"

URI_x86_64_v2_rust-tinyvec+rustc_1_61-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+rustc_1_61-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+rustc_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+rustc_1_61-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+rustc_1_61-devel.sha256sum] = "2bf429584f417557d91cf1d5d68a610ffa9230644b00e15ea16952927fbc4dc1"

URI_x86_64_v2_rust-tinyvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+serde-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+serde-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+serde-devel.sha256sum] = "39b07856cdfffd68b342ebf2ef55dd14147e50b24ce93ac3fcf0225da993e45c"

URI_x86_64_v2_rust-tinyvec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+std-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+std-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+std-devel.sha256sum] = "55433537ca7e54419a7e415ac17be406be05a12efb4c36ad82c8835f1f166f2e"

URI_x86_64_v2_rust-tinyvec+tinyvec_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec+tinyvec_macros-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec+tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec+tinyvec_macros-devel}"
SRC_URI[x86_64_v2_rust-tinyvec+tinyvec_macros-devel.sha256sum] = "178b918f591685181f5de98a1103be40526439468e95ace6080745599983ab44"

URI_x86_64_v2_rust-tinyvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinyvec-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tinyvec-devel}"
SRC_URI[x86_64_v2_rust-tinyvec-devel.sha256sum] = "8d334e359a762ef354a70fe7272428cb254265e22be6a3a4576974da7af55760"

URI_aarch64_rust-tinyvec+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+alloc-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+alloc-devel}"
SRC_URI[aarch64_rust-tinyvec+alloc-devel.sha256sum] = "2ca573a38b3ee9984daa437d3a829cbcc3646139a656b6df8484b1679f602aa7"

URI_aarch64_rust-tinyvec+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+arbitrary-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+arbitrary-devel}"
SRC_URI[aarch64_rust-tinyvec+arbitrary-devel.sha256sum] = "2a67166d1952b48fec85ce8ae26fd218f383b1f6d090776917e7d342cd9b0b8f"

URI_aarch64_rust-tinyvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+default-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+default-devel}"
SRC_URI[aarch64_rust-tinyvec+default-devel.sha256sum] = "8762418c510f67924584c00f38e8546ab810b81daf3b5441be6a27301aeff803"

URI_aarch64_rust-tinyvec+experimental_write_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+experimental_write_impl-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+experimental_write_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+experimental_write_impl-devel}"
SRC_URI[aarch64_rust-tinyvec+experimental_write_impl-devel.sha256sum] = "1bd489d9acf27036679673dfd8662deba6c52457a3b39dd1a709de893337ad08"

URI_aarch64_rust-tinyvec+grab_spare_slice-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+grab_spare_slice-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+grab_spare_slice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+grab_spare_slice-devel}"
SRC_URI[aarch64_rust-tinyvec+grab_spare_slice-devel.sha256sum] = "1fca6f3f3bbf79ebeb15ec1fa9b0fdc1f20e13ca971350cbee718d6bc47379ee"

URI_aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+nightly_slice_partition_dedup-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel}"
SRC_URI[aarch64_rust-tinyvec+nightly_slice_partition_dedup-devel.sha256sum] = "580f6d07f06f6776c95e9b1a146d2756a83afe2ff8b87a3879843e834e1087e1"

URI_aarch64_rust-tinyvec+rustc_1_40-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_40-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_40-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_40-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_40-devel.sha256sum] = "873245fb897c2e750595201e4f4500888b15eb8d48044cd86ca90862e9b8b7f5"

URI_aarch64_rust-tinyvec+rustc_1_55-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_55-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_55-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_55-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_55-devel.sha256sum] = "aa3a978f4be701d7271b7ee48af9ed5bfd86e33f23fb3633275865619d50ebdc"

URI_aarch64_rust-tinyvec+rustc_1_57-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_57-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_57-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_57-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_57-devel.sha256sum] = "128ac6187301ceb5e9225d79397a46252598ff989c366a00d912d0b770b6c90d"

URI_aarch64_rust-tinyvec+rustc_1_61-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+rustc_1_61-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+rustc_1_61-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+rustc_1_61-devel}"
SRC_URI[aarch64_rust-tinyvec+rustc_1_61-devel.sha256sum] = "c9c72855511a417cd68ef6974f0d51e8fbb7332f0d17ad40adb551e0297dd1e2"

URI_aarch64_rust-tinyvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+serde-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+serde-devel}"
SRC_URI[aarch64_rust-tinyvec+serde-devel.sha256sum] = "d7d5dead8e351d122fc7c27432b996fc4158b812231ac090bb5902e6fe5a809b"

URI_aarch64_rust-tinyvec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+std-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+std-devel}"
SRC_URI[aarch64_rust-tinyvec+std-devel.sha256sum] = "af19222399201ea0ae55f782d6070ef6d77a06ed30e9599ea034e5af24bc4c77"

URI_aarch64_rust-tinyvec+tinyvec_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec+tinyvec_macros-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec+tinyvec_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec+tinyvec_macros-devel}"
SRC_URI[aarch64_rust-tinyvec+tinyvec_macros-devel.sha256sum] = "c5edaddf252251a5cda7755ab52f45011a70252036c986891b09c0296ca238e8"

URI_aarch64_rust-tinyvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tinyvec-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tinyvec-devel}"
SRC_URI[aarch64_rust-tinyvec-devel.sha256sum] = "f07256ffc45ca0a2ecb4804e8b4c01453ae7c1df391ef77e69e5c92faba1d44d"

RDEPENDS:rust-tinyvec+alloc-devel = " \
 cargo \
 rust-tinyvec+tinyvec_macros-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+default-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+experimental_write_impl-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+grab_spare_slice-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+nightly_slice_partition_dedup-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_40-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_55-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_57-devel = " \
 cargo \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+rustc_1_61-devel = " \
 cargo \
 rust-tinyvec+rustc_1_57-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+std-devel = " \
 cargo \
 rust-tinyvec+alloc-devel \
 rust-tinyvec-devel \
 "
RDEPENDS:rust-tinyvec+tinyvec_macros-devel = " \
 cargo \
 rust-tinyvec-devel \
 rust-tinyvec_macros+default-devel \
 "
RDEPENDS:rust-tinyvec-devel = " \
 cargo \
 "
