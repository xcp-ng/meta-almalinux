# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-humanize"
PV = "4.15.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-humanize \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-humanize-4.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0762b280f874d5d67dea4880f0d64fc248a9d613920005cf33b9728242fc680f"

URI_x86_64_v2_python3-humanize = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-humanize-4.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-humanize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-humanize}"
SRC_URI[x86_64_v2_python3-humanize.sha256sum] = "94cf17686660732c8eefe9758f53369d1f6ec6ce7d22f2f4cecd1db85e5e31a1"

URI_aarch64_python3-humanize = "${EPEL_MIRROR}/aarch64/Packages/p/python3-humanize-4.15.0-1.el10_2.noarch.rpm;name=aarch64_python3-humanize;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-humanize}"
SRC_URI[aarch64_python3-humanize.sha256sum] = "820aba8555534cc92f89bbad6a8e1efe9a5230c25d6498b6a9f08c6ee781ee6e"

RDEPENDS:python3-humanize = " \
 python3 \
 "
