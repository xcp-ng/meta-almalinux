# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "barman"
PV = "3.16.1"
PR = "1.el10_0"
PACKAGES = " \
 barman \
 barman-cli \
 python3-barman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/barman-3.16.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e5a1ad974b5e55c93e95142684e4c70a0c51305fb3e43a7c2c9ec49ce9e0b7bd"

URI_x86_64_v2_barman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-3.16.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_barman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barman}"
SRC_URI[x86_64_v2_barman.sha256sum] = "19a8ad6ced6e9af913933da0480b8a444b16c4fa72de4df1073ae018af02dd9a"

URI_x86_64_v2_barman-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/barman-cli-3.16.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_barman-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_barman-cli}"
SRC_URI[x86_64_v2_barman-cli.sha256sum] = "ecff140ea487aa4d0b7b393417ef3837254a6fe2594f44ebc217c129c6702cb4"

URI_x86_64_v2_python3-barman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-barman-3.16.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-barman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-barman}"
SRC_URI[x86_64_v2_python3-barman.sha256sum] = "eb19d9aea5a313dd25d9eeafffc79016e033e9836bdab1599e0dfb379991bac3"

URI_aarch64_barman = "${EPEL_MIRROR}/aarch64/Packages/b/barman-3.16.1-1.el10_0.noarch.rpm;name=aarch64_barman;unpack=0"
SRC_URI:append = " ${URI_aarch64_barman}"
SRC_URI[aarch64_barman.sha256sum] = "6f8e2805632f47f87f1dddcf70598cf896e4c90a05d151b75df4813681e19f36"

URI_aarch64_barman-cli = "${EPEL_MIRROR}/aarch64/Packages/b/barman-cli-3.16.1-1.el10_0.noarch.rpm;name=aarch64_barman-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_barman-cli}"
SRC_URI[aarch64_barman-cli.sha256sum] = "78e310048747a5f2f3d5ecc3341b2a73ce2211c0f3eeb950adb3d85cb09398d4"

URI_aarch64_python3-barman = "${EPEL_MIRROR}/aarch64/Packages/p/python3-barman-3.16.1-1.el10_0.noarch.rpm;name=aarch64_python3-barman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-barman}"
SRC_URI[aarch64_python3-barman.sha256sum] = "98f7cfcd323d5416e46cce93d0278b9f8a2649efb9a5a435dd9b163379fac71a"

RDEPENDS:barman = " \
 bash \
 cronie \
 logrotate \
 python3 \
 python3-argcomplete \
 python3-barman \
 rsync \
 shadow-utils \
 "
RDEPENDS:barman-cli = " \
 python3 \
 python3-barman \
 "
RDEPENDS:python3-barman = " \
 python3 \
 python3-dateutil \
 python3-psycopg2 \
 python3-setuptools \
 "
