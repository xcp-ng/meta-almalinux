# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mutter"
PV = "49.4"
PR = "6.el10"
PACKAGES = " \
 mutter \
 mutter-common \
 mutter-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mutter-49.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4ff17281a5beaf0b2ee27b0096587da566ad2f06af938bad00549b546faa5930"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mutter-49.4-6.el10.x86_64_v2.rpm;name=x86_64_v2_mutter;unpack=0"
SRC_URI[x86_64_v2_mutter.sha256sum] = "ce7ed6cd80236ccedd4e4783e864ec7ecb4f0522cf36fe267881292ea09eaff8"
RPROVIDES:mutter:append:x86_64_v2 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mutter-common-49.4-6.el10.noarch.rpm;name=x86_64_v2_mutter-common;unpack=0"
SRC_URI[x86_64_v2_mutter-common.sha256sum] = "8612bd79ccffe2082fc6778f84d8caf14580fdf9befc08bef15d7893c55e30b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mutter-devel-49.4-6.el10.x86_64_v2.rpm;name=x86_64_v2_mutter-devel;unpack=0"
SRC_URI[x86_64_v2_mutter-devel.sha256sum] = "f2a5e5ee1b1ae2bca6598b79cbcb39b6b6673ef6b9d505d9b6b79abe19384a94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mutter-49.4-6.el10.aarch64.rpm;name=aarch64_mutter;unpack=0"
SRC_URI[aarch64_mutter.sha256sum] = "db6f675b21b4a21fc053dfb54641736d826d8833cec2a06b059e03fadcb8b3e7"
RPROVIDES:mutter:append:aarch64 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mutter-common-49.4-6.el10.noarch.rpm;name=aarch64_mutter-common;unpack=0"
SRC_URI[aarch64_mutter-common.sha256sum] = "8612bd79ccffe2082fc6778f84d8caf14580fdf9befc08bef15d7893c55e30b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mutter-devel-49.4-6.el10.aarch64.rpm;name=aarch64_mutter-devel;unpack=0"
SRC_URI[aarch64_mutter-devel.sha256sum] = "40a8aa4efea4d4efae7fb66a8129b90c9e519ed0c6c8268c9ca572bf4b34d830"

RDEPENDS:mutter = " \
 atk \
 cairo \
 colord-libs \
 dbus \
 fribidi \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-control-center-filesystem \
 gnome-desktop4 \
 gnome-settings-daemon \
 graphene \
 gsettings-desktop-schemas \
 gtk4 \
 harfbuzz \
 lcms2 \
 libX11 \
 libX11-xcb \
 libXau \
 libXcomposite \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libXtst \
 libcanberra \
 libdisplay-info \
 libdrm \
 libeis \
 libgcc \
 libglvnd-egl \
 libglvnd-gles \
 libglvnd-glx \
 libgudev \
 libinput \
 libwacom \
 libwayland-server \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 libxkbfile \
 mesa-libgbm \
 mutter-common \
 pango \
 pipewire \
 pipewire-libs \
 pixman \
 python3 \
 python3-argcomplete \
 startup-notification \
 systemd-libs \
 "
RDEPENDS:mutter-common = " \
 "
RDEPENDS:mutter-devel = " \
 atk-devel \
 cairo \
 cairo-devel \
 colord-devel \
 fribidi-devel \
 gdk-pixbuf2-devel \
 glib2 \
 glib2-devel \
 glibc \
 gnome-desktop4-devel \
 gnome-settings-daemon-devel \
 gobject-introspection-devel \
 graphene-devel \
 gsettings-desktop-schemas-devel \
 gtk4 \
 harfbuzz-devel \
 lcms2-devel \
 libX11-devel \
 libXau-devel \
 libXcomposite-devel \
 libXcursor-devel \
 libXdamage-devel \
 libXext \
 libXext-devel \
 libXfixes-devel \
 libXi-devel \
 libXinerama-devel \
 libXrandr-devel \
 libXtst-devel \
 libadwaita \
 libcanberra-devel \
 libdisplay-info-devel \
 libdrm-devel \
 libei \
 libeis-devel \
 libevdev \
 libgcc \
 libglvnd-devel \
 libglvnd-gles \
 libgudev \
 libgudev-devel \
 libinput-devel \
 libwacom-devel \
 libwayland-client \
 libxcb \
 libxcb-devel \
 libxkbcommon \
 libxkbcommon-devel \
 libxkbcommon-x11-devel \
 libxkbfile-devel \
 mesa-libEGL-devel \
 mesa-libgbm-devel \
 mutter \
 mutter-devel \
 pango-devel \
 pipewire-devel \
 pipewire-libs \
 pixman-devel \
 pkgconf-pkg-config \
 startup-notification-devel \
 sysprof-capture-devel \
 systemd-devel \
 wayland-devel \
 "
