# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-breeze"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 breeze-cursor-theme \
 plasma-breeze \
 plasma-breeze-common \
 plasma-breeze-qt6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-breeze-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6d0031194bd4ba0fa0dd37b19c5e1828d416ccadfcceadb122306eca1ba8d36"

URI_x86_64_v2_breeze-cursor-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-cursor-theme-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-cursor-theme}"
SRC_URI[x86_64_v2_breeze-cursor-theme.sha256sum] = "da70362413addedc4fd3ff8226bf80b586bd43393a6cf7d1b87b184027d0bf3c"

URI_x86_64_v2_plasma-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze}"
SRC_URI[x86_64_v2_plasma-breeze.sha256sum] = "746b0c8f1dbade68fcdc0aeacba42ef14df9d792c312eed4d870677b52324830"

URI_x86_64_v2_plasma-breeze-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-common-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-breeze-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze-common}"
SRC_URI[x86_64_v2_plasma-breeze-common.sha256sum] = "cd6de774bfa84a60e044acbf0a0a675f99b94ef02f9ede8253559e70d1c1e38a"

URI_x86_64_v2_plasma-breeze-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-qt6-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-breeze-qt6}"
SRC_URI[x86_64_v2_plasma-breeze-qt6.sha256sum] = "843951e983daa713e5f89ae319d5375c5e2a054deed7b8aea00f4c95b37eb458"

URI_aarch64_breeze-cursor-theme = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-cursor-theme-6.7.3-1.el10_3.noarch.rpm;name=aarch64_breeze-cursor-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-cursor-theme}"
SRC_URI[aarch64_breeze-cursor-theme.sha256sum] = "74cb13631a2ff61d2c9b3ff1c264439a90a94db66c98e66a0606da677f25a1e9"

URI_aarch64_plasma-breeze = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze}"
SRC_URI[aarch64_plasma-breeze.sha256sum] = "17dbfa6d6d5c90f2c2352ef347d9888167f2ff9b8fb81d46e02316ccc55d48ca"

URI_aarch64_plasma-breeze-common = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-common-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma-breeze-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze-common}"
SRC_URI[aarch64_plasma-breeze-common.sha256sum] = "6e3d2f5e555c5e45aee4fdb4713fe16a3a8b1a39e25d9afd84b8a09e10e022f7"

URI_aarch64_plasma-breeze-qt6 = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-qt6-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-breeze-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-breeze-qt6}"
SRC_URI[aarch64_plasma-breeze-qt6.sha256sum] = "aced22fea196da4416e7bc17aed85c080b6287e780762da7695dde2434e01573"

RDEPENDS:breeze-cursor-theme = " \
 "
RDEPENDS:plasma-breeze = " \
 cmake-filesystem \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 libstdc++ \
 plasma-breeze-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:plasma-breeze-common = " \
 "
RDEPENDS:plasma-breeze-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-breeze-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
