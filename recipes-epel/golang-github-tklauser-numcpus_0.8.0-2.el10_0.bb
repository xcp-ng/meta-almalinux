# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-tklauser-numcpus"
PV = "0.8.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-tklauser-numcpus \
 golang-github-tklauser-numcpus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-tklauser-numcpus-0.8.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2820a21e90c0d9ac3a96ebbec0695883c7a278fe41a2a561d8ecc7d5bced51f1"

URI_x86_64_v2_golang-github-tklauser-numcpus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-tklauser-numcpus-0.8.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-tklauser-numcpus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-tklauser-numcpus}"
SRC_URI[x86_64_v2_golang-github-tklauser-numcpus.sha256sum] = "89c1e14b7a087d9b68ae9491b4ca3dca0932bc25005b940ef2003b9d1ae7a8d1"

URI_x86_64_v2_golang-github-tklauser-numcpus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-tklauser-numcpus-devel-0.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-tklauser-numcpus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-tklauser-numcpus-devel}"
SRC_URI[x86_64_v2_golang-github-tklauser-numcpus-devel.sha256sum] = "37783fadadf02eabed8f03e89917ace46ca586913c5d6762189d376ce819a035"

URI_aarch64_golang-github-tklauser-numcpus = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-tklauser-numcpus-0.8.0-2.el10_0.aarch64.rpm;name=aarch64_golang-github-tklauser-numcpus;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-tklauser-numcpus}"
SRC_URI[aarch64_golang-github-tklauser-numcpus.sha256sum] = "ea5c6fa2e3a083e937feed3637b1190f66def108d895600cf573efeb29ed2e37"

URI_aarch64_golang-github-tklauser-numcpus-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-tklauser-numcpus-devel-0.8.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-tklauser-numcpus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-tklauser-numcpus-devel}"
SRC_URI[aarch64_golang-github-tklauser-numcpus-devel.sha256sum] = "c1ed0f029bdcde6ed7d43910f9fcffee2330dfdbcef87152c0125821824dd5a1"

RDEPENDS:golang-github-tklauser-numcpus = " \
 glibc \
 "
RDEPENDS:golang-github-tklauser-numcpus-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
