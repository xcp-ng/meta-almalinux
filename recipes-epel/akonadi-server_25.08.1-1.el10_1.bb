# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-server"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 akonadi-server \
 akonadi-server-devel \
 akonadi-server-doc \
 akonadi-server-mysql \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-server-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b9270a1c0ad7c301a38f8ec09e912feb8816202bb5d53b3525fd2f3d73e3d08"

URI_x86_64_v2_akonadi-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server}"
SRC_URI[x86_64_v2_akonadi-server.sha256sum] = "2490d92e12b81f6fcb6f6b61518c50a1289ad421ad8fcf872142c8a9966a8f34"

URI_x86_64_v2_akonadi-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-devel}"
SRC_URI[x86_64_v2_akonadi-server-devel.sha256sum] = "ee4c81ea8aef9e24cc08f9031759c79cf603b647db72ed1b57efaf3331d18047"

URI_x86_64_v2_akonadi-server-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-server-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-doc}"
SRC_URI[x86_64_v2_akonadi-server-doc.sha256sum] = "30402cc46cc9d3b226562fa802630c22b4adf6ed219efb0eeae406e3c0b62121"

URI_x86_64_v2_akonadi-server-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-mysql-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-mysql}"
SRC_URI[x86_64_v2_akonadi-server-mysql.sha256sum] = "882129342cacb68fea1d8b6c890f6d239fb6f73beeaa2fd8a41858df8a9d570d"

URI_aarch64_akonadi-server = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server}"
SRC_URI[aarch64_akonadi-server.sha256sum] = "e9e8e88e37aac177ecf6abc56b4d9b51de0080a963fb5505845daac0d9517f1c"

URI_aarch64_akonadi-server-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-devel}"
SRC_URI[aarch64_akonadi-server-devel.sha256sum] = "bad0558a49f3c63af8656fcf039582ee1a83cc360e8d16579c9f7bf05302b96b"

URI_aarch64_akonadi-server-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_akonadi-server-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-doc}"
SRC_URI[aarch64_akonadi-server-doc.sha256sum] = "eb1a23de44f02f656bdbac97ac7224812b41396e8b5c95ab0a8e923a6a1be566"

URI_aarch64_akonadi-server-mysql = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-mysql-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-server-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-mysql}"
SRC_URI[aarch64_akonadi-server-mysql.sha256sum] = "80223646d1a025b41e6af6f20cc9a0512b1ce114bee24d7e7377c1aad1abfe03"

RDEPENDS:akonadi-server = " \
 alternatives \
 bash \
 glibc \
 kaccounts-integration-qt6 \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libaccounts-qt6 \
 libgcc \
 libstdc++ \
 libxml2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xz-libs \
 "
RDEPENDS:akonadi-server-devel = " \
 akonadi-server \
 cmake-filesystem \
 glibc \
 kf6-kconfig \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kcoreaddons-devel \
 kf6-ki18n \
 kf6-kio-devel \
 kf6-kitemmodels-devel \
 kf6-kxmlgui-devel \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-server-doc = " \
 "
RDEPENDS:akonadi-server-mysql = " \
 akonadi-server \
 alternatives \
 bash \
 mariadb-server \
 qt6-qtbase-mysql \
 "
