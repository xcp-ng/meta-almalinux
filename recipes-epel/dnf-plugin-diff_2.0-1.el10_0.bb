# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnf-plugin-diff"
PV = "2.0"
PR = "1.el10_0"
PACKAGES = " \
 dnf-plugin-diff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnf-plugin-diff-2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40fe46829e1799dc76f4e692ab53a4435dd2b7152beafeba4544ee849e2dbfe0"

URI_x86_64_v2_dnf-plugin-diff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnf-plugin-diff-2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dnf-plugin-diff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnf-plugin-diff}"
SRC_URI[x86_64_v2_dnf-plugin-diff.sha256sum] = "e46d92351694cf81950b71cfe77758ef4123706442020a1091e281a1a2b0f397"

URI_aarch64_dnf-plugin-diff = "${EPEL_MIRROR}/aarch64/Packages/d/dnf-plugin-diff-2.0-1.el10_0.noarch.rpm;name=aarch64_dnf-plugin-diff;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnf-plugin-diff}"
SRC_URI[aarch64_dnf-plugin-diff.sha256sum] = "48a6bade02757f1d165d86371aed1da99d005a3a46b4616c4c1736d535cc1671"

RDEPENDS:dnf-plugin-diff = " \
 bash \
 cpio \
 file \
 python3 \
 python3-dnf \
 python3-dnf-plugins-core \
 "
