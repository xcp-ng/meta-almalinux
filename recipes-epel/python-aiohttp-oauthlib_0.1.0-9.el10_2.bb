# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiohttp-oauthlib"
PV = "0.1.0"
PR = "9.el10_2"
PACKAGES = " \
 python3-aiohttp-oauthlib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiohttp-oauthlib-0.1.0-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a25609edff3032eefc72eb38f4f578a51ddab1fd7996f7505869d68f6b6564f4"

URI_x86_64_v2_python3-aiohttp-oauthlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiohttp-oauthlib-0.1.0-9.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiohttp-oauthlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiohttp-oauthlib}"
SRC_URI[x86_64_v2_python3-aiohttp-oauthlib.sha256sum] = "c472d0a219df46058862c7eeede5df51fb55f2e05dfeb3f555ba4a2ff81790be"

URI_aarch64_python3-aiohttp-oauthlib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiohttp-oauthlib-0.1.0-9.el10_2.noarch.rpm;name=aarch64_python3-aiohttp-oauthlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiohttp-oauthlib}"
SRC_URI[aarch64_python3-aiohttp-oauthlib.sha256sum] = "d86d7473eee5c831f3506f745190879eebbd7c4a212559864af296976882aedb"

RDEPENDS:python3-aiohttp-oauthlib = " \
 python3 \
 python3-aiohttp \
 python3-oauthlib \
 "
