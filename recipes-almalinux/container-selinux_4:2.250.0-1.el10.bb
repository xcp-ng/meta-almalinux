# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "container-selinux"
PE = "4"
PV = "2.250.0"
PR = "1.el10"
PACKAGES = " \
 container-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/container-selinux-2.250.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ea13b6bd9fd27cf2992ca36b62daf73d262d2cd3f8cd3fea927687e692b77b6"

URI_x86_64_v2_container-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/container-selinux-2.250.0-1.el10.noarch.rpm;name=x86_64_v2_container-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_container-selinux}"
SRC_URI[x86_64_v2_container-selinux.sha256sum] = "7e9d228a63628f286a5a5356748b665185a5d7a0442eef203ce48d5b50c97f8d"

URI_aarch64_container-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/container-selinux-2.250.0-1.el10.noarch.rpm;name=aarch64_container-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_container-selinux}"
SRC_URI[aarch64_container-selinux.sha256sum] = "7e9d228a63628f286a5a5356748b665185a5d7a0442eef203ce48d5b50c97f8d"

RDEPENDS:container-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 sed \
 selinux-policy \
 virtual/selinux-policy-any_ge_42.1.25 \
 "
