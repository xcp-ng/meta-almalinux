# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jsonschema-path"
PV = "0.3.4"
PR = "6.el10_1"
PACKAGES = " \
 python3-jsonschema-path \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jsonschema-path-0.3.4-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02318162785d1ec6d6791a99e43bb6a85528e7d694af79e4380d393cc7fdf9b2"

URI_x86_64_v2_python3-jsonschema-path = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jsonschema-path-0.3.4-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jsonschema-path;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jsonschema-path}"
SRC_URI[x86_64_v2_python3-jsonschema-path.sha256sum] = "1e5d9e4c96f1ef0356be3c97aff0d59d886cc800ac048a3e47efda6031a89277"

URI_aarch64_python3-jsonschema-path = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jsonschema-path-0.3.4-6.el10_1.noarch.rpm;name=aarch64_python3-jsonschema-path;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jsonschema-path}"
SRC_URI[aarch64_python3-jsonschema-path.sha256sum] = "dcc7ba1eba92d4b70aac2c1b4cd24ecc387a7a7f0b77e48e40d36686c4657a0a"

RDEPENDS:python3-jsonschema-path = " \
 python3 \
 python3-pathable \
 python3-pyyaml \
 python3-referencing \
 python3-requests \
 "
