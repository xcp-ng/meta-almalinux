# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-css"
PV = "0.23.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-tree-sitter-css+default-devel \
 rust-tree-sitter-css-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-css-0.23.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8d18f0bc9190a3cbcfc2162ce5c1bc78d5c818c620af58b1596a40b42854044"

URI_x86_64_v2_rust-tree-sitter-css+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-css+default-devel-0.23.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-css+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-css+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-css+default-devel.sha256sum] = "cd33ba6c6d4b7a05f67dd1cc7970bdbf510fc867874592f1458e103363f50396"

URI_x86_64_v2_rust-tree-sitter-css-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-css-devel-0.23.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-css-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-css-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-css-devel.sha256sum] = "b4044c71369bf8d37a390f16b486bc5ee74c359fe313334171acbf2a252585ad"

URI_aarch64_rust-tree-sitter-css+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-css+default-devel-0.23.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-css+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-css+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-css+default-devel.sha256sum] = "53609fd6d9ab4b2b7373f1228346878360b9f0597c85ebbe08876729ed1b3994"

URI_aarch64_rust-tree-sitter-css-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-css-devel-0.23.2-1.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-css-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-css-devel}"
SRC_URI[aarch64_rust-tree-sitter-css-devel.sha256sum] = "28f7e63f51e7892e4ced3821fb0769006d907b60e90003b3f3c9c962e9b35078"

RDEPENDS:rust-tree-sitter-css+default-devel = " \
 cargo \
 rust-tree-sitter-css-devel \
 "
RDEPENDS:rust-tree-sitter-css-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
