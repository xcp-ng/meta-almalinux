# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-openapi-swag"
PV = "0.21.1"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-openapi-swag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-openapi-swag-0.21.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6cfced46cf8a9b18533e094436980002dc5a4d49974dcda194d33fd3ce0b2d3"

URI_x86_64_v2_golang-github-openapi-swag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-openapi-swag-devel-0.21.1-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-openapi-swag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-openapi-swag-devel}"
SRC_URI[x86_64_v2_golang-github-openapi-swag-devel.sha256sum] = "031e5978a336fe36b87e59a52dcc3376fccdfcc87660cde7206d5c8f9c6309d6"

URI_aarch64_golang-github-openapi-swag-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-openapi-swag-devel-0.21.1-10.el10_0.noarch.rpm;name=aarch64_golang-github-openapi-swag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-openapi-swag-devel}"
SRC_URI[aarch64_golang-github-openapi-swag-devel.sha256sum] = "4d09fd8bd9e3beb7d485b7c1f5efb02d71726b6a4a0aebe9d497c0624866dcc7"

RDEPENDS:golang-github-openapi-swag-devel = " \
 go-filesystem \
 golang-github-mailru-easyjson-devel \
 golang-gopkg-yaml-2-devel \
 "
