# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-findshlibs"
PV = "0.10.2"
PR = "7.el10_0"
PACKAGES = " \
 rust-findshlibs+default-devel \
 rust-findshlibs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-findshlibs-0.10.2-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f19a79dc206ef5b52243ba3bc6a427d271d16e7a60998bf68844108edff11a3c"

URI_x86_64_v2_rust-findshlibs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-findshlibs+default-devel-0.10.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-findshlibs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-findshlibs+default-devel}"
SRC_URI[x86_64_v2_rust-findshlibs+default-devel.sha256sum] = "77d0e7da00f0902ca1a0aa7e4bf7436ba283477a3d2923120a668be68bb2bc6a"

URI_x86_64_v2_rust-findshlibs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-findshlibs-devel-0.10.2-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-findshlibs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-findshlibs-devel}"
SRC_URI[x86_64_v2_rust-findshlibs-devel.sha256sum] = "cbab3f31cfa96105b5ad155046fb40bd10ab61445f25c85411512b1313d42ee1"

URI_aarch64_rust-findshlibs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-findshlibs+default-devel-0.10.2-7.el10_0.noarch.rpm;name=aarch64_rust-findshlibs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-findshlibs+default-devel}"
SRC_URI[aarch64_rust-findshlibs+default-devel.sha256sum] = "0e15d15fb9edf74f1ed77d5099ea7300c7b273a23cfe6064e5c6751c600bc070"

URI_aarch64_rust-findshlibs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-findshlibs-devel-0.10.2-7.el10_0.noarch.rpm;name=aarch64_rust-findshlibs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-findshlibs-devel}"
SRC_URI[aarch64_rust-findshlibs-devel.sha256sum] = "7d374e4a4e5b0e619ec95057f54a01c08dc57cbad23ac630e6c085fb788a56d4"

RDEPENDS:rust-findshlibs+default-devel = " \
 cargo \
 rust-findshlibs-devel \
 "
RDEPENDS:rust-findshlibs-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-libc+default-devel \
 "
