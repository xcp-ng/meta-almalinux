# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sympa"
PV = "6.2.78"
PR = "3.el10_2"
PACKAGES = " \
 sympa \
 sympa-devel-doc \
 sympa-httpd \
 sympa-lighttpd \
 sympa-nginx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sympa-6.2.78-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2ea101e8782231967bd34ea320b4a33d2900c21d6ec730bd3d8f88206cedf6e"

URI_x86_64_v2_sympa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-6.2.78-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa}"
SRC_URI[x86_64_v2_sympa.sha256sum] = "7b553ea487ee10102d61ff389a8bf605028e9af9896fbf89dc9cdf10f56f0055"

URI_x86_64_v2_sympa-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-devel-doc-6.2.78-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-devel-doc}"
SRC_URI[x86_64_v2_sympa-devel-doc.sha256sum] = "186b3f17a648970a0a81a740e5ab048ef014540cd9a5ceb60a9999d1c29b92d8"

URI_x86_64_v2_sympa-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-httpd-6.2.78-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-httpd}"
SRC_URI[x86_64_v2_sympa-httpd.sha256sum] = "d83825f104f0e5827824cfc5996e5958c12fbd41e6c2d619e38d77dd2d8f41d3"

URI_x86_64_v2_sympa-lighttpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-lighttpd-6.2.78-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-lighttpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-lighttpd}"
SRC_URI[x86_64_v2_sympa-lighttpd.sha256sum] = "d7c2374a17583984926e46ea6fb7ba73954787ffc90d0b3d3d21ef8d27da81db"

URI_x86_64_v2_sympa-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-nginx-6.2.78-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-nginx}"
SRC_URI[x86_64_v2_sympa-nginx.sha256sum] = "743ab0d38f5342311dcbbe5d119d76bbf5852e64833909be8731cc6ebffd120a"

URI_aarch64_sympa = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-6.2.78-3.el10_2.aarch64.rpm;name=aarch64_sympa;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa}"
SRC_URI[aarch64_sympa.sha256sum] = "f66276cd252ab3bdd44fc62fda46dfce131b9a3da05b84b11bc5294255352b7b"

URI_aarch64_sympa-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-devel-doc-6.2.78-3.el10_2.noarch.rpm;name=aarch64_sympa-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-devel-doc}"
SRC_URI[aarch64_sympa-devel-doc.sha256sum] = "9a92ee80f17cdcba6a176cf62a6c2ed8de66699b221868171b15fc58ba1c9112"

URI_aarch64_sympa-httpd = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-httpd-6.2.78-3.el10_2.noarch.rpm;name=aarch64_sympa-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-httpd}"
SRC_URI[aarch64_sympa-httpd.sha256sum] = "35d2787f72b0a3289183ebb3b2ba5fe5c2b766cf5ef2efc5e5e034fec1748154"

URI_aarch64_sympa-lighttpd = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-lighttpd-6.2.78-3.el10_2.noarch.rpm;name=aarch64_sympa-lighttpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-lighttpd}"
SRC_URI[aarch64_sympa-lighttpd.sha256sum] = "15e6339d81a958ca7c177ce1d58246c8658fe8fe0d7040f5060b2ebc4d8ce679"

URI_aarch64_sympa-nginx = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-nginx-6.2.78-3.el10_2.noarch.rpm;name=aarch64_sympa-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-nginx}"
SRC_URI[aarch64_sympa-nginx.sha256sum] = "c1ffd1ced50b277e58823a8d783daa9a24faf229de1cb28d6cdb8932d5178792"

RDEPENDS:sympa = " \
 bash \
 glibc \
 js-jquery \
 js-jquery-ui \
 logrotate \
 mhonarc \
 perl-Archive-Zip-SimpleZip \
 perl-AuthCAS \
 perl-CGI \
 perl-CGI-Fast \
 perl-Carp \
 perl-Class-Singleton \
 perl-Clone \
 perl-Crypt-CipherSaber \
 perl-Crypt-Eksblowfish \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-SMIME \
 perl-DBD-CSV \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Data-Dumper \
 perl-Data-Password \
 perl-DateTime \
 perl-DateTime-Format-Mail \
 perl-DateTime-TimeZone \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Encode-EUCJPASCII \
 perl-Encode-HanExtra \
 perl-Encode-Locale \
 perl-English \
 perl-FCGI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Copy-Recursive \
 perl-File-Find \
 perl-File-NFSLock \
 perl-File-Path \
 perl-Getopt-Long \
 perl-HTML-Formatter \
 perl-HTML-Parser \
 perl-HTML-StripScripts-Parser \
 perl-HTML-Tree \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-IO-stringy \
 perl-LDAP \
 perl-LWP-Protocol-https \
 perl-MIME-Base64 \
 perl-MIME-Charset \
 perl-MIME-EncWords \
 perl-MIME-Lite-HTML \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-MailTools \
 perl-Net-CIDR \
 perl-Net-DNS \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Template-Toolkit \
 perl-Term-ProgressBar \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-URI \
 perl-URI-Find \
 perl-Unicode-LineBreak \
 perl-Unicode-Normalize \
 perl-Unicode-UTF8 \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libintl-perl \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 perl-parent \
 shadow-utils \
 sympa \
 systemd \
 virtual/smtpdaemon \
 "
RDEPENDS:sympa-devel-doc = " \
 sympa \
 "
RDEPENDS:sympa-httpd = " \
 bash \
 httpd \
 multiwatch \
 sympa \
 "
RDEPENDS:sympa-lighttpd = " \
 lighttpd \
 lighttpd-fastcgi \
 sympa \
 "
RDEPENDS:sympa-nginx = " \
 bash \
 multiwatch \
 nginx \
 sympa \
 "
