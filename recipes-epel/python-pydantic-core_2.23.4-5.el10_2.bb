# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic-core"
PV = "2.23.4"
PR = "5.el10_2"
PACKAGES = " \
 python3-pydantic-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-core-2.23.4-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdab1b64775b707bfd6905bb3eeb6e7703d5b14167fd1bbc0678ae2829267975"

URI_x86_64_v2_python3-pydantic-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-core-2.23.4-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pydantic-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-core}"
SRC_URI[x86_64_v2_python3-pydantic-core.sha256sum] = "ecd2164f91198f99cb32b2893afbc933fc8f3cc4e2594fe1e12fb1948f2fa34e"

URI_aarch64_python3-pydantic-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-core-2.23.4-5.el10_2.aarch64.rpm;name=aarch64_python3-pydantic-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-core}"
SRC_URI[aarch64_python3-pydantic-core.sha256sum] = "1dc71afe1c3312070a7ec901d4b9be2dfa0a7c237fa291b798ba5d5d1e1268fe"

RDEPENDS:python3-pydantic-core = " \
 glibc \
 libgcc \
 python3 \
 python3-typing-extensions \
 "
