# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xcursor"
PV = "0.3.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-xcursor+default-devel \
 rust-xcursor-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-xcursor-0.3.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "69e3f80744a13979b76c1e533baae9163fa32609e15a22dc4efc5716dc1a67e3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xcursor+default-devel-0.3.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xcursor+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xcursor+default-devel.sha256sum] = "a56f8778aaeb2606778ff43e85a8063a8d388a25c43b50096c6a024d750c7968"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xcursor-devel-0.3.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xcursor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xcursor-devel.sha256sum] = "b463beb6178ae924c9b6cd0a97dc38c23ecf448761bcb5aa8b479de4b77da75e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xcursor+default-devel-0.3.11-1.el10_3.noarch.rpm;name=aarch64_rust-xcursor+default-devel;unpack=0"
SRC_URI[aarch64_rust-xcursor+default-devel.sha256sum] = "ba8ce9165046ef73f1e14ca2b81c09663ed3ec911aa2947bfd2434cdf28256cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xcursor-devel-0.3.11-1.el10_3.noarch.rpm;name=aarch64_rust-xcursor-devel;unpack=0"
SRC_URI[aarch64_rust-xcursor-devel.sha256sum] = "e736313cf642a27feea2bb217ccb5e3f0626047ad1132261e2c5e4ea09921aaf"

RDEPENDS:rust-xcursor+default-devel = " \
 cargo \
 rust-xcursor-devel \
 "
RDEPENDS:rust-xcursor-devel = " \
 cargo \
 "
