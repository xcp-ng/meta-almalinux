# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qwt"
PV = "6.2.0"
PR = "11.el10_2"
PACKAGES = " \
 qwt-doc \
 qwt-qt5 \
 qwt-qt5-devel \
 qwt-qt6 \
 qwt-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qwt-6.2.0-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac92a8f3cbc2ee56fe30a2881c995094319dbac7d22cb3298c334233feb7b921"

URI_x86_64_v2_qwt-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qwt-doc-6.2.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qwt-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qwt-doc}"
SRC_URI[x86_64_v2_qwt-doc.sha256sum] = "0c98106245d7b819518794538d4612ab43c30f88183fc7618b3fa4b624fdee7d"

URI_x86_64_v2_qwt-qt5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qwt-qt5-6.2.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qwt-qt5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qwt-qt5}"
SRC_URI[x86_64_v2_qwt-qt5.sha256sum] = "f9b06af8fc8a2a369db649659377814289e50579ba1bb4559a2bb817e7570d64"

URI_x86_64_v2_qwt-qt5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qwt-qt5-devel-6.2.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qwt-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qwt-qt5-devel}"
SRC_URI[x86_64_v2_qwt-qt5-devel.sha256sum] = "934cd86150e3e5adef273b95264fa083d73ff0e73178a03c038069c23a449499"

URI_x86_64_v2_qwt-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qwt-qt6-6.2.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qwt-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qwt-qt6}"
SRC_URI[x86_64_v2_qwt-qt6.sha256sum] = "351e75de28a696f40b177a325dc490f8c000cb2b2df55b34d83ca689bba7c729"

URI_x86_64_v2_qwt-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qwt-qt6-devel-6.2.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qwt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qwt-qt6-devel}"
SRC_URI[x86_64_v2_qwt-qt6-devel.sha256sum] = "c2509d30e35a429795eaa83adb96ebc85b9fa379bc0e89c14841d7c9b228dbd1"

URI_aarch64_qwt-doc = "${EPEL_MIRROR}/aarch64/Packages/q/qwt-doc-6.2.0-11.el10_2.noarch.rpm;name=aarch64_qwt-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qwt-doc}"
SRC_URI[aarch64_qwt-doc.sha256sum] = "82b5df9b10210faceb20eec0dba9adbc5602bb12c537776db81496c460871a24"

URI_aarch64_qwt-qt5 = "${EPEL_MIRROR}/aarch64/Packages/q/qwt-qt5-6.2.0-11.el10_2.aarch64.rpm;name=aarch64_qwt-qt5;unpack=0"
SRC_URI:append = " ${URI_aarch64_qwt-qt5}"
SRC_URI[aarch64_qwt-qt5.sha256sum] = "bb7ff9ba1a73812d6097c76006fffc89dad327012e9d369580a8d8734d8f4f46"

URI_aarch64_qwt-qt5-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qwt-qt5-devel-6.2.0-11.el10_2.aarch64.rpm;name=aarch64_qwt-qt5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qwt-qt5-devel}"
SRC_URI[aarch64_qwt-qt5-devel.sha256sum] = "2e1dbb9190b2f5b1a467d3db4a79d5623613a45b5a371dd1b73b206a4931a8fa"

URI_aarch64_qwt-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qwt-qt6-6.2.0-11.el10_2.aarch64.rpm;name=aarch64_qwt-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qwt-qt6}"
SRC_URI[aarch64_qwt-qt6.sha256sum] = "284558b9812f5c74eb6f208f77c5c29542e27bdaba7d584f35d89b5bac1e8e04"

URI_aarch64_qwt-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qwt-qt6-devel-6.2.0-11.el10_2.aarch64.rpm;name=aarch64_qwt-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qwt-qt6-devel}"
SRC_URI[aarch64_qwt-qt6-devel.sha256sum] = "312b05153cf7577cc70b79f798ab14e11c73481ce9865ca49ccb29573abb3bb3"

RDEPENDS:qwt-doc = " \
 "
RDEPENDS:qwt-qt5 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 "
RDEPENDS:qwt-qt5-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-qtsvg-devel \
 qwt-qt5 \
 "
RDEPENDS:qwt-qt6 = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:qwt-qt6-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtsvg-devel \
 qwt-qt6 \
 "
