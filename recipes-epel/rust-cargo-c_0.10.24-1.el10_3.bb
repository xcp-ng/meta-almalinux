# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-c"
PV = "0.10.24"
PR = "1.el10_3"
PACKAGES = " \
 cargo-c \
 rust-cargo-c+default-devel \
 rust-cargo-c-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-c-0.10.24-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eed27b08fd6384caa90af69787b75663c8b9cdddf9195b8cbd787c84b0abc62c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-c-0.10.24-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-c;unpack=0"
SRC_URI[x86_64_v2_cargo-c.sha256sum] = "4e57aa0a3c250594c576b5e90345f0bca96c7b2b1e99e0d4eedc71e4a5b52791"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-c+default-devel-0.10.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-c+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-c+default-devel.sha256sum] = "d26bc5b0241b8b5fdf2fc41908343ffb48c1d58a327c8c30c629b7a26d33d7ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-c-devel-0.10.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-c-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-c-devel.sha256sum] = "eeb00be47672ae2eae8fffdf8254dd38a59f976ab74eace76637dd844cfc9a02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cargo-c-0.10.24-1.el10_3.aarch64.rpm;name=aarch64_cargo-c;unpack=0"
SRC_URI[aarch64_cargo-c.sha256sum] = "d9abbc4b7f4424b5ac902a9c23596f13f67e45207fd83e454a1192ca5ea5fa92"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-c+default-devel-0.10.24-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-c+default-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-c+default-devel.sha256sum] = "82d6925432b47ef68aa56e2a3d45b5f365219aabc47ffbf028ec2daa78188d41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-c-devel-0.10.24-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-c-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-c-devel.sha256sum] = "ab792b22b7864487d2317c4f5c71ad69615b08fbbb2c95b04b84d648d93596bc"

RDEPENDS:cargo-c = " \
 glibc \
 libgcc \
 libgit2_1.9 \
 libssh2 \
 openssl-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rust-cargo-c+default-devel = " \
 cargo \
 rust-cargo-c-devel \
 "
RDEPENDS:rust-cargo-c-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-camino+default-devel \
 rust-cargo+default-devel \
 rust-cargo-platform+default-devel \
 rust-cargo-util+default-devel \
 rust-cbindgen-devel \
 rust-cc+default-devel \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+string-devel \
 rust-clap+wrap_help-devel \
 rust-clap_complete+default-devel \
 rust-glob+default-devel \
 rust-implib+default-devel \
 rust-itertools+default-devel \
 rust-log+default-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object-devel \
 rust-regex+default-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-toml+default-devel \
 "
