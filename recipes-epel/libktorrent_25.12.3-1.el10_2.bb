# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libktorrent"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libktorrent \
 libktorrent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libktorrent-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "474a5e9938540ef3ee52c29e248342d8547b4220850ac339c0e3c3e64dce340b"

URI_x86_64_v2_libktorrent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libktorrent}"
SRC_URI[x86_64_v2_libktorrent.sha256sum] = "f0cd8945c6f1a532c2091b2d91b8d613771b21b986d4aa6121dc985cb8a11960"

URI_x86_64_v2_libktorrent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libktorrent-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libktorrent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libktorrent-devel}"
SRC_URI[x86_64_v2_libktorrent-devel.sha256sum] = "726f90af368819a0dba28265fd1134d3e056220ed27f2ac62010efbf021dffbf"

URI_aarch64_libktorrent = "${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libktorrent;unpack=0"
SRC_URI:append = " ${URI_aarch64_libktorrent}"
SRC_URI[aarch64_libktorrent.sha256sum] = "0e9d896128809aece6f3498a6611751025893ba216a9a180f4997e06deb42d49"

URI_aarch64_libktorrent-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libktorrent-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libktorrent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libktorrent-devel}"
SRC_URI[aarch64_libktorrent-devel.sha256sum] = "7dbd9b1b1660d502a7e237bb849345d801b8a519d0874f44fa3a26cce7d09b09"

RDEPENDS:libktorrent = " \
 glibc \
 gmp \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libgcc \
 libgcrypt \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libktorrent-devel = " \
 boost-devel \
 cmake-filesystem \
 gmp-devel \
 kf6-karchive-devel \
 kf6-kconfig-devel \
 kf6-kio-devel \
 libgcrypt-devel \
 libktorrent \
 qt6-qtbase-devel \
 "
