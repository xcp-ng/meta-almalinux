# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-triomphe"
PV = "0.1.16"
PR = "1.el10_3"
PACKAGES = " \
 rust-triomphe+arc-swap-devel \
 rust-triomphe+default-devel \
 rust-triomphe+serde-devel \
 rust-triomphe+stable_deref_trait-devel \
 rust-triomphe+std-devel \
 rust-triomphe+unstable_dropck_eyepatch-devel \
 rust-triomphe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-triomphe-0.1.16-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f9637c5cfc782728ca2a95220685431ab618b9c5515efb7e2ce76a3b2c8e8f4"

URI_x86_64_v2_rust-triomphe+arc-swap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-triomphe+arc-swap-devel-0.1.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-triomphe+arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-triomphe+arc-swap-devel}"
SRC_URI[x86_64_v2_rust-triomphe+arc-swap-devel.sha256sum] = "4192766fce85d4285463ff6533c4b01412966442c566bc385e640d5d70379f48"

URI_x86_64_v2_rust-triomphe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-triomphe+default-devel-0.1.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-triomphe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-triomphe+default-devel}"
SRC_URI[x86_64_v2_rust-triomphe+default-devel.sha256sum] = "5537047c7abcfe8beb2d448f99f421e5b25057e1205519030dc3c2eb7ac143be"

URI_x86_64_v2_rust-triomphe+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-triomphe+serde-devel-0.1.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-triomphe+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-triomphe+serde-devel}"
SRC_URI[x86_64_v2_rust-triomphe+serde-devel.sha256sum] = "1a127c011ce00e3aab343734136d9217ecc736329ca40986d38176ee484b5d80"

URI_x86_64_v2_rust-triomphe+stable_deref_trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-triomphe+stable_deref_trait-devel-0.1.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-triomphe+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-triomphe+stable_deref_trait-devel}"
SRC_URI[x86_64_v2_rust-triomphe+stable_deref_trait-devel.sha256sum] = "d57e50e54f3c7ceef8f7a7d11eb186507c5a19607fc41d171a8e0a7d0f186a1b"

URI_x86_64_v2_rust-triomphe+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-triomphe+std-devel-0.1.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-triomphe+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-triomphe+std-devel}"
SRC_URI[x86_64_v2_rust-triomphe+std-devel.sha256sum] = "d16567beed45204f47398e76625aa47601a411664a1489c8ed7a49297a412a5f"

URI_x86_64_v2_rust-triomphe+unstable_dropck_eyepatch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-triomphe+unstable_dropck_eyepatch-devel-0.1.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-triomphe+unstable_dropck_eyepatch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-triomphe+unstable_dropck_eyepatch-devel}"
SRC_URI[x86_64_v2_rust-triomphe+unstable_dropck_eyepatch-devel.sha256sum] = "f05e93b776c50291e20e84f4c4891b226cf3888128886f6140a7ac590f3a32be"

URI_x86_64_v2_rust-triomphe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-triomphe-devel-0.1.16-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-triomphe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-triomphe-devel}"
SRC_URI[x86_64_v2_rust-triomphe-devel.sha256sum] = "858cb04a1849438ff953d1fddbd5f2e3bea162ba09a8892f0c11d46047cfceeb"

URI_aarch64_rust-triomphe+arc-swap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-triomphe+arc-swap-devel-0.1.16-1.el10_3.noarch.rpm;name=aarch64_rust-triomphe+arc-swap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-triomphe+arc-swap-devel}"
SRC_URI[aarch64_rust-triomphe+arc-swap-devel.sha256sum] = "093396ecf8d42605e0977ed53b6cc13739fcc88757cce26bdbe18f7b60d070d6"

URI_aarch64_rust-triomphe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-triomphe+default-devel-0.1.16-1.el10_3.noarch.rpm;name=aarch64_rust-triomphe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-triomphe+default-devel}"
SRC_URI[aarch64_rust-triomphe+default-devel.sha256sum] = "195f564fbd585567e87a3be5ec6941bb08b8cc6ccf7277c91b94ff749449cdfc"

URI_aarch64_rust-triomphe+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-triomphe+serde-devel-0.1.16-1.el10_3.noarch.rpm;name=aarch64_rust-triomphe+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-triomphe+serde-devel}"
SRC_URI[aarch64_rust-triomphe+serde-devel.sha256sum] = "c83846d22919c3294ceeb5ce93383fff8a2edc719c12d8dc6ad2a79a2fffc335"

URI_aarch64_rust-triomphe+stable_deref_trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-triomphe+stable_deref_trait-devel-0.1.16-1.el10_3.noarch.rpm;name=aarch64_rust-triomphe+stable_deref_trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-triomphe+stable_deref_trait-devel}"
SRC_URI[aarch64_rust-triomphe+stable_deref_trait-devel.sha256sum] = "0e78ecd147f8e871686b9cee5b0d2d5099ce79cef4aed61daeb872efbfd6b7a4"

URI_aarch64_rust-triomphe+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-triomphe+std-devel-0.1.16-1.el10_3.noarch.rpm;name=aarch64_rust-triomphe+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-triomphe+std-devel}"
SRC_URI[aarch64_rust-triomphe+std-devel.sha256sum] = "2f8caab879d67cd768b9334f2c31c426762abd171b36156fc745f9610b9e4acc"

URI_aarch64_rust-triomphe+unstable_dropck_eyepatch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-triomphe+unstable_dropck_eyepatch-devel-0.1.16-1.el10_3.noarch.rpm;name=aarch64_rust-triomphe+unstable_dropck_eyepatch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-triomphe+unstable_dropck_eyepatch-devel}"
SRC_URI[aarch64_rust-triomphe+unstable_dropck_eyepatch-devel.sha256sum] = "f45f02a7f3a8abd398c7f24af249b407184f7c49e7cc4ba857118dfa87263929"

URI_aarch64_rust-triomphe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-triomphe-devel-0.1.16-1.el10_3.noarch.rpm;name=aarch64_rust-triomphe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-triomphe-devel}"
SRC_URI[aarch64_rust-triomphe-devel.sha256sum] = "1b442fdf9dcbbdda46e5f49d1ce1e7a4b7fa827906496783ad574ef14375b067"

RDEPENDS:rust-triomphe+arc-swap-devel = " \
 cargo \
 rust-arc-swap+default-devel \
 rust-triomphe-devel \
 "
RDEPENDS:rust-triomphe+default-devel = " \
 cargo \
 rust-triomphe+serde-devel \
 rust-triomphe+stable_deref_trait-devel \
 rust-triomphe+std-devel \
 rust-triomphe-devel \
 "
RDEPENDS:rust-triomphe+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-triomphe-devel \
 "
RDEPENDS:rust-triomphe+stable_deref_trait-devel = " \
 cargo \
 rust-stable_deref_trait-devel \
 rust-triomphe-devel \
 "
RDEPENDS:rust-triomphe+std-devel = " \
 cargo \
 rust-triomphe-devel \
 "
RDEPENDS:rust-triomphe+unstable_dropck_eyepatch-devel = " \
 cargo \
 rust-triomphe-devel \
 "
RDEPENDS:rust-triomphe-devel = " \
 cargo \
 rust \
 "
