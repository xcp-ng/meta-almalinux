# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debconf"
PV = "1.5.87"
PR = "2.el10_0"
PACKAGES = " \
 debconf \
 debconf-LDAP \
 debconf-doc \
 debconf-i18n \
 debconf-utils \
 python3-debconf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debconf-1.5.87-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d94accdc5288f3b2ecadf18290a60abc5cd5121600e6db3c02194499d6ace77"

URI_x86_64_v2_debconf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-1.5.87-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_debconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf}"
SRC_URI[x86_64_v2_debconf.sha256sum] = "4d8434c23be37db4336b2b93ff82309bedf42078c3ae58c4a994f86e7405096d"

URI_x86_64_v2_debconf-LDAP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-LDAP-1.5.87-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_debconf-LDAP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf-LDAP}"
SRC_URI[x86_64_v2_debconf-LDAP.sha256sum] = "70d68a1f82d03ec0e31cd9eab0907a772bf17997ae1e95b12fd656b7a0864496"

URI_x86_64_v2_debconf-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-doc-1.5.87-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_debconf-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf-doc}"
SRC_URI[x86_64_v2_debconf-doc.sha256sum] = "57c27466a7afc974bf2221bb5fc15d143fb639ebc374534e65c3eabb647d2136"

URI_x86_64_v2_debconf-i18n = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-i18n-1.5.87-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_debconf-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf-i18n}"
SRC_URI[x86_64_v2_debconf-i18n.sha256sum] = "22a1f045821ab7cf198303e7b5cb902559f4f9e31a9a5df4352b525c404e61a9"

URI_x86_64_v2_debconf-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debconf-utils-1.5.87-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_debconf-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debconf-utils}"
SRC_URI[x86_64_v2_debconf-utils.sha256sum] = "a4f8ad35cdf057466740ca03bb389b3e466346830513f3f8d6bf97aa2cc40d03"

URI_x86_64_v2_python3-debconf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-debconf-1.5.87-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-debconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-debconf}"
SRC_URI[x86_64_v2_python3-debconf.sha256sum] = "84ac6f3555745d4d16b8bf8b2c286ab9d57e2a97727fb426d27ee97e832ebfb8"

URI_aarch64_debconf = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-1.5.87-2.el10_0.noarch.rpm;name=aarch64_debconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf}"
SRC_URI[aarch64_debconf.sha256sum] = "f9c601f5b1a6e1bf18703cfc86c71d0ff595ebf853dd5f380045e087c4aa9fd9"

URI_aarch64_debconf-LDAP = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-LDAP-1.5.87-2.el10_0.noarch.rpm;name=aarch64_debconf-LDAP;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf-LDAP}"
SRC_URI[aarch64_debconf-LDAP.sha256sum] = "50edd7f3bb3edaefd7662458238bd6aa404c13a9d63b5320a8349230a69a74a6"

URI_aarch64_debconf-doc = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-doc-1.5.87-2.el10_0.noarch.rpm;name=aarch64_debconf-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf-doc}"
SRC_URI[aarch64_debconf-doc.sha256sum] = "f5250a877d41a83682b5fd9a821f313e99049c38755b8b6feed3d07de137a069"

URI_aarch64_debconf-i18n = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-i18n-1.5.87-2.el10_0.noarch.rpm;name=aarch64_debconf-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf-i18n}"
SRC_URI[aarch64_debconf-i18n.sha256sum] = "fa269d2c12cda3233fb3867db36e76ee7a48e4f62d5fbc946814fadb06b87140"

URI_aarch64_debconf-utils = "${EPEL_MIRROR}/aarch64/Packages/d/debconf-utils-1.5.87-2.el10_0.noarch.rpm;name=aarch64_debconf-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_debconf-utils}"
SRC_URI[aarch64_debconf-utils.sha256sum] = "2a219bea909e3504181d964b2eb61ca640236e14a85030c23982f45b6f45a67a"

URI_aarch64_python3-debconf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-debconf-1.5.87-2.el10_0.noarch.rpm;name=aarch64_python3-debconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-debconf}"
SRC_URI[aarch64_python3-debconf.sha256sum] = "97d0e11d6ad7ff93f76b84d394da0e2ed2c04ff87564d919c2b31df63e999778"

RDEPENDS:debconf = " \
 bash \
 perl-CGI \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-Locale-gettext \
 perl-POSIX \
 perl-PathTools \
 perl-Term-ReadLine \
 perl-Text-CharWidth \
 perl-Text-Iconv \
 perl-Text-Tabs+Wrap \
 perl-Text-WrapI18N \
 perl-base \
 perl-fields \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:debconf-LDAP = " \
 debconf \
 perl-LDAP \
 perl-base \
 perl-fields \
 perl-libs \
 "
RDEPENDS:debconf-doc = " \
 debconf \
 "
RDEPENDS:debconf-i18n = " \
 debconf \
 "
RDEPENDS:debconf-utils = " \
 debconf \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:python3-debconf = " \
 python3 \
 "
