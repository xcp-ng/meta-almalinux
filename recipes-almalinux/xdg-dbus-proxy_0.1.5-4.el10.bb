# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdg-dbus-proxy"
PV = "0.1.5"
PR = "4.el10"
PACKAGES = " \
 xdg-dbus-proxy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdg-dbus-proxy-0.1.5-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a886ca0025a042a8ed95d87255acf1cfdc745ced8c0452d4e95a32369431385"

URI_x86_64_v2_xdg-dbus-proxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdg-dbus-proxy-0.1.5-4.el10.x86_64_v2.rpm;name=x86_64_v2_xdg-dbus-proxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdg-dbus-proxy}"
SRC_URI[x86_64_v2_xdg-dbus-proxy.sha256sum] = "a096d504190610f939c9cdc75c841723aaad6d882f7fb2c22110cce23bd30a0f"

URI_aarch64_xdg-dbus-proxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdg-dbus-proxy-0.1.5-4.el10.aarch64.rpm;name=aarch64_xdg-dbus-proxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdg-dbus-proxy}"
SRC_URI[aarch64_xdg-dbus-proxy.sha256sum] = "3d26315bc6fa5125fe32ac8b3d8caeda24a64e25d2a01779354b7a9657bafa5d"

RDEPENDS:xdg-dbus-proxy = " \
 dbus \
 glib2 \
 glibc \
 libgcc \
 "
