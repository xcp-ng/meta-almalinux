# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-metakernel"
PV = "0.32.0"
PR = "1.el10_3"
PACKAGES = " \
 python-metakernel-doc \
 python3-metakernel \
 python3-metakernel-echo \
 python3-metakernel-python \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-metakernel-0.32.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff540abf2288c54f43454ec0a4fd16a13f650e322941504c69fb21cc775771dc"

URI_x86_64_v2_python-metakernel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-metakernel-doc-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-metakernel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-metakernel-doc}"
SRC_URI[x86_64_v2_python-metakernel-doc.sha256sum] = "2393c692ca082b54585b1e9a4c8ea55cd39406dbadfb4ff29e84c3990f6e1794"

URI_x86_64_v2_python3-metakernel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-metakernel-0.32.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-metakernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-metakernel}"
SRC_URI[x86_64_v2_python3-metakernel.sha256sum] = "3add8b47a70647475c2ca30efc3415e61032f1ab1e6352accc24f602dc2402f6"

URI_x86_64_v2_python3-metakernel-echo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-metakernel-echo-0.19.1-82.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-metakernel-echo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-metakernel-echo}"
SRC_URI[x86_64_v2_python3-metakernel-echo.sha256sum] = "89a5dd298c3c712040755bfa4d0a8b6174e9f25d33168a7e91ce89033ae2372f"

URI_x86_64_v2_python3-metakernel-python = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-metakernel-python-0.19.1-82.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-metakernel-python;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-metakernel-python}"
SRC_URI[x86_64_v2_python3-metakernel-python.sha256sum] = "7138c9fc69452c8fd198abbca91f2eb85bc5497ee6722320802efeb5501c100f"

URI_aarch64_python-metakernel-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-metakernel-doc-0.32.0-1.el10_3.noarch.rpm;name=aarch64_python-metakernel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-metakernel-doc}"
SRC_URI[aarch64_python-metakernel-doc.sha256sum] = "56a061f050218669fe2a54530bde1fde079f6f09dd3a3c0a7a6262865bf3c119"

URI_aarch64_python3-metakernel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-metakernel-0.32.0-1.el10_3.noarch.rpm;name=aarch64_python3-metakernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-metakernel}"
SRC_URI[aarch64_python3-metakernel.sha256sum] = "160eab0b00c9d7c013391d6de8e7cc2c6290f6325cd0e7c7b6780637e5e7f025"

URI_aarch64_python3-metakernel-echo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-metakernel-echo-0.19.1-82.el10_3.noarch.rpm;name=aarch64_python3-metakernel-echo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-metakernel-echo}"
SRC_URI[aarch64_python3-metakernel-echo.sha256sum] = "78342d60a0d74cbeb9e99e924b9c2adac9838311a76abd3de9f581cab75b1db9"

URI_aarch64_python3-metakernel-python = "${EPEL_MIRROR}/aarch64/Packages/p/python3-metakernel-python-0.19.1-82.el10_3.noarch.rpm;name=aarch64_python3-metakernel-python;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-metakernel-python}"
SRC_URI[aarch64_python3-metakernel-python.sha256sum] = "61535336acefa3e133d2db9a23ef6edadc71bd0523e32f50b422b67a9c3db9b6"

RDEPENDS:python-metakernel-doc = " \
 "
RDEPENDS:python3-metakernel = " \
 python3 \
 python3-comm \
 python3-ipykernel \
 python3-jedi \
 python3-jupyter-core \
 python3-pexpect \
 "
RDEPENDS:python3-metakernel-echo = " \
 python-jupyter-filesystem \
 python3 \
 python3-metakernel \
 "
RDEPENDS:python3-metakernel-python = " \
 python-jupyter-filesystem \
 python3 \
 python3-ipython \
 python3-jedi \
 python3-metakernel \
 "
