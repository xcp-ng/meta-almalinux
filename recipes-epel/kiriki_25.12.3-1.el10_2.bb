# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiriki"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kiriki \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kiriki-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f678b0d8e6e10d93269dec3f3020348f08c5530f345f5cb8c12baa8cee495eb6"

URI_x86_64_v2_kiriki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiriki-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiriki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kiriki}"
SRC_URI[x86_64_v2_kiriki.sha256sum] = "4cc9af50312dced1962d8368005be19e19cd31cb1728fb54bdeeff3dddde2108"

URI_aarch64_kiriki = "${EPEL_MIRROR}/aarch64/Packages/k/kiriki-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kiriki;unpack=0"
SRC_URI:append = " ${URI_aarch64_kiriki}"
SRC_URI[aarch64_kiriki.sha256sum] = "a9af635bc323ee83673d7d50b2ea99d605a7b16347dca788c29f73c6d643d6fb"

RDEPENDS:kiriki = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
