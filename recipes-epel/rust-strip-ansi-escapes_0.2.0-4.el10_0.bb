# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strip-ansi-escapes"
PV = "0.2.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-strip-ansi-escapes+default-devel \
 rust-strip-ansi-escapes-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-strip-ansi-escapes-0.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f81cdbaa1cfc9164e345ef876bfaeda68fa13a612b3a0f3d8499549877b01d16"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strip-ansi-escapes+default-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strip-ansi-escapes+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-strip-ansi-escapes+default-devel.sha256sum] = "71f22c9b7dfff7b9950f626903ffc7cf937e96b2e3af3038847a341a43e0ff64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strip-ansi-escapes-devel-0.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strip-ansi-escapes-devel;unpack=0"
SRC_URI[x86_64_v2_rust-strip-ansi-escapes-devel.sha256sum] = "c81d9314280562f1f3cfa50c9b77fa20eb20a698d41af70e43ae21c62bb402e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-strip-ansi-escapes+default-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-strip-ansi-escapes+default-devel;unpack=0"
SRC_URI[aarch64_rust-strip-ansi-escapes+default-devel.sha256sum] = "573fa1d61bf9e4a26fd4ce8dd74daa848b4206f23b9d4ddd0ce765ec73ccfc36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-strip-ansi-escapes-devel-0.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-strip-ansi-escapes-devel;unpack=0"
SRC_URI[aarch64_rust-strip-ansi-escapes-devel.sha256sum] = "4a11d760db8eab78165f642c2d8bc742fbf393a0e99608face0c66d3e51a443b"

RDEPENDS:rust-strip-ansi-escapes+default-devel = " \
 cargo \
 rust-strip-ansi-escapes-devel \
 "
RDEPENDS:rust-strip-ansi-escapes-devel = " \
 cargo \
 rust-vte-devel \
 "
