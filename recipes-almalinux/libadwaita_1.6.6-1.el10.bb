# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libadwaita"
PV = "1.6.6"
PR = "1.el10"
PACKAGES = " \
 libadwaita \
 libadwaita-devel \
 libadwaita-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libadwaita-1.6.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ddff68d2cbd67867ae0bd27b43a2cefee41c9a9f9b2186291e780e7b7ab723b"

URI_x86_64_v2_libadwaita = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libadwaita-1.6.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_libadwaita;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libadwaita}"
SRC_URI[x86_64_v2_libadwaita.sha256sum] = "61114cad73515b99fb56bde9c4768bd2acaf6b816c59c430ba2e377ff6b30cfe"

URI_x86_64_v2_libadwaita-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libadwaita-devel-1.6.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_libadwaita-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libadwaita-devel}"
SRC_URI[x86_64_v2_libadwaita-devel.sha256sum] = "72a3269ec43ed3173cb976433fea67f1ca796060366eef0a2858c8bc9aa967ed"

URI_x86_64_v2_libadwaita-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libadwaita-doc-1.6.6-1.el10.noarch.rpm;name=x86_64_v2_libadwaita-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libadwaita-doc}"
SRC_URI[x86_64_v2_libadwaita-doc.sha256sum] = "bbcc4f56270f74cc523fe82df14088edd818db4699989e7b3d24e63e12184fc6"

URI_aarch64_libadwaita = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libadwaita-1.6.6-1.el10.aarch64.rpm;name=aarch64_libadwaita;unpack=0"
SRC_URI:append = " ${URI_aarch64_libadwaita}"
SRC_URI[aarch64_libadwaita.sha256sum] = "899dfdf822e48bac5e4e9cd2430508de4c89d7a8a7c61a3d6cc80e4f1cd6d5d9"

URI_aarch64_libadwaita-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libadwaita-devel-1.6.6-1.el10.aarch64.rpm;name=aarch64_libadwaita-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libadwaita-devel}"
SRC_URI[aarch64_libadwaita-devel.sha256sum] = "050ae588d37a637ed9f02d5ffa45c90528dd96cbf14dd31b5f7ce511548f97d9"

URI_aarch64_libadwaita-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libadwaita-doc-1.6.6-1.el10.noarch.rpm;name=aarch64_libadwaita-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libadwaita-doc}"
SRC_URI[aarch64_libadwaita-doc.sha256sum] = "bbcc4f56270f74cc523fe82df14088edd818db4699989e7b3d24e63e12184fc6"

RDEPENDS:libadwaita = " \
 appstream \
 fribidi \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 pango \
 "
RDEPENDS:libadwaita-devel = " \
 appstream-devel \
 fribidi-devel \
 glib2-devel \
 gtk4-devel \
 libadwaita \
 pkgconf-pkg-config \
 vala \
 "
RDEPENDS:libadwaita-doc = " \
 "
