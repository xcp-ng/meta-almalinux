# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-qdoc-common"
PV = "1.0.0"
PR = "1.el10_0"
PACKAGES = " \
 kde-qdoc-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-qdoc-common-1.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa35671a0a83d5f099d666a80f21293b5efda5030eed249f7697b8ae801f52f9"

URI_x86_64_v2_kde-qdoc-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-qdoc-common-1.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kde-qdoc-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-qdoc-common}"
SRC_URI[x86_64_v2_kde-qdoc-common.sha256sum] = "43e0b82f3ad6e7b83253b62656c93d312fd2275de5533f7f279cc2858d444f6c"

URI_aarch64_kde-qdoc-common = "${EPEL_MIRROR}/aarch64/Packages/k/kde-qdoc-common-1.0.0-1.el10_0.noarch.rpm;name=aarch64_kde-qdoc-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-qdoc-common}"
SRC_URI[aarch64_kde-qdoc-common.sha256sum] = "c8c9230351f4ab8efe0a1ead20809a778d319aac3b788e3b3f1980f8aa7643a1"

RDEPENDS:kde-qdoc-common = " \
 "
