# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "retsnoop"
PV = "0.11"
PR = "4.el10_2"
PACKAGES = " \
 retsnoop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/retsnoop-0.11-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25b0a15d71ff895b09761f9863a37e8b4107d36af49a0e91f8f20abd0e0992b4"

URI_x86_64_v2_retsnoop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/retsnoop-0.11-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_retsnoop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_retsnoop}"
SRC_URI[x86_64_v2_retsnoop.sha256sum] = "4ba98cd47601b42f2b05f5c20a0827fccc4a9f93962dead2247fd47be414e244"

URI_aarch64_retsnoop = "${EPEL_MIRROR}/aarch64/Packages/r/retsnoop-0.11-4.el10_2.aarch64.rpm;name=aarch64_retsnoop;unpack=0"
SRC_URI:append = " ${URI_aarch64_retsnoop}"
SRC_URI[aarch64_retsnoop.sha256sum] = "b1b542fc60dc9c340bf93530aa0f1368d70d742400784e0275661f023acc7f39"

RDEPENDS:retsnoop = " \
 elfutils-libelf \
 glibc \
 zlib-ng-compat \
 "
