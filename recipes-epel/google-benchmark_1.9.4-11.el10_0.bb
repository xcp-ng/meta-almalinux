# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-benchmark"
PV = "1.9.4"
PR = "11.el10_0"
PACKAGES = " \
 google-benchmark \
 google-benchmark-devel \
 google-benchmark-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/google-benchmark-1.9.4-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2d285f6e3be416d4d3b297031412972f0d1d33c58a632b785205bec9ef9895b"

URI_x86_64_v2_google-benchmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-benchmark-1.9.4-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-benchmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-benchmark}"
SRC_URI[x86_64_v2_google-benchmark.sha256sum] = "66a3e75a42863b4b70815b12f811c596219460ba2a1591870456071105d4a833"

URI_x86_64_v2_google-benchmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-benchmark-devel-1.9.4-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-benchmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-benchmark-devel}"
SRC_URI[x86_64_v2_google-benchmark-devel.sha256sum] = "6b769cd7ff52b3056d4d9e5edafe20244276500772406f0aadae18dc83a70bd4"

URI_x86_64_v2_google-benchmark-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-benchmark-doc-1.9.4-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_google-benchmark-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-benchmark-doc}"
SRC_URI[x86_64_v2_google-benchmark-doc.sha256sum] = "67ad2e2bcb115e8a39f2929988dfc7c1d6a4b962e82388581f7f712672ab7567"

URI_aarch64_google-benchmark = "${EPEL_MIRROR}/aarch64/Packages/g/google-benchmark-1.9.4-11.el10_0.aarch64.rpm;name=aarch64_google-benchmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-benchmark}"
SRC_URI[aarch64_google-benchmark.sha256sum] = "6dcf562ed6a83c49ebf6f2fbe1e8e46a7a4dd407fce46cae238ebea800c17fdf"

URI_aarch64_google-benchmark-devel = "${EPEL_MIRROR}/aarch64/Packages/g/google-benchmark-devel-1.9.4-11.el10_0.aarch64.rpm;name=aarch64_google-benchmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-benchmark-devel}"
SRC_URI[aarch64_google-benchmark-devel.sha256sum] = "c28ed94fe3115ea6b7feb4c23f864eb7c1e48ecd205e82f90d3fed5bd65ea2a0"

URI_aarch64_google-benchmark-doc = "${EPEL_MIRROR}/aarch64/Packages/g/google-benchmark-doc-1.9.4-11.el10_0.noarch.rpm;name=aarch64_google-benchmark-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-benchmark-doc}"
SRC_URI[aarch64_google-benchmark-doc.sha256sum] = "4e526285dc914510374c53573bc1d8a3d852df6795b1b3fd7babc77066e924fe"

RDEPENDS:google-benchmark = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:google-benchmark-devel = " \
 cmake-filesystem \
 google-benchmark \
 google-benchmark-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:google-benchmark-doc = " \
 google-benchmark \
 "
