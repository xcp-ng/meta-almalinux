# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "createrepo-agent"
PV = "0.4.2"
PR = "1.el10_0"
PACKAGES = " \
 createrepo-agent \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/createrepo-agent-0.4.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "73271bb4fdc4a183c4886b8e2763b5e756b4f61b5627711e485b561f12b0eb21"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/createrepo-agent-0.4.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_createrepo-agent;unpack=0"
SRC_URI[x86_64_v2_createrepo-agent.sha256sum] = "f3023ff39deeee20118c21b8aa4a17b9874f494c536a865163d6542ff6ec73b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/createrepo-agent-0.4.2-1.el10_0.aarch64.rpm;name=aarch64_createrepo-agent;unpack=0"
SRC_URI[aarch64_createrepo-agent.sha256sum] = "3e3260e11eb06f7f926c734998611af7b9d5e1f8927e350b9b6a152e4560858c"

RDEPENDS:createrepo-agent = " \
 createrepo_c-libs \
 glib2 \
 glibc \
 gpgme \
 libassuan \
 libgpg-error \
 "
