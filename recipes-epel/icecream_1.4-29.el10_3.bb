# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "icecream"
PV = "1.4"
PR = "29.el10_3"
PACKAGES = " \
 icecream \
 icecream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/icecream-1.4-29.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dab57bd82f8aab090ff876e5532c4645d89eb901a79e0eb083163272a1a14c1e"

URI_x86_64_v2_icecream = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icecream-1.4-29.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icecream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icecream}"
SRC_URI[x86_64_v2_icecream.sha256sum] = "4db1842dde55a37e172f84d377aa4b0f72951e4123cb4fe7f4613ef8d9af5bee"

URI_x86_64_v2_icecream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/icecream-devel-1.4-29.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_icecream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_icecream-devel}"
SRC_URI[x86_64_v2_icecream-devel.sha256sum] = "0d4087706379beb9b4361c388bef148195ed3f00022be1ac3976bdc35de5b74a"

URI_aarch64_icecream = "${EPEL_MIRROR}/aarch64/Packages/i/icecream-1.4-29.el10_3.aarch64.rpm;name=aarch64_icecream;unpack=0"
SRC_URI:append = " ${URI_aarch64_icecream}"
SRC_URI[aarch64_icecream.sha256sum] = "4aebc434924f4e282a596c06ceeb17573a81a524ec3bc5a1c3d677045b94c08b"

URI_aarch64_icecream-devel = "${EPEL_MIRROR}/aarch64/Packages/i/icecream-devel-1.4-29.el10_3.aarch64.rpm;name=aarch64_icecream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_icecream-devel}"
SRC_URI[aarch64_icecream-devel.sha256sum] = "ff8e14fe0e354270f02fb261b5ba0dc9f630124f7e6f5288947e93b4800b503a"

RDEPENDS:icecream = " \
 bash \
 firewalld-filesystem \
 glibc \
 libarchive \
 libcap-ng \
 libgcc \
 libstdc++ \
 libzstd \
 lzo \
 policycoreutils \
 policycoreutils-python-utils \
 shadow-utils \
 systemd \
 virtual/environment_modules_ \
 "
RDEPENDS:icecream-devel = " \
 icecream \
 libarchive-devel \
 libcap-ng-devel \
 libzstd-devel \
 lzo-devel \
 pkgconf-pkg-config \
 "
