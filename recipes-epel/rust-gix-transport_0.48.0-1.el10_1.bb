# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-transport"
PV = "0.48.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-transport+async-client-devel \
 rust-gix-transport+async-std-devel \
 rust-gix-transport+async-trait-devel \
 rust-gix-transport+base64-devel \
 rust-gix-transport+blocking-client-devel \
 rust-gix-transport+curl-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+document-features-devel \
 rust-gix-transport+futures-io-devel \
 rust-gix-transport+futures-lite-devel \
 rust-gix-transport+gix-credentials-devel \
 rust-gix-transport+http-client-curl-devel \
 rust-gix-transport+http-client-devel \
 rust-gix-transport+http-client-insecure-credentials-devel \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport+http-client-reqwest-native-tls-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel \
 rust-gix-transport+pin-project-lite-devel \
 rust-gix-transport+reqwest-devel \
 rust-gix-transport+serde-devel \
 rust-gix-transport-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-transport-0.48.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d8ad0b461fa759d29ec181dfb0859d93ec62b7814b22cff2ec1ecc6f33d7acf"

URI_x86_64_v2_rust-gix-transport+async-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-client-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-client-devel.sha256sum] = "57d39a585c11c52d411174bbcfcd61a575bece52fd65ed15cbaecc78b72cad22"

URI_x86_64_v2_rust-gix-transport+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-std-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-std-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-std-devel.sha256sum] = "edf1e428e6520087642ebdd9a59e7792fcebcfd5d5d4a062d9bbabf2de7cec33"

URI_x86_64_v2_rust-gix-transport+async-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+async-trait-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+async-trait-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+async-trait-devel.sha256sum] = "64c2d49b4daf401be61fc4e79a73bfcbcd5287dc55e2214f84331733748ed91a"

URI_x86_64_v2_rust-gix-transport+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+base64-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+base64-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+base64-devel.sha256sum] = "68267d9dd2fbecf2e14871eed6ed4bab7c0b3e592486b125a3e6fa7b5039a6b1"

URI_x86_64_v2_rust-gix-transport+blocking-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+blocking-client-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+blocking-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+blocking-client-devel.sha256sum] = "f07ec4331faeece83d4291dba0de67163d52d37a098b69b40c0ea6e7c486d966"

URI_x86_64_v2_rust-gix-transport+curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+curl-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+curl-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+curl-devel.sha256sum] = "34bade238220600e87ac40768c7fa2f1e1a6f4da903527dbac4f9f83d34d5cd6"

URI_x86_64_v2_rust-gix-transport+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+default-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+default-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+default-devel.sha256sum] = "afaa38d9e0f6b6ce2ca59c9beb2903971c28c6b84648cf77821c3def0c9e5b3a"

URI_x86_64_v2_rust-gix-transport+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+document-features-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+document-features-devel.sha256sum] = "7917f1fb2b69a30b1d668d8e40404e36e216b8f52bcb3aa5420c09c7d2c7c65b"

URI_x86_64_v2_rust-gix-transport+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+futures-io-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+futures-io-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+futures-io-devel.sha256sum] = "c162acdcb04c26142a405671ebb7067f731a5677f8a224efc10d74a40301da71"

URI_x86_64_v2_rust-gix-transport+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+futures-lite-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+futures-lite-devel.sha256sum] = "130594fba3856694a9e101726525c82dedefee6ccdcc9a7a3328d0d86636bfcf"

URI_x86_64_v2_rust-gix-transport+gix-credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+gix-credentials-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+gix-credentials-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+gix-credentials-devel.sha256sum] = "44a67180fe7286d0223e9be7738532dc8ec74981fc61228d4f7e6fce101f2cc5"

URI_x86_64_v2_rust-gix-transport+http-client-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-curl-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-curl-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-curl-devel.sha256sum] = "309333c11ae9e9284cfea3a6b010c02a959c6302a7242a5051d8cd3c1593f00a"

URI_x86_64_v2_rust-gix-transport+http-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-devel.sha256sum] = "2ecb25cd742156d730afe19c6ca1df124ae477a8ba3f10d53c616c6aac901e44"

URI_x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-insecure-credentials-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-insecure-credentials-devel.sha256sum] = "a20e4a5d88eb359895e62ee701c0843de41a4f5b4cec50ef72ccd38a0d07f3b0"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-devel.sha256sum] = "d00c9ceb5d56fa31d1cbeb316a84e20298463dcdf1f7886009fe3325df3bc5b2"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-native-tls-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-native-tls-devel.sha256sum] = "3ede17e53e278543d2e6220fedc96fa1feaa339aa64938d3bdda24ccbb9efd6c"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-rust-tls-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-devel.sha256sum] = "147c0ef62e594efa5c824feacfd9bd978f9d779b493c286af8fa1b7fc4662697"

URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel.sha256sum] = "0740be4c075a9c0d054184edace74c4d6422f224c0b4781e033c046fb0aadfce"

URI_x86_64_v2_rust-gix-transport+pin-project-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+pin-project-lite-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+pin-project-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+pin-project-lite-devel.sha256sum] = "6b36e22563c329557a22dfa8482cbbd82ae460503f8c5b5d8992bf1a9b3ad6e8"

URI_x86_64_v2_rust-gix-transport+reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+reqwest-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+reqwest-devel.sha256sum] = "bbdce63a998cda12004caaffac1c5ead59098c9e6db03975a6e4f3d2ff7eb374"

URI_x86_64_v2_rust-gix-transport+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport+serde-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-transport+serde-devel.sha256sum] = "1d55d77e2afad1bb6e09e843fc24024b19f2c31208ba0581199be459f801ae27"

URI_x86_64_v2_rust-gix-transport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-transport-devel-0.48.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-transport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-transport-devel}"
SRC_URI[x86_64_v2_rust-gix-transport-devel.sha256sum] = "07582d4c71d8e0046676c59ea580bd3c8688f006e6fa57796a66e6f12db35215"

URI_aarch64_rust-gix-transport+async-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-client-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-client-devel}"
SRC_URI[aarch64_rust-gix-transport+async-client-devel.sha256sum] = "3c25b1182ac03645bd224210deb64638c257d623c234fd0e20967821016197b6"

URI_aarch64_rust-gix-transport+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-std-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-std-devel}"
SRC_URI[aarch64_rust-gix-transport+async-std-devel.sha256sum] = "4a862acfa4e7a2ff2fe987aa4d9fe2eaca4aad1d80a9e1deeb4cb693d751e8d8"

URI_aarch64_rust-gix-transport+async-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+async-trait-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+async-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+async-trait-devel}"
SRC_URI[aarch64_rust-gix-transport+async-trait-devel.sha256sum] = "c61a4d2317fed43e0cb3f0406bc428225ff3f4ffcd7bfecd684e2d83148a926e"

URI_aarch64_rust-gix-transport+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+base64-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+base64-devel}"
SRC_URI[aarch64_rust-gix-transport+base64-devel.sha256sum] = "3b9e5fe85e148553f3bda990b69b1f58cb23fc607db8997cf248dd749e90728e"

URI_aarch64_rust-gix-transport+blocking-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+blocking-client-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+blocking-client-devel}"
SRC_URI[aarch64_rust-gix-transport+blocking-client-devel.sha256sum] = "355e2685ddecbbb77fefac2c47ce26f4288af9e0666ab043ac7603b97ea473d7"

URI_aarch64_rust-gix-transport+curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+curl-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+curl-devel}"
SRC_URI[aarch64_rust-gix-transport+curl-devel.sha256sum] = "866bf2cb89deedcc1cc70a7b2fa9e14850bdbc37833c9bd8556ffcf39c87a934"

URI_aarch64_rust-gix-transport+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+default-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+default-devel}"
SRC_URI[aarch64_rust-gix-transport+default-devel.sha256sum] = "b2713bc8bdc73b7c1e22816f08abef2074cf3c8ce4e2a30735bb5a224fa1d26d"

URI_aarch64_rust-gix-transport+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+document-features-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+document-features-devel}"
SRC_URI[aarch64_rust-gix-transport+document-features-devel.sha256sum] = "02304e2059d363e29cc413038474125df28f8f7f596b3cf63a91e185913c8a9b"

URI_aarch64_rust-gix-transport+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+futures-io-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+futures-io-devel}"
SRC_URI[aarch64_rust-gix-transport+futures-io-devel.sha256sum] = "0f08f355970cb5ae475dcb64e14854f00b6f62442dc3391b046d24f552bbe790"

URI_aarch64_rust-gix-transport+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+futures-lite-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-transport+futures-lite-devel.sha256sum] = "f917b57c8fa9b4c074c4bfc805706e028bb545bb479541272b1051d2b4ee2437"

URI_aarch64_rust-gix-transport+gix-credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+gix-credentials-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+gix-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+gix-credentials-devel}"
SRC_URI[aarch64_rust-gix-transport+gix-credentials-devel.sha256sum] = "b24d8ad38467ff534d0f9bf0853afe79e9f8b7abb18e1789d7f5c5894dab3fb8"

URI_aarch64_rust-gix-transport+http-client-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-curl-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+http-client-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-curl-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-curl-devel.sha256sum] = "b00010334446ed018f78721bb6bbd8e50ac918826992283d32eef1564e9c9639"

URI_aarch64_rust-gix-transport+http-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+http-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-devel.sha256sum] = "9d68173ae17a25fa4f451bed404b39409a61e57cfd3e1f05e757444afe9666ee"

URI_aarch64_rust-gix-transport+http-client-insecure-credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-insecure-credentials-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+http-client-insecure-credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-insecure-credentials-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-insecure-credentials-devel.sha256sum] = "31d7400db38bd90b1013dbd1d191363f912760b8bfbd39d4789dedcdd5ad2b8b"

URI_aarch64_rust-gix-transport+http-client-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-devel.sha256sum] = "1dbdb962e46497f7bfde34a8e096d3a5366683325c730e219b3993a0c1281c69"

URI_aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-native-tls-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-native-tls-devel.sha256sum] = "571e9a0ad75133a04b11edf87c8544e1d44da022a7fdf84f8ce0e0c6adddf057"

URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-rust-tls-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-rust-tls-devel.sha256sum] = "7fe871ddc0e95d4fc613d2997265ae253ba3fb58d681b2669e88e4ba15a183e8"

URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[aarch64_rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel.sha256sum] = "7f63a4f1867a9f881aeb2c052fdf95b58cb35140b20aa0c20a195bde24138e8b"

URI_aarch64_rust-gix-transport+pin-project-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+pin-project-lite-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+pin-project-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+pin-project-lite-devel}"
SRC_URI[aarch64_rust-gix-transport+pin-project-lite-devel.sha256sum] = "30f85903ccc3d16d1a0dede6cc7cb6b6b1d8106f7426af82088dbb3be26ec1a0"

URI_aarch64_rust-gix-transport+reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+reqwest-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+reqwest-devel}"
SRC_URI[aarch64_rust-gix-transport+reqwest-devel.sha256sum] = "d723b2f80ff55912e2949d5c429abd8261d112ffe911ad0359f0d15d8f4020c2"

URI_aarch64_rust-gix-transport+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport+serde-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport+serde-devel}"
SRC_URI[aarch64_rust-gix-transport+serde-devel.sha256sum] = "fb30f6d22efa3ff500be7f9d76fbfe77b8f64f1790307566f38d6c18f24103be"

URI_aarch64_rust-gix-transport-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-transport-devel-0.48.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-transport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-transport-devel}"
SRC_URI[aarch64_rust-gix-transport-devel.sha256sum] = "98b89f340f8f0a0706a5e4c1f509e60861639b7f240f3910fed22cc6b5263ee6"

RDEPENDS:rust-gix-transport+async-client-devel = " \
 cargo \
 rust-gix-packetline+async-io-devel \
 rust-gix-transport+async-trait-devel \
 rust-gix-transport+futures-io-devel \
 rust-gix-transport+futures-lite-devel \
 rust-gix-transport+pin-project-lite-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+async-trait-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+blocking-client-devel = " \
 cargo \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+curl-devel = " \
 cargo \
 rust-curl+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+default-devel = " \
 cargo \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+gix-credentials-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-curl-devel = " \
 cargo \
 rust-gix-transport+curl-devel \
 rust-gix-transport+http-client-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-devel = " \
 cargo \
 rust-gix-features+io-pipe-devel \
 rust-gix-transport+base64-devel \
 rust-gix-transport+blocking-client-devel \
 rust-gix-transport+gix-credentials-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-insecure-credentials-devel = " \
 cargo \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-devel = " \
 cargo \
 rust-gix-transport+http-client-devel \
 rust-gix-transport+reqwest-devel \
 rust-gix-transport-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-native-tls-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+http2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-rust-tls-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel = " \
 cargo \
 rust-gix-transport+http-client-reqwest-devel \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest+trust-dns-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+pin-project-lite-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-gix-transport+reqwest-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+http2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-gix-transport+serde-devel = " \
 cargo \
 rust-gix-transport-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-transport-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-command+default-devel \
 rust-gix-features+default-devel \
 rust-gix-packetline+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-url+default-devel \
 rust-thiserror+default-devel \
 "
