# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zstarfile"
PV = "0.3.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-zstarfile \
 python3-zstarfile+all \
 python3-zstarfile+lz4 \
 python3-zstarfile+zstandard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zstarfile-0.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0091d70d483b0b7bec5b8e46c90605f9a2f2b182defe82c99389adba587e214e"

URI_x86_64_v2_python3-zstarfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstarfile-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zstarfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstarfile}"
SRC_URI[x86_64_v2_python3-zstarfile.sha256sum] = "544dfd1ce99106c73059e4e34684f55de1cae86c8588f68a10debb094261345d"

URI_x86_64_v2_python3-zstarfile+all = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstarfile+all-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zstarfile+all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstarfile+all}"
SRC_URI[x86_64_v2_python3-zstarfile+all.sha256sum] = "7f0dfc21b6d4be5531dd83fff9bdd9db49fc1390954351a7bd9e89e742e604ea"

URI_x86_64_v2_python3-zstarfile+lz4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstarfile+lz4-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zstarfile+lz4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstarfile+lz4}"
SRC_URI[x86_64_v2_python3-zstarfile+lz4.sha256sum] = "8104b0b89eda62cf194056d86c11c310075f4d948aec8284d8922501d4895cc6"

URI_x86_64_v2_python3-zstarfile+zstandard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-zstarfile+zstandard-0.3.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-zstarfile+zstandard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-zstarfile+zstandard}"
SRC_URI[x86_64_v2_python3-zstarfile+zstandard.sha256sum] = "c8a89ad924d4729602343f4947fdbab0262af4a84c820e10427b6c0394100ca8"

URI_aarch64_python3-zstarfile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstarfile-0.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-zstarfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstarfile}"
SRC_URI[aarch64_python3-zstarfile.sha256sum] = "441704b34a6554a1feae19be982d91a0ec1f87ce2b768f1b2e7aefea132fc132"

URI_aarch64_python3-zstarfile+all = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstarfile+all-0.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-zstarfile+all;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstarfile+all}"
SRC_URI[aarch64_python3-zstarfile+all.sha256sum] = "c1ec75bb531a3cf85793a843e0dacc64f169596b8c1477db2b87571ac367707f"

URI_aarch64_python3-zstarfile+lz4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstarfile+lz4-0.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-zstarfile+lz4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstarfile+lz4}"
SRC_URI[aarch64_python3-zstarfile+lz4.sha256sum] = "26a143325d61032f88bdf89941217829c1d601c2c7f58588cb9cc730ae76ac53"

URI_aarch64_python3-zstarfile+zstandard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-zstarfile+zstandard-0.3.0-1.el10_1.noarch.rpm;name=aarch64_python3-zstarfile+zstandard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-zstarfile+zstandard}"
SRC_URI[aarch64_python3-zstarfile+zstandard.sha256sum] = "1ddd09b53a7a4b31a6e997acde4ad3fe87092bad95234ffff90a46051fb4726d"

RDEPENDS:python3-zstarfile = " \
 python3 \
 "
RDEPENDS:python3-zstarfile+all = " \
 python3 \
 python3-zstarfile \
 python3-zstarfile+lz4 \
 python3-zstarfile+zstandard \
 "
RDEPENDS:python3-zstarfile+lz4 = " \
 python3 \
 python3-lz4 \
 python3-zstarfile \
 "
RDEPENDS:python3-zstarfile+zstandard = " \
 python3 \
 python3-pyzstd \
 python3-zstarfile \
 "
