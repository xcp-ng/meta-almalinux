# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oxygen-sounds"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 oxygen-sounds \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oxygen-sounds-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a9875a0bd8a45c8f0c3b324d179cf45b778a54f73aa33546e025abb7c7de516"

URI_x86_64_v2_oxygen-sounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-sounds-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-sounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxygen-sounds}"
SRC_URI[x86_64_v2_oxygen-sounds.sha256sum] = "78720cc5808542492dd7429f79a7796c12c57a76046f61bce5de140d74013612"

URI_aarch64_oxygen-sounds = "${EPEL_MIRROR}/aarch64/Packages/o/oxygen-sounds-6.3.6-1.el10_0.noarch.rpm;name=aarch64_oxygen-sounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxygen-sounds}"
SRC_URI[aarch64_oxygen-sounds.sha256sum] = "001eec1d21aa7da388b0f31d343498a30b31d30e3c628a8d3b6de1d030b5217e"

RDEPENDS:oxygen-sounds = " \
 "
