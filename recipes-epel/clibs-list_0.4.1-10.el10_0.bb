# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clibs-list"
PV = "0.4.1"
PR = "10.el10_0"
PACKAGES = " \
 clibs-list \
 clibs-list-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/clibs-list-0.4.1-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62c3c45d6d6443e5487f56c96f1871f6bf61b1e7ad6240ba744877de1a448467"

URI_x86_64_v2_clibs-list = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clibs-list-0.4.1-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clibs-list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clibs-list}"
SRC_URI[x86_64_v2_clibs-list.sha256sum] = "3a22746a5b79afd2aa8f50a1632697da87f14f2ac83720fd825441f9eb60e9fd"

URI_x86_64_v2_clibs-list-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clibs-list-devel-0.4.1-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clibs-list-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clibs-list-devel}"
SRC_URI[x86_64_v2_clibs-list-devel.sha256sum] = "50c29dc2bd9633afa9b2120c55b0fd603d51c9f447c68e476c0c5ea3660cfacb"

URI_aarch64_clibs-list = "${EPEL_MIRROR}/aarch64/Packages/c/clibs-list-0.4.1-10.el10_0.aarch64.rpm;name=aarch64_clibs-list;unpack=0"
SRC_URI:append = " ${URI_aarch64_clibs-list}"
SRC_URI[aarch64_clibs-list.sha256sum] = "f72131babec69efdd793335b4dfb896ec11f737536c279cf3f77bac3aa22d80a"

URI_aarch64_clibs-list-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clibs-list-devel-0.4.1-10.el10_0.aarch64.rpm;name=aarch64_clibs-list-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clibs-list-devel}"
SRC_URI[aarch64_clibs-list-devel.sha256sum] = "d87d49be586f654031c924e48f8e52dc3d0b39c33997fc0fa84dc52ea929964d"

RDEPENDS:clibs-list = " \
 glibc \
 "
RDEPENDS:clibs-list-devel = " \
 clibs-list \
 "
