# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yaml-cpp"
PV = "0.7.0"
PR = "6.el10_0"
PACKAGES = " \
 yaml-cpp \
 yaml-cpp-devel \
 yaml-cpp-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/y/yaml-cpp-0.7.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d31f9337e130bf579bc2e5e9c176f211a0eda41dcb96504668f72863d9906bd8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yaml-cpp-0.7.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yaml-cpp;unpack=0"
SRC_URI[x86_64_v2_yaml-cpp.sha256sum] = "231e886e5376943dd036dbcbc7bb21fd6053ff311585c6de4d57dcbc95dc9fd8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yaml-cpp-devel-0.7.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yaml-cpp-devel;unpack=0"
SRC_URI[x86_64_v2_yaml-cpp-devel.sha256sum] = "ca65fe6614cbcdcb671aeef871a79c0ace859b2afa1fb1e43122a7042431f47c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yaml-cpp-static-0.7.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yaml-cpp-static;unpack=0"
SRC_URI[x86_64_v2_yaml-cpp-static.sha256sum] = "95947584fca7554a8b703d8e86b5f810a824391a8a9804e485adebd22676408e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yaml-cpp-0.7.0-6.el10_0.aarch64.rpm;name=aarch64_yaml-cpp;unpack=0"
SRC_URI[aarch64_yaml-cpp.sha256sum] = "789a390c8d568dde615b73e73ee9eb83143032d27c322c83977c63e6149a7f47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yaml-cpp-devel-0.7.0-6.el10_0.aarch64.rpm;name=aarch64_yaml-cpp-devel;unpack=0"
SRC_URI[aarch64_yaml-cpp-devel.sha256sum] = "10f08becd7498639a544d2f71850856709fa748a7e7ea8fbd1e90ed5b6383a35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/y/yaml-cpp-static-0.7.0-6.el10_0.aarch64.rpm;name=aarch64_yaml-cpp-static;unpack=0"
SRC_URI[aarch64_yaml-cpp-static.sha256sum] = "3179822c4c6c8e6931493a302f7d15d79ddd07d6050175a722fe4e189d03a836"

RDEPENDS:yaml-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:yaml-cpp-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 pkgconf-pkg-config \
 yaml-cpp \
 "
RDEPENDS:yaml-cpp-static = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 yaml-cpp-devel \
 "
