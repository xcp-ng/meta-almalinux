# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocwmma"
PV = "7.2.0"
PR = "4.el10_3"
PACKAGES:x86_64_v2 = " \
 rocwmma-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocwmma-7.2.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86017be1607c665e58cea92f3b62c5b49d4b517d16ef3026c3eb9128dd1a4c51"

URI_x86_64_v2_rocwmma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocwmma-devel-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocwmma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocwmma-devel}"
SRC_URI[x86_64_v2_rocwmma-devel.sha256sum] = "a47acbc4e0db29d3f7771e75922ddb4a594fd1037c6989aa766646dd81b735dd"

RDEPENDS:rocwmma-devel = " \
 cmake-filesystem \
 "
