# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kruler"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kruler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kruler-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f78b6d4446ef17027d2e6b57c5fb806414c0ed861ae97924747a889fbb8a11d"

URI_x86_64_v2_kruler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kruler-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kruler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kruler}"
SRC_URI[x86_64_v2_kruler.sha256sum] = "a749a5b8802a0e6a3ad190b2034fd7985a6adfdd5f46c46855c7d6ea14a346d4"

URI_aarch64_kruler = "${EPEL_MIRROR}/aarch64/Packages/k/kruler-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kruler;unpack=0"
SRC_URI:append = " ${URI_aarch64_kruler}"
SRC_URI[aarch64_kruler.sha256sum] = "35bf21a2e87b86499ed0a2f96acc04b91ff0fee42d2255d9b594b4c8997759dc"

RDEPENDS:kruler = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
