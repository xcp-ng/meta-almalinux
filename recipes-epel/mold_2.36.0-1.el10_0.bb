# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mold"
PV = "2.36.0"
PR = "1.el10_0"
PACKAGES = " \
 mold \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mold-2.36.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b8d17d60d71543ba5a7e11fee3ef26c4fb5b7479d2ace85b86beefef0ed0f79"

URI_x86_64_v2_mold = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mold-2.36.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mold;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mold}"
SRC_URI[x86_64_v2_mold.sha256sum] = "df55ac3be64d24655cca64c278159bc2a7fdc8c849591e59988f5e82c527cfc0"

URI_aarch64_mold = "${EPEL_MIRROR}/aarch64/Packages/m/mold-2.36.0-1.el10_0.aarch64.rpm;name=aarch64_mold;unpack=0"
SRC_URI:append = " ${URI_aarch64_mold}"
SRC_URI[aarch64_mold.sha256sum] = "17d994ccd28cee9b5aa62e673191ddce1c5394e8295af2705b8fddfce3177456"

RDEPENDS:mold = " \
 alternatives \
 bash \
 blake3 \
 glibc \
 libstdc++ \
 libzstd \
 mimalloc \
 tbb \
 zlib-ng-compat \
 "
