# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Monitoring-Plugin"
PV = "0.40"
PR = "18.el10_0"
PACKAGES = " \
 perl-Monitoring-Plugin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Monitoring-Plugin-0.40-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1161d0c18221285a40cb76b8085f27c98e7a648650e34241b051a3211347d3a4"

URI_x86_64_v2_perl-Monitoring-Plugin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Monitoring-Plugin-0.40-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Monitoring-Plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Monitoring-Plugin}"
SRC_URI[x86_64_v2_perl-Monitoring-Plugin.sha256sum] = "0664bb8a7a4baec10b43d71ac7e01c421b387739452e0a90afd1ca418f6401ef"

URI_aarch64_perl-Monitoring-Plugin = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Monitoring-Plugin-0.40-18.el10_0.noarch.rpm;name=aarch64_perl-Monitoring-Plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Monitoring-Plugin}"
SRC_URI[aarch64_perl-Monitoring-Plugin.sha256sum] = "c259deda26e72a58f65e5ef5bb38448a0142b00ba6a4931fae2cccefa9261eb0"

RDEPENDS:perl-Monitoring-Plugin = " \
 perl-Carp \
 perl-Class-Accessor \
 perl-Config-Tiny \
 perl-Exporter \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-Math-Calc-Units \
 perl-Monitoring-Plugin \
 perl-Params-Validate \
 perl-PathTools \
 perl-base \
 perl-constant \
 perl-libs \
 perl-overload \
 perl-vars \
 "
