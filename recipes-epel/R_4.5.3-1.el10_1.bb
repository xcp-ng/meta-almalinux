# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R"
PV = "4.5.3"
PR = "1.el10_1"
PACKAGES = " \
 R \
 R-core \
 R-core-devel \
 R-devel \
 R-java \
 R-java-devel \
 libRmath \
 libRmath-devel \
 libRmath-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-4.5.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b74d8a35d156474df58812fe4c5f43a6f0726186c718d85c3f8fa9d893cdcbe"

URI_x86_64_v2_R = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-4.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R}"
SRC_URI[x86_64_v2_R.sha256sum] = "24be27f967d1382395b5eb865f2cbb70cb2e894efea4eb8d94c5a06ed1b4d8ac"

URI_x86_64_v2_R-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-core-4.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-core}"
SRC_URI[x86_64_v2_R-core.sha256sum] = "029286000dd337442d6c8565a812bbd7ac5333b887fbfb11e97001eaddf0cb28"

URI_x86_64_v2_R-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-core-devel-4.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-core-devel}"
SRC_URI[x86_64_v2_R-core-devel.sha256sum] = "4475a05445a5828f3cf36159066318078497f0318f497592be29b313ef43ab6a"

URI_x86_64_v2_R-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-devel-4.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-devel}"
SRC_URI[x86_64_v2_R-devel.sha256sum] = "a58466ab9458796d23a44c4fd58cbc3c106dccda1af969154e50aca55b0bf589"

URI_x86_64_v2_R-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-java-4.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-java}"
SRC_URI[x86_64_v2_R-java.sha256sum] = "28817003efa643cd7df22e5846080ef23dc80922c8575c15aa9c7e9d55b7f14b"

URI_x86_64_v2_R-java-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-java-devel-4.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-java-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-java-devel}"
SRC_URI[x86_64_v2_R-java-devel.sha256sum] = "20f2e49f92f312e2f447e51080e7a79e65dcf7e22f36a00fef74a82a6adbe85d"

URI_x86_64_v2_libRmath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libRmath-4.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libRmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libRmath}"
SRC_URI[x86_64_v2_libRmath.sha256sum] = "ce2b60f7d85cccddf627ceef8c2449368025aa705fc285a894f50af705fcfbad"

URI_x86_64_v2_libRmath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libRmath-devel-4.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libRmath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libRmath-devel}"
SRC_URI[x86_64_v2_libRmath-devel.sha256sum] = "ebccc421fe9c86e2c8e91e93c61cf26e2a1d31f06fb104ca1018a67b9b832d9b"

URI_x86_64_v2_libRmath-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libRmath-static-4.5.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libRmath-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libRmath-static}"
SRC_URI[x86_64_v2_libRmath-static.sha256sum] = "cf6b5cc9672fe4fcb7b6143cde079021dac6f42aee79046c0ee1ee36ab97a676"

URI_aarch64_R = "${EPEL_MIRROR}/aarch64/Packages/r/R-4.5.3-1.el10_1.aarch64.rpm;name=aarch64_R;unpack=0"
SRC_URI:append = " ${URI_aarch64_R}"
SRC_URI[aarch64_R.sha256sum] = "2c614d0557843b1535dbc09241d5a5050c40963ec0255941df1176b477aefa01"

URI_aarch64_R-core = "${EPEL_MIRROR}/aarch64/Packages/r/R-core-4.5.3-1.el10_1.aarch64.rpm;name=aarch64_R-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-core}"
SRC_URI[aarch64_R-core.sha256sum] = "57a09cd0aeb625916d681b377d9f09092b0ca441f565d0c7476a7c7bdab8951d"

URI_aarch64_R-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/R-core-devel-4.5.3-1.el10_1.aarch64.rpm;name=aarch64_R-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-core-devel}"
SRC_URI[aarch64_R-core-devel.sha256sum] = "c123810e9b2d5e09cbc77fd3ba6078ff39e7c0f6b0111c3d00e7a883dd8f083e"

URI_aarch64_R-devel = "${EPEL_MIRROR}/aarch64/Packages/r/R-devel-4.5.3-1.el10_1.aarch64.rpm;name=aarch64_R-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-devel}"
SRC_URI[aarch64_R-devel.sha256sum] = "57309761854a10aa0058aee99050a60d3445fa0d8fc8ee21f0497f0c8d48d7fd"

URI_aarch64_R-java = "${EPEL_MIRROR}/aarch64/Packages/r/R-java-4.5.3-1.el10_1.aarch64.rpm;name=aarch64_R-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-java}"
SRC_URI[aarch64_R-java.sha256sum] = "d5d43cbaf71a49c799abfef7ef4def44e843b572d137d9d96e0ee8d876fb6ea9"

URI_aarch64_R-java-devel = "${EPEL_MIRROR}/aarch64/Packages/r/R-java-devel-4.5.3-1.el10_1.aarch64.rpm;name=aarch64_R-java-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-java-devel}"
SRC_URI[aarch64_R-java-devel.sha256sum] = "6b34f3257768fb76db7879dd184ebdb9f04660785fe6696e240ba6e6f25a45dc"

URI_aarch64_libRmath = "${EPEL_MIRROR}/aarch64/Packages/l/libRmath-4.5.3-1.el10_1.aarch64.rpm;name=aarch64_libRmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libRmath}"
SRC_URI[aarch64_libRmath.sha256sum] = "82e5c4b07226b414d000ff19a6df0a219c19c5df0adfbabbf3d19a2a0055dc33"

URI_aarch64_libRmath-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libRmath-devel-4.5.3-1.el10_1.aarch64.rpm;name=aarch64_libRmath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libRmath-devel}"
SRC_URI[aarch64_libRmath-devel.sha256sum] = "12996840a2efae4d8365f1edd59fc0aacb9cf096eade7c377ad921ddc1821297"

URI_aarch64_libRmath-static = "${EPEL_MIRROR}/aarch64/Packages/l/libRmath-static-4.5.3-1.el10_1.aarch64.rpm;name=aarch64_libRmath-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libRmath-static}"
SRC_URI[aarch64_libRmath-static.sha256sum] = "c98bd47157bf5f99969941734f4261ad97debfeb6a5e681e91701e20c9d38bdb"

RDEPENDS:R = " \
 R-devel \
 "
RDEPENDS:R-core = " \
 bash \
 bzip2-libs \
 cairo \
 flexiblas-netlib \
 glib2 \
 glibc \
 less \
 libRmath \
 libX11 \
 libXmu \
 libXt \
 libdeflate \
 libgcc \
 libgomp \
 libicu \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtirpc \
 libzstd \
 pango \
 pcre2 \
 readline \
 tcl \
 tk \
 tre \
 tzdata \
 unzip \
 virtual/libcurl.so.4___64bit_ \
 xdg-utils \
 xz-libs \
 zip \
 zlib-ng-compat \
 "
RDEPENDS:R-core-devel = " \
 R-core \
 bzip2-devel \
 flexiblas-devel \
 gcc-c++ \
 gcc-gfortran \
 libRmath-devel \
 libX11-devel \
 libdeflate-devel \
 libicu-devel \
 libtirpc-devel \
 libzstd-devel \
 make \
 pcre2-devel \
 pkgconf-pkg-config \
 redhat-rpm-config \
 tre-devel \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:R-devel = " \
 R-core-devel \
 R-java-devel \
 R-rpm-macros \
 "
RDEPENDS:R-java = " \
 R-core \
 java-21-openjdk-headless \
 "
RDEPENDS:R-java-devel = " \
 R-core-devel \
 R-java \
 java-21-openjdk-devel \
 "
RDEPENDS:libRmath = " \
 glibc \
 "
RDEPENDS:libRmath-devel = " \
 libRmath \
 pkgconf-pkg-config \
 "
RDEPENDS:libRmath-static = " \
 libRmath-devel \
 "
