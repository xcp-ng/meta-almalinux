# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-cyclonedx"
PV = "0.5.9"
PR = "1.el10_3"
PACKAGES = " \
 cargo-cyclonedx \
 rust-cargo-cyclonedx+default-devel \
 rust-cargo-cyclonedx-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-cyclonedx-0.5.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "746538b422e37678539b3ca80e999afb7e4bfed9e22a3949e401b0e9dc40ea8a"

URI_x86_64_v2_cargo-cyclonedx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-cyclonedx-0.5.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-cyclonedx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-cyclonedx}"
SRC_URI[x86_64_v2_cargo-cyclonedx.sha256sum] = "f78173e5a26448971089a71ec453a8eb412e72bf1e4280b249d1ed47f4a540a9"

URI_x86_64_v2_rust-cargo-cyclonedx+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-cyclonedx+default-devel-0.5.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-cyclonedx+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-cyclonedx+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-cyclonedx+default-devel.sha256sum] = "2fd5a0ecb0cc86e3342598fa37394c3064102195f1802fc7bb1dfea8eb5a9357"

URI_x86_64_v2_rust-cargo-cyclonedx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-cyclonedx-devel-0.5.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-cyclonedx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-cyclonedx-devel}"
SRC_URI[x86_64_v2_rust-cargo-cyclonedx-devel.sha256sum] = "65319debc8d11cb658f65a76f80ac0d3d673966433a07258a057f7194d26ee2a"

URI_aarch64_cargo-cyclonedx = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-cyclonedx-0.5.9-1.el10_3.aarch64.rpm;name=aarch64_cargo-cyclonedx;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-cyclonedx}"
SRC_URI[aarch64_cargo-cyclonedx.sha256sum] = "22ec8b5f7839f7f89c976c2850b5bea55609ada5c22124a301d425e2dad8a225"

URI_aarch64_rust-cargo-cyclonedx+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-cyclonedx+default-devel-0.5.9-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-cyclonedx+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-cyclonedx+default-devel}"
SRC_URI[aarch64_rust-cargo-cyclonedx+default-devel.sha256sum] = "80e1aac0acecccc794d2a6e2001fc073a58c447582e713876fe355eb4e04d785"

URI_aarch64_rust-cargo-cyclonedx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-cyclonedx-devel-0.5.9-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-cyclonedx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-cyclonedx-devel}"
SRC_URI[aarch64_rust-cargo-cyclonedx-devel.sha256sum] = "06c417c0105f98949b03f0781ed59637353bff03a28fd099b7a8a44e8a98b576"

RDEPENDS:cargo-cyclonedx = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-cargo-cyclonedx+default-devel = " \
 cargo \
 rust-cargo-cyclonedx-devel \
 "
RDEPENDS:rust-cargo-cyclonedx-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-cargo-lock+default-devel \
 rust-cargo_metadata0.18+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-cyclonedx-bom+default-devel \
 rust-env_logger+default-devel \
 rust-log+default-devel \
 rust-once_cell+default-devel \
 rust-pathdiff+camino-devel \
 rust-pathdiff+default-devel \
 rust-percent-encoding+default-devel \
 rust-purl+package-type-devel \
 rust-purl-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-validator+default-devel \
 "
