# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-local-lib"
PV = "2.000029"
PR = "9.el10"
PACKAGES = " \
 perl-local-lib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-local-lib-2.000029-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e2812b3e5e86506129ce570f1c969f0d9ecaa13b9377a72c2a9a51d7a9b5b07"

URI_x86_64_v2_perl-local-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-local-lib-2.000029-9.el10.noarch.rpm;name=x86_64_v2_perl-local-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-local-lib}"
SRC_URI[x86_64_v2_perl-local-lib.sha256sum] = "e69645d8c4e0b66033073578e788b58478e21260a6e3509e2ab8b06429b43d6c"

URI_aarch64_perl-local-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-local-lib-2.000029-9.el10.noarch.rpm;name=aarch64_perl-local-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-local-lib}"
SRC_URI[aarch64_perl-local-lib.sha256sum] = "e69645d8c4e0b66033073578e788b58478e21260a6e3509e2ab8b06429b43d6c"

RDEPENDS:perl-local-lib = " \
 perl-Carp \
 perl-File-Basename \
 perl-PathTools \
 perl-libs \
 "
