# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stow"
PV = "2.4.1"
PR = "4.el10_1"
PACKAGES = " \
 stow \
 stow-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/stow-2.4.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8f1760b358399622b7ee0ead435a0eeeda16485db18ea508f2c726cbe483d63e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stow-2.4.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_stow;unpack=0"
SRC_URI[x86_64_v2_stow.sha256sum] = "aebe24438cf0fc12c18ea3d71e715cb01a5b3ccea97b94b245d7ba3f717d2489"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stow-doc-2.4.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_stow-doc;unpack=0"
SRC_URI[x86_64_v2_stow-doc.sha256sum] = "a1ad0ec5afdf0a28a4fdd61590ca38860f5c7927b8450c5b8787f99a501a5626"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stow-2.4.1-4.el10_1.noarch.rpm;name=aarch64_stow;unpack=0"
SRC_URI[aarch64_stow.sha256sum] = "03b820e0ee0ae15f51c57e11aa1167475af9caaf37a8b4a5ec87a2c38c4f197b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/stow-doc-2.4.1-4.el10_1.noarch.rpm;name=aarch64_stow-doc;unpack=0"
SRC_URI[aarch64_stow-doc.sha256sum] = "245f85424a979179db5334231fcecebecdcd82eb33d208796b22b7ce4b42617e"

RDEPENDS:stow = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Copy \
 perl-File-Find \
 perl-Getopt-Long \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Text-ParseWords \
 perl-base \
 perl-interpreter \
 perl-libs \
 stow \
 "
RDEPENDS:stow-doc = " \
 stow \
 "
