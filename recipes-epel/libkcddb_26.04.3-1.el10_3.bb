# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkcddb"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 libkcddb \
 libkcddb-devel \
 libkcddb-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkcddb-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21dd9242a81a615c1768fbef52fa9a12a15e0c725af749022b4e27d741f72322"

URI_x86_64_v2_libkcddb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb}"
SRC_URI[x86_64_v2_libkcddb.sha256sum] = "a19fe0ef214614d70e4b2ec5bca8b7157737561cc81e8ba3492db35103f394a7"

URI_x86_64_v2_libkcddb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkcddb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb-devel}"
SRC_URI[x86_64_v2_libkcddb-devel.sha256sum] = "4c8b589101191961acb3d3d0f73c14b157ac60c6ae176ffb53f38b90d3e801e3"

URI_x86_64_v2_libkcddb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkcddb-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkcddb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkcddb-doc}"
SRC_URI[x86_64_v2_libkcddb-doc.sha256sum] = "e2087aa14fb294d1eb02fc01a45675c8189d0d3a5447255e4bd9714240b00bf5"

URI_aarch64_libkcddb = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkcddb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb}"
SRC_URI[aarch64_libkcddb.sha256sum] = "a26f67657584fce366e35d5402194ee59ae55f7c20c3c7b253716864848803e1"

URI_aarch64_libkcddb-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_libkcddb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb-devel}"
SRC_URI[aarch64_libkcddb-devel.sha256sum] = "6d994c9068a1841603372b972d7fc2161799c0824177402fb0de3c1c7cb77c5c"

URI_aarch64_libkcddb-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkcddb-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_libkcddb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkcddb-doc}"
SRC_URI[aarch64_libkcddb-doc.sha256sum] = "d399a8df5930cc068b1ffbf5073e2a8ff2f33f80d99d734298cbab8a20ba1d56"

RDEPENDS:libkcddb = " \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-solid \
 libgcc \
 libkcddb-doc \
 libmusicbrainz5 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkcddb-devel = " \
 cmake-filesystem \
 libkcddb \
 "
RDEPENDS:libkcddb-doc = " \
 libkcddb \
 "
