# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-mobile"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-lookandfeel-fedora-mobile \
 plasma-mobile \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-mobile-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8ebc5fea13f4d2177b889229ca8e38a1bc6314c7ad80ce15f733ce8eabac41c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-lookandfeel-fedora-mobile-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-lookandfeel-fedora-mobile;unpack=0"
SRC_URI[x86_64_v2_plasma-lookandfeel-fedora-mobile.sha256sum] = "e5e23c0fcdbf7ebfacea37c0640d8a75be550776e96028e248b4b4a7c061e4e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-mobile-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-mobile;unpack=0"
SRC_URI[x86_64_v2_plasma-mobile.sha256sum] = "4f5ffae284a3812f69cb9450473c98ef49ceb07ab75d4a0673742dfb276cec0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-lookandfeel-fedora-mobile-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma-lookandfeel-fedora-mobile;unpack=0"
SRC_URI[aarch64_plasma-lookandfeel-fedora-mobile.sha256sum] = "215b6a40253013b7b3c70d1bab7d99f42dcbcde97b3e0237f2c237479bf28c54"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-mobile-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-mobile;unpack=0"
SRC_URI[aarch64_plasma-mobile.sha256sum] = "0b1b162f52381b34d4f7ce2ce2b169e4bd0f3979f5f474ad8d456ca7fc43fb48"

RDEPENDS:plasma-lookandfeel-fedora-mobile = " \
 plasma-mobile \
 "
RDEPENDS:plasma-mobile = " \
 bash \
 glibc \
 kf6-bluez-qt \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-modemmanager-qt \
 kf6-networkmanager-qt \
 kf6-solid \
 kpipewire \
 kscreen \
 kwayland \
 kwin \
 kwin-libs \
 layer-shell-qt \
 libgcc \
 libkscreen \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 plasma-activities \
 plasma-lookandfeel-fedora-mobile \
 plasma-milou \
 plasma-nano \
 plasma-nm \
 plasma-pa \
 plasma-workspace \
 qcoro-qt6 \
 qqc2-breeze-style \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsensors \
 qt6-qtwayland \
 systemd-libs \
 virtual/system-backgrounds-kde \
 "
