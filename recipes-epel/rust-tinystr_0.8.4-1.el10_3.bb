# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tinystr"
PV = "0.8.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-tinystr+alloc-devel \
 rust-tinystr+databake-devel \
 rust-tinystr+default-devel \
 rust-tinystr+serde-devel \
 rust-tinystr+std-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tinystr-0.8.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e4d13c56fd8bc1a373c414483bb636448b11f89762bbc6f1a41de2ec48fcee1a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+alloc-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tinystr+alloc-devel.sha256sum] = "491cc406abef2cfa63aa0a675816cf978494ef5171ff689db4d7e893f47c819d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+databake-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+databake-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tinystr+databake-devel.sha256sum] = "549b4b47427ac846ef288182c843bdfc032e3acca8468c89c73aeb832077ada4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+default-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tinystr+default-devel.sha256sum] = "e8ee145e997d2b4b7c20632d303bb6154f5ca17ce86cbd950902bbca2d7a1d69"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+serde-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tinystr+serde-devel.sha256sum] = "0d0ab561ff67a75f2b516b564f665bd0013fcc98de594ac2063c694c801f8d4e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+std-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tinystr+std-devel.sha256sum] = "743852297a6439a70e7ae3042709f4ab26604e5ea8a002dd6e87dc8c6cad2a9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr+zerovec-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tinystr+zerovec-devel.sha256sum] = "ffa37528b717bb40716898621ad4c17f9b5f0f1879c0785f22b1abd325cce8ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tinystr-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tinystr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tinystr-devel.sha256sum] = "992c4c7aa824152bc6605adcf9bbc67cc5af8ce3ceb634daacd39417a347b624"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+alloc-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-tinystr+alloc-devel.sha256sum] = "378ea0b339b78288c18b2b2fe629bbcb267f1ea3361af620af9bc3bb00e2aab2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+databake-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+databake-devel;unpack=0"
SRC_URI[aarch64_rust-tinystr+databake-devel.sha256sum] = "b7618d30b8d4c425a420a41de9529ef289ca7e589a642dee9ac879a01e8e9115"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+default-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+default-devel;unpack=0"
SRC_URI[aarch64_rust-tinystr+default-devel.sha256sum] = "47f401e7e136ac6d173524b2435d2e4f1782621396e796c92f20d23e1abd7e6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+serde-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+serde-devel;unpack=0"
SRC_URI[aarch64_rust-tinystr+serde-devel.sha256sum] = "c2917b1e513f3e1223398259b0db2a57ebde782e14a6f2b220be595fcb697f46"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+std-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+std-devel;unpack=0"
SRC_URI[aarch64_rust-tinystr+std-devel.sha256sum] = "34c38b0cf8dc4249f7bf07578313aeda961fdec85f46237ef57598b30a5fa6bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr+zerovec-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr+zerovec-devel;unpack=0"
SRC_URI[aarch64_rust-tinystr+zerovec-devel.sha256sum] = "c5f70ebe068dff505bab7771c7a9603fb5b0318af508b9f56e8d9535d86ca329"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tinystr-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-tinystr-devel;unpack=0"
SRC_URI[aarch64_rust-tinystr-devel.sha256sum] = "395822798d4b6043ce869df86b199dcacd0d2fe52557a95e573b4d64e15265df"

RDEPENDS:rust-tinystr+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-tinystr-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-tinystr+databake-devel = " \
 cargo \
 rust-databake-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+default-devel = " \
 cargo \
 rust-tinystr+alloc-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+std-devel = " \
 cargo \
 rust-tinystr-devel \
 "
RDEPENDS:rust-tinystr+zerovec-devel = " \
 cargo \
 rust-tinystr-devel \
 rust-zerovec-devel \
 "
RDEPENDS:rust-tinystr-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 "
