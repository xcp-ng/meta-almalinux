# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ImageMagick"
PE = "1"
PV = "7.1.1.43"
PR = "1.el10_0"
PACKAGES = " \
 ImageMagick \
 ImageMagick-c++ \
 ImageMagick-c++-devel \
 ImageMagick-devel \
 ImageMagick-djvu \
 ImageMagick-doc \
 ImageMagick-heic \
 ImageMagick-libs \
 ImageMagick-perl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ImageMagick-7.1.1.43-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f40c5f4b73790b44dbb019691ef5b8a0abc8c9d4fd265ba8386359a36a98c7e"

URI_x86_64_v2_ImageMagick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-7.1.1.43-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick}"
SRC_URI[x86_64_v2_ImageMagick.sha256sum] = "f99cb0b8256cb0b0a79c3443ae50444af81df0a5bb4845756db75ac49be5b03b"

URI_x86_64_v2_ImageMagick-c++ = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-c++-7.1.1.43-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-c++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-c++}"
SRC_URI[x86_64_v2_ImageMagick-c++.sha256sum] = "ebe440b62283cdea9a166cf99409555247b03760425905426d478b3e8af9d698"

URI_x86_64_v2_ImageMagick-c++-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-c++-devel-7.1.1.43-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-c++-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-c++-devel}"
SRC_URI[x86_64_v2_ImageMagick-c++-devel.sha256sum] = "a79ac0d6feedf424f28f5d9d8a18b449ef7344ec188b23ae6e320de57737785c"

URI_x86_64_v2_ImageMagick-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-devel-7.1.1.43-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-devel}"
SRC_URI[x86_64_v2_ImageMagick-devel.sha256sum] = "c16bf944b1efd949f825cbac1fb863270266020777b7fec31f58a26878d547ad"

URI_x86_64_v2_ImageMagick-djvu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-djvu-7.1.1.43-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-djvu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-djvu}"
SRC_URI[x86_64_v2_ImageMagick-djvu.sha256sum] = "f938643ea238208b0ef23a2c8b223cd26b9c2c37a8a63ed3689fe362805b8d67"

URI_x86_64_v2_ImageMagick-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-doc-7.1.1.43-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-doc}"
SRC_URI[x86_64_v2_ImageMagick-doc.sha256sum] = "c9d5106efa2486957a7eb7cacc95cab860dcbb3e3d41d982d1607ecbdae113c1"

URI_x86_64_v2_ImageMagick-heic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-heic-7.1.1.43-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-heic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-heic}"
SRC_URI[x86_64_v2_ImageMagick-heic.sha256sum] = "280bdfac9acb9cf041ac220d95c12995694d5db45360b76d575885f11fbafde9"

URI_x86_64_v2_ImageMagick-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-libs-7.1.1.43-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-libs}"
SRC_URI[x86_64_v2_ImageMagick-libs.sha256sum] = "7786b9f4fc3ececbca631d3cb4f2b85ddbf55c070ef2b18c437059402c0d9749"

URI_x86_64_v2_ImageMagick-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ImageMagick-perl-7.1.1.43-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ImageMagick-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ImageMagick-perl}"
SRC_URI[x86_64_v2_ImageMagick-perl.sha256sum] = "c13c28b3caf74a5dabadfc8dc2c25ad3be503b6d4918c99241fbb80f34987ff3"

URI_aarch64_ImageMagick = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-7.1.1.43-1.el10_0.aarch64.rpm;name=aarch64_ImageMagick;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick}"
SRC_URI[aarch64_ImageMagick.sha256sum] = "d388eae155ad2cbb24fbcafe30b326b8919821e2ce811873bcccd499f281e62c"

URI_aarch64_ImageMagick-c++ = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-c++-7.1.1.43-1.el10_0.aarch64.rpm;name=aarch64_ImageMagick-c++;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-c++}"
SRC_URI[aarch64_ImageMagick-c++.sha256sum] = "7a6d00b2d75d2a4b5d4ed964ffb9382c288269371aa9125beb115ca867948d97"

URI_aarch64_ImageMagick-c++-devel = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-c++-devel-7.1.1.43-1.el10_0.aarch64.rpm;name=aarch64_ImageMagick-c++-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-c++-devel}"
SRC_URI[aarch64_ImageMagick-c++-devel.sha256sum] = "e80a8a12c95c5462539d2b21e6ff4b06ff3f07fd1b6ed878feae2d9bd197e981"

URI_aarch64_ImageMagick-devel = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-devel-7.1.1.43-1.el10_0.aarch64.rpm;name=aarch64_ImageMagick-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-devel}"
SRC_URI[aarch64_ImageMagick-devel.sha256sum] = "79965af2addc4aecbf374de639f6ac51fc8367d76e9adecf87198d846b27515c"

URI_aarch64_ImageMagick-djvu = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-djvu-7.1.1.43-1.el10_0.aarch64.rpm;name=aarch64_ImageMagick-djvu;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-djvu}"
SRC_URI[aarch64_ImageMagick-djvu.sha256sum] = "9f9e4363fbb53304d1b35b105ffdb17ab9065398139b394506023b5f2b6f927e"

URI_aarch64_ImageMagick-doc = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-doc-7.1.1.43-1.el10_0.aarch64.rpm;name=aarch64_ImageMagick-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-doc}"
SRC_URI[aarch64_ImageMagick-doc.sha256sum] = "301cb54a0ad3c1e60bfc6f6f2cd8ba3dec55001936d0fe668393db615c8222d8"

URI_aarch64_ImageMagick-heic = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-heic-7.1.1.43-1.el10_0.aarch64.rpm;name=aarch64_ImageMagick-heic;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-heic}"
SRC_URI[aarch64_ImageMagick-heic.sha256sum] = "13346d59180f21513dc59b35672a0dce717d632e08f109cc980007aaa48259cd"

URI_aarch64_ImageMagick-libs = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-libs-7.1.1.43-1.el10_0.aarch64.rpm;name=aarch64_ImageMagick-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-libs}"
SRC_URI[aarch64_ImageMagick-libs.sha256sum] = "bf241b078a81b8da16a7cbf080420304e016cf7f7d0cb5296f7568de6f13e934"

URI_aarch64_ImageMagick-perl = "${EPEL_MIRROR}/aarch64/Packages/i/ImageMagick-perl-7.1.1.43-1.el10_0.aarch64.rpm;name=aarch64_ImageMagick-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ImageMagick-perl}"
SRC_URI[aarch64_ImageMagick-perl.sha256sum] = "9120ff5f817e1ea95493f1645c10ed8db3a32ce447dc8c6ad9b16eff641ccc7b"

RDEPENDS:ImageMagick = " \
 ImageMagick-libs \
 glibc \
 "
RDEPENDS:ImageMagick-c++ = " \
 ImageMagick-libs \
 bzip2-libs \
 fftw-libs-double \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXt \
 libgcc \
 libgomp \
 liblqr-1 \
 libraqm \
 libstdc++ \
 libtool-ltdl \
 libxml2 \
 libzip \
 zlib-ng-compat \
 "
RDEPENDS:ImageMagick-c++-devel = " \
 ImageMagick-c++ \
 ImageMagick-devel \
 bash \
 pkgconf-pkg-config \
 "
RDEPENDS:ImageMagick-devel = " \
 ImageMagick \
 ImageMagick-devel \
 ImageMagick-libs \
 bash \
 pkgconf-pkg-config \
 "
RDEPENDS:ImageMagick-djvu = " \
 ImageMagick-libs \
 bzip2-libs \
 djvulibre-libs \
 fftw-libs-double \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXt \
 libjpeg-turbo \
 liblqr-1 \
 libraqm \
 libtool-ltdl \
 libxml2 \
 libzip \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:ImageMagick-doc = " \
 "
RDEPENDS:ImageMagick-heic = " \
 ImageMagick-libs \
 bzip2-libs \
 fftw-libs-double \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXt \
 libheif \
 liblqr-1 \
 libraqm \
 libtool-ltdl \
 libxml2 \
 libzip \
 zlib-ng-compat \
 "
RDEPENDS:ImageMagick-libs = " \
 LibRaw \
 bzip2-libs \
 cairo \
 fftw-libs-double \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphviz \
 harfbuzz \
 imath \
 jbigkit-libs \
 lcms2 \
 libICE \
 libSM \
 libX11 \
 libXext \
 libXt \
 libgcc \
 libgomp \
 libgs \
 libjpeg-turbo \
 libjxl \
 liblqr-1 \
 libpng \
 libraqm \
 librsvg2 \
 libtiff \
 libtool-ltdl \
 libwebp \
 libwmf-lite \
 libxml2 \
 libzip \
 openexr-libs \
 openjpeg2 \
 pango \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:ImageMagick-perl = " \
 ImageMagick-libs \
 ImageMagick-perl \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-parent \
 perl-vars \
 "
