# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "appliance-tools"
PV = "011.3"
PR = "5.el10_1"
PACKAGES = " \
 appliance-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/appliance-tools-011.3-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d13682e63a5138ac83d2f00b8159ead63ce9bc3a674b7cd79796e74f5a226301"

URI_x86_64_v2_appliance-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/appliance-tools-011.3-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_appliance-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_appliance-tools}"
SRC_URI[x86_64_v2_appliance-tools.sha256sum] = "c537e4aa22c931c8df010ba6222a619cc4af726fa2c407c318fe9dab46c23c3e"

URI_aarch64_appliance-tools = "${EPEL_MIRROR}/aarch64/Packages/a/appliance-tools-011.3-5.el10_1.noarch.rpm;name=aarch64_appliance-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_appliance-tools}"
SRC_URI[aarch64_appliance-tools.sha256sum] = "f70b402106d63c9b115b6740659f179555dbd6c86c9e80f63cd54eeba48dd756"

RDEPENDS:appliance-tools = " \
 curl \
 kpartx \
 python3 \
 python3-imgcreate \
 python3-progress \
 python3-setuptools \
 qemu-img \
 rsync \
 sssd-client \
 xfsprogs \
 xz \
 zlib-ng-compat \
 "
