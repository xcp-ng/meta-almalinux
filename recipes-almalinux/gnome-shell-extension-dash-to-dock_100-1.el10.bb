# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-dash-to-dock"
PV = "100"
PR = "1.el10"
PACKAGES = " \
 gnome-shell-extension-dash-to-dock \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-extension-dash-to-dock-100-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a30b93b565967da59321020220ba9d47b71bb44412734479bc1a86c673f68d8"

URI_x86_64_v2_gnome-shell-extension-dash-to-dock = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-dash-to-dock-100-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-dash-to-dock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-dash-to-dock}"
SRC_URI[x86_64_v2_gnome-shell-extension-dash-to-dock.sha256sum] = "c0452b12a2ac2191b4dab0f84b20a9841adc498c2be9a717f69266b2470142fd"

URI_aarch64_gnome-shell-extension-dash-to-dock = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-dash-to-dock-100-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-dash-to-dock;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-dash-to-dock}"
SRC_URI[aarch64_gnome-shell-extension-dash-to-dock.sha256sum] = "c0452b12a2ac2191b4dab0f84b20a9841adc498c2be9a717f69266b2470142fd"

RDEPENDS:gnome-shell-extension-dash-to-dock = " \
 gnome-shell-extension-common \
 "
