# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hdf5"
PV = "1.14.5"
PR = "1.el10_0"
PACKAGES = " \
 hdf5 \
 hdf5-devel \
 hdf5-mpich \
 hdf5-mpich-devel \
 hdf5-mpich-static \
 hdf5-openmpi \
 hdf5-openmpi-devel \
 hdf5-openmpi-static \
 hdf5-static \
 java-hdf5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hdf5-1.14.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe56403d73acaf991de06809d04eb037f0037a62e976a5cf39105f4dc0708dce"

URI_x86_64_v2_hdf5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf5-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf5}"
SRC_URI[x86_64_v2_hdf5.sha256sum] = "dd0f52ff92904999863679205185a806c05772cb56e6cc0b65b672e7195fd262"

URI_x86_64_v2_hdf5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf5-devel-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf5-devel}"
SRC_URI[x86_64_v2_hdf5-devel.sha256sum] = "4c2831c1be719af54c5753df0b88cf2036526ae55b9995b43dbb29e4a3ea8d4d"

URI_x86_64_v2_hdf5-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf5-mpich-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf5-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf5-mpich}"
SRC_URI[x86_64_v2_hdf5-mpich.sha256sum] = "a2a12b8c0b3f16935555107b89a5997c70b12b2c1aa52470e404283d79099745"

URI_x86_64_v2_hdf5-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf5-mpich-devel-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf5-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf5-mpich-devel}"
SRC_URI[x86_64_v2_hdf5-mpich-devel.sha256sum] = "576be25a8666f8517417ffec6be76782a3f74cd57c1bbb0451a908f662172c3a"

URI_x86_64_v2_hdf5-mpich-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf5-mpich-static-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf5-mpich-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf5-mpich-static}"
SRC_URI[x86_64_v2_hdf5-mpich-static.sha256sum] = "e4156fc26759b7ea71cd06a50567dd109567e6487bb6f708be3da410f543d993"

URI_x86_64_v2_hdf5-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf5-openmpi-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf5-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf5-openmpi}"
SRC_URI[x86_64_v2_hdf5-openmpi.sha256sum] = "4748fe39eebb246e0b9193d66c6a6a10606b7ced7fd10b3413ebf4a2ec84f4a3"

URI_x86_64_v2_hdf5-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf5-openmpi-devel-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf5-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf5-openmpi-devel}"
SRC_URI[x86_64_v2_hdf5-openmpi-devel.sha256sum] = "bc057731c3ab21fe798ef637e5e4047e882339d6c46581f535869eed3858e33c"

URI_x86_64_v2_hdf5-openmpi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf5-openmpi-static-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf5-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf5-openmpi-static}"
SRC_URI[x86_64_v2_hdf5-openmpi-static.sha256sum] = "4bba0720ed99a888af55f7970908d3ebca58e7079495a86a60ea2de554eb0d0d"

URI_x86_64_v2_hdf5-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf5-static-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf5-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf5-static}"
SRC_URI[x86_64_v2_hdf5-static.sha256sum] = "81cb28011941dd9b74fd607f7fadd0ed30eaa7649a1fc239c89d28149be01c7f"

URI_x86_64_v2_java-hdf5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-hdf5-1.14.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-hdf5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-hdf5}"
SRC_URI[x86_64_v2_java-hdf5.sha256sum] = "b08cf7334902d0dfd050f817ee2774683b39b0d91c9bdbc83ccab58e8c2a07aa"

URI_aarch64_hdf5 = "${EPEL_MIRROR}/aarch64/Packages/h/hdf5-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_hdf5;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf5}"
SRC_URI[aarch64_hdf5.sha256sum] = "1adadfa5143fa98e423d59d4ab0a633f1278e793804580abfa03a1393f1bbb38"

URI_aarch64_hdf5-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hdf5-devel-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_hdf5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf5-devel}"
SRC_URI[aarch64_hdf5-devel.sha256sum] = "d79a3a73de6643257f6cebab91536b2674f5c832ff99db77299ded696e35c477"

URI_aarch64_hdf5-mpich = "${EPEL_MIRROR}/aarch64/Packages/h/hdf5-mpich-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_hdf5-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf5-mpich}"
SRC_URI[aarch64_hdf5-mpich.sha256sum] = "9ab0a79af3bb1802592f7f334a42d9fc57f2a59ef9c344e72e0d64a0d7e90e28"

URI_aarch64_hdf5-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hdf5-mpich-devel-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_hdf5-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf5-mpich-devel}"
SRC_URI[aarch64_hdf5-mpich-devel.sha256sum] = "a812a67e3275868b40d41924c3a1d70b9f87a8c423d33d8a7c106dcfb791016c"

URI_aarch64_hdf5-mpich-static = "${EPEL_MIRROR}/aarch64/Packages/h/hdf5-mpich-static-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_hdf5-mpich-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf5-mpich-static}"
SRC_URI[aarch64_hdf5-mpich-static.sha256sum] = "03476d6a0757379774ded1b1a71215444f2c17ad9ac9742760716338ac9e30e7"

URI_aarch64_hdf5-openmpi = "${EPEL_MIRROR}/aarch64/Packages/h/hdf5-openmpi-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_hdf5-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf5-openmpi}"
SRC_URI[aarch64_hdf5-openmpi.sha256sum] = "293ea988a9298c1d1898bb12cae17ebc9135c7bf35cd7a24c705e29783957b24"

URI_aarch64_hdf5-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hdf5-openmpi-devel-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_hdf5-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf5-openmpi-devel}"
SRC_URI[aarch64_hdf5-openmpi-devel.sha256sum] = "95d2f175290ef2b9d8cb02e89ed741528ff770f0a13171a34724c3fd6b8531ac"

URI_aarch64_hdf5-openmpi-static = "${EPEL_MIRROR}/aarch64/Packages/h/hdf5-openmpi-static-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_hdf5-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf5-openmpi-static}"
SRC_URI[aarch64_hdf5-openmpi-static.sha256sum] = "ff934996e72bf4d82c6a3e9327d5e7dc7a19497440ff2f945cf753a3a89b88da"

URI_aarch64_hdf5-static = "${EPEL_MIRROR}/aarch64/Packages/h/hdf5-static-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_hdf5-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf5-static}"
SRC_URI[aarch64_hdf5-static.sha256sum] = "868b2e8ee86b2ecfa2eb92c5e12a4da2a5f6aed835a9ee1c51aa976cd761d2b6"

URI_aarch64_java-hdf5 = "${EPEL_MIRROR}/aarch64/Packages/j/java-hdf5-1.14.5-1.el10_0.aarch64.rpm;name=aarch64_java-hdf5;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-hdf5}"
SRC_URI[aarch64_java-hdf5.sha256sum] = "a7f759f677cf91f0db6d440e7e23207bf7f4d3b6e6520054da321f53217f9c34"

RDEPENDS:hdf5 = " \
 bash \
 glibc \
 libaec \
 libgcc \
 libgfortran \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:hdf5-devel = " \
 bash \
 gcc-gfortran \
 hdf5 \
 libaec-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:hdf5-mpich = " \
 bash \
 glibc \
 libaec \
 libgcc \
 libgfortran \
 mpich \
 zlib-ng-compat \
 "
RDEPENDS:hdf5-mpich-devel = " \
 bash \
 hdf5-mpich \
 libaec-devel \
 mpich-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:hdf5-mpich-static = " \
 hdf5-mpich-devel \
 "
RDEPENDS:hdf5-openmpi = " \
 bash \
 glibc \
 libaec \
 libgcc \
 libgfortran \
 openmpi \
 zlib-ng-compat \
 "
RDEPENDS:hdf5-openmpi-devel = " \
 bash \
 hdf5-openmpi \
 libaec-devel \
 openmpi-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:hdf5-openmpi-static = " \
 hdf5-openmpi-devel \
 "
RDEPENDS:hdf5-static = " \
 hdf5-devel \
 "
RDEPENDS:java-hdf5 = " \
 glibc \
 hdf5 \
 slf4j \
 "
