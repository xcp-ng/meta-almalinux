# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest-middleware"
PV = "0.4.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-reqwest-middleware+charset-devel \
 rust-reqwest-middleware+default-devel \
 rust-reqwest-middleware+http2-devel \
 rust-reqwest-middleware+json-devel \
 rust-reqwest-middleware+multipart-devel \
 rust-reqwest-middleware+rustls-tls-devel \
 rust-reqwest-middleware-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-middleware-0.4.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac8601ee97faa9358969182fe581f8a1aa0100126ed0004705dd4efbe663cd67"

URI_x86_64_v2_rust-reqwest-middleware+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+charset-devel-0.4.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+charset-devel.sha256sum] = "e9ad23a66069744d34371d3c1c3d0e963841db6e381ea406e3ae0e70f5ba2762"

URI_x86_64_v2_rust-reqwest-middleware+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+default-devel-0.4.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+default-devel.sha256sum] = "7bbc0486641f4237531db3c5b56932a5602fc3386c7cfc96b41cf165c2d7f9df"

URI_x86_64_v2_rust-reqwest-middleware+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+http2-devel-0.4.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+http2-devel.sha256sum] = "2da3cbd82bc67b011aed904af541727f2d7a397bb4324cf0e4771ed6a2e270fe"

URI_x86_64_v2_rust-reqwest-middleware+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+json-devel-0.4.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+json-devel.sha256sum] = "eb53530ca727628f98c9bc924eb1acd1c2edccc80f7e215e1752c83e074f714c"

URI_x86_64_v2_rust-reqwest-middleware+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+multipart-devel-0.4.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+multipart-devel.sha256sum] = "2ddd72aebd056b9afed7f4ca111071f70e012cc680ced34bf9d70a685577164f"

URI_x86_64_v2_rust-reqwest-middleware+rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware+rustls-tls-devel-0.4.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware+rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware+rustls-tls-devel.sha256sum] = "c9e53f81f5b3e3de1502f79b5374dd2a1ac1e15061f6b3561a9d7880fa531d74"

URI_x86_64_v2_rust-reqwest-middleware-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-middleware-devel-0.4.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-middleware-devel}"
SRC_URI[x86_64_v2_rust-reqwest-middleware-devel.sha256sum] = "ba8751087cc3208f09a013a7c8d924f1680728506a8661a7fbf8d7ba710bb24e"

URI_aarch64_rust-reqwest-middleware+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+charset-devel-0.4.2-4.el10_0.noarch.rpm;name=aarch64_rust-reqwest-middleware+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+charset-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+charset-devel.sha256sum] = "53c168175ae0dff8b4198b85d87118f7b62e62308a183ae28c3da572bae3f77d"

URI_aarch64_rust-reqwest-middleware+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+default-devel-0.4.2-4.el10_0.noarch.rpm;name=aarch64_rust-reqwest-middleware+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+default-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+default-devel.sha256sum] = "80fff3246a021db850ef3bd0bf661d9a6651374d3b007ccd95155a668b9ccd75"

URI_aarch64_rust-reqwest-middleware+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+http2-devel-0.4.2-4.el10_0.noarch.rpm;name=aarch64_rust-reqwest-middleware+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+http2-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+http2-devel.sha256sum] = "e6c451f631cab245972709f86bceebc6b3460a29bf5814206a994a096e37ac4d"

URI_aarch64_rust-reqwest-middleware+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+json-devel-0.4.2-4.el10_0.noarch.rpm;name=aarch64_rust-reqwest-middleware+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+json-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+json-devel.sha256sum] = "26a63ab9bc4c3efce6a959eeb75c08401c2d141159613724a0e9b5160cfbbe60"

URI_aarch64_rust-reqwest-middleware+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+multipart-devel-0.4.2-4.el10_0.noarch.rpm;name=aarch64_rust-reqwest-middleware+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+multipart-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+multipart-devel.sha256sum] = "baf2850d70a766e451835fc16bdf9cb927f2b7e40e4a093ecd981457f810c41b"

URI_aarch64_rust-reqwest-middleware+rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware+rustls-tls-devel-0.4.2-4.el10_0.noarch.rpm;name=aarch64_rust-reqwest-middleware+rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware+rustls-tls-devel}"
SRC_URI[aarch64_rust-reqwest-middleware+rustls-tls-devel.sha256sum] = "8eee82fd5c012a944b8a77091e2cf231c25b91d5b1980e7e2b2afbcd500e4c01"

URI_aarch64_rust-reqwest-middleware-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-middleware-devel-0.4.2-4.el10_0.noarch.rpm;name=aarch64_rust-reqwest-middleware-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-middleware-devel}"
SRC_URI[aarch64_rust-reqwest-middleware-devel.sha256sum] = "514fbc816854e4c954807fe7bb57835d21752cd8891d70d832c56738ef39250b"

RDEPENDS:rust-reqwest-middleware+charset-devel = " \
 cargo \
 rust-reqwest+charset-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+default-devel = " \
 cargo \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+http2-devel = " \
 cargo \
 rust-reqwest+http2-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+json-devel = " \
 cargo \
 rust-reqwest+json-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+multipart-devel = " \
 cargo \
 rust-reqwest+multipart-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware+rustls-tls-devel = " \
 cargo \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest-middleware-devel \
 "
RDEPENDS:rust-reqwest-middleware-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-http+default-devel \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-thiserror1+default-devel \
 rust-tower-service+default-devel \
 "
