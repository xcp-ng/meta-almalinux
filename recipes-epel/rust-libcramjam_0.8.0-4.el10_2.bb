# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libcramjam"
PV = "0.8.0"
PR = "4.el10_2"
PACKAGES = " \
 rust-libcramjam+brotli-devel \
 rust-libcramjam+bzip2-devel \
 rust-libcramjam+capi-devel \
 rust-libcramjam+default-devel \
 rust-libcramjam+deflate-devel \
 rust-libcramjam+deflate-shared-devel \
 rust-libcramjam+gzip-devel \
 rust-libcramjam+gzip-shared-devel \
 rust-libcramjam+lz4-devel \
 rust-libcramjam+snappy-devel \
 rust-libcramjam+xz-devel \
 rust-libcramjam+xz-shared-devel \
 rust-libcramjam+zlib-devel \
 rust-libcramjam+zlib-shared-devel \
 rust-libcramjam+zstd-devel \
 rust-libcramjam-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libcramjam-0.8.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fda7b557299f4e671ad57ff6d2fedc49804ec9018bdd1cec9c17ab7289089c4"

URI_x86_64_v2_rust-libcramjam+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+brotli-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+brotli-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+brotli-devel.sha256sum] = "38bdb075098200b02eb52476307a9a517b372e9d3f16ff424e7ba95832b7969a"

URI_x86_64_v2_rust-libcramjam+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+bzip2-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+bzip2-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+bzip2-devel.sha256sum] = "73bc8cbd3c40247ea4b4e1381420c34bf849893ba2b44b5d87014819f0d9a721"

URI_x86_64_v2_rust-libcramjam+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+capi-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+capi-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+capi-devel.sha256sum] = "fd9f61712d6584f7ec7f470beb4874195fa38795233ece21017d0c58d1272e02"

URI_x86_64_v2_rust-libcramjam+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+default-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+default-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+default-devel.sha256sum] = "1c61f5989f4a7309b0854ff58a971023443f2739249709a86ca96f788752595b"

URI_x86_64_v2_rust-libcramjam+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+deflate-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+deflate-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+deflate-devel.sha256sum] = "4b7070bdbf37ee6a502481f024b6514f4369a64a05b2cb84711825d1f26d4f18"

URI_x86_64_v2_rust-libcramjam+deflate-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+deflate-shared-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+deflate-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+deflate-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+deflate-shared-devel.sha256sum] = "be67980af7d95c55ed0ec46b7d3d535702ff95341a92fb4f1320197d3fadb2e9"

URI_x86_64_v2_rust-libcramjam+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+gzip-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+gzip-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+gzip-devel.sha256sum] = "0aa9aeb1a2c39ac2275734a71e2545b0180c87be169e06eba953ee50b3658218"

URI_x86_64_v2_rust-libcramjam+gzip-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+gzip-shared-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+gzip-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+gzip-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+gzip-shared-devel.sha256sum] = "909fa2b765fc0fe590b2771a8fe2a80dce9ff0cd1f025d776977bbb065474be4"

URI_x86_64_v2_rust-libcramjam+lz4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+lz4-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+lz4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+lz4-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+lz4-devel.sha256sum] = "77d6fcc5fc45d0455679b9270f96f126a7669606c84db16046b5b28c306e3ca5"

URI_x86_64_v2_rust-libcramjam+snappy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+snappy-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+snappy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+snappy-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+snappy-devel.sha256sum] = "fbb9cc72f4c088820314d2618ac54068d34bbb354cffce9fbb87705bbcc17b97"

URI_x86_64_v2_rust-libcramjam+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+xz-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+xz-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+xz-devel.sha256sum] = "8aa6b5e7427bc9d114a46341c8f2251e3d3b1d67702164f039831cfdfba05d77"

URI_x86_64_v2_rust-libcramjam+xz-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+xz-shared-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+xz-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+xz-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+xz-shared-devel.sha256sum] = "b888f78fe9f049ba816ff7b4885a3c9bfa36cb53729f431871bb3dc1958600df"

URI_x86_64_v2_rust-libcramjam+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+zlib-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+zlib-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+zlib-devel.sha256sum] = "e532053d1bd5231f5959f3f67f0a7ab727ac3bbbb0be082f8b731d9aecc2207b"

URI_x86_64_v2_rust-libcramjam+zlib-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+zlib-shared-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+zlib-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+zlib-shared-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+zlib-shared-devel.sha256sum] = "4f94d88868875cd3a6b60e04faccbb80dcb6b7e7faebd960f1828c51492215b3"

URI_x86_64_v2_rust-libcramjam+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam+zstd-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam+zstd-devel}"
SRC_URI[x86_64_v2_rust-libcramjam+zstd-devel.sha256sum] = "4cff9702961b20a0d6542d436a3e8e2d4e144deff1b5c6ea3becff5153ae9c26"

URI_x86_64_v2_rust-libcramjam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcramjam-devel-0.8.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcramjam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libcramjam-devel}"
SRC_URI[x86_64_v2_rust-libcramjam-devel.sha256sum] = "8f790f843f6ce1b69a8e75c6995519c9adfea317b50053a8fece3a726ab97d56"

URI_aarch64_rust-libcramjam+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+brotli-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+brotli-devel}"
SRC_URI[aarch64_rust-libcramjam+brotli-devel.sha256sum] = "15724ecd4fe6e925be849cdc13026d1010f25985537244a0d782d7c00df58c2e"

URI_aarch64_rust-libcramjam+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+bzip2-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+bzip2-devel}"
SRC_URI[aarch64_rust-libcramjam+bzip2-devel.sha256sum] = "218000e059aca43402f26e70ebd3072fe4835da62be1452151f0ba0de585e93a"

URI_aarch64_rust-libcramjam+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+capi-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+capi-devel}"
SRC_URI[aarch64_rust-libcramjam+capi-devel.sha256sum] = "37cc43af6d1a02da0de4e669f38e3c371d278debe7a147b52a164f34c391af0c"

URI_aarch64_rust-libcramjam+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+default-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+default-devel}"
SRC_URI[aarch64_rust-libcramjam+default-devel.sha256sum] = "0d0d6613f38d67ad963498deb12ba2b169fe72eecc57bb84cf1464084527f3e5"

URI_aarch64_rust-libcramjam+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+deflate-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+deflate-devel}"
SRC_URI[aarch64_rust-libcramjam+deflate-devel.sha256sum] = "bca513bd1cf6696f0715ea674eb7a1afad0c8af28b7981598f332468313813e5"

URI_aarch64_rust-libcramjam+deflate-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+deflate-shared-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+deflate-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+deflate-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+deflate-shared-devel.sha256sum] = "d5faf827c946b5c05f98e4f9f3608a06a2f0811cc77fd4fe31c095063c1b963c"

URI_aarch64_rust-libcramjam+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+gzip-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+gzip-devel}"
SRC_URI[aarch64_rust-libcramjam+gzip-devel.sha256sum] = "59c6cbad2371d72cb32440624c9a69f7f6154033cf7779c3d12cab17974f01de"

URI_aarch64_rust-libcramjam+gzip-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+gzip-shared-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+gzip-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+gzip-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+gzip-shared-devel.sha256sum] = "a17fddc5c908d1697b013b2739bf639c1f20415dd5e1c18779a0b7e6d0250bac"

URI_aarch64_rust-libcramjam+lz4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+lz4-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+lz4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+lz4-devel}"
SRC_URI[aarch64_rust-libcramjam+lz4-devel.sha256sum] = "c73b88404efb2c67adba764127005d8c5d35cd897bfbea9701cad88edc484a9a"

URI_aarch64_rust-libcramjam+snappy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+snappy-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+snappy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+snappy-devel}"
SRC_URI[aarch64_rust-libcramjam+snappy-devel.sha256sum] = "26d9310e74ed1a17a8b9d8675f3785f41839837d9d23b6d488e0f40069c3b66b"

URI_aarch64_rust-libcramjam+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+xz-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+xz-devel}"
SRC_URI[aarch64_rust-libcramjam+xz-devel.sha256sum] = "2b849440378198cecf5ced9e9e5efa9e1528f929a6eaab9eaea1e70dcc24b368"

URI_aarch64_rust-libcramjam+xz-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+xz-shared-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+xz-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+xz-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+xz-shared-devel.sha256sum] = "dfd59ac4410602ceac5e47f4c42d38f1fae7a6aa266c8312dbe4905e63af526b"

URI_aarch64_rust-libcramjam+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+zlib-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+zlib-devel}"
SRC_URI[aarch64_rust-libcramjam+zlib-devel.sha256sum] = "3c065647cbd732460d73dab483e0401dc62d0f35ca61f674103a53bebf1aac5c"

URI_aarch64_rust-libcramjam+zlib-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+zlib-shared-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+zlib-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+zlib-shared-devel}"
SRC_URI[aarch64_rust-libcramjam+zlib-shared-devel.sha256sum] = "3de51bbb9f584a33406c962965978d43258c0dcdfd4f7e9ddd4fa6321f385004"

URI_aarch64_rust-libcramjam+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam+zstd-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam+zstd-devel}"
SRC_URI[aarch64_rust-libcramjam+zstd-devel.sha256sum] = "b116ac8e1beb4e2607dac240303b1d512cd58866056b736412b1a438d6662763"

URI_aarch64_rust-libcramjam-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libcramjam-devel-0.8.0-4.el10_2.noarch.rpm;name=aarch64_rust-libcramjam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libcramjam-devel}"
SRC_URI[aarch64_rust-libcramjam-devel.sha256sum] = "2e0d9a43021c7e15bf977271c72fcaffc6517e6f428341760a42e02711a5c895"

RDEPENDS:rust-libcramjam+brotli-devel = " \
 cargo \
 rust-brotli+ffi-api-devel \
 rust-brotli+std-devel \
 rust-brotli-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+bzip2-devel = " \
 cargo \
 rust-bzip2+default-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+capi-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+default-devel = " \
 cargo \
 rust-libcramjam+brotli-devel \
 rust-libcramjam+bzip2-devel \
 rust-libcramjam+deflate-devel \
 rust-libcramjam+gzip-devel \
 rust-libcramjam+lz4-devel \
 rust-libcramjam+snappy-devel \
 rust-libcramjam+xz-devel \
 rust-libcramjam+zlib-devel \
 rust-libcramjam+zstd-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+deflate-devel = " \
 cargo \
 rust-libcramjam+deflate-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+deflate-shared-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-libcramjam-devel \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 "
RDEPENDS:rust-libcramjam+gzip-devel = " \
 cargo \
 rust-libcramjam+gzip-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+gzip-shared-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-libcramjam+deflate-shared-devel \
 rust-libcramjam-devel \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 "
RDEPENDS:rust-libcramjam+lz4-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-lz4+default-devel \
 "
RDEPENDS:rust-libcramjam+snappy-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-snap+default-devel \
 "
RDEPENDS:rust-libcramjam+xz-devel = " \
 cargo \
 rust-libcramjam+xz-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+xz-shared-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-libcramjam+zlib-devel = " \
 cargo \
 rust-libcramjam+zlib-shared-devel \
 rust-libcramjam-devel \
 "
RDEPENDS:rust-libcramjam+zlib-shared-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-libcramjam+deflate-shared-devel \
 rust-libcramjam-devel \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 "
RDEPENDS:rust-libcramjam+zstd-devel = " \
 cargo \
 rust-libcramjam-devel \
 rust-zstd+default-devel \
 "
RDEPENDS:rust-libcramjam-devel = " \
 cargo \
 "
