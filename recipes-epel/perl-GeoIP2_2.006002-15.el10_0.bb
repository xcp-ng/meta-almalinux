# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GeoIP2"
PV = "2.006002"
PR = "15.el10_0"
PACKAGES = " \
 perl-GeoIP2 \
 perl-GeoIP2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GeoIP2-2.006002-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d59388db245db630037d1576e88884cdd43d5094200d51803730aa5d0c0a0066"

URI_x86_64_v2_perl-GeoIP2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GeoIP2-2.006002-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GeoIP2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GeoIP2}"
SRC_URI[x86_64_v2_perl-GeoIP2.sha256sum] = "c7feabe0cbbd98ea1d76bbbd58ded6054762e84ad513556f8f7f0cd934193b08"

URI_x86_64_v2_perl-GeoIP2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GeoIP2-tests-2.006002-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GeoIP2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GeoIP2-tests}"
SRC_URI[x86_64_v2_perl-GeoIP2-tests.sha256sum] = "a81fe40b80e3261a7a5b83980421ad62fc5eb93e99e36ef95516eee980d92944"

URI_aarch64_perl-GeoIP2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GeoIP2-2.006002-15.el10_0.noarch.rpm;name=aarch64_perl-GeoIP2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GeoIP2}"
SRC_URI[aarch64_perl-GeoIP2.sha256sum] = "4720c6da092aea03899656a3743105a630e0057702b4a3cd74e78a3fa9eec1cc"

URI_aarch64_perl-GeoIP2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GeoIP2-tests-2.006002-15.el10_0.noarch.rpm;name=aarch64_perl-GeoIP2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GeoIP2-tests}"
SRC_URI[aarch64_perl-GeoIP2-tests.sha256sum] = "25175e7aa3f1412dad26d02290c4a850839d88923156b34ac9bc7e4a128d5b7e"

RDEPENDS:perl-GeoIP2 = " \
 perl-B \
 perl-Data-Dumper \
 perl-Data-Validate-IP \
 perl-Exporter \
 perl-GeoIP2 \
 perl-Getopt-Long \
 perl-HTTP-Message \
 perl-JSON-MaybeXS \
 perl-LWP-Protocol-https \
 perl-List-SomeUtils \
 perl-MIME-Base64 \
 perl-MaxMind-DB-Reader \
 perl-Moo \
 perl-Params-Validate \
 perl-Scalar-List-Utils \
 perl-Sub-Quote \
 perl-Throwable \
 perl-Try-Tiny \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-namespace-clean \
 "
RDEPENDS:perl-GeoIP2-tests = " \
 bash \
 perl-B \
 perl-Exporter \
 perl-ExtUtils-MakeMaker \
 perl-GeoIP2 \
 perl-HTTP-Message \
 perl-IO-Compress \
 perl-JSON-MaybeXS \
 perl-MaxMind-DB-Common \
 perl-Path-Class \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Number-Delta \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-URI \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-libwww-perl \
 "
