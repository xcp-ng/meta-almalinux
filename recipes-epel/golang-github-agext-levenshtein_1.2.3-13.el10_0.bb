# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-agext-levenshtein"
PV = "1.2.3"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-agext-levenshtein-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-agext-levenshtein-1.2.3-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5dc0d8e8541213ee5dcdaef1ba122165e42b59876d42f101aaefacb20c38271"

URI_x86_64_v2_golang-github-agext-levenshtein-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-agext-levenshtein-devel-1.2.3-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-agext-levenshtein-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-agext-levenshtein-devel}"
SRC_URI[x86_64_v2_golang-github-agext-levenshtein-devel.sha256sum] = "18d90730b989a8ad47a25b8681ed95b6c335791a53bd7486734267a733669061"

URI_aarch64_golang-github-agext-levenshtein-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-agext-levenshtein-devel-1.2.3-13.el10_0.noarch.rpm;name=aarch64_golang-github-agext-levenshtein-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-agext-levenshtein-devel}"
SRC_URI[aarch64_golang-github-agext-levenshtein-devel.sha256sum] = "b95a4037fc44e457add56af4cce9ab56f1dcf1701b9e70fd256880611f6319f2"

RDEPENDS:golang-github-agext-levenshtein-devel = " \
 go-filesystem \
 "
