# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-modemmanager-qt"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-modemmanager-qt \
 kf6-modemmanager-qt-devel \
 kf6-modemmanager-qt-doc \
 kf6-modemmanager-qt-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-modemmanager-qt-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f379579039e4a54c7e1becdb4f8cf77cca3de0dcdc353d2c737020f5290af4d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt;unpack=0"
SRC_URI[x86_64_v2_kf6-modemmanager-qt.sha256sum] = "84cd431ad946327ca52c038ff6b379896a24d48bdcfcf69db76d73ef7d954d5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-devel.sha256sum] = "eb018371dde5b57cabb435a65de6eb4eeabd2984988ce5e1795bd8dfe4a7f348"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-doc.sha256sum] = "1b5397f18eb1f6ba97fb11295f737391f4e491ddfe9a433143e8ee345b5c362b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-modemmanager-qt-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-modemmanager-qt-html;unpack=0"
SRC_URI[x86_64_v2_kf6-modemmanager-qt-html.sha256sum] = "661369848474af294c4c2006cb11d0d6a60d5b468155c226f868ebbd8e2b1063"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-modemmanager-qt;unpack=0"
SRC_URI[aarch64_kf6-modemmanager-qt.sha256sum] = "1db41e6c610415aabbf7931232f0ed5e21c4afb31c6db9224e36266d225d8b5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-modemmanager-qt-devel;unpack=0"
SRC_URI[aarch64_kf6-modemmanager-qt-devel.sha256sum] = "b6b6aefe340ff836550fb14791272cfd2c28af065a889be19ef9eae0bff86a0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-modemmanager-qt-doc;unpack=0"
SRC_URI[aarch64_kf6-modemmanager-qt-doc.sha256sum] = "8974480e279b2fa7dff20f76e1484e5aab5e350d0991ffdadcb3790bae8dbf37"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-modemmanager-qt-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-modemmanager-qt-html;unpack=0"
SRC_URI[aarch64_kf6-modemmanager-qt-html.sha256sum] = "992c3a0ee57bb1302e2716f18def28e08302d965f6f228a44bbb531c9a51c8f2"

RDEPENDS:kf6-modemmanager-qt = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-modemmanager-qt-devel = " \
 ModemManager-devel \
 cmake-filesystem \
 kf6-modemmanager-qt \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-modemmanager-qt-doc = " \
 "
RDEPENDS:kf6-modemmanager-qt-html = " \
 "
