# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk4"
PV = "4.16.7"
PR = "5.el10_2"
PACKAGES = " \
 gtk4 \
 gtk4-devel \
 gtk4-devel-docs \
 gtk4-devel-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gtk4-4.16.7-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "56388a081aca06f04b44d1df1f98e686ff79c5c1b00218e76b345a9154963927"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk4-4.16.7-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gtk4;unpack=0"
SRC_URI[x86_64_v2_gtk4.sha256sum] = "e4efce08dd12b3408e9747ea3677331619328384556f273828b5e55536f23238"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gtk4-devel-4.16.7-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gtk4-devel;unpack=0"
SRC_URI[x86_64_v2_gtk4-devel.sha256sum] = "2c8d9405248989d71326888db48bc2eb87ae655e83e74df6766ea7d3336befc7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk4-devel-docs-4.16.7-5.el10_2.noarch.rpm;name=x86_64_v2_gtk4-devel-docs;unpack=0"
SRC_URI[x86_64_v2_gtk4-devel-docs.sha256sum] = "151e64d11d430e8a64bc2ec75d954dcf7bb6738bcd88f3c0fd17c9fdc9f85d55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gtk4-devel-tools-4.16.7-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_gtk4-devel-tools;unpack=0"
SRC_URI[x86_64_v2_gtk4-devel-tools.sha256sum] = "e155020e74ded58414498844aec6d6f39e5cee217afbbeea08722f1f72fe21c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk4-4.16.7-5.el10_2.aarch64.rpm;name=aarch64_gtk4;unpack=0"
SRC_URI[aarch64_gtk4.sha256sum] = "cd0c694f746788a16c40e1f9be8ed5e532207637bac56df3add56f232ac45e99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gtk4-devel-4.16.7-5.el10_2.aarch64.rpm;name=aarch64_gtk4-devel;unpack=0"
SRC_URI[aarch64_gtk4-devel.sha256sum] = "2a531bb828674a19200f2eda1c8c99254210ca3f948668ff10b39bf9b5d82acd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk4-devel-docs-4.16.7-5.el10_2.noarch.rpm;name=aarch64_gtk4-devel-docs;unpack=0"
SRC_URI[aarch64_gtk4-devel-docs.sha256sum] = "151e64d11d430e8a64bc2ec75d954dcf7bb6738bcd88f3c0fd17c9fdc9f85d55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gtk4-devel-tools-4.16.7-5.el10_2.aarch64.rpm;name=aarch64_gtk4-devel-tools;unpack=0"
SRC_URI[aarch64_gtk4-devel-tools.sha256sum] = "068f80c5e0177fed377d05c6aca9217c8fa9eab1eb9dd032f2e283d485af8ff6"

RDEPENDS:gtk4 = " \
 adwaita-icon-theme \
 cairo \
 cairo-gobject \
 colord-libs \
 cups-libs \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-modules \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk-update-icon-cache \
 harfbuzz \
 hicolor-icon-theme \
 libX11 \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtracker-sparql \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 pango \
 vulkan-loader \
 "
RDEPENDS:gtk4-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 cairo-gobject-devel \
 fontconfig \
 fribidi \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 glib2 \
 glib2-devel \
 glibc \
 graphene \
 graphene-devel \
 gtk4 \
 gtk4-devel \
 harfbuzz \
 libX11 \
 libX11-devel \
 libXcursor \
 libXdamage \
 libXext \
 libXfixes \
 libXi \
 libXinerama \
 libXrandr \
 libepoxy \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtracker-sparql \
 libwayland-client \
 libwayland-egl \
 libxkbcommon \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vulkan-loader \
 vulkan-loader-devel \
 wayland-devel \
 "
RDEPENDS:gtk4-devel-docs = " \
 gtk4 \
 "
RDEPENDS:gtk4-devel-tools = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 harfbuzz \
 libepoxy \
 pango \
 "
