# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tryfn"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tryfn+color-auto-devel \
 rust-tryfn+color-devel \
 rust-tryfn+default-devel \
 rust-tryfn+diff-devel \
 rust-tryfn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tryfn-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12209c76ad6922ef7f255ba005cc6d0c2094a08a2a2849ee7bfae971e3d34275"

URI_x86_64_v2_rust-tryfn+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+color-auto-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+color-auto-devel}"
SRC_URI[x86_64_v2_rust-tryfn+color-auto-devel.sha256sum] = "d1f20d27fd76240427bd9e3acd8e520b0912c1547dc9119d58bf86e05da3bda8"

URI_x86_64_v2_rust-tryfn+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+color-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+color-devel}"
SRC_URI[x86_64_v2_rust-tryfn+color-devel.sha256sum] = "921ca00730879150d1e4d5be70315a7a8125aa7cbeb84f463c3852b9795a2f86"

URI_x86_64_v2_rust-tryfn+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+default-devel}"
SRC_URI[x86_64_v2_rust-tryfn+default-devel.sha256sum] = "e4280b9c171a20d6dbcd65c479a61df5a166dfadb096334c254bb6ae16247806"

URI_x86_64_v2_rust-tryfn+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+diff-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+diff-devel}"
SRC_URI[x86_64_v2_rust-tryfn+diff-devel.sha256sum] = "5a20700b83fa26a3ef4bf2785f6d165e4cde5c4e84c7d6bd6b1a9e6b52a2ad17"

URI_x86_64_v2_rust-tryfn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn-devel}"
SRC_URI[x86_64_v2_rust-tryfn-devel.sha256sum] = "965e15bd375870ab425d4a089f94a19768dc1a700956a1368617e55ed71bf8f1"

URI_aarch64_rust-tryfn+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+color-auto-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+color-auto-devel}"
SRC_URI[aarch64_rust-tryfn+color-auto-devel.sha256sum] = "725856eba8e8b3c83478598516de7d7937916fa1cb8a4c9142e39205710d0ebb"

URI_aarch64_rust-tryfn+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+color-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+color-devel}"
SRC_URI[aarch64_rust-tryfn+color-devel.sha256sum] = "a290551fd1279830d09531152b583e1cfbd5f0e2364abc0594dbd78fadb0eaa1"

URI_aarch64_rust-tryfn+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+default-devel}"
SRC_URI[aarch64_rust-tryfn+default-devel.sha256sum] = "92322b484fafd8086b021f7ef9755cf5d0d737db501ca1d6131fe61b3e6c72b9"

URI_aarch64_rust-tryfn+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+diff-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+diff-devel}"
SRC_URI[aarch64_rust-tryfn+diff-devel.sha256sum] = "343ca71df1deeb4cdb932865f4550f584634e80a1f429c3c9aa2792a76e2e4bf"

URI_aarch64_rust-tryfn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tryfn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn-devel}"
SRC_URI[aarch64_rust-tryfn-devel.sha256sum] = "43ddfd84b1201e4646ce3215fa68a0b3a7eac18860f10caebc8cc2603c7f49a0"

RDEPENDS:rust-tryfn+color-auto-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn+color-devel = " \
 cargo \
 rust-snapbox+color-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn+default-devel = " \
 cargo \
 rust-tryfn+color-auto-devel \
 rust-tryfn+diff-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn+diff-devel = " \
 cargo \
 rust-snapbox+diff-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn-devel = " \
 cargo \
 rust \
 rust-ignore+default-devel \
 rust-libtest-mimic+default-devel \
 rust-snapbox-devel \
 "
