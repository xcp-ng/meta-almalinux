# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tox"
PV = "4.24.1"
PR = "1.el10_0"
PACKAGES = " \
 tox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tox-4.24.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f063de465f6c41f1f4319314a00b1646b301f85b0528e6c5dd0758a5f972d323"

URI_x86_64_v2_tox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tox-4.24.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_tox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tox}"
SRC_URI[x86_64_v2_tox.sha256sum] = "6538787748132c76b8061cf62fd512eb8f74e30163641f9f0b59e6177f555897"

URI_aarch64_tox = "${EPEL_MIRROR}/aarch64/Packages/t/tox-4.24.1-1.el10_0.noarch.rpm;name=aarch64_tox;unpack=0"
SRC_URI:append = " ${URI_aarch64_tox}"
SRC_URI[aarch64_tox.sha256sum] = "2526e1828222e3534604559da48b492d5d5864a4275849a28a93b2ba8ee7f656"

RDEPENDS:tox = " \
 python3 \
 python3-cachetools \
 python3-chardet \
 python3-colorama \
 python3-filelock \
 python3-packaging \
 python3-platformdirs \
 python3-pluggy \
 python3-pyproject-api \
 python3-virtualenv \
 "
