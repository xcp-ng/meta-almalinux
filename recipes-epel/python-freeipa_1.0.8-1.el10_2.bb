# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-freeipa"
PV = "1.0.8"
PR = "1.el10_2"
PACKAGES = " \
 python3-freeipa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-freeipa-1.0.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cecc3daa9bcdec19baa9803c5c90afabf3e0df44df9a6973de9a491ed530f9ac"

URI_x86_64_v2_python3-freeipa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-freeipa-1.0.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-freeipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-freeipa}"
SRC_URI[x86_64_v2_python3-freeipa.sha256sum] = "a17cbd2f37ccc8a1595e9ed30edaca2319b4bbc2e97f492fd96d9ff251c69fac"

URI_aarch64_python3-freeipa = "${EPEL_MIRROR}/aarch64/Packages/p/python3-freeipa-1.0.8-1.el10_2.noarch.rpm;name=aarch64_python3-freeipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-freeipa}"
SRC_URI[aarch64_python3-freeipa.sha256sum] = "71444630fac1b8631ffc6b8db1e78b77f375f5f98826f5ac09ded5f0389b0cd4"

RDEPENDS:python3-freeipa = " \
 python3 \
 python3-requests \
 "
