# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rfc3986"
PV = "2.0.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-rfc3986 \
 python3-rfc3986+idna2008 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rfc3986-2.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23fc67d9477ff414f03bb932e226eb985d5e5de163f436d594a77c6e25e39d03"

URI_x86_64_v2_python3-rfc3986 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rfc3986-2.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rfc3986;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rfc3986}"
SRC_URI[x86_64_v2_python3-rfc3986.sha256sum] = "8031649a66a2a7c0f004c456e83057e96f6b4d867ef4801cb4905429ae37b326"

URI_x86_64_v2_python3-rfc3986+idna2008 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rfc3986+idna2008-2.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rfc3986+idna2008;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rfc3986+idna2008}"
SRC_URI[x86_64_v2_python3-rfc3986+idna2008.sha256sum] = "387668ff05026fb3723ecd3f24c755d9bb4200b9448957d2759b7c117f75e146"

URI_aarch64_python3-rfc3986 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rfc3986-2.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-rfc3986;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rfc3986}"
SRC_URI[aarch64_python3-rfc3986.sha256sum] = "1b7a01a8964f704e3c393fac04588346febfd1da64c8269195b7701b779b577e"

URI_aarch64_python3-rfc3986+idna2008 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rfc3986+idna2008-2.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-rfc3986+idna2008;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rfc3986+idna2008}"
SRC_URI[aarch64_python3-rfc3986+idna2008.sha256sum] = "2f4119fb77a5d0b130b773d20d5da972cbbb4b932118cb682eb787415c53f6be"

RDEPENDS:python3-rfc3986 = " \
 python3 \
 "
RDEPENDS:python3-rfc3986+idna2008 = " \
 python3 \
 python3-idna \
 python3-rfc3986 \
 "
