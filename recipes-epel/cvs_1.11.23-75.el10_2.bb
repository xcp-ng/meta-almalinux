# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cvs"
PV = "1.11.23"
PR = "75.el10_2"
PACKAGES = " \
 cvs \
 cvs-contrib \
 cvs-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cvs-1.11.23-75.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52dd861f150fc5fe162ef98daf695b85c454d7c42cb855ab346829ced365e067"

URI_x86_64_v2_cvs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cvs-1.11.23-75.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cvs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cvs}"
SRC_URI[x86_64_v2_cvs.sha256sum] = "c7dccaad3c5c96faa335c209424a46646cb28de60811fb825b08bb6c27af4521"

URI_x86_64_v2_cvs-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cvs-contrib-1.11.23-75.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_cvs-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cvs-contrib}"
SRC_URI[x86_64_v2_cvs-contrib.sha256sum] = "f5bb2939ffbb9441e307ae260d6fa1c78271a8c836d07b087aafc61e777b8a94"

URI_x86_64_v2_cvs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cvs-doc-1.11.23-75.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cvs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cvs-doc}"
SRC_URI[x86_64_v2_cvs-doc.sha256sum] = "fd0a1bafba6b93aca4aa10cf06d2a5f3fe0fdef53a40d377bc02ea5113841f86"

URI_aarch64_cvs = "${EPEL_MIRROR}/aarch64/Packages/c/cvs-1.11.23-75.el10_2.aarch64.rpm;name=aarch64_cvs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cvs}"
SRC_URI[aarch64_cvs.sha256sum] = "6456e6d6e20fbd644624b02d32e4fab677222c99fbf08e7a952720f9ef3fa99a"

URI_aarch64_cvs-contrib = "${EPEL_MIRROR}/aarch64/Packages/c/cvs-contrib-1.11.23-75.el10_2.noarch.rpm;name=aarch64_cvs-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cvs-contrib}"
SRC_URI[aarch64_cvs-contrib.sha256sum] = "0976019505e7053d8f16e5b19170b47f1be80f8e02582a8eb546d3dad65cb989"

URI_aarch64_cvs-doc = "${EPEL_MIRROR}/aarch64/Packages/c/cvs-doc-1.11.23-75.el10_2.aarch64.rpm;name=aarch64_cvs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cvs-doc}"
SRC_URI[aarch64_cvs-doc.sha256sum] = "95f47cde67313dfed4a771a40a28ce849991cd3aaabd80be373ef435f2b85e29"

RDEPENDS:cvs = " \
 bash \
 glibc \
 krb5-libs \
 libxcrypt \
 pam-libs \
 vim-minimal \
 zlib-ng-compat \
 "
RDEPENDS:cvs-contrib = " \
 bash \
 cvs \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IO \
 perl-PathTools \
 perl-Perl4-CoreLibs \
 perl-interpreter \
 perl-libs \
 tcsh \
 "
RDEPENDS:cvs-doc = " \
 "
