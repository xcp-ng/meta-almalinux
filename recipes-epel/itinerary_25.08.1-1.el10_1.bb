# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "itinerary"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 itinerary \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/itinerary-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b4ea7b008adc7808d7858c427e94459a961f33daaf554fee09f45f8e27193f6"

URI_x86_64_v2_itinerary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/itinerary-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_itinerary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_itinerary}"
SRC_URI[x86_64_v2_itinerary.sha256sum] = "3cf8dfe7ba2b5bb679f28b2427b3e7c6b25777d962ce5516df367f8fb92f87e7"

URI_aarch64_itinerary = "${EPEL_MIRROR}/aarch64/Packages/i/itinerary-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_itinerary;unpack=0"
SRC_URI:append = " ${URI_aarch64_itinerary}"
SRC_URI[aarch64_itinerary.sha256sum] = "c3173f8b696bdac42e31bcfb6c0889e59567060ccd7a8b9b88575ddd29c4ffde"

RDEPENDS:itinerary = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kunitconversion \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-qqc2-desktop-style \
 khealthcertificate \
 kitinerary \
 kosmindoormap \
 kpkpass \
 kpublictransport \
 libquotient-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qtkeychain-qt6 \
 zlib-ng-compat \
 "
