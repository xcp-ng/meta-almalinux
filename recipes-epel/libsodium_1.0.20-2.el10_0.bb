# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsodium"
PV = "1.0.20"
PR = "2.el10_0"
PACKAGES = " \
 libsodium \
 libsodium-devel \
 libsodium-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libsodium-1.0.20-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b64023dbdb848de7b33675318416a1d7576994c1e9ef31b8a23d7562f9c48e2f"

URI_x86_64_v2_libsodium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-1.0.20-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsodium}"
SRC_URI[x86_64_v2_libsodium.sha256sum] = "48e448bbd7bfd7f4f2d29a2035e5a39a0ee3f1346a83594676669204761e864b"

URI_x86_64_v2_libsodium-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-devel-1.0.20-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsodium-devel}"
SRC_URI[x86_64_v2_libsodium-devel.sha256sum] = "00d9d9b1a7a394e35348c8b69345b734c45b537c312671ce972aca9031cba560"

URI_x86_64_v2_libsodium-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-static-1.0.20-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsodium-static}"
SRC_URI[x86_64_v2_libsodium-static.sha256sum] = "7f112f773ef6058a784465768c619be9ad609e394ff46a6415ca4362233a7091"

URI_aarch64_libsodium = "${EPEL_MIRROR}/aarch64/Packages/l/libsodium-1.0.20-2.el10_0.aarch64.rpm;name=aarch64_libsodium;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsodium}"
SRC_URI[aarch64_libsodium.sha256sum] = "c434319ee73e64fd7dde52433bd2922e24f8fff0e68e4b3040af20fd65c3b709"

URI_aarch64_libsodium-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsodium-devel-1.0.20-2.el10_0.aarch64.rpm;name=aarch64_libsodium-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsodium-devel}"
SRC_URI[aarch64_libsodium-devel.sha256sum] = "626e2b8825b0c38bc6e81c2932e1820b03aebe2c8ed3090fb4d827e8b5f16840"

URI_aarch64_libsodium-static = "${EPEL_MIRROR}/aarch64/Packages/l/libsodium-static-1.0.20-2.el10_0.aarch64.rpm;name=aarch64_libsodium-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsodium-static}"
SRC_URI[aarch64_libsodium-static.sha256sum] = "005e0c2b9d89c0449325e1f56afc05595c61dee6b09f886456b4ec6a8888c421"

RDEPENDS:libsodium = " \
 glibc \
 "
RDEPENDS:libsodium-devel = " \
 libsodium \
 pkgconf-pkg-config \
 "
RDEPENDS:libsodium-static = " \
 libsodium-devel \
 "
