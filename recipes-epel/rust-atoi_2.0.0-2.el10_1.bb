# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-atoi"
PV = "2.0.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-atoi+default-devel \
 rust-atoi+std-devel \
 rust-atoi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-atoi-2.0.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c85e9fc49f6069a31efbc440c72b3924db92b1fff301fc17781080a41a0ae589"

URI_x86_64_v2_rust-atoi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atoi+default-devel-2.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atoi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atoi+default-devel}"
SRC_URI[x86_64_v2_rust-atoi+default-devel.sha256sum] = "427628bb2745fb9a8d89595ff848c1a58c10c600df877944879f0fde7d70ea56"

URI_x86_64_v2_rust-atoi+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atoi+std-devel-2.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atoi+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atoi+std-devel}"
SRC_URI[x86_64_v2_rust-atoi+std-devel.sha256sum] = "59e9cdfcd94148e7d19d6d88636544b5c18fb4a5a5a7f9cc164b1927933a1a20"

URI_x86_64_v2_rust-atoi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-atoi-devel-2.0.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-atoi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-atoi-devel}"
SRC_URI[x86_64_v2_rust-atoi-devel.sha256sum] = "839549ca8639e8254ca18f3c4eff90ad385f198e18d6c33d6d536c42a23115e9"

URI_aarch64_rust-atoi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atoi+default-devel-2.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-atoi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atoi+default-devel}"
SRC_URI[aarch64_rust-atoi+default-devel.sha256sum] = "5e1f8765f9a8a63f13a5abb35c5baf14d78afa95731b1a2ca7f1c4a819a1022b"

URI_aarch64_rust-atoi+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atoi+std-devel-2.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-atoi+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atoi+std-devel}"
SRC_URI[aarch64_rust-atoi+std-devel.sha256sum] = "5592f012a4e20d1dfe56599bfd188fa8115a674c944d95ca81b7030552a1f8df"

URI_aarch64_rust-atoi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-atoi-devel-2.0.0-2.el10_1.noarch.rpm;name=aarch64_rust-atoi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-atoi-devel}"
SRC_URI[aarch64_rust-atoi-devel.sha256sum] = "8b5f45e15c53457062ba68d10c83495f095a0b424b1c4916264c81114d256592"

RDEPENDS:rust-atoi+default-devel = " \
 cargo \
 rust-atoi+std-devel \
 rust-atoi-devel \
 "
RDEPENDS:rust-atoi+std-devel = " \
 cargo \
 rust-atoi-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-atoi-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 "
