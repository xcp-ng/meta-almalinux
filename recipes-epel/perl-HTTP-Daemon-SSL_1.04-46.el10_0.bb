# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Daemon-SSL"
PV = "1.04"
PR = "46.el10_0"
PACKAGES = " \
 perl-HTTP-Daemon-SSL \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-Daemon-SSL-1.04-46.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1ed3f546eeb4e6dc4ed39ad26a6ec415de1e8c33122b41e9cf2a44013c54e1c"

URI_x86_64_v2_perl-HTTP-Daemon-SSL = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Daemon-SSL-1.04-46.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Daemon-SSL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Daemon-SSL}"
SRC_URI[x86_64_v2_perl-HTTP-Daemon-SSL.sha256sum] = "429811e2ab08aaae55f3e054a9ae1534b17d1363edd1a38117a59ba0fbd29128"

URI_aarch64_perl-HTTP-Daemon-SSL = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Daemon-SSL-1.04-46.el10_0.noarch.rpm;name=aarch64_perl-HTTP-Daemon-SSL;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Daemon-SSL}"
SRC_URI[aarch64_perl-HTTP-Daemon-SSL.sha256sum] = "6acb8ba52aa446606286cdd8959a2a27f246bca3444dacc15c0ac6c515ab4607"

RDEPENDS:perl-HTTP-Daemon-SSL = " \
 perl-HTTP-Daemon \
 perl-IO-Socket-SSL \
 perl-libs \
 perl-vars \
 "
