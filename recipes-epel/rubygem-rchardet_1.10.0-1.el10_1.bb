# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rchardet"
PV = "1.10.0"
PR = "1.el10_1"
PACKAGES = " \
 rubygem-rchardet \
 rubygem-rchardet-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-rchardet-1.10.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3bb4eaaaafa2cc1553803f3b9638b50951e1ffe3a37f5431807766b67ec3cea1"

URI_x86_64_v2_rubygem-rchardet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rchardet-1.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rchardet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rchardet}"
SRC_URI[x86_64_v2_rubygem-rchardet.sha256sum] = "69cd1a81834573dee61d8ef46db4f2af73d6512f9f4a613b36ee21026ef69efe"

URI_x86_64_v2_rubygem-rchardet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-rchardet-doc-1.10.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-rchardet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rchardet-doc}"
SRC_URI[x86_64_v2_rubygem-rchardet-doc.sha256sum] = "a1fc1ac83264c6992a90793042ced1eb3d5a71be5cd12a11d882eff1d840d4cb"

URI_aarch64_rubygem-rchardet = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rchardet-1.10.0-1.el10_1.noarch.rpm;name=aarch64_rubygem-rchardet;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rchardet}"
SRC_URI[aarch64_rubygem-rchardet.sha256sum] = "7f9f33cebed47c205ea4b9e0e09eadd0c240f9e2a2112f34b5f41142ae64ecda"

URI_aarch64_rubygem-rchardet-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-rchardet-doc-1.10.0-1.el10_1.noarch.rpm;name=aarch64_rubygem-rchardet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rchardet-doc}"
SRC_URI[aarch64_rubygem-rchardet-doc.sha256sum] = "b3e739a8e92e2eec8bf90246b74c83593129cbd6534a1d30c6baadf683a414da"

RDEPENDS:rubygem-rchardet = " \
 rubygems \
 "
RDEPENDS:rubygem-rchardet-doc = " \
 rubygem-rchardet \
 "
