# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-regex-applicative"
PV = "0.3.4"
PR = "43.el10_0"
PACKAGES = " \
 ghc-regex-applicative \
 ghc-regex-applicative-devel \
 ghc-regex-applicative-doc \
 ghc-regex-applicative-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-regex-applicative-0.3.4-43.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4f3a24780a16427cf2554da4f9e5644269eca46cb6079cec9f7ebae9caebf2e"

URI_x86_64_v2_ghc-regex-applicative = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-applicative-0.3.4-43.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-applicative;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-applicative}"
SRC_URI[x86_64_v2_ghc-regex-applicative.sha256sum] = "e74904ccd493e4377e94eee54395414fb42cff752155842c5910eee267d3ff50"

URI_x86_64_v2_ghc-regex-applicative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-applicative-devel-0.3.4-43.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-applicative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-applicative-devel}"
SRC_URI[x86_64_v2_ghc-regex-applicative-devel.sha256sum] = "3f240a7ded7e3ded4151bcd7b75a6676ce623ed5c35385960848a3cc22a552ec"

URI_x86_64_v2_ghc-regex-applicative-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-applicative-doc-0.3.4-43.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-regex-applicative-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-applicative-doc}"
SRC_URI[x86_64_v2_ghc-regex-applicative-doc.sha256sum] = "60e81ec045c6ccdfe52377cca7e0b10b5dd05cc07ee56a15fa0b8d402cb7bf7b"

URI_x86_64_v2_ghc-regex-applicative-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-applicative-prof-0.3.4-43.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-applicative-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-applicative-prof}"
SRC_URI[x86_64_v2_ghc-regex-applicative-prof.sha256sum] = "df29768aff618727d7bbcf43c2bbd6c5880a895dfcac4215be4f58b40092126d"

URI_aarch64_ghc-regex-applicative = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-applicative-0.3.4-43.el10_0.aarch64.rpm;name=aarch64_ghc-regex-applicative;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-applicative}"
SRC_URI[aarch64_ghc-regex-applicative.sha256sum] = "a4e251e70f85079070ff5bda02e4d8d13bf20ee063fd255da8662279ef37be7d"

URI_aarch64_ghc-regex-applicative-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-applicative-devel-0.3.4-43.el10_0.aarch64.rpm;name=aarch64_ghc-regex-applicative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-applicative-devel}"
SRC_URI[aarch64_ghc-regex-applicative-devel.sha256sum] = "f7e7287c1ce0ac835bc2a34c0726ce67fdf0b114949fc4e1cb1b7d22c1652fd8"

URI_aarch64_ghc-regex-applicative-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-applicative-doc-0.3.4-43.el10_0.noarch.rpm;name=aarch64_ghc-regex-applicative-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-applicative-doc}"
SRC_URI[aarch64_ghc-regex-applicative-doc.sha256sum] = "4dd12ebf26c28386640b0a3ae2a05c0c97ef685b112f8ae5a1dfa746948d82ee"

URI_aarch64_ghc-regex-applicative-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-applicative-prof-0.3.4-43.el10_0.aarch64.rpm;name=aarch64_ghc-regex-applicative-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-applicative-prof}"
SRC_URI[aarch64_ghc-regex-applicative-prof.sha256sum] = "a415a3a362a613964ba6a4dfbbc7639f65b3c59bd6aaf9f9c8c2b21baa848df0"

RDEPENDS:ghc-regex-applicative = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-filtrable \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-regex-applicative-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-filtrable-devel \
 ghc-regex-applicative \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-regex-applicative-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-regex-applicative-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-filtrable-prof \
 ghc-regex-applicative-devel \
 ghc-transformers-prof \
 "
