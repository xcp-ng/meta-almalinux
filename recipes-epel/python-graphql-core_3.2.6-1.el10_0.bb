# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-graphql-core"
PV = "3.2.6"
PR = "1.el10_0"
PACKAGES = " \
 python-graphql-core-doc \
 python3-graphql-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-graphql-core-3.2.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb8e46716002749b7a19b8a7bb048d90380432211ab15561bad0e3ec5f131830"

URI_x86_64_v2_python-graphql-core-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-graphql-core-doc-3.2.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-graphql-core-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-graphql-core-doc}"
SRC_URI[x86_64_v2_python-graphql-core-doc.sha256sum] = "94077a43d603293e63e549d6cc7de82c5a62ebd88d9a275ec2a0db794405982c"

URI_x86_64_v2_python3-graphql-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-graphql-core-3.2.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-graphql-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-graphql-core}"
SRC_URI[x86_64_v2_python3-graphql-core.sha256sum] = "aecbeb074829c2fe209e138ee96a90f0bc339e375d3e4d13b4fe49787d51d9e6"

URI_aarch64_python-graphql-core-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-graphql-core-doc-3.2.6-1.el10_0.noarch.rpm;name=aarch64_python-graphql-core-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-graphql-core-doc}"
SRC_URI[aarch64_python-graphql-core-doc.sha256sum] = "7685649f7d003d838482f753e8a32ab04e805e6ab03c188e1ad04eeb43a01c06"

URI_aarch64_python3-graphql-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-graphql-core-3.2.6-1.el10_0.noarch.rpm;name=aarch64_python3-graphql-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-graphql-core}"
SRC_URI[aarch64_python3-graphql-core.sha256sum] = "46baf4e4216f600b77d4cb8803572ab7cdbead84f5f9fb7f15b75a71ab434815"

RDEPENDS:python-graphql-core-doc = " \
 "
RDEPENDS:python3-graphql-core = " \
 python3 \
 "
