# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "crypto-policies"
PV = "20260811"
PR = "1.git4dcd294.el10.alma.1"
PACKAGES = " \
 crypto-policies \
 crypto-policies-scripts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/crypto-policies-20260811-1.git4dcd294.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "97090a735220469aae2878d35ad41044668c5bfa0ded72e604c02779d6c76726"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-20260811-1.git4dcd294.el10.alma.1.noarch.rpm;name=x86_64_v2_crypto-policies;unpack=0"
SRC_URI[x86_64_v2_crypto-policies.sha256sum] = "5e0618d86f7dbffa950430e363518c72019b3fbb24dacb5705e932152b5be756"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/crypto-policies-scripts-20260811-1.git4dcd294.el10.alma.1.noarch.rpm;name=x86_64_v2_crypto-policies-scripts;unpack=0"
SRC_URI[x86_64_v2_crypto-policies-scripts.sha256sum] = "1b4417d700609d007b969ffc5527d1429fe8266143e5d3e6df9dd616993c163d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-20260811-1.git4dcd294.el10.alma.1.noarch.rpm;name=aarch64_crypto-policies;unpack=0"
SRC_URI[aarch64_crypto-policies.sha256sum] = "5e0618d86f7dbffa950430e363518c72019b3fbb24dacb5705e932152b5be756"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/crypto-policies-scripts-20260811-1.git4dcd294.el10.alma.1.noarch.rpm;name=aarch64_crypto-policies-scripts;unpack=0"
SRC_URI[aarch64_crypto-policies-scripts.sha256sum] = "1b4417d700609d007b969ffc5527d1429fe8266143e5d3e6df9dd616993c163d"

RDEPENDS:crypto-policies = " \
 bash \
 "
RDEPENDS:crypto-policies-scripts = " \
 bash \
 crypto-policies \
 python3 \
 "
