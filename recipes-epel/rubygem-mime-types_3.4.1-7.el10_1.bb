# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-mime-types"
PV = "3.4.1"
PR = "7.el10_1"
PACKAGES = " \
 rubygem-mime-types \
 rubygem-mime-types-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-mime-types-3.4.1-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4ffe512282c847b553f21bbb55bacf822318324bd72bd59edaf83fa76e23f9b"

URI_x86_64_v2_rubygem-mime-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mime-types-3.4.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mime-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mime-types}"
SRC_URI[x86_64_v2_rubygem-mime-types.sha256sum] = "9bd1dc10d5f53964937dca1ed38f7048b2f7c5384b759fe1105cfa4b9317ad0d"

URI_x86_64_v2_rubygem-mime-types-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-mime-types-doc-3.4.1-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-mime-types-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mime-types-doc}"
SRC_URI[x86_64_v2_rubygem-mime-types-doc.sha256sum] = "b28318cd034295438ee81a2c270abef764fca30cc774deb034667274014c0964"

URI_aarch64_rubygem-mime-types = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mime-types-3.4.1-7.el10_1.noarch.rpm;name=aarch64_rubygem-mime-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mime-types}"
SRC_URI[aarch64_rubygem-mime-types.sha256sum] = "f0a4695198b954668e4ceac3f6d0712c874a4aef2de6d8ebe91e8a1489fb6046"

URI_aarch64_rubygem-mime-types-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-mime-types-doc-3.4.1-7.el10_1.noarch.rpm;name=aarch64_rubygem-mime-types-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mime-types-doc}"
SRC_URI[aarch64_rubygem-mime-types-doc.sha256sum] = "a18386f6118054ba17c994cfe55a2376c89ceb152b159f90b57fcd5fbcca7cbf"

RDEPENDS:rubygem-mime-types = " \
 rubygem-mime-types-data \
 rubygems \
 "
RDEPENDS:rubygem-mime-types-doc = " \
 rubygem-mime-types \
 "
