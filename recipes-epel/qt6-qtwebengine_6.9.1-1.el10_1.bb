# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebengine"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 qt6-qtpdf \
 qt6-qtpdf-devel \
 qt6-qtpdf-examples \
 qt6-qtwebengine \
 qt6-qtwebengine-devel \
 qt6-qtwebengine-devtools \
 qt6-qtwebengine-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtwebengine-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44e41a9b7006fd3ea9fb9b151165714195075b146ef86c2028172461c093352b"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - qt6-qtwebengine: libavcodec.so.61()(64bit)
# - qt6-qtwebengine: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - qt6-qtwebengine: libavformat.so.61()(64bit)
# - qt6-qtwebengine: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - qt6-qtwebengine: libavutil.so.59()(64bit)
# - qt6-qtwebengine: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_qt6-qtpdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtpdf-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpdf}"
SRC_URI[x86_64_v2_qt6-qtpdf.sha256sum] = "f049acc14fac41fda01b6db733aa5092d9f71190f2ac543944af1c1d468dad6c"

URI_x86_64_v2_qt6-qtpdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtpdf-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpdf-devel}"
SRC_URI[x86_64_v2_qt6-qtpdf-devel.sha256sum] = "31abccb8d720da248b3db51481edf7873987481738e711ad88be8e8c22f18910"

URI_x86_64_v2_qt6-qtpdf-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtpdf-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtpdf-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtpdf-examples}"
SRC_URI[x86_64_v2_qt6-qtpdf-examples.sha256sum] = "e1ee48d158cf9701389ea5b2daf0ba99b88a68169e97f891da0bbfa6949f3795"

URI_x86_64_v2_qt6-qtwebengine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine}"
SRC_URI[x86_64_v2_qt6-qtwebengine.sha256sum] = "05283bd8ae16e1cf6792f1e963a3b537ec03f86ca917d205fa5e4339a4e057f9"

URI_x86_64_v2_qt6-qtwebengine-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine-devel}"
SRC_URI[x86_64_v2_qt6-qtwebengine-devel.sha256sum] = "9f36b9a59c3c3ce2bd06c0016f6c84d520f1e97eb479f63063de2676f0e94ab1"

URI_x86_64_v2_qt6-qtwebengine-devtools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-devtools-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine-devtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine-devtools}"
SRC_URI[x86_64_v2_qt6-qtwebengine-devtools.sha256sum] = "49eacaf744bc3952a68830d031c2fceff68d7791d493d8e9fbd2fc1c7b74ea36"

URI_x86_64_v2_qt6-qtwebengine-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebengine-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebengine-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebengine-examples}"
SRC_URI[x86_64_v2_qt6-qtwebengine-examples.sha256sum] = "9ea7bf4f14aa251a2705d87b1b9a8accd81d5135e567b9d34d78e7ec7e9aebe5"

URI_aarch64_qt6-qtpdf = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtpdf-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtpdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpdf}"
SRC_URI[aarch64_qt6-qtpdf.sha256sum] = "16991eba13dd1ac28530845b0abd386ba815e730cb30bda8b16953e76cec061d"

URI_aarch64_qt6-qtpdf-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtpdf-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtpdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpdf-devel}"
SRC_URI[aarch64_qt6-qtpdf-devel.sha256sum] = "8d52cc152d03ada97535e8aac6db013f3fb67f51ba2c40d355d61778ef617518"

URI_aarch64_qt6-qtpdf-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtpdf-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtpdf-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtpdf-examples}"
SRC_URI[aarch64_qt6-qtpdf-examples.sha256sum] = "2d6486116dd7bc57a28a8c5e94be219cae165f70ad02b8d7419a8445f14ce6b1"

URI_aarch64_qt6-qtwebengine = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtwebengine;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine}"
SRC_URI[aarch64_qt6-qtwebengine.sha256sum] = "7eecf797995dc5426408fa19276019f929a447e7dcbfaa5d759033c5405a651e"

URI_aarch64_qt6-qtwebengine-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtwebengine-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine-devel}"
SRC_URI[aarch64_qt6-qtwebengine-devel.sha256sum] = "501d3572152f8d08f4bd1fcbae4f3e0b8ccacd8839e1587bffa1c4bde438b002"

URI_aarch64_qt6-qtwebengine-devtools = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-devtools-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtwebengine-devtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine-devtools}"
SRC_URI[aarch64_qt6-qtwebengine-devtools.sha256sum] = "88fc9ef1177bea74b3291d8b8375f37c22929420185e819b8f3278484c6e2ece"

URI_aarch64_qt6-qtwebengine-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebengine-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qtwebengine-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebengine-examples}"
SRC_URI[aarch64_qt6-qtwebengine-examples.sha256sum] = "64f5742fc353a33b43342cda60ed82dcc579b0a930132b49d5bdcee058574b4d"

RDEPENDS:qt6-qtpdf = " \
 glibc \
 libgcc \
 libicu \
 libpng \
 libstdc++ \
 libtiff \
 openjpeg2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtpdf-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtpdf \
 qt6-qtpdf-devel \
 "
RDEPENDS:qt6-qtpdf-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 qt6-qtsvg \
 "
RDEPENDS:qt6-qtwebengine:x86_64_v2 = " \
 alsa-lib \
 bash \
 dbus-libs \
 expat \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 lcms2 \
 libX11 \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libXtst \
 libdrm \
 libevent \
 libgcc \
 libglvnd-glx \
 libicu \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 libwebp \
 libxcb \
 libxkbcommon \
 libxkbfile \
 libxml2 \
 libxslt \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 openjpeg2 \
 opus \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 qt6-qtpositioning \
 qt6-qtwebchannel \
 re2 \
 snappy \
 systemd-libs \
"
RDEPENDS:qt6-qtwebengine:aarch64 = " \
 alsa-lib \
 bash \
 dbus-libs \
 expat \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 harfbuzz \
 lcms2 \
 libX11 \
 libXcomposite \
 libXdamage \
 libXext \
 libXfixes \
 libXrandr \
 libXtst \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libdrm \
 libevent \
 libgcc \
 libglvnd-glx \
 libicu \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libtiff \
 libwebp \
 libxcb \
 libxkbcommon \
 libxkbfile \
 libxml2 \
 libxslt \
 mesa-libgbm \
 noopenh264 \
 nspr \
 nss \
 nss-util \
 openjpeg2 \
 opus \
 pipewire-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpdf \
 qt6-qtpositioning \
 qt6-qtwebchannel \
 re2 \
 snappy \
 systemd-libs \
"
RDEPENDS:qt6-qtwebengine-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 qt6-qtdeclarative-devel \
 qt6-qtpdf-devel \
 qt6-qtpositioning-devel \
 qt6-qtwebchannel-devel \
 qt6-qtwebengine \
 qt6-qtwebengine-devel \
 qt6-qtwebengine-devtools \
 "
RDEPENDS:qt6-qtwebengine-devtools = " \
 qt6-qtwebengine \
 "
RDEPENDS:qt6-qtwebengine-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
