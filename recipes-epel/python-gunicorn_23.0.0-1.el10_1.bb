# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gunicorn"
PV = "23.0.0"
PR = "1.el10_1"
PACKAGES = " \
 python-gunicorn-doc \
 python3-gunicorn \
 python3-gunicorn+gevent \
 python3-gunicorn+setproctitle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gunicorn-23.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8213a4ced8859b57770d2bee5d8f299a77fa84b54083133c47fec6e5318e3a2"

URI_x86_64_v2_python-gunicorn-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-gunicorn-doc-23.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-gunicorn-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-gunicorn-doc}"
SRC_URI[x86_64_v2_python-gunicorn-doc.sha256sum] = "095c878248e6a067efc7ee2e35751f72c71d044abfcaac8dfbbc6506ce69a80f"

URI_x86_64_v2_python3-gunicorn = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gunicorn-23.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gunicorn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gunicorn}"
SRC_URI[x86_64_v2_python3-gunicorn.sha256sum] = "ae81b91a02f31dcfa1615522ab7772bc317114ae9596e6249679064b13a530d3"

URI_x86_64_v2_python3-gunicorn+gevent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gunicorn+gevent-23.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gunicorn+gevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gunicorn+gevent}"
SRC_URI[x86_64_v2_python3-gunicorn+gevent.sha256sum] = "7bc41a70544bc59c1cb553c631e0682a528bea5d9c06682ec469bc8c3fadec88"

URI_x86_64_v2_python3-gunicorn+setproctitle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gunicorn+setproctitle-23.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gunicorn+setproctitle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gunicorn+setproctitle}"
SRC_URI[x86_64_v2_python3-gunicorn+setproctitle.sha256sum] = "88bb9615a8c307ecbaf7aa9d0d97f949352ba0070ebbc10cdc414969f38a8f29"

URI_aarch64_python-gunicorn-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-gunicorn-doc-23.0.0-1.el10_1.noarch.rpm;name=aarch64_python-gunicorn-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-gunicorn-doc}"
SRC_URI[aarch64_python-gunicorn-doc.sha256sum] = "0e18c52707bdfd46c5ecba34e25c4be0c6176e364614ffb679c8b6bc5698686e"

URI_aarch64_python3-gunicorn = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gunicorn-23.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-gunicorn;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gunicorn}"
SRC_URI[aarch64_python3-gunicorn.sha256sum] = "0a7275f2b6dc962163ac4794fb045d939b18e1952adcfed6e1aa24f1dff82f7e"

URI_aarch64_python3-gunicorn+gevent = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gunicorn+gevent-23.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-gunicorn+gevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gunicorn+gevent}"
SRC_URI[aarch64_python3-gunicorn+gevent.sha256sum] = "c2d7f39591242a82aed11513c1c7a475444efc9b59a4949692dfe9fbd66e1ca0"

URI_aarch64_python3-gunicorn+setproctitle = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gunicorn+setproctitle-23.0.0-1.el10_1.noarch.rpm;name=aarch64_python3-gunicorn+setproctitle;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gunicorn+setproctitle}"
SRC_URI[aarch64_python3-gunicorn+setproctitle.sha256sum] = "1b06b044f2d0f28798fbdc01e285aa7641f9474a839cef8c164919498c088ef4"

RDEPENDS:python-gunicorn-doc = " \
 "
RDEPENDS:python3-gunicorn = " \
 python3 \
 python3-packaging \
 "
RDEPENDS:python3-gunicorn+gevent = " \
 python3 \
 python3-gevent \
 python3-gunicorn \
 "
RDEPENDS:python3-gunicorn+setproctitle = " \
 python3 \
 python3-gunicorn \
 python3-setproctitle \
 "
