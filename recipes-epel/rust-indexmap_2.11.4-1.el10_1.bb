# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indexmap"
PV = "2.11.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-indexmap+arbitrary-devel \
 rust-indexmap+default-devel \
 rust-indexmap+quickcheck-devel \
 rust-indexmap+rayon-devel \
 rust-indexmap+serde-devel \
 rust-indexmap+std-devel \
 rust-indexmap+test_debug-devel \
 rust-indexmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indexmap-2.11.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec57d9d4f085b50efe24f6250890e05d04857d8e6f9185724bb18494720e93e2"

URI_x86_64_v2_rust-indexmap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+arbitrary-devel-2.11.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-indexmap+arbitrary-devel.sha256sum] = "bc0bb72948bff1967e694c9d0993a077d7481a93df42faca38c067eadbdded22"

URI_x86_64_v2_rust-indexmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+default-devel-2.11.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+default-devel}"
SRC_URI[x86_64_v2_rust-indexmap+default-devel.sha256sum] = "ea3fd09ccc76cc3d34aa9b116239833347dfa3b6de2753c8b3980fac6f5a44d6"
RPROVIDES:rust-indexmap+default-devel:append:x86_64_v2 = " virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_x86_64_v2_rust-indexmap+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+quickcheck-devel-2.11.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-indexmap+quickcheck-devel.sha256sum] = "0b8d2856b1327011b7b2768ca57068893ef12d841668857633c611fb94323850"

URI_x86_64_v2_rust-indexmap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+rayon-devel-2.11.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+rayon-devel}"
SRC_URI[x86_64_v2_rust-indexmap+rayon-devel.sha256sum] = "ab778beb3cec567a0a364df543c0abf0d382796f34395edf65c7dc1e8835d1ee"

URI_x86_64_v2_rust-indexmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+serde-devel-2.11.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+serde-devel}"
SRC_URI[x86_64_v2_rust-indexmap+serde-devel.sha256sum] = "082f230f04024acb42f1d059d696c6da063ab799fd0579f9f120fd222be41b37"

URI_x86_64_v2_rust-indexmap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+std-devel-2.11.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+std-devel}"
SRC_URI[x86_64_v2_rust-indexmap+std-devel.sha256sum] = "2e012387660249335b8da0883abf9d696565428206a89e348d521861e3324756"

URI_x86_64_v2_rust-indexmap+test_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap+test_debug-devel-2.11.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap+test_debug-devel}"
SRC_URI[x86_64_v2_rust-indexmap+test_debug-devel.sha256sum] = "ab5f688619300a5d75ff53ff0173e52930d8bc6966c358012ec79cd9cb7a685b"

URI_x86_64_v2_rust-indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indexmap-devel-2.11.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indexmap-devel}"
SRC_URI[x86_64_v2_rust-indexmap-devel.sha256sum] = "ce15e98d210835bbe7fe6a42f189dde0302c921b0140b91a000cbdc2428ffac6"

URI_aarch64_rust-indexmap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+arbitrary-devel-2.11.4-1.el10_1.noarch.rpm;name=aarch64_rust-indexmap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+arbitrary-devel}"
SRC_URI[aarch64_rust-indexmap+arbitrary-devel.sha256sum] = "d206ebac35bcc4ba13754f66ccdf8084093afcc25676b0a9b92f337adb6ee6e1"

URI_aarch64_rust-indexmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+default-devel-2.11.4-1.el10_1.noarch.rpm;name=aarch64_rust-indexmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+default-devel}"
SRC_URI[aarch64_rust-indexmap+default-devel.sha256sum] = "25a7d99e336ee520d8f26e778491caf571e33e5ad7d157a3d6ef2b7a0fe925a7"
RPROVIDES:rust-indexmap+default-devel:append:aarch64 = " virtual/crate_indexmap/default__ge_1.6.0_with_crate_indexmap/default__lt_3.0.0~"

URI_aarch64_rust-indexmap+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+quickcheck-devel-2.11.4-1.el10_1.noarch.rpm;name=aarch64_rust-indexmap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+quickcheck-devel}"
SRC_URI[aarch64_rust-indexmap+quickcheck-devel.sha256sum] = "462b6903c119fe88a1d89bb08e4c9c59561d677f435626b33a656d7cfb413039"

URI_aarch64_rust-indexmap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+rayon-devel-2.11.4-1.el10_1.noarch.rpm;name=aarch64_rust-indexmap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+rayon-devel}"
SRC_URI[aarch64_rust-indexmap+rayon-devel.sha256sum] = "031e3b25aa192091f00ca3fdbe99b8673ca4e92fb6cf01216478237ba828de27"

URI_aarch64_rust-indexmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+serde-devel-2.11.4-1.el10_1.noarch.rpm;name=aarch64_rust-indexmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+serde-devel}"
SRC_URI[aarch64_rust-indexmap+serde-devel.sha256sum] = "9167543722e9a0408ae9f14154a47d76a609ac64df25b215e288ffbfb212c41f"

URI_aarch64_rust-indexmap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+std-devel-2.11.4-1.el10_1.noarch.rpm;name=aarch64_rust-indexmap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+std-devel}"
SRC_URI[aarch64_rust-indexmap+std-devel.sha256sum] = "3891186041d8aef29ed18e19417e7e4516ea196ae7f571e07555f43dfa4f2075"

URI_aarch64_rust-indexmap+test_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap+test_debug-devel-2.11.4-1.el10_1.noarch.rpm;name=aarch64_rust-indexmap+test_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap+test_debug-devel}"
SRC_URI[aarch64_rust-indexmap+test_debug-devel.sha256sum] = "f5692f876c67dcf62479b91b64c14f931ae9fa4870b1a4e3dbeeb521b5dfaaa9"

URI_aarch64_rust-indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indexmap-devel-2.11.4-1.el10_1.noarch.rpm;name=aarch64_rust-indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indexmap-devel}"
SRC_URI[aarch64_rust-indexmap-devel.sha256sum] = "fbfa07c71a1e1d4a06dee7b042846be7c8493461bcb7fde2ea1e47c19b9285a0"

RDEPENDS:rust-indexmap+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+default-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+quickcheck-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-indexmap+rayon-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indexmap+serde-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-indexmap+std-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap+test_debug-devel = " \
 cargo \
 rust-indexmap-devel \
 "
RDEPENDS:rust-indexmap-devel = " \
 cargo \
 rust \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "
