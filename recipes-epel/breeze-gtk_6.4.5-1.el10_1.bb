# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "breeze-gtk"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 breeze-gtk \
 breeze-gtk-common \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/breeze-gtk-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "172952d9aeaa55768084cf634f77a697f011b50b8f362cf2d720de58d4e7c29d"

URI_x86_64_v2_breeze-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk}"
SRC_URI[x86_64_v2_breeze-gtk.sha256sum] = "10e2683469e83e60a94926ddcda034924dedb84f715d108618f4a18b41784b58"

URI_x86_64_v2_breeze-gtk-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-common-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-common}"
SRC_URI[x86_64_v2_breeze-gtk-common.sha256sum] = "33c9399faaeceac65b48acd8eba3574b45515e951827abcda0712d7f1c9d0f0d"

URI_x86_64_v2_breeze-gtk-gtk2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk2-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk2}"
SRC_URI[x86_64_v2_breeze-gtk-gtk2.sha256sum] = "465549107e4c46eef963b5f12e9ae20dd263a3535923fb1a5c8c263175a7763f"

URI_x86_64_v2_breeze-gtk-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk3-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk3}"
SRC_URI[x86_64_v2_breeze-gtk-gtk3.sha256sum] = "dddb9dc087d0f613866d2357ad84aacb1b2b7afda2ed6e64e23f194472979b9f"

URI_x86_64_v2_breeze-gtk-gtk4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk4-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk4}"
SRC_URI[x86_64_v2_breeze-gtk-gtk4.sha256sum] = "6406b52b541bc3b39312995238ccf5d19994f285b93a31ae54991c824b18e587"

URI_aarch64_breeze-gtk = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-6.4.5-1.el10_1.noarch.rpm;name=aarch64_breeze-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk}"
SRC_URI[aarch64_breeze-gtk.sha256sum] = "760cb1788e3ca325e7c6d234c3d4c7fe2ad5e3098d92b370a86b95f3aa434e2a"

URI_aarch64_breeze-gtk-common = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-common-6.4.5-1.el10_1.noarch.rpm;name=aarch64_breeze-gtk-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-common}"
SRC_URI[aarch64_breeze-gtk-common.sha256sum] = "0cb07f06bd6d2fa1260dbc28dfc2c3c4d90949e361c48547f1328caaa70adb35"

URI_aarch64_breeze-gtk-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk2-6.4.5-1.el10_1.noarch.rpm;name=aarch64_breeze-gtk-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk2}"
SRC_URI[aarch64_breeze-gtk-gtk2.sha256sum] = "8b605eb8ced2bbfe065bbad01ee109c0a692c2ef8e9a3ab769ee669aef0cc0f9"

URI_aarch64_breeze-gtk-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk3-6.4.5-1.el10_1.noarch.rpm;name=aarch64_breeze-gtk-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk3}"
SRC_URI[aarch64_breeze-gtk-gtk3.sha256sum] = "a74e9fb07b1704d143681ddee349f1d8745c34992238080c955c24e801f8ba60"

URI_aarch64_breeze-gtk-gtk4 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk4-6.4.5-1.el10_1.noarch.rpm;name=aarch64_breeze-gtk-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk4}"
SRC_URI[aarch64_breeze-gtk-gtk4.sha256sum] = "d4c0a7490389b81b6028f16913d7769cbca1088ca9d855ea1a0d1a42762611a0"

RDEPENDS:breeze-gtk = " \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "
RDEPENDS:breeze-gtk-common = " \
 "
RDEPENDS:breeze-gtk-gtk2 = " \
 breeze-gtk-common \
 gtk2-engines \
 "
RDEPENDS:breeze-gtk-gtk3 = " \
 breeze-gtk-common \
 "
RDEPENDS:breeze-gtk-gtk4 = " \
 breeze-gtk-common \
 "
