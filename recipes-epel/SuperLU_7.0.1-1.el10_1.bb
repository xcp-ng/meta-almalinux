# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "SuperLU"
PV = "7.0.1"
PR = "1.el10_1"
PACKAGES = " \
 SuperLU \
 SuperLU-devel \
 SuperLU-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/SuperLU-7.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de109ec66dfe9e67196a9ebf2076cac1b61dd2537fea013213c1085378187408"

URI_x86_64_v2_SuperLU = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLU-7.0.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLU;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLU}"
SRC_URI[x86_64_v2_SuperLU.sha256sum] = "eafb0b71c81ecf561f98c02620eb7d85593e8a1533457b11c7e88d68fe106639"

URI_x86_64_v2_SuperLU-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLU-devel-7.0.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_SuperLU-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLU-devel}"
SRC_URI[x86_64_v2_SuperLU-devel.sha256sum] = "0278866671a6840fec28c0e63fa5bcac748ff2e23092db4ba51a39f836c3e045"

URI_x86_64_v2_SuperLU-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/SuperLU-doc-7.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_SuperLU-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_SuperLU-doc}"
SRC_URI[x86_64_v2_SuperLU-doc.sha256sum] = "6a4442b2fd0c5835cfdf66d33f0eaef3230787426ebab1398a675590f0a5c96b"

URI_aarch64_SuperLU = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLU-7.0.1-1.el10_1.aarch64.rpm;name=aarch64_SuperLU;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLU}"
SRC_URI[aarch64_SuperLU.sha256sum] = "eb4104bbc1eb35978617bd53eb5e0a1d6a261936080c492f24eb1530997d77c9"

URI_aarch64_SuperLU-devel = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLU-devel-7.0.1-1.el10_1.aarch64.rpm;name=aarch64_SuperLU-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLU-devel}"
SRC_URI[aarch64_SuperLU-devel.sha256sum] = "36766c53ccb7262291afb5f8645bf8b95f6ccf42d140426d6fc9e77ee6120ce6"

URI_aarch64_SuperLU-doc = "${EPEL_MIRROR}/aarch64/Packages/s/SuperLU-doc-7.0.1-1.el10_1.noarch.rpm;name=aarch64_SuperLU-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_SuperLU-doc}"
SRC_URI[aarch64_SuperLU-doc.sha256sum] = "d1396d0fa5f29618bbe37770017ba916dafadf3fc10e36066257b2d228d1fd71"

RDEPENDS:SuperLU = " \
 flexiblas-netlib \
 glibc \
 metis \
 "
RDEPENDS:SuperLU-devel = " \
 SuperLU \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:SuperLU-doc = " \
 "
