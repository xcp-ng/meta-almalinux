# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kidentitymanagement"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kidentitymanagement \
 kidentitymanagement-devel \
 kidentitymanagement-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kidentitymanagement-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffa6844d25af682433216e891b6e60268451cb05432905cd6b67f1223a5af8aa"

URI_x86_64_v2_kidentitymanagement = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kidentitymanagement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kidentitymanagement}"
SRC_URI[x86_64_v2_kidentitymanagement.sha256sum] = "4f8a76cc73d3d305178412d837789aa21d9a77a12ca1de4d761400f4a758117d"

URI_x86_64_v2_kidentitymanagement-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kidentitymanagement-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kidentitymanagement-devel}"
SRC_URI[x86_64_v2_kidentitymanagement-devel.sha256sum] = "490c50ae4a892366305761defe086a17457f7d3b7fef22dce58aefcebf1b9ee5"

URI_x86_64_v2_kidentitymanagement-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kidentitymanagement-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kidentitymanagement-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kidentitymanagement-doc}"
SRC_URI[x86_64_v2_kidentitymanagement-doc.sha256sum] = "d101d54a0ae810395c06d9e05c33ecf6f87f517e9d0ffe79d7251ede32d939ff"

URI_aarch64_kidentitymanagement = "${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kidentitymanagement;unpack=0"
SRC_URI:append = " ${URI_aarch64_kidentitymanagement}"
SRC_URI[aarch64_kidentitymanagement.sha256sum] = "c3dd3a053504fdc808f84c7e5f78f8a0a6ff22f63c99bc4c4144b8bef44a0769"

URI_aarch64_kidentitymanagement-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kidentitymanagement-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kidentitymanagement-devel}"
SRC_URI[aarch64_kidentitymanagement-devel.sha256sum] = "0a2da737cd9186fed1da182009e09748d3d3c3d13f045c2551dfdb4d78878def"

URI_aarch64_kidentitymanagement-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kidentitymanagement-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kidentitymanagement-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kidentitymanagement-doc}"
SRC_URI[aarch64_kidentitymanagement-doc.sha256sum] = "7c71818ae03d36eb28893022fede604f144207414536285a58c85bd889a56efb"

RDEPENDS:kidentitymanagement = " \
 glibc \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kpimtextedit \
 ktextaddons-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kidentitymanagement-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kidentitymanagement \
 kpimtextedit-devel \
 "
RDEPENDS:kidentitymanagement-doc = " \
 "
