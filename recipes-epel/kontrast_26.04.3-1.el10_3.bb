# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kontrast"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kontrast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kontrast-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6186c4e792626969e60d7b33c32250f0173f08a94926e64b11dbf760882fe668"

URI_x86_64_v2_kontrast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kontrast-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kontrast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kontrast}"
SRC_URI[x86_64_v2_kontrast.sha256sum] = "d3823f4fd578db6df8d4ffeae1da91509e475ecd4c6513adc16b5a70e7796a01"

URI_aarch64_kontrast = "${EPEL_MIRROR}/aarch64/Packages/k/kontrast-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kontrast;unpack=0"
SRC_URI:append = " ${URI_aarch64_kontrast}"
SRC_URI[aarch64_kontrast.sha256sum] = "96a96523023a0561e4d7f2cfc872e78b37e3fc7ac3ac29797a06d3ae0ad34860"

RDEPENDS:kontrast = " \
 futuresql-qt6 \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
