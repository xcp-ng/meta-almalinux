# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "epel-rpm-macros"
PV = "10"
PR = "7.el10_1"
PACKAGES = " \
 epel-rpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/epel-rpm-macros-10-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e03fad8f654f8d721debab7f3cca124243afb8c56ae2eebd1d50af8081fe12cf"

URI_x86_64_v2_epel-rpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/epel-rpm-macros-10-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_epel-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_epel-rpm-macros}"
SRC_URI[x86_64_v2_epel-rpm-macros.sha256sum] = "5632971a6f191f75c0aceecc46634f93a0de51acad5f861f56abf4fded24d34c"

URI_aarch64_epel-rpm-macros = "${EPEL_MIRROR}/aarch64/Packages/e/epel-rpm-macros-10-7.el10_1.noarch.rpm;name=aarch64_epel-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_epel-rpm-macros}"
SRC_URI[aarch64_epel-rpm-macros.sha256sum] = "d50bc44418f4535205bd9c3818f7ced26fe1435fb5fec191aee09f8db8366ea5"

RDEPENDS:epel-rpm-macros = " \
 R-srpm-macros \
 almalinux-release \
 ansible-srpm-macros \
 fpc-srpm-macros \
 ghc-srpm-macros \
 "
