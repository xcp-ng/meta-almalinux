# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shdoc"
PV = "1.4"
PR = "1.el10_2"
PACKAGES = " \
 shdoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/shdoc-1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af5efe95e5754bcec386a03b49dd45ffa283af0f70ac0b6f2e758bc0da95f1b6"

URI_x86_64_v2_shdoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shdoc-1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_shdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shdoc}"
SRC_URI[x86_64_v2_shdoc.sha256sum] = "e6c8aab1b6114c6859ed1aad1625739a2ca79784957429cf0919049b30ab2df3"

URI_aarch64_shdoc = "${EPEL_MIRROR}/aarch64/Packages/s/shdoc-1.4-1.el10_2.noarch.rpm;name=aarch64_shdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_shdoc}"
SRC_URI[aarch64_shdoc.sha256sum] = "5d84a517e5ed4901a99b8af02d32132faa067bee2ffb9bef307005419a5f0af0"

RDEPENDS:shdoc = " \
 gawk \
 vim-filesystem \
 "
