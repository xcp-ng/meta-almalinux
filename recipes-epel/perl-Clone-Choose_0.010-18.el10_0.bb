# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Clone-Choose"
PV = "0.010"
PR = "18.el10_0"
PACKAGES = " \
 perl-Clone-Choose \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Clone-Choose-0.010-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6425638b358e7466fa2fd57c609a93911e867b442371723b304fa0da1a59dc6"

URI_x86_64_v2_perl-Clone-Choose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Clone-Choose-0.010-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Clone-Choose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Clone-Choose}"
SRC_URI[x86_64_v2_perl-Clone-Choose.sha256sum] = "0c57d3e37ff16e0ad33904149ced7842cd95b81de5487ec3f4e29de71fc12a4e"

URI_aarch64_perl-Clone-Choose = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Clone-Choose-0.010-18.el10_0.noarch.rpm;name=aarch64_perl-Clone-Choose;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Clone-Choose}"
SRC_URI[aarch64_perl-Clone-Choose.sha256sum] = "765a364510443dedb80a343bf9baff8af4981a54a863a3b8656f81dafb8d0dcc"

RDEPENDS:perl-Clone-Choose = " \
 perl-Carp \
 perl-Storable \
 perl-libs \
 "
