# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-distroinfo"
PV = "0.6.3"
PR = "7.el10_3"
PACKAGES = " \
 python3-distroinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-distroinfo-0.6.3-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "116e8c9ad2d8114b65dc90f70f65bf80ab6774d7499265fd6a23108e95924d46"

URI_x86_64_v2_python3-distroinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-distroinfo-0.6.3-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-distroinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-distroinfo}"
SRC_URI[x86_64_v2_python3-distroinfo.sha256sum] = "3ca94a7e33e267aa8957edfd13945b0abeaa5f893f6eb3907c4962983b74a540"

URI_aarch64_python3-distroinfo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-distroinfo-0.6.3-7.el10_3.noarch.rpm;name=aarch64_python3-distroinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-distroinfo}"
SRC_URI[aarch64_python3-distroinfo.sha256sum] = "4030af40cf258073251365525e54e5797b69146717f7db574551a16057394c5a"

RDEPENDS:python3-distroinfo = " \
 git-core \
 python3 \
 python3-pbr \
 python3-pyyaml \
 python3-requests \
 python3-six \
 "
