# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-owo-colors3"
PV = "3.5.0"
PR = "3.el10_0"
PACKAGES = " \
 rust-owo-colors3+alloc-devel \
 rust-owo-colors3+default-devel \
 rust-owo-colors3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-owo-colors3-3.5.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11868f58ad62656bd785e39cb233b5937082af556ccf40def61e621b6ea58b9a"

URI_x86_64_v2_rust-owo-colors3+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors3+alloc-devel-3.5.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors3+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors3+alloc-devel}"
SRC_URI[x86_64_v2_rust-owo-colors3+alloc-devel.sha256sum] = "22f97cc1c11e9aa8a5f686722d0c81525b9de746d851f349ee26b7a54cf3acf2"

URI_x86_64_v2_rust-owo-colors3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors3+default-devel-3.5.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors3+default-devel}"
SRC_URI[x86_64_v2_rust-owo-colors3+default-devel.sha256sum] = "a5485bd36d9679f3824553b7af98e9601fe5d0a52e4b7dd9725f69a8038f5352"

URI_x86_64_v2_rust-owo-colors3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors3-devel-3.5.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-owo-colors3-devel}"
SRC_URI[x86_64_v2_rust-owo-colors3-devel.sha256sum] = "8db861570943dd3bc30b6d90ec197d1d534684667e3822be409a2ef141213356"
RPROVIDES:rust-owo-colors3-devel:append:x86_64_v2 = " virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

URI_aarch64_rust-owo-colors3+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors3+alloc-devel-3.5.0-3.el10_0.noarch.rpm;name=aarch64_rust-owo-colors3+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors3+alloc-devel}"
SRC_URI[aarch64_rust-owo-colors3+alloc-devel.sha256sum] = "d78a88daff73455a155a85cc29aa1dcabcaf08941e48214e8586aafd6596c065"

URI_aarch64_rust-owo-colors3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors3+default-devel-3.5.0-3.el10_0.noarch.rpm;name=aarch64_rust-owo-colors3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors3+default-devel}"
SRC_URI[aarch64_rust-owo-colors3+default-devel.sha256sum] = "fa0b44bf19645b45cba0e30aa9c71fb6ff5f7ca5b15f69bfe03967916406de13"

URI_aarch64_rust-owo-colors3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors3-devel-3.5.0-3.el10_0.noarch.rpm;name=aarch64_rust-owo-colors3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-owo-colors3-devel}"
SRC_URI[aarch64_rust-owo-colors3-devel.sha256sum] = "7c05ad2a98f8169c8ec3498f4b81e897a5f2669d421dfff5461748ac116314c7"
RPROVIDES:rust-owo-colors3-devel:append:aarch64 = " virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

RDEPENDS:rust-owo-colors3+alloc-devel = " \
 cargo \
 rust-owo-colors3-devel \
 "
RDEPENDS:rust-owo-colors3+default-devel = " \
 cargo \
 rust-owo-colors3-devel \
 "
RDEPENDS:rust-owo-colors3-devel = " \
 cargo \
 rust \
 "
