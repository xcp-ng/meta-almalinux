# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squidclamav"
PV = "7.5"
PR = "1.el10_2"
PACKAGES = " \
 squidclamav \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/squidclamav-7.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9722673ffb739842ae7b44c4555abf9129b507fce9bfb692ef47106392d44836"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/squidclamav-7.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_squidclamav;unpack=0"
SRC_URI[x86_64_v2_squidclamav.sha256sum] = "b39cfd9fd342bbb3d35dea061e2e67fcd1f9035a0a278956a8ea1255990b3041"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/squidclamav-7.5-1.el10_2.aarch64.rpm;name=aarch64_squidclamav;unpack=0"
SRC_URI[aarch64_squidclamav.sha256sum] = "228493f8af1f553564f0c5a887a3d70fb1da7a375194c41d9fbd395b6fed3c87"

RDEPENDS:squidclamav = " \
 bzip2-libs \
 c-icap \
 glibc \
 httpd-filesystem \
 libarchive \
 perl-interpreter \
 squid \
 zlib-ng-compat \
 "
