# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-io"
PV = "0.3.32"
PR = "1.el10_2"
PACKAGES = " \
 rust-futures-io+default-devel \
 rust-futures-io+std-devel \
 rust-futures-io+unstable-devel \
 rust-futures-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-io-0.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9f2a12bc7766e69d678be9da59a696841eb2a50faa8c1506cd10dce74402420"

URI_x86_64_v2_rust-futures-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+default-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io+default-devel}"
SRC_URI[x86_64_v2_rust-futures-io+default-devel.sha256sum] = "8a1c34dc843de570f9470bced624b41e95bf1c569c8da1ec918cb95ebabdba62"

URI_x86_64_v2_rust-futures-io+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+std-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io+std-devel}"
SRC_URI[x86_64_v2_rust-futures-io+std-devel.sha256sum] = "7fe063de574b2b117115c48dfb82b97d50c5c48fe5a863c766cb37179f57bfc5"

URI_x86_64_v2_rust-futures-io+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io+unstable-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-io+unstable-devel.sha256sum] = "3bb28c064e9563e9d5ca699b343b6ada22bce99f3b679b0116350fc96cba3d30"

URI_x86_64_v2_rust-futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-io-devel-0.3.32-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-io-devel}"
SRC_URI[x86_64_v2_rust-futures-io-devel.sha256sum] = "ec4f3c7d49c78934c19e8a5fb3baa45df79b987e020c7fb1bba5cc895aa463ef"

URI_aarch64_rust-futures-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+default-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io+default-devel}"
SRC_URI[aarch64_rust-futures-io+default-devel.sha256sum] = "fb57d49d56d53574ed8645c3b28e132e62f35c1e4579b1efa72bd0e0874830db"

URI_aarch64_rust-futures-io+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+std-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io+std-devel}"
SRC_URI[aarch64_rust-futures-io+std-devel.sha256sum] = "5526ddeab8b2a1f52bf72265549d8cbe306c75424cde0fa71656e17685bb80b1"

URI_aarch64_rust-futures-io+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io+unstable-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-io+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io+unstable-devel}"
SRC_URI[aarch64_rust-futures-io+unstable-devel.sha256sum] = "19c257b2fa2865e4863196c4140e0593b2e298fc92cc979cb900e79367938abc"

URI_aarch64_rust-futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-io-devel-0.3.32-1.el10_2.noarch.rpm;name=aarch64_rust-futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-io-devel}"
SRC_URI[aarch64_rust-futures-io-devel.sha256sum] = "9432c7faf819d58168b6d7c1d7774e1256e448806be4264f6209f709d1be494b"

RDEPENDS:rust-futures-io+default-devel = " \
 cargo \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io+std-devel = " \
 cargo \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io+unstable-devel = " \
 cargo \
 rust-futures-io-devel \
 "
RDEPENDS:rust-futures-io-devel = " \
 cargo \
 rust \
 "
