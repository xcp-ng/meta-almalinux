# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-attributes"
PV = "1.1.2"
PR = "10.el10_0"
PACKAGES = " \
 rust-async-attributes+default-devel \
 rust-async-attributes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-attributes-1.1.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4dc1c1a25b58356f8c586533bac06ddf0c7e173eb2784494f67a80df913e7872"

URI_x86_64_v2_rust-async-attributes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-attributes+default-devel-1.1.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-attributes+default-devel}"
SRC_URI[x86_64_v2_rust-async-attributes+default-devel.sha256sum] = "9e90b40403518eb98623d335dc8e25720b4b585707a99d9fecdebc2ea4902263"

URI_x86_64_v2_rust-async-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-attributes-devel-1.1.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-attributes-devel}"
SRC_URI[x86_64_v2_rust-async-attributes-devel.sha256sum] = "c75eab1873ed7e3994c95ae4579a24b4f2431cec00b8e0932e10417f01da9680"

URI_aarch64_rust-async-attributes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-attributes+default-devel-1.1.2-10.el10_0.noarch.rpm;name=aarch64_rust-async-attributes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-attributes+default-devel}"
SRC_URI[aarch64_rust-async-attributes+default-devel.sha256sum] = "b62377fea9a3c0ee5ede9cc0ec3dfc075a68f4a1cd1d35de764750515f94da78"

URI_aarch64_rust-async-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-attributes-devel-1.1.2-10.el10_0.noarch.rpm;name=aarch64_rust-async-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-attributes-devel}"
SRC_URI[aarch64_rust-async-attributes-devel.sha256sum] = "e347280e2b8bcedbd082f985c0d36770871f076e5c1a0d2cffb69f7d8c4df225"

RDEPENDS:rust-async-attributes+default-devel = " \
 cargo \
 rust-async-attributes-devel \
 "
RDEPENDS:rust-async-attributes-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 rust-syn1+full-devel \
 "
