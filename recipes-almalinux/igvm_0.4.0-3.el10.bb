# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "igvm"
PV = "0.4.0"
PR = "3.el10"
PACKAGES = " \
 igvm-devel \
 igvm-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/igvm-0.4.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8b8aa2419bea21722ebd1876fee45bfdf18580178aacd1f28049d29bc7b265f"

URI_x86_64_v2_igvm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/igvm-devel-0.4.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_igvm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_igvm-devel}"
SRC_URI[x86_64_v2_igvm-devel.sha256sum] = "a153639503289b921cfc5edddc24bb94e6c1ef57183061f22a791cb8573bb2e4"

URI_x86_64_v2_igvm-libs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/igvm-libs-0.4.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_igvm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_igvm-libs}"
SRC_URI[x86_64_v2_igvm-libs.sha256sum] = "c697fcbc0495584bc6cc30a68d3ebe1c23a5bb9a493d8a1c0388538a7fd0d986"

URI_aarch64_igvm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/igvm-devel-0.4.0-3.el10.aarch64.rpm;name=aarch64_igvm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_igvm-devel}"
SRC_URI[aarch64_igvm-devel.sha256sum] = "3c93d63edf624f5e7fc4659dd9cb1d4a192a60336778183993b707537a09d5ae"

URI_aarch64_igvm-libs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/igvm-libs-0.4.0-3.el10.aarch64.rpm;name=aarch64_igvm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_igvm-libs}"
SRC_URI[aarch64_igvm-libs.sha256sum] = "1787c038919aa78e1ef0529fcc98172d0c720c712ade87af8b3436dc2e28c633"

RDEPENDS:igvm-devel = " \
 igvm-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:igvm-libs = " \
 glibc \
 libgcc \
 "
