# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libloading"
PV = "0.8.9"
PR = "1.el10_0"
PACKAGES = " \
 rust-libloading+default-devel \
 rust-libloading-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libloading-0.8.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "19ee69a64752f0b8b384dea4d42f5388dfbc10c26d47f978b1a433d88f45a770"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libloading+default-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libloading+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libloading+default-devel.sha256sum] = "90b37af88b0e8a878e05b537187bbb41bd63c46b435f17daafce4c7c3ba9f1c5"
RPROVIDES:rust-libloading+default-devel:append:x86_64_v2 = " virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libloading-devel-0.8.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libloading-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libloading-devel.sha256sum] = "0f39e314aaab66a2a57a6bc20b485eb91377d86c927c3a8da4be3410d9f0426d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libloading+default-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-libloading+default-devel;unpack=0"
SRC_URI[aarch64_rust-libloading+default-devel.sha256sum] = "b02c8b86e580158e6f4abb11ccd0351f97e52df7afcc5674ce194a2d95d5538f"
RPROVIDES:rust-libloading+default-devel:append:aarch64 = " virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libloading-devel-0.8.9-1.el10_0.noarch.rpm;name=aarch64_rust-libloading-devel;unpack=0"
SRC_URI[aarch64_rust-libloading-devel.sha256sum] = "30f1a2e40154163e14e3bdf5d873bb105ba7725317db41510165225cb7b4685f"

RDEPENDS:rust-libloading+default-devel = " \
 cargo \
 rust-libloading-devel \
 "
RDEPENDS:rust-libloading-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
