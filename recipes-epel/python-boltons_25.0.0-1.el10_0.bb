# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-boltons"
PV = "25.0.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-boltons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-boltons-25.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d569db0e170cdab7d678fba805f34942be3742749079940a6a933bf683c2e4c1"

URI_x86_64_v2_python3-boltons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-boltons-25.0.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-boltons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-boltons}"
SRC_URI[x86_64_v2_python3-boltons.sha256sum] = "1d43865e3ac26a16acb40429ad2bccabf1dea749b5e33a2977b0550d7669c036"

URI_aarch64_python3-boltons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-boltons-25.0.0-1.el10_0.noarch.rpm;name=aarch64_python3-boltons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-boltons}"
SRC_URI[aarch64_python3-boltons.sha256sum] = "9d3f37f23cc98078920f98bfaed571724524849b635411d6b92b76c4d7cc9279"

RDEPENDS:python3-boltons = " \
 python3 \
 "
