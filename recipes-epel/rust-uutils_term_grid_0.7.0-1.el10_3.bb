# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uutils_term_grid"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uutils_term_grid+default-devel \
 rust-uutils_term_grid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uutils_term_grid-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edfe58048f01215318cbc7796cb2f112297a46e341edb272a7544a3acb124039"

URI_x86_64_v2_rust-uutils_term_grid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uutils_term_grid+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uutils_term_grid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uutils_term_grid+default-devel}"
SRC_URI[x86_64_v2_rust-uutils_term_grid+default-devel.sha256sum] = "16e4f6a8f146b03d50808a320bebd5015b6ce9794c2cc93ff8ba896fc0af6ff1"

URI_x86_64_v2_rust-uutils_term_grid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uutils_term_grid-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uutils_term_grid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uutils_term_grid-devel}"
SRC_URI[x86_64_v2_rust-uutils_term_grid-devel.sha256sum] = "ac735e607bd12b67e1e790ce4cb7dd52c71fc48b13666e1aa19e88cb77ea89ea"

URI_aarch64_rust-uutils_term_grid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uutils_term_grid+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uutils_term_grid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uutils_term_grid+default-devel}"
SRC_URI[aarch64_rust-uutils_term_grid+default-devel.sha256sum] = "201153bd91d4998fe8ca6663d3c554be87576a3172c33d60a7df9f72186cc964"

URI_aarch64_rust-uutils_term_grid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uutils_term_grid-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uutils_term_grid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uutils_term_grid-devel}"
SRC_URI[aarch64_rust-uutils_term_grid-devel.sha256sum] = "8308d9c45c20b62130549d60c293aa648b91579b37d6682ea6a63a288f7d5249"

RDEPENDS:rust-uutils_term_grid+default-devel = " \
 cargo \
 rust-uutils_term_grid-devel \
 "
RDEPENDS:rust-uutils_term_grid-devel = " \
 cargo \
 rust \
 rust-ansi-width+default-devel \
 "
