# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kfilemetadata"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kfilemetadata \
 kf6-kfilemetadata-devel \
 kf6-kfilemetadata-doc \
 kf6-kfilemetadata-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kfilemetadata-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a41c4a00f0f8ef4f28fcbcdcf58b9ba405da9a2f11701ec5d36a92d0dfc5f0e"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - kf6-kfilemetadata: libavcodec.so.61()(64bit)
# - kf6-kfilemetadata: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - kf6-kfilemetadata: libavformat.so.61()(64bit)
# - kf6-kfilemetadata: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - kf6-kfilemetadata: libavutil.so.59()(64bit)
# - kf6-kfilemetadata: libavutil.so.59(LIBAVUTIL_59)(64bit)

URI_x86_64_v2_kf6-kfilemetadata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata}"
SRC_URI[x86_64_v2_kf6-kfilemetadata.sha256sum] = "fcd4b3f76b937f54ad490c4cac585b1a281bc0ef9187d4db9d0b7588d7751070"

URI_x86_64_v2_kf6-kfilemetadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kfilemetadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-devel}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-devel.sha256sum] = "954262be17886106e083794dad3830e679e51880b7332e4f596d18b6034575b8"

URI_x86_64_v2_kf6-kfilemetadata-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kfilemetadata-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-doc}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-doc.sha256sum] = "1cf67c4d75d89f28701af14abd27840632dba5a56520fd85bf3be3e32c7e9ed1"

URI_x86_64_v2_kf6-kfilemetadata-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kfilemetadata-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kfilemetadata-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kfilemetadata-html}"
SRC_URI[x86_64_v2_kf6-kfilemetadata-html.sha256sum] = "6cf7e245ee452830af3f55bda7fba12eb3888f6c2e16ca4ff6ea876fa57ee92e"

URI_aarch64_kf6-kfilemetadata = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kfilemetadata;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata}"
SRC_URI[aarch64_kf6-kfilemetadata.sha256sum] = "7ff33aaed64d4f65b502a49cc953c7f8033d76b1c9394cc67ccea78f2e5ef213"

URI_aarch64_kf6-kfilemetadata-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kfilemetadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-devel}"
SRC_URI[aarch64_kf6-kfilemetadata-devel.sha256sum] = "ad2d4c929bdc0a82a09e58ec110dbfbcb672a4f4ae3b02bb0d2c11a7047004a6"

URI_aarch64_kf6-kfilemetadata-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kfilemetadata-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-doc}"
SRC_URI[aarch64_kf6-kfilemetadata-doc.sha256sum] = "ed045cab5c74d6d66c128992d7c1edf1657d49350f5c581f5aae85b0d7d77694"

URI_aarch64_kf6-kfilemetadata-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kfilemetadata-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kfilemetadata-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kfilemetadata-html}"
SRC_URI[aarch64_kf6-kfilemetadata-html.sha256sum] = "a5a54ead5062013b1f0b4563507862dfd1b6bee25e9950e0ebf8f173bb2e5813"

RDEPENDS:kf6-kfilemetadata:x86_64_v2 = " \
 ebook-tools-libs \
 exiv2-libs \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 taglib \
"
RDEPENDS:kf6-kfilemetadata:aarch64 = " \
 ebook-tools-libs \
 exiv2-libs \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcoreaddons \
 kf6-ki18n \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libstdc++ \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 taglib \
"
RDEPENDS:kf6-kfilemetadata-devel = " \
 cmake-filesystem \
 kf6-kfilemetadata \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kfilemetadata-doc = " \
 "
RDEPENDS:kf6-kfilemetadata-html = " \
 "
