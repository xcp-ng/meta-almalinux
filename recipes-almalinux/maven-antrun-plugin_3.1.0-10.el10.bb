# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-antrun-plugin"
PV = "3.1.0"
PR = "10.el10"
PACKAGES = " \
 maven-antrun-plugin \
 maven-antrun-plugin-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-antrun-plugin-3.1.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bd39c8a4150e7ceba8a6057d0d43db3f5f50cd136ac60f262d19d26a17f391c"

URI_x86_64_v2_maven-antrun-plugin = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-antrun-plugin-3.1.0-10.el10.noarch.rpm;name=x86_64_v2_maven-antrun-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-antrun-plugin}"
SRC_URI[x86_64_v2_maven-antrun-plugin.sha256sum] = "297b94aa8ef1b5d2baaf8c920d5f424377efbae80ac3b8cc160f8cc494d5b111"

URI_x86_64_v2_maven-antrun-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-antrun-plugin-javadoc-3.1.0-10.el10.noarch.rpm;name=x86_64_v2_maven-antrun-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-antrun-plugin-javadoc}"
SRC_URI[x86_64_v2_maven-antrun-plugin-javadoc.sha256sum] = "a01a6eb5a5994cddf5cd05fa1d70910a12789739ba47c8d40d735c6b67a9c69c"

URI_aarch64_maven-antrun-plugin = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-antrun-plugin-3.1.0-10.el10.noarch.rpm;name=aarch64_maven-antrun-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-antrun-plugin}"
SRC_URI[aarch64_maven-antrun-plugin.sha256sum] = "297b94aa8ef1b5d2baaf8c920d5f424377efbae80ac3b8cc160f8cc494d5b111"

URI_aarch64_maven-antrun-plugin-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-antrun-plugin-javadoc-3.1.0-10.el10.noarch.rpm;name=aarch64_maven-antrun-plugin-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-antrun-plugin-javadoc}"
SRC_URI[aarch64_maven-antrun-plugin-javadoc.sha256sum] = "a01a6eb5a5994cddf5cd05fa1d70910a12789739ba47c8d40d735c6b67a9c69c"

RDEPENDS:maven-antrun-plugin = " \
 ant-lib \
 javapackages-filesystem \
 plexus-utils \
 "
RDEPENDS:maven-antrun-plugin-javadoc = " \
 javapackages-filesystem \
 "
