# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdnssd"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdnssd \
 kf6-kdnssd-devel \
 kf6-kdnssd-doc \
 kf6-kdnssd-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdnssd-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5169a533e4045c98800e0bc3d7cf8e9618c8ee1a150061723217f25d1b6a0010"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd;unpack=0"
SRC_URI[x86_64_v2_kf6-kdnssd.sha256sum] = "6d00c20c8cb87b8cba2246ed37cb4dc1e0c38dc443f07d1d1c4163ac83c62622"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdnssd-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdnssd-devel.sha256sum] = "93720ec5ebd7e97918a1f031cb5fd5082649e50aa9d5ddaa9b4c0b6fd8f2a30d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdnssd-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdnssd-doc.sha256sum] = "8143b5fdcdf4cfee1f8d2db2ea2704835cd20866153760e42dead4b3c7a86ca9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdnssd-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdnssd-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kdnssd-html.sha256sum] = "9e2649f8516318670805b02aa79203b6185da2c8979a9dde32e0af49a2c4ed49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdnssd;unpack=0"
SRC_URI[aarch64_kf6-kdnssd.sha256sum] = "a56e26191083ccf4d1c91525610efc7b44454ee48b9581e5917aad3a7e1bf035"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdnssd-devel;unpack=0"
SRC_URI[aarch64_kf6-kdnssd-devel.sha256sum] = "2e44ca282df139d21adbd56084a21b0f86a0b581c78c160f514cb3b781c4a282"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdnssd-doc;unpack=0"
SRC_URI[aarch64_kf6-kdnssd-doc.sha256sum] = "78916960af889a044a53eedb79c837bc25ae9d15b541b41b84e2e2ddbd676b0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdnssd-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdnssd-html;unpack=0"
SRC_URI[aarch64_kf6-kdnssd-html.sha256sum] = "e42eec686712a9ae3f47a441f19c4983ef43f84b37f943de440e52c7ba01dded"

RDEPENDS:kf6-kdnssd = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 nss-mdns \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdnssd-devel = " \
 cmake-filesystem \
 kf6-kdnssd \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdnssd-doc = " \
 "
RDEPENDS:kf6-kdnssd-html = " \
 "
