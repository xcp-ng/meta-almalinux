# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deranged"
PV = "0.5.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-deranged+alloc-devel \
 rust-deranged+default-devel \
 rust-deranged+num-devel \
 rust-deranged+powerfmt-devel \
 rust-deranged+quickcheck-devel \
 rust-deranged+rand-devel \
 rust-deranged+rand010-devel \
 rust-deranged+rand08-devel \
 rust-deranged+rand09-devel \
 rust-deranged+serde-devel \
 rust-deranged-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deranged-0.5.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45f043f0721aef544eb978e9ebebfe3e2a84e5e61a77990f44e5d12db078d8a1"

URI_x86_64_v2_rust-deranged+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+alloc-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+alloc-devel}"
SRC_URI[x86_64_v2_rust-deranged+alloc-devel.sha256sum] = "9b6739165b1ceac5094d1e22d56380e95df1791c387ca7be69445398af94fc46"

URI_x86_64_v2_rust-deranged+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+default-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+default-devel}"
SRC_URI[x86_64_v2_rust-deranged+default-devel.sha256sum] = "1f3278b2cd33d93cf3a00a794b03ed0d192b0c10e83a60ebf40a7db31dfd2e3c"

URI_x86_64_v2_rust-deranged+num-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+num-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+num-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+num-devel}"
SRC_URI[x86_64_v2_rust-deranged+num-devel.sha256sum] = "a21a647b3dedfa90d0d96d6fbd7f6d665d563eda7c907bdcefed14e49c0c23ce"

URI_x86_64_v2_rust-deranged+powerfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+powerfmt-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+powerfmt-devel}"
SRC_URI[x86_64_v2_rust-deranged+powerfmt-devel.sha256sum] = "349044db5bcbeee180ce10745c736a026fa07e684ff2ac9b525b5bd74c0a9192"

URI_x86_64_v2_rust-deranged+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+quickcheck-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-deranged+quickcheck-devel.sha256sum] = "7d07e7aa966683be85c02fe48483dd2f4a89542a5d0696f7d5b9a7e51e409391"

URI_x86_64_v2_rust-deranged+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand-devel.sha256sum] = "ef0501ac97a90e2582d3dbdc663e4bb3e8733edd2ed3d868a10d9b7a8e19b4d4"

URI_x86_64_v2_rust-deranged+rand010-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand010-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand010-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand010-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand010-devel.sha256sum] = "b49b3a1aa51367bdb48e80e806a75a3219bc4e0f047f89f182741744225d0a9e"

URI_x86_64_v2_rust-deranged+rand08-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand08-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand08-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand08-devel.sha256sum] = "7b75dc225218aed844786b248a6c5c83a01d886f3b8706ac44bf54b0a65c6958"

URI_x86_64_v2_rust-deranged+rand09-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+rand09-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+rand09-devel}"
SRC_URI[x86_64_v2_rust-deranged+rand09-devel.sha256sum] = "619d306da61ae4ac7b9f8770bd0ec4758f471717cde895ae4e5c9c57305a5d18"

URI_x86_64_v2_rust-deranged+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged+serde-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged+serde-devel}"
SRC_URI[x86_64_v2_rust-deranged+serde-devel.sha256sum] = "31e498b21206ead5bb0773cf05ea99bdd77fa198994cd377a16c8a7ba9bed9dd"

URI_x86_64_v2_rust-deranged-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deranged-devel-0.5.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deranged-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deranged-devel}"
SRC_URI[x86_64_v2_rust-deranged-devel.sha256sum] = "48abbdcacb5231d4c32f3af37dc8bff0c90ceeea8ae8fa59274597a076ab8ddb"

URI_aarch64_rust-deranged+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+alloc-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+alloc-devel}"
SRC_URI[aarch64_rust-deranged+alloc-devel.sha256sum] = "09e4e46a14e4976cd52913ccf9bf9a668428dbcf69e0822e68b874481bd48ceb"

URI_aarch64_rust-deranged+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+default-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+default-devel}"
SRC_URI[aarch64_rust-deranged+default-devel.sha256sum] = "57d33b2ce448eebe762494abb4f32c7a201dfe5826c04611a344229dceb91581"

URI_aarch64_rust-deranged+num-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+num-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+num-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+num-devel}"
SRC_URI[aarch64_rust-deranged+num-devel.sha256sum] = "865c4c91e0926b4598b6e53192c7f5b290d3a5ff191f02ccf6e3728fde34344c"

URI_aarch64_rust-deranged+powerfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+powerfmt-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+powerfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+powerfmt-devel}"
SRC_URI[aarch64_rust-deranged+powerfmt-devel.sha256sum] = "54548d7636ac76b19ddd7bda3add862ac0ffc1cd3bcc0208cdac7d84be42de84"

URI_aarch64_rust-deranged+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+quickcheck-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+quickcheck-devel}"
SRC_URI[aarch64_rust-deranged+quickcheck-devel.sha256sum] = "d15ffc0e97efba796042f095807db07aa234e4078a8ca1554da00908f3b527c5"

URI_aarch64_rust-deranged+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand-devel}"
SRC_URI[aarch64_rust-deranged+rand-devel.sha256sum] = "d11abab89c8b26f34babd7deacd1b355267ea89e39ed5c97713b5db3f71ab2ce"

URI_aarch64_rust-deranged+rand010-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand010-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+rand010-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand010-devel}"
SRC_URI[aarch64_rust-deranged+rand010-devel.sha256sum] = "5c3ba7b4059054587bec00260bbacebe7badc55f78feca67bb1982059d287d1c"

URI_aarch64_rust-deranged+rand08-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand08-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+rand08-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand08-devel}"
SRC_URI[aarch64_rust-deranged+rand08-devel.sha256sum] = "6fc72394bcdca646e371c9d1f7d85f07193227bd5fa5c026503e18a4fd4da864"

URI_aarch64_rust-deranged+rand09-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+rand09-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+rand09-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+rand09-devel}"
SRC_URI[aarch64_rust-deranged+rand09-devel.sha256sum] = "f6fbd21e60002970356a417b8c4ce2f533995046b726957e0e797938bcbcbe44"

URI_aarch64_rust-deranged+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged+serde-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged+serde-devel}"
SRC_URI[aarch64_rust-deranged+serde-devel.sha256sum] = "051c63b149d8c518deb785636de3893da7abb91cc9678bc25367295e7b6452d6"

URI_aarch64_rust-deranged-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deranged-devel-0.5.8-1.el10_3.noarch.rpm;name=aarch64_rust-deranged-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deranged-devel}"
SRC_URI[aarch64_rust-deranged-devel.sha256sum] = "9e39503690768678eabb10b9c15e8915bc7aa20d58b27bf11fafd4b866b875c1"

RDEPENDS:rust-deranged+alloc-devel = " \
 cargo \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+default-devel = " \
 cargo \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+num-devel = " \
 cargo \
 rust-deranged-devel \
 rust-num-traits-devel \
 "
RDEPENDS:rust-deranged+powerfmt-devel = " \
 cargo \
 rust-deranged-devel \
 rust-powerfmt-devel \
 "
RDEPENDS:rust-deranged+quickcheck-devel = " \
 cargo \
 rust-deranged+alloc-devel \
 rust-deranged-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-deranged+rand-devel = " \
 cargo \
 rust-deranged+rand010-devel \
 rust-deranged+rand08-devel \
 rust-deranged+rand09-devel \
 rust-deranged-devel \
 "
RDEPENDS:rust-deranged+rand010-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-deranged+rand08-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-deranged+rand09-devel = " \
 cargo \
 rust-deranged-devel \
 rust-rand0.9-devel \
 "
RDEPENDS:rust-deranged+serde-devel = " \
 cargo \
 rust-deranged-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-deranged-devel = " \
 cargo \
 rust \
 "
