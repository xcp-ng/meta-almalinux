# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror"
PV = "2.0.21"
PR = "1.el10_3"
PACKAGES = " \
 rust-thiserror+default-devel \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-2.0.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "208b05b935b44fa857e377b34c00b43a2c31506b44f2326699a6723b4dbc3c63"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+default-devel-2.0.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thiserror+default-devel.sha256sum] = "b59e648d04713d606856e815b0f50ab00f2f57fa09057d92adff4808fcc1cff3"
RPROVIDES:rust-thiserror+default-devel:append:x86_64_v2 = " virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror+std-devel-2.0.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thiserror+std-devel.sha256sum] = "3647130f8861bfafda0f755831d13bad9749b6cd991514be7473e16810057feb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-devel-2.0.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thiserror-devel.sha256sum] = "370c416e172091a61d735f5d47feddd643f21f56b72f93d49d6679d85992ad36"
RPROVIDES:rust-thiserror-devel:append:x86_64_v2 = " virtual/crate_thiserror__ge_1.0.0_with_crate_thiserror__lt_3.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+default-devel-2.0.21-1.el10_3.noarch.rpm;name=aarch64_rust-thiserror+default-devel;unpack=0"
SRC_URI[aarch64_rust-thiserror+default-devel.sha256sum] = "6119a3aa5c279dad1e7364b0055f7e462d1adf3b9d5491f8b13672dca875fbac"
RPROVIDES:rust-thiserror+default-devel:append:aarch64 = " virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror+std-devel-2.0.21-1.el10_3.noarch.rpm;name=aarch64_rust-thiserror+std-devel;unpack=0"
SRC_URI[aarch64_rust-thiserror+std-devel.sha256sum] = "9329f7d4305141bd5515f207fcbd7513d72158248967843ef94b5bdbcd94d431"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-devel-2.0.21-1.el10_3.noarch.rpm;name=aarch64_rust-thiserror-devel;unpack=0"
SRC_URI[aarch64_rust-thiserror-devel.sha256sum] = "d306df6e81c835de75da60afa11b9e2889bb0cc16a72b886f127b4056d5c93e0"
RPROVIDES:rust-thiserror-devel:append:aarch64 = " virtual/crate_thiserror__ge_1.0.0_with_crate_thiserror__lt_3.0.0~"

RDEPENDS:rust-thiserror+default-devel = " \
 cargo \
 rust-thiserror+std-devel \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror+std-devel = " \
 cargo \
 rust-thiserror-devel \
 "
RDEPENDS:rust-thiserror-devel = " \
 cargo \
 rust \
 rust-thiserror-impl+default-devel \
 "
