# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcacard"
PE = "3"
PV = "2.8.1"
PR = "6.el10"
PACKAGES = " \
 libcacard \
 libcacard-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libcacard-2.8.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1accf08a22ae5a46953e00ea869ad7ef9fbde714f8e621c5a984ae9085a09cb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcacard-2.8.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_libcacard;unpack=0"
SRC_URI[x86_64_v2_libcacard.sha256sum] = "82fa72d1968e1c158ac61c369d64d8dcc26076c5114ea168a214075c70587d75"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcacard-devel-2.8.1-6.el10.x86_64_v2.rpm;name=x86_64_v2_libcacard-devel;unpack=0"
SRC_URI[x86_64_v2_libcacard-devel.sha256sum] = "7b1593b4f6c933fd770748088218765103b19cb84ff9046bbd530813a860f0e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcacard-2.8.1-6.el10.aarch64.rpm;name=aarch64_libcacard;unpack=0"
SRC_URI[aarch64_libcacard.sha256sum] = "426d6bf4268781cfd8de9520e6a25535f126e280d8d80dde4c99be4122be7573"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcacard-devel-2.8.1-6.el10.aarch64.rpm;name=aarch64_libcacard-devel;unpack=0"
SRC_URI[aarch64_libcacard-devel.sha256sum] = "86338ff6ab25145c3ebff9f6afe03914b4a3f6d5d6c5588adf86ccad9d562335"

RDEPENDS:libcacard = " \
 glib2 \
 glibc \
 nspr \
 nss \
 pcsc-lite-libs \
 "
RDEPENDS:libcacard-devel = " \
 glib2-devel \
 libcacard \
 nss-devel \
 pcsc-lite-devel \
 pkgconf-pkg-config \
 "
