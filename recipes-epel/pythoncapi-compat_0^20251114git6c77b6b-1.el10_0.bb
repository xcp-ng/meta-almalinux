# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pythoncapi-compat"
PV = "0^20251114git6c77b6b"
PR = "1.el10_0"
PACKAGES = " \
 pythoncapi-compat-devel \
 pythoncapi-compat-doc \
 pythoncapi-compat-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pythoncapi-compat-0^20251114git6c77b6b-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a3f2e703719bcbca082d108adf751afd19fd4d407455a84aefeaef330db8e8d"

URI_x86_64_v2_pythoncapi-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-devel-0^20251114git6c77b6b-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-devel}"
SRC_URI[x86_64_v2_pythoncapi-compat-devel.sha256sum] = "1739db342210d0874288bea9395ca88343692553ea9ffa70e0be3f28e7690b77"

URI_x86_64_v2_pythoncapi-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-doc-0^20251114git6c77b6b-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-doc}"
SRC_URI[x86_64_v2_pythoncapi-compat-doc.sha256sum] = "2427dd89160b2492fe3f9ea86be96938dabf37ddf7c4b25efa4ea6fe51b68f4e"

URI_x86_64_v2_pythoncapi-compat-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-tools-0^20251114git6c77b6b-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-tools}"
SRC_URI[x86_64_v2_pythoncapi-compat-tools.sha256sum] = "23ce54f55b10e91145d4e11551806389bcdf6624916cc5fb6c3f5b6735444d33"

URI_aarch64_pythoncapi-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-devel-0^20251114git6c77b6b-1.el10_0.noarch.rpm;name=aarch64_pythoncapi-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-devel}"
SRC_URI[aarch64_pythoncapi-compat-devel.sha256sum] = "6a913dd733fa626d800a45e7ceabf9eae21dfeb7500c3eed1848771c81ebe8ae"

URI_aarch64_pythoncapi-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-doc-0^20251114git6c77b6b-1.el10_0.noarch.rpm;name=aarch64_pythoncapi-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-doc}"
SRC_URI[aarch64_pythoncapi-compat-doc.sha256sum] = "dba6edee7a7f2ac9e3111ba9eb1c0ac4b2fc6cab132e2306509149c7e67ff601"

URI_aarch64_pythoncapi-compat-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-tools-0^20251114git6c77b6b-1.el10_0.noarch.rpm;name=aarch64_pythoncapi-compat-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-tools}"
SRC_URI[aarch64_pythoncapi-compat-tools.sha256sum] = "b524bb1357a60c1407f71cc2c72e3f386197e7a48557453bef22ba893bd3421d"

RDEPENDS:pythoncapi-compat-devel = " \
 "
RDEPENDS:pythoncapi-compat-doc = " \
 "
RDEPENDS:pythoncapi-compat-tools = " \
 python3 \
 "
