# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "whois"
PV = "5.5.20"
PR = "6.el10"
PACKAGES = " \
 mkpasswd \
 whois \
 whois-nls \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/whois-5.5.20-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52fd336e97a0aa7dbb23abd66b8fe8cb38808eb87730a0b62c29b2a340cffd11"

URI_x86_64_v2_mkpasswd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mkpasswd-5.5.20-6.el10.x86_64_v2.rpm;name=x86_64_v2_mkpasswd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mkpasswd}"
SRC_URI[x86_64_v2_mkpasswd.sha256sum] = "d17523950be26e0c26d95d474f718fcc6e16eac580ceca42a226f2de8a304807"

URI_x86_64_v2_whois = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/whois-5.5.20-6.el10.x86_64_v2.rpm;name=x86_64_v2_whois;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_whois}"
SRC_URI[x86_64_v2_whois.sha256sum] = "e26d7d9a48e81b9a8c8b6f3647a5e1b83cbc6463d1c06edfb184fb33c71f28d6"

URI_x86_64_v2_whois-nls = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/whois-nls-5.5.20-6.el10.noarch.rpm;name=x86_64_v2_whois-nls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_whois-nls}"
SRC_URI[x86_64_v2_whois-nls.sha256sum] = "78d4e48b1ede5644312b3ce8f940aa0e79e88f15d9e7058990e0244628e8d629"

URI_aarch64_mkpasswd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mkpasswd-5.5.20-6.el10.aarch64.rpm;name=aarch64_mkpasswd;unpack=0"
SRC_URI:append = " ${URI_aarch64_mkpasswd}"
SRC_URI[aarch64_mkpasswd.sha256sum] = "bb6cd09123250361a56142565b5af4c4bdd9aaf09959d748ac3c3d97fd3f807a"

URI_aarch64_whois = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/whois-5.5.20-6.el10.aarch64.rpm;name=aarch64_whois;unpack=0"
SRC_URI:append = " ${URI_aarch64_whois}"
SRC_URI[aarch64_whois.sha256sum] = "efd423af47567aa925d89acf7836ca936516a68fd01867abc21013e2b1184ea4"

URI_aarch64_whois-nls = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/whois-nls-5.5.20-6.el10.noarch.rpm;name=aarch64_whois-nls;unpack=0"
SRC_URI:append = " ${URI_aarch64_whois-nls}"
SRC_URI[aarch64_whois-nls.sha256sum] = "78d4e48b1ede5644312b3ce8f940aa0e79e88f15d9e7058990e0244628e8d629"

RDEPENDS:mkpasswd = " \
 glibc \
 libxcrypt \
 whois-nls \
 "
RDEPENDS:whois = " \
 alternatives \
 bash \
 glibc \
 libidn2 \
 whois-nls \
 "
RDEPENDS:whois-nls = " \
 "
