# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Tiny-Multipart"
PV = "0.08"
PR = "19.el10_1"
PACKAGES = " \
 perl-HTTP-Tiny-Multipart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-Tiny-Multipart-0.08-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f41cdf7436b0fa9dcfeeb06d6062e3499bfc7cd89eedccb07c7a9952be2ecf63"

URI_x86_64_v2_perl-HTTP-Tiny-Multipart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Tiny-Multipart-0.08-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Tiny-Multipart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Tiny-Multipart}"
SRC_URI[x86_64_v2_perl-HTTP-Tiny-Multipart.sha256sum] = "0ebbe3a98f6eeed20f3de85b95ab9d0562c699d55b99b58a131287df03dcb2dc"

URI_aarch64_perl-HTTP-Tiny-Multipart = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Tiny-Multipart-0.08-19.el10_1.noarch.rpm;name=aarch64_perl-HTTP-Tiny-Multipart;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Tiny-Multipart}"
SRC_URI[aarch64_perl-HTTP-Tiny-Multipart.sha256sum] = "31c325d0aba0be23acbef43a6f4ccd364e21f43ac40bcae55fb8d94e85d28034"

RDEPENDS:perl-HTTP-Tiny-Multipart = " \
 perl-Carp \
 perl-File-Basename \
 perl-HTTP-Tiny \
 perl-MIME-Base64 \
 perl-libs \
 "
