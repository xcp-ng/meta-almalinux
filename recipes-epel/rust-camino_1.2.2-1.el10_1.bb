# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-camino"
PV = "1.2.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-camino+default-devel \
 rust-camino+proptest1-devel \
 rust-camino+serde1-devel \
 rust-camino-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-camino-1.2.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4fc98c7c82e1666a4f6bd5dfa1832c55accd7ef1cc865a02e49528eb9c88a03"

URI_x86_64_v2_rust-camino+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+default-devel-1.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+default-devel}"
SRC_URI[x86_64_v2_rust-camino+default-devel.sha256sum] = "836f7ad7bdd4e02d35031faf900996f64ab84a420ae93add3cedc566dbced42e"

URI_x86_64_v2_rust-camino+proptest1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+proptest1-devel-1.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+proptest1-devel}"
SRC_URI[x86_64_v2_rust-camino+proptest1-devel.sha256sum] = "2fd5c5a54fd355249f26eb68e7e53df1a74b17c96e43c711e66c285ed6026ef0"

URI_x86_64_v2_rust-camino+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+serde1-devel-1.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+serde1-devel}"
SRC_URI[x86_64_v2_rust-camino+serde1-devel.sha256sum] = "a5d8a059efd1729be6234edc92ff801439c9f31d1b23f40359e0c633d579dcb0"

URI_x86_64_v2_rust-camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino-devel-1.2.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino-devel}"
SRC_URI[x86_64_v2_rust-camino-devel.sha256sum] = "35d20b9f0d6e29e043df7a7fea7fde4ca59be0deda8e92f0ca58349eacc3dbef"

URI_aarch64_rust-camino+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+default-devel-1.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-camino+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+default-devel}"
SRC_URI[aarch64_rust-camino+default-devel.sha256sum] = "dff4e9cfd50e2d860b3343a02a3b94a5c109ba1195a52c1f6c89b7f8e4bb7a67"

URI_aarch64_rust-camino+proptest1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+proptest1-devel-1.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-camino+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+proptest1-devel}"
SRC_URI[aarch64_rust-camino+proptest1-devel.sha256sum] = "80dc0eccd58dafc5da53b51498ced5b3face7352ebe0fe4b5b177dedb6c03fae"

URI_aarch64_rust-camino+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+serde1-devel-1.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-camino+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+serde1-devel}"
SRC_URI[aarch64_rust-camino+serde1-devel.sha256sum] = "67a64e88a73a21331cdc39bf0c08e9f41108d60b62874e0dac4728247d09d62b"

URI_aarch64_rust-camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino-devel-1.2.2-1.el10_1.noarch.rpm;name=aarch64_rust-camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino-devel}"
SRC_URI[aarch64_rust-camino-devel.sha256sum] = "fe7ae9bfd0ee49ef74f71d4cd428193669a29ab8f3e0fb44cc937987814b977d"

RDEPENDS:rust-camino+default-devel = " \
 cargo \
 rust-camino-devel \
 "
RDEPENDS:rust-camino+proptest1-devel = " \
 cargo \
 rust-camino-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-camino+serde1-devel = " \
 cargo \
 rust-camino-devel \
 rust-serde_core+default-devel \
 "
RDEPENDS:rust-camino-devel = " \
 cargo \
 rust \
 "
