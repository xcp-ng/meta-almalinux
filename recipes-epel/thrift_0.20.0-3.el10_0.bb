# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thrift"
PV = "0.20.0"
PR = "3.el10_0"
PACKAGES = " \
 perl-thrift \
 python3-thrift \
 thrift \
 thrift-devel \
 thrift-glib \
 thrift-qt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/thrift-0.20.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "339192530f13616bc21bff9dfb4daafb4b7ddaed2df501f9d15f13cc83400e5c"

URI_x86_64_v2_perl-thrift = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-thrift-0.20.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-thrift;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-thrift}"
SRC_URI[x86_64_v2_perl-thrift.sha256sum] = "3f75589cd47a2d40a755e12061e1777ee85021b915336a7b216c20afa7fce07f"

URI_x86_64_v2_python3-thrift = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-thrift-0.20.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-thrift;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-thrift}"
SRC_URI[x86_64_v2_python3-thrift.sha256sum] = "5277ec66e15b99e7a4fb3d6f7382acac83d7f7c1a07ab6e921ae613f501bf1ed"

URI_x86_64_v2_thrift = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/thrift-0.20.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_thrift;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thrift}"
SRC_URI[x86_64_v2_thrift.sha256sum] = "876e282d5e91213cea4ab369fae668c59e0807d05ccec19d0f4735cf332df327"

URI_x86_64_v2_thrift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/thrift-devel-0.20.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_thrift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thrift-devel}"
SRC_URI[x86_64_v2_thrift-devel.sha256sum] = "79be60ef98d786740543d3954d558b16f38a1dba89625b64eba619bc1b987772"

URI_x86_64_v2_thrift-glib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/thrift-glib-0.20.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_thrift-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thrift-glib}"
SRC_URI[x86_64_v2_thrift-glib.sha256sum] = "f1dec0bf15090c5a5b093030b947880f068cc0564ca5eda90465648c3e3d5e72"

URI_x86_64_v2_thrift-qt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/thrift-qt-0.20.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_thrift-qt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thrift-qt}"
SRC_URI[x86_64_v2_thrift-qt.sha256sum] = "69a864c587a453b8d9b169954b9cc6ac6d15f46aa72d4079daa12df141ecb129"

URI_aarch64_perl-thrift = "${EPEL_MIRROR}/aarch64/Packages/p/perl-thrift-0.20.0-3.el10_0.noarch.rpm;name=aarch64_perl-thrift;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-thrift}"
SRC_URI[aarch64_perl-thrift.sha256sum] = "fa941e75b0288b45eaf700527f5e475cb57f59fe9f10a353bcb4d3cce6204b51"

URI_aarch64_python3-thrift = "${EPEL_MIRROR}/aarch64/Packages/p/python3-thrift-0.20.0-3.el10_0.aarch64.rpm;name=aarch64_python3-thrift;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-thrift}"
SRC_URI[aarch64_python3-thrift.sha256sum] = "bf0c3e451c6bc4b2dd3ccec13f649f1653719aca5ee65d6be29fe1287caa7731"

URI_aarch64_thrift = "${EPEL_MIRROR}/aarch64/Packages/t/thrift-0.20.0-3.el10_0.aarch64.rpm;name=aarch64_thrift;unpack=0"
SRC_URI:append = " ${URI_aarch64_thrift}"
SRC_URI[aarch64_thrift.sha256sum] = "e6b8e35d99480fa92460bae7eafed2c81244ab3bdec8757e75162ccf4d96f3f6"

URI_aarch64_thrift-devel = "${EPEL_MIRROR}/aarch64/Packages/t/thrift-devel-0.20.0-3.el10_0.aarch64.rpm;name=aarch64_thrift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_thrift-devel}"
SRC_URI[aarch64_thrift-devel.sha256sum] = "858921c6591979bdc2fbcd1b643718a6e26d472f4a15c2e4114c791738835ea4"

URI_aarch64_thrift-glib = "${EPEL_MIRROR}/aarch64/Packages/t/thrift-glib-0.20.0-3.el10_0.aarch64.rpm;name=aarch64_thrift-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_thrift-glib}"
SRC_URI[aarch64_thrift-glib.sha256sum] = "d3120087f218a22b3726f233c685524f4ff9bfb458b0b18dc5dfe5a595d046d8"

URI_aarch64_thrift-qt = "${EPEL_MIRROR}/aarch64/Packages/t/thrift-qt-0.20.0-3.el10_0.aarch64.rpm;name=aarch64_thrift-qt;unpack=0"
SRC_URI:append = " ${URI_aarch64_thrift-qt}"
SRC_URI[aarch64_thrift-qt.sha256sum] = "8adcaec19ca3a32cdcced5ace1ddbbf5d2994f1642e58c12e4cecfd87c31c7c3"

RDEPENDS:perl-thrift = " \
 perl-Bit-Vector \
 perl-Encode \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-IO-String \
 perl-POSIX \
 perl-base \
 perl-constant \
 perl-libs \
 perl-libwww-perl \
 perl-overload \
 perl-parent \
 perl-version \
 "
RDEPENDS:python3-thrift = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-six \
 thrift \
 "
RDEPENDS:thrift = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:thrift-devel = " \
 boost-devel \
 glib2 \
 glib2-devel \
 glibc \
 openssl-libs \
 pkgconf-pkg-config \
 thrift \
 zlib-ng-compat \
 "
RDEPENDS:thrift-glib = " \
 glib2 \
 glibc \
 openssl-libs \
 thrift \
 zlib-ng-compat \
 "
RDEPENDS:thrift-qt = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 thrift \
 "
