# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-s3transfer"
PV = "0.10.4"
PR = "1.el10_0"
PACKAGES = " \
 python3-s3transfer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-s3transfer-0.10.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "caca25f354335d1efb9e840bb1a3540a7f726684c0bf3b80a8d2701894d8a765"

URI_x86_64_v2_python3-s3transfer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-s3transfer-0.10.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-s3transfer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-s3transfer}"
SRC_URI[x86_64_v2_python3-s3transfer.sha256sum] = "2a9346a3c8ede9a7cd2637c47e8f6397aae856b0711899039deacfac8d165987"

URI_aarch64_python3-s3transfer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-s3transfer-0.10.4-1.el10_0.noarch.rpm;name=aarch64_python3-s3transfer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-s3transfer}"
SRC_URI[aarch64_python3-s3transfer.sha256sum] = "41d495828d683d609c44f5d1a6a16763c6ff6b710d7e157f798bab5743c7b72f"

RDEPENDS:python3-s3transfer = " \
 python3 \
 python3-botocore \
 "
