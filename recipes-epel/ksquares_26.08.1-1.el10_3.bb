# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksquares"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ksquares \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ksquares-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d2213e809f01d9322cea022e9cf3afef2ff38781344f773fffb05ceed307895c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksquares-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksquares;unpack=0"
SRC_URI[x86_64_v2_ksquares.sha256sum] = "895b5e7e0e75eebda08c825d5ed8318d8b3a0e8fcad406d70208d77c8d88ce09"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksquares-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ksquares;unpack=0"
SRC_URI[aarch64_ksquares.sha256sum] = "61bdb552416667baddc6aefe823701c98bcfbe8d422ff2e44ca2853a119b521c"

RDEPENDS:ksquares = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
