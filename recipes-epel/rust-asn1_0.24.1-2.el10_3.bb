# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-asn1"
PV = "0.24.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-asn1+default-devel \
 rust-asn1+std-devel \
 rust-asn1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-asn1-0.24.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df245083cbfffaa5c9ca8baad4f3d7d61d3a08a6f235cff0cc2a36bcfd9d3cdc"

URI_x86_64_v2_rust-asn1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1+default-devel-0.24.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1+default-devel}"
SRC_URI[x86_64_v2_rust-asn1+default-devel.sha256sum] = "066f8faada8eb02116e79a9bbb3d66ef6843e3906de17d234e21532c3491c8fa"

URI_x86_64_v2_rust-asn1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1+std-devel-0.24.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1+std-devel}"
SRC_URI[x86_64_v2_rust-asn1+std-devel.sha256sum] = "e18bdb0236fd10fcb794342167c556b4fc6df2c8a0a667bbcef6e8c0b3f67de6"

URI_x86_64_v2_rust-asn1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-asn1-devel-0.24.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-asn1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-asn1-devel}"
SRC_URI[x86_64_v2_rust-asn1-devel.sha256sum] = "a0a3de471ac16614ea2c43c4a22db51e787ba72f63e117d7abd40ef8c86b87b0"

URI_aarch64_rust-asn1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1+default-devel-0.24.1-2.el10_3.noarch.rpm;name=aarch64_rust-asn1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1+default-devel}"
SRC_URI[aarch64_rust-asn1+default-devel.sha256sum] = "50963ca1b15274692a15245dde2c231499842815d82767945846ceef02fcd01d"

URI_aarch64_rust-asn1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1+std-devel-0.24.1-2.el10_3.noarch.rpm;name=aarch64_rust-asn1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1+std-devel}"
SRC_URI[aarch64_rust-asn1+std-devel.sha256sum] = "27e93bdd623b2fee03c22731a282c155961270670b22b8dee9104d3c43821743"

URI_aarch64_rust-asn1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-asn1-devel-0.24.1-2.el10_3.noarch.rpm;name=aarch64_rust-asn1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-asn1-devel}"
SRC_URI[aarch64_rust-asn1-devel.sha256sum] = "a5034c4d09452b753821dbf11524c8c80209c52a2ca09bf89db39728947fbe48"

RDEPENDS:rust-asn1+default-devel = " \
 cargo \
 rust-asn1+std-devel \
 rust-asn1-devel \
 "
RDEPENDS:rust-asn1+std-devel = " \
 cargo \
 rust-asn1-devel \
 "
RDEPENDS:rust-asn1-devel = " \
 cargo \
 rust \
 rust-asn1_derive+default-devel \
 rust-itoa+default-devel \
 "
