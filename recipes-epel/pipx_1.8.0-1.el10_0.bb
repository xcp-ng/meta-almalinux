# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipx"
PV = "1.8.0"
PR = "1.el10_0"
PACKAGES = " \
 pipx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pipx-1.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3c2764cf7e8bf6000b279ce0c445b56e13b366ebf2703a1064d0d0c13e7e4b5"

URI_x86_64_v2_pipx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipx-1.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pipx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pipx}"
SRC_URI[x86_64_v2_pipx.sha256sum] = "666e84f6aaae6bb512a6ab0ee81cd2fa5b419b345c1c253b7558b99612ff3cc5"

URI_aarch64_pipx = "${EPEL_MIRROR}/aarch64/Packages/p/pipx-1.8.0-1.el10_0.noarch.rpm;name=aarch64_pipx;unpack=0"
SRC_URI:append = " ${URI_aarch64_pipx}"
SRC_URI[aarch64_pipx.sha256sum] = "5db64360bbe13bfe7d0d615d41a42de97addfd9e787d4c4948a29e0f9fa1381e"

RDEPENDS:pipx = " \
 python3 \
 python3-argcomplete \
 python3-packaging \
 python3-platformdirs \
 python3-userpath \
 "
