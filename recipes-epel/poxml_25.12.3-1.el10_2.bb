# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poxml"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 poxml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/poxml-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80e33f41fd220fd61b2ba97930c263296d3e62afee43cd7c49f50d973c2d1a1c"

URI_x86_64_v2_poxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/poxml-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_poxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poxml}"
SRC_URI[x86_64_v2_poxml.sha256sum] = "99bc30effcce645d9cbb4402292bbdf3e60d21771fcd44788c017fc4ce6aab7c"

URI_aarch64_poxml = "${EPEL_MIRROR}/aarch64/Packages/p/poxml-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_poxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_poxml}"
SRC_URI[aarch64_poxml.sha256sum] = "88a80a3834e144fc5ab632d25024ea88221bd11164593e5c69cbb94400053f62"

RDEPENDS:poxml = " \
 gettext-libs \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
