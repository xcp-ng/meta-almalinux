# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "httpcomponents-client"
PV = "4.5.14"
PR = "9.el10"
PACKAGES = " \
 httpcomponents-client \
 httpcomponents-client-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/httpcomponents-client-4.5.14-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "be50fa2307a4cbc1c2332a609ac995cff2f7060d4d969a371b8ce5a3634b8b69"

URI_x86_64_v2_httpcomponents-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpcomponents-client-4.5.14-9.el10.noarch.rpm;name=x86_64_v2_httpcomponents-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpcomponents-client}"
SRC_URI[x86_64_v2_httpcomponents-client.sha256sum] = "900a827852449c849a35bb37454aba5fd3bf56535be457fa6636cbc1a322430c"

URI_x86_64_v2_httpcomponents-client-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/httpcomponents-client-javadoc-4.5.14-9.el10.noarch.rpm;name=x86_64_v2_httpcomponents-client-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpcomponents-client-javadoc}"
SRC_URI[x86_64_v2_httpcomponents-client-javadoc.sha256sum] = "29010123a63f0dcdaec0e4d865cb19de7aceb7186dc468d1949d9781d86bb14d"

URI_aarch64_httpcomponents-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpcomponents-client-4.5.14-9.el10.noarch.rpm;name=aarch64_httpcomponents-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpcomponents-client}"
SRC_URI[aarch64_httpcomponents-client.sha256sum] = "900a827852449c849a35bb37454aba5fd3bf56535be457fa6636cbc1a322430c"

URI_aarch64_httpcomponents-client-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/httpcomponents-client-javadoc-4.5.14-9.el10.noarch.rpm;name=aarch64_httpcomponents-client-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpcomponents-client-javadoc}"
SRC_URI[aarch64_httpcomponents-client-javadoc.sha256sum] = "29010123a63f0dcdaec0e4d865cb19de7aceb7186dc468d1949d9781d86bb14d"

RDEPENDS:httpcomponents-client = " \
 apache-commons-codec \
 httpcomponents-core \
 javapackages-filesystem \
 publicsuffix-list \
 "
RDEPENDS:httpcomponents-client-javadoc = " \
 javapackages-filesystem \
 "
