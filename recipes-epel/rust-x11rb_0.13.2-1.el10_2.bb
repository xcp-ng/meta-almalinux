# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-x11rb"
PV = "0.13.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-x11rb+all-extensions-devel \
 rust-x11rb+allow-unsafe-code-devel \
 rust-x11rb+as-raw-xcb-connection-devel \
 rust-x11rb+composite-devel \
 rust-x11rb+cursor-devel \
 rust-x11rb+damage-devel \
 rust-x11rb+dbe-devel \
 rust-x11rb+default-devel \
 rust-x11rb+dl-libxcb-devel \
 rust-x11rb+dpms-devel \
 rust-x11rb+dri2-devel \
 rust-x11rb+dri3-devel \
 rust-x11rb+extra-traits-devel \
 rust-x11rb+glx-devel \
 rust-x11rb+image-devel \
 rust-x11rb+libc-devel \
 rust-x11rb+libloading-devel \
 rust-x11rb+once_cell-devel \
 rust-x11rb+present-devel \
 rust-x11rb+randr-devel \
 rust-x11rb+raw-window-handle-devel \
 rust-x11rb+record-devel \
 rust-x11rb+render-devel \
 rust-x11rb+request-parsing-devel \
 rust-x11rb+res-devel \
 rust-x11rb+resource_manager-devel \
 rust-x11rb+screensaver-devel \
 rust-x11rb+shape-devel \
 rust-x11rb+shm-devel \
 rust-x11rb+sync-devel \
 rust-x11rb+tracing-devel \
 rust-x11rb+xcursor-devel \
 rust-x11rb+xevie-devel \
 rust-x11rb+xf86dri-devel \
 rust-x11rb+xf86vidmode-devel \
 rust-x11rb+xfixes-devel \
 rust-x11rb+xinerama-devel \
 rust-x11rb+xinput-devel \
 rust-x11rb+xkb-devel \
 rust-x11rb+xprint-devel \
 rust-x11rb+xselinux-devel \
 rust-x11rb+xtest-devel \
 rust-x11rb+xv-devel \
 rust-x11rb+xvmc-devel \
 rust-x11rb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-x11rb-0.13.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97d5a7701275fcfe61353beb8eb608b1f4f00d3dcb17d0421a8f38bd4934f849"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - rust-x11rb+xcursor-devel: (crate(xcursor/default) >= 0.3.7 with crate(xcursor/default) < 0.4.0~)

URI_x86_64_v2_rust-x11rb+all-extensions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+all-extensions-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+all-extensions-devel}"
SRC_URI[x86_64_v2_rust-x11rb+all-extensions-devel.sha256sum] = "646d884fc8cf969dd487482c4d6a0f2783f8e59a4fd022ee190eb244ed503bce"

URI_x86_64_v2_rust-x11rb+allow-unsafe-code-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+allow-unsafe-code-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+allow-unsafe-code-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+allow-unsafe-code-devel}"
SRC_URI[x86_64_v2_rust-x11rb+allow-unsafe-code-devel.sha256sum] = "720551d160afb36469e07b8a9b19449c93f0fdf740bab0f98e517317eb0191f0"

URI_x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+as-raw-xcb-connection-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel}"
SRC_URI[x86_64_v2_rust-x11rb+as-raw-xcb-connection-devel.sha256sum] = "c39c9bd892b9f08d834faa6219971647f23d5d7cc91f1093abada29ff868b0f6"

URI_x86_64_v2_rust-x11rb+composite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+composite-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+composite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+composite-devel}"
SRC_URI[x86_64_v2_rust-x11rb+composite-devel.sha256sum] = "3830704028e380e3fd70b93573f91bfcc2b6ad19c1dc23843539d32879f6591c"

URI_x86_64_v2_rust-x11rb+cursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+cursor-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+cursor-devel}"
SRC_URI[x86_64_v2_rust-x11rb+cursor-devel.sha256sum] = "836e72e8ff1f20936825d86208419fea323f3bb4f41c7006d026614b44777c0f"

URI_x86_64_v2_rust-x11rb+damage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+damage-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+damage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+damage-devel}"
SRC_URI[x86_64_v2_rust-x11rb+damage-devel.sha256sum] = "dfa3b04749ebb807e5102151f8365786e869b865bc5f830d032da21b47831738"

URI_x86_64_v2_rust-x11rb+dbe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dbe-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dbe-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dbe-devel.sha256sum] = "76adf97deb6a02d8ce675a0ee2f7fa3a1c60b5e3316575f96d99dbe90d5ab0ea"

URI_x86_64_v2_rust-x11rb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+default-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+default-devel}"
SRC_URI[x86_64_v2_rust-x11rb+default-devel.sha256sum] = "8d1bf669c92c20231a426094816295922e45be32870bcb053e88b16d3724dcdb"

URI_x86_64_v2_rust-x11rb+dl-libxcb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dl-libxcb-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dl-libxcb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dl-libxcb-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dl-libxcb-devel.sha256sum] = "9c3f876c7dd328231f59e41bb1cef974e85f70e23b3a12038dd511227aa06d1e"

URI_x86_64_v2_rust-x11rb+dpms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dpms-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dpms-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dpms-devel.sha256sum] = "3302f765ac8a29af77e34ca8d143006ac3420b13b9144393a5cd092e8b8b9918"

URI_x86_64_v2_rust-x11rb+dri2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dri2-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dri2-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dri2-devel.sha256sum] = "3b62faf991efad66742aeb86385eb5d721489e2242de50bdb6602c6a43600c13"

URI_x86_64_v2_rust-x11rb+dri3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+dri3-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+dri3-devel}"
SRC_URI[x86_64_v2_rust-x11rb+dri3-devel.sha256sum] = "8bd936235102c27ec31f855d62bf1c0ec00df5eaed5eb7e33e4506706b5d6788"

URI_x86_64_v2_rust-x11rb+extra-traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+extra-traits-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+extra-traits-devel}"
SRC_URI[x86_64_v2_rust-x11rb+extra-traits-devel.sha256sum] = "7de6f3e26f93b4a492126526ad9d43d8b167041996b76bab1d9176d834d0e308"

URI_x86_64_v2_rust-x11rb+glx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+glx-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+glx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+glx-devel}"
SRC_URI[x86_64_v2_rust-x11rb+glx-devel.sha256sum] = "b596b5775af3815ce1ec91b2fb68f1e61001242115de921b92510ed17ed3dc34"

URI_x86_64_v2_rust-x11rb+image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+image-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+image-devel}"
SRC_URI[x86_64_v2_rust-x11rb+image-devel.sha256sum] = "4587fc83630058076305541ff50232a6e420b7aa8c277e611b1ac29848858921"

URI_x86_64_v2_rust-x11rb+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+libc-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+libc-devel}"
SRC_URI[x86_64_v2_rust-x11rb+libc-devel.sha256sum] = "85fd1d66bf87c5f1f123add749873e013eaf040347ca452dd28571a79ad748a8"

URI_x86_64_v2_rust-x11rb+libloading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+libloading-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+libloading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+libloading-devel}"
SRC_URI[x86_64_v2_rust-x11rb+libloading-devel.sha256sum] = "c57fdf8a36fe9834776f73f04abc8ef681b7b1d5012707aba9f13eaf4d72e4a8"

URI_x86_64_v2_rust-x11rb+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+once_cell-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+once_cell-devel}"
SRC_URI[x86_64_v2_rust-x11rb+once_cell-devel.sha256sum] = "946abcc2919466e3d1396be93b9dd008ed9ca42baa82df702245224f07c9d6bf"

URI_x86_64_v2_rust-x11rb+present-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+present-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+present-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+present-devel}"
SRC_URI[x86_64_v2_rust-x11rb+present-devel.sha256sum] = "5bbe4b50cef523ac55f844c854b6107f85d54188d7c2353be7f614ecb1086afd"

URI_x86_64_v2_rust-x11rb+randr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+randr-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+randr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+randr-devel}"
SRC_URI[x86_64_v2_rust-x11rb+randr-devel.sha256sum] = "9707c0c548ed4ba1929c2e23573e0871c55461f87cd36c6a9fe2928d55548ad0"

URI_x86_64_v2_rust-x11rb+raw-window-handle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+raw-window-handle-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+raw-window-handle-devel}"
SRC_URI[x86_64_v2_rust-x11rb+raw-window-handle-devel.sha256sum] = "45af6f67721e82bc95c6c7f1b3ecd9caf8162cba4e7ec25bfd7bba31447764ac"

URI_x86_64_v2_rust-x11rb+record-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+record-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+record-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+record-devel}"
SRC_URI[x86_64_v2_rust-x11rb+record-devel.sha256sum] = "c0b3d6102c011d3e9db43b204b2bc3cf3af4bdbf00b8286c296d5dd17f15c675"

URI_x86_64_v2_rust-x11rb+render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+render-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+render-devel}"
SRC_URI[x86_64_v2_rust-x11rb+render-devel.sha256sum] = "76af6c953894a360a2747daf7fcc8ffecf38a033b8f257cb3e759ad27264c85a"

URI_x86_64_v2_rust-x11rb+request-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+request-parsing-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+request-parsing-devel}"
SRC_URI[x86_64_v2_rust-x11rb+request-parsing-devel.sha256sum] = "da96ecac482fa3ed19457e7ed0b35cd505fd5debd573b6f138220c70501afe7c"

URI_x86_64_v2_rust-x11rb+res-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+res-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+res-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+res-devel}"
SRC_URI[x86_64_v2_rust-x11rb+res-devel.sha256sum] = "5d50116147038ef56ed05003130eecc49aabdf3c4386d16f8cb1bcfda3a89f53"

URI_x86_64_v2_rust-x11rb+resource_manager-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+resource_manager-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+resource_manager-devel}"
SRC_URI[x86_64_v2_rust-x11rb+resource_manager-devel.sha256sum] = "a3c08d8d7d8e2a19a4c0efb5bcbdbb520160c342ea635b1e1ce4c59ce6751d90"

URI_x86_64_v2_rust-x11rb+screensaver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+screensaver-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+screensaver-devel}"
SRC_URI[x86_64_v2_rust-x11rb+screensaver-devel.sha256sum] = "39082b160a47e8cbe0f2c033dd8303c8560a21329e5adbb897578a61e296952d"

URI_x86_64_v2_rust-x11rb+shape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+shape-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+shape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+shape-devel}"
SRC_URI[x86_64_v2_rust-x11rb+shape-devel.sha256sum] = "a8be58b4e00c767b5522c0c5ffd37d08372eb44b535fae9380214a5ced80f9a5"

URI_x86_64_v2_rust-x11rb+shm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+shm-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+shm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+shm-devel}"
SRC_URI[x86_64_v2_rust-x11rb+shm-devel.sha256sum] = "f5e592ea6a78883f32d80ac8aabf0a82a4a717e931190b12e6a1a7d190ac2cce"

URI_x86_64_v2_rust-x11rb+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+sync-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+sync-devel}"
SRC_URI[x86_64_v2_rust-x11rb+sync-devel.sha256sum] = "6f425188a5f435f5ba5ef280109b62683baedfc933fd2cb76257a923611e8e36"

URI_x86_64_v2_rust-x11rb+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+tracing-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+tracing-devel}"
SRC_URI[x86_64_v2_rust-x11rb+tracing-devel.sha256sum] = "69615bfb726d88069e6e7d437627eb0cb7e72406f9a0c79049afd25575208c2c"

URI_x86_64_v2_rust-x11rb+xcursor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xcursor-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xcursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xcursor-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xcursor-devel.sha256sum] = "e1f5fc9842227219eb7f38f337042df7231151df77f85151d5ade3989f340870"

URI_x86_64_v2_rust-x11rb+xevie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xevie-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xevie-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xevie-devel.sha256sum] = "dffcf1e229f0d2f70babff3518f378a73be2118302d67df9db74d2a107c440cd"

URI_x86_64_v2_rust-x11rb+xf86dri-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xf86dri-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xf86dri-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xf86dri-devel.sha256sum] = "77eb5eec8f0ff3c1d21cc926ebc9c60c6cc1ec07545f333127de792fdcce1f10"

URI_x86_64_v2_rust-x11rb+xf86vidmode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xf86vidmode-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xf86vidmode-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xf86vidmode-devel.sha256sum] = "f94a771f6674c2911e0cc42845d6a0029d431239a985d3b10e0d62d010d451be"

URI_x86_64_v2_rust-x11rb+xfixes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xfixes-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xfixes-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xfixes-devel.sha256sum] = "bc813fce4e04e40e4539e99d3c8aacea7abfb399a16007ce2a87d9cd0cdb2cee"

URI_x86_64_v2_rust-x11rb+xinerama-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xinerama-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xinerama-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xinerama-devel.sha256sum] = "84c182979022efd8735f170dd1bbcc4b93182c7cd212d1b6f37fa0daf4646f6c"

URI_x86_64_v2_rust-x11rb+xinput-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xinput-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xinput-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xinput-devel.sha256sum] = "1eb9b4456bd48388b121ff7d266d9be2b387ef49f8db01adc04f8ff8e5836ea4"

URI_x86_64_v2_rust-x11rb+xkb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xkb-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xkb-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xkb-devel.sha256sum] = "ce77d515df895f451a9d8a544e1f5a9ac1c27dc708d26466183b5145c19c31eb"

URI_x86_64_v2_rust-x11rb+xprint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xprint-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xprint-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xprint-devel.sha256sum] = "156f17718bf882607a421c7d08bb2542948714930456b4acaaeae0fc59c06f28"

URI_x86_64_v2_rust-x11rb+xselinux-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xselinux-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xselinux-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xselinux-devel.sha256sum] = "cc0b1e75dd73379dc59631c414441c0ce87179f622271765468f523453e0e081"

URI_x86_64_v2_rust-x11rb+xtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xtest-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xtest-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xtest-devel.sha256sum] = "f0f37fa70a3826353d7577d4916aad3126bbfc3e6fa26bd80caab77545431803"

URI_x86_64_v2_rust-x11rb+xv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xv-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xv-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xv-devel.sha256sum] = "6969dc2eaa889887a062efd255c729fe803745be22de77485b220b808edd28b8"

URI_x86_64_v2_rust-x11rb+xvmc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb+xvmc-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb+xvmc-devel}"
SRC_URI[x86_64_v2_rust-x11rb+xvmc-devel.sha256sum] = "f333ef090993f68d345c42917fb76cf66a0036fe418e4ee201b16e904419ec38"

URI_x86_64_v2_rust-x11rb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-x11rb-devel-0.13.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-x11rb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-x11rb-devel}"
SRC_URI[x86_64_v2_rust-x11rb-devel.sha256sum] = "51df630bcf714ba7ab83381b62d87c0e1222a25378bdcd44c48b413729392d9f"

URI_aarch64_rust-x11rb+all-extensions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+all-extensions-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+all-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+all-extensions-devel}"
SRC_URI[aarch64_rust-x11rb+all-extensions-devel.sha256sum] = "f614732465aa91939be85091418799e8ff7e8b3d2316ed1badb7c596aa14e5be"

URI_aarch64_rust-x11rb+allow-unsafe-code-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+allow-unsafe-code-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+allow-unsafe-code-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+allow-unsafe-code-devel}"
SRC_URI[aarch64_rust-x11rb+allow-unsafe-code-devel.sha256sum] = "2e9856fdf914062199f3fdbb6ceb88671373f6ad071c0ee6c236c6d82db3603e"

URI_aarch64_rust-x11rb+as-raw-xcb-connection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+as-raw-xcb-connection-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+as-raw-xcb-connection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+as-raw-xcb-connection-devel}"
SRC_URI[aarch64_rust-x11rb+as-raw-xcb-connection-devel.sha256sum] = "e262a2ac18b80194e2a176e8e81384e3b54cb76df11c4c24c2d7c6835402352b"

URI_aarch64_rust-x11rb+composite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+composite-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+composite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+composite-devel}"
SRC_URI[aarch64_rust-x11rb+composite-devel.sha256sum] = "9d410353ef9213306e13c3a99496386b29e48f38cf264e90de2ff3abb59f9886"

URI_aarch64_rust-x11rb+cursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+cursor-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+cursor-devel}"
SRC_URI[aarch64_rust-x11rb+cursor-devel.sha256sum] = "57bd064be50e57cdd272b7fad75ac6bd4e80d4705069100fa46dffe65befbac9"

URI_aarch64_rust-x11rb+damage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+damage-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+damage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+damage-devel}"
SRC_URI[aarch64_rust-x11rb+damage-devel.sha256sum] = "2ee486e3192f474094434606c4e9cde69827339723d66f19ab4982f1424256b9"

URI_aarch64_rust-x11rb+dbe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dbe-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+dbe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dbe-devel}"
SRC_URI[aarch64_rust-x11rb+dbe-devel.sha256sum] = "70ff3aae61e1d960d4fc31115e333b5c25d160f805ad68e29977cef7fe6f2491"

URI_aarch64_rust-x11rb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+default-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+default-devel}"
SRC_URI[aarch64_rust-x11rb+default-devel.sha256sum] = "16367e42817f0c42c6b34dc15ce36272dc57e744cb0e4ffd9fde242716723d3b"

URI_aarch64_rust-x11rb+dl-libxcb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dl-libxcb-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+dl-libxcb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dl-libxcb-devel}"
SRC_URI[aarch64_rust-x11rb+dl-libxcb-devel.sha256sum] = "ac11a9eac48559b65615fe6f3438a39ea12a59a615a2e8fba9d42912eab70d70"

URI_aarch64_rust-x11rb+dpms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dpms-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+dpms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dpms-devel}"
SRC_URI[aarch64_rust-x11rb+dpms-devel.sha256sum] = "bbce8be02b40a3e469a9e4f89d0bf8f1d264a703cc927e7a19ff9739e452ae1f"

URI_aarch64_rust-x11rb+dri2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dri2-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+dri2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dri2-devel}"
SRC_URI[aarch64_rust-x11rb+dri2-devel.sha256sum] = "a863cf57e15b3de322238148cc7fc42a7ed529a0d169ec470e081c92635625a8"

URI_aarch64_rust-x11rb+dri3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+dri3-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+dri3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+dri3-devel}"
SRC_URI[aarch64_rust-x11rb+dri3-devel.sha256sum] = "876c87089c9154a00ef04d079e2b17d5b84f704f90e2c459d21a73b952b2418d"

URI_aarch64_rust-x11rb+extra-traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+extra-traits-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+extra-traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+extra-traits-devel}"
SRC_URI[aarch64_rust-x11rb+extra-traits-devel.sha256sum] = "4bdfae8e0a4db029b7a6547303c1ba6b8ed5a511e4dfecc1916b911643e3659a"

URI_aarch64_rust-x11rb+glx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+glx-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+glx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+glx-devel}"
SRC_URI[aarch64_rust-x11rb+glx-devel.sha256sum] = "ac40be34b102bfb40a368149b3b63a576218dc51f074146a5d81ca748686b9b8"

URI_aarch64_rust-x11rb+image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+image-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+image-devel}"
SRC_URI[aarch64_rust-x11rb+image-devel.sha256sum] = "e92dd46fb889e0a6dc39cb10aabeae40ad762fd259856d541d32e2fef9f618cc"

URI_aarch64_rust-x11rb+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+libc-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+libc-devel}"
SRC_URI[aarch64_rust-x11rb+libc-devel.sha256sum] = "c35a33b2cc79f6b9feb40376f954742fafd3b70ff872ee5cb60c4b868b691661"

URI_aarch64_rust-x11rb+libloading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+libloading-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+libloading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+libloading-devel}"
SRC_URI[aarch64_rust-x11rb+libloading-devel.sha256sum] = "63897e9fd89031a5d2b30304b2f16ce13a6ac693af37a7334c50be38929306d1"

URI_aarch64_rust-x11rb+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+once_cell-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+once_cell-devel}"
SRC_URI[aarch64_rust-x11rb+once_cell-devel.sha256sum] = "912dc0ae9146636c65981e9017442de0b9d1946abcb6fecb943b8c95570639fa"

URI_aarch64_rust-x11rb+present-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+present-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+present-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+present-devel}"
SRC_URI[aarch64_rust-x11rb+present-devel.sha256sum] = "e245a37cb7fc15858f37fefb00b21ed85ec5f0be1d46661e5f77bbbb467699ae"

URI_aarch64_rust-x11rb+randr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+randr-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+randr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+randr-devel}"
SRC_URI[aarch64_rust-x11rb+randr-devel.sha256sum] = "ec8277ea0a1e034f1a4d3d37ee458f09ab000c0e3e67be6839f481b914048571"

URI_aarch64_rust-x11rb+raw-window-handle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+raw-window-handle-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+raw-window-handle-devel}"
SRC_URI[aarch64_rust-x11rb+raw-window-handle-devel.sha256sum] = "4520f86f793ae97bf6477d689e04f70eb5f2f94c697a59998057660aa83a3c37"

URI_aarch64_rust-x11rb+record-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+record-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+record-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+record-devel}"
SRC_URI[aarch64_rust-x11rb+record-devel.sha256sum] = "4a053eea9a20c057c271b2db7792e8b0026bf3c71da5bf139f7e226d5424e215"

URI_aarch64_rust-x11rb+render-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+render-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+render-devel}"
SRC_URI[aarch64_rust-x11rb+render-devel.sha256sum] = "3ef17eb11d13f2e15404e6e1b8652d9bdefe4cdceb635c1440c4c5cd6062fe8e"

URI_aarch64_rust-x11rb+request-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+request-parsing-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+request-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+request-parsing-devel}"
SRC_URI[aarch64_rust-x11rb+request-parsing-devel.sha256sum] = "e3eabbe5b42685f4eadd6890954d0766db73bfb5adf4dcb290aaf04890e0ce39"

URI_aarch64_rust-x11rb+res-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+res-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+res-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+res-devel}"
SRC_URI[aarch64_rust-x11rb+res-devel.sha256sum] = "e81779fba09c111af19358f02fcd007a1933b1920b52f535fb96046db02aba96"

URI_aarch64_rust-x11rb+resource_manager-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+resource_manager-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+resource_manager-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+resource_manager-devel}"
SRC_URI[aarch64_rust-x11rb+resource_manager-devel.sha256sum] = "af9faa40f5b4fec7f69ec47f81af5946ed051ef3a8fa06b2e688855a7f596889"

URI_aarch64_rust-x11rb+screensaver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+screensaver-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+screensaver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+screensaver-devel}"
SRC_URI[aarch64_rust-x11rb+screensaver-devel.sha256sum] = "b294f9c6b6b88d40542645d66616923bae51be82aa27a73569588d35d3ee51d0"

URI_aarch64_rust-x11rb+shape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+shape-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+shape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+shape-devel}"
SRC_URI[aarch64_rust-x11rb+shape-devel.sha256sum] = "4753245b49de3e4a173d86a32bd081e65424ac93c9018c0c543631356d7356e5"

URI_aarch64_rust-x11rb+shm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+shm-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+shm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+shm-devel}"
SRC_URI[aarch64_rust-x11rb+shm-devel.sha256sum] = "2f4eff14fa643bc6b471123ea5785eddb0b369bbbdf674dea62caa295a0b4195"

URI_aarch64_rust-x11rb+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+sync-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+sync-devel}"
SRC_URI[aarch64_rust-x11rb+sync-devel.sha256sum] = "b53a7db8fc47a7086007e1bc07bcbb7db0707c601b9807e672feddc79c731180"

URI_aarch64_rust-x11rb+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+tracing-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+tracing-devel}"
SRC_URI[aarch64_rust-x11rb+tracing-devel.sha256sum] = "aee5a60f843f78f3b9362e05f4652591a96f644180d139b05d17ef4bf2af204e"

URI_aarch64_rust-x11rb+xcursor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xcursor-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xcursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xcursor-devel}"
SRC_URI[aarch64_rust-x11rb+xcursor-devel.sha256sum] = "a714e8e7da539589e9d1610d6250adf788d823be92939c6121339582e104b470"

URI_aarch64_rust-x11rb+xevie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xevie-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xevie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xevie-devel}"
SRC_URI[aarch64_rust-x11rb+xevie-devel.sha256sum] = "d1df0a1ee23b8eae780cdea333670dc4c3f8b5264a6d00ed10273f7bc1bdb4f0"

URI_aarch64_rust-x11rb+xf86dri-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xf86dri-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xf86dri-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xf86dri-devel}"
SRC_URI[aarch64_rust-x11rb+xf86dri-devel.sha256sum] = "891bbc627867b4b053a21d6440f5807c8602320d7f0e0f41160db8b24b8b838c"

URI_aarch64_rust-x11rb+xf86vidmode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xf86vidmode-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xf86vidmode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xf86vidmode-devel}"
SRC_URI[aarch64_rust-x11rb+xf86vidmode-devel.sha256sum] = "fc08d98065e4951b06b959a2ed17880f43ab5b4ba4770e00173cf263d0407972"

URI_aarch64_rust-x11rb+xfixes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xfixes-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xfixes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xfixes-devel}"
SRC_URI[aarch64_rust-x11rb+xfixes-devel.sha256sum] = "21d983e44e7401c09968e9643b67ccac4e97e37e7d20825454fb029406135df2"

URI_aarch64_rust-x11rb+xinerama-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xinerama-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xinerama-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xinerama-devel}"
SRC_URI[aarch64_rust-x11rb+xinerama-devel.sha256sum] = "1aa36457575eced7ea3b74c6d86b1764bc30558715ab0833e3ad1c38e747e082"

URI_aarch64_rust-x11rb+xinput-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xinput-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xinput-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xinput-devel}"
SRC_URI[aarch64_rust-x11rb+xinput-devel.sha256sum] = "61b0aa736d126f9c31c2b41725b18c5edc92d6bcde4b03c0ed1210d609f4f61c"

URI_aarch64_rust-x11rb+xkb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xkb-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xkb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xkb-devel}"
SRC_URI[aarch64_rust-x11rb+xkb-devel.sha256sum] = "a411ff5e58c6bcfdc27ea10560b11442c09549c28e4903d12149303f0e2e4698"

URI_aarch64_rust-x11rb+xprint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xprint-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xprint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xprint-devel}"
SRC_URI[aarch64_rust-x11rb+xprint-devel.sha256sum] = "dc450b4c0949e989ecf5c54a179af77acbf460ba59668e0654ed74da73284567"

URI_aarch64_rust-x11rb+xselinux-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xselinux-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xselinux-devel}"
SRC_URI[aarch64_rust-x11rb+xselinux-devel.sha256sum] = "d3ff42e07b7b3e0e3e53fa05051b4e5ad26a824d44bb11107b7642e096f25b0d"

URI_aarch64_rust-x11rb+xtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xtest-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xtest-devel}"
SRC_URI[aarch64_rust-x11rb+xtest-devel.sha256sum] = "ff16270f365e288885ed23de3bf06802d055031af3e8b8e7c87d9331c8ebb27b"

URI_aarch64_rust-x11rb+xv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xv-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xv-devel}"
SRC_URI[aarch64_rust-x11rb+xv-devel.sha256sum] = "ee9c5baac57c2d22c333f13cdd43778d066251ae608642f308ce48d3ca0a402d"

URI_aarch64_rust-x11rb+xvmc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb+xvmc-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb+xvmc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb+xvmc-devel}"
SRC_URI[aarch64_rust-x11rb+xvmc-devel.sha256sum] = "df0de522a3d5ac08e7f7e742dad298d21063c1352d151f012e1684b292434664"

URI_aarch64_rust-x11rb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-x11rb-devel-0.13.2-1.el10_2.noarch.rpm;name=aarch64_rust-x11rb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-x11rb-devel}"
SRC_URI[aarch64_rust-x11rb-devel.sha256sum] = "1ca0be32b8a83d77558e260800f829f8054c7b6673baf8a66dd74cad6dbdd82d"

RDEPENDS:rust-x11rb+all-extensions-devel = " \
 cargo \
 rust-x11rb+composite-devel \
 rust-x11rb+damage-devel \
 rust-x11rb+dbe-devel \
 rust-x11rb+dpms-devel \
 rust-x11rb+dri2-devel \
 rust-x11rb+dri3-devel \
 rust-x11rb+glx-devel \
 rust-x11rb+present-devel \
 rust-x11rb+randr-devel \
 rust-x11rb+record-devel \
 rust-x11rb+render-devel \
 rust-x11rb+res-devel \
 rust-x11rb+screensaver-devel \
 rust-x11rb+shape-devel \
 rust-x11rb+shm-devel \
 rust-x11rb+sync-devel \
 rust-x11rb+xevie-devel \
 rust-x11rb+xf86dri-devel \
 rust-x11rb+xf86vidmode-devel \
 rust-x11rb+xfixes-devel \
 rust-x11rb+xinerama-devel \
 rust-x11rb+xinput-devel \
 rust-x11rb+xkb-devel \
 rust-x11rb+xprint-devel \
 rust-x11rb+xselinux-devel \
 rust-x11rb+xtest-devel \
 rust-x11rb+xv-devel \
 rust-x11rb+xvmc-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+all-extensions-devel \
 "
RDEPENDS:rust-x11rb+allow-unsafe-code-devel = " \
 cargo \
 rust-x11rb+as-raw-xcb-connection-devel \
 rust-x11rb+libc-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+as-raw-xcb-connection-devel = " \
 cargo \
 rust-as-raw-xcb-connection+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+composite-devel = " \
 cargo \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+composite-devel \
 "
RDEPENDS:rust-x11rb+cursor-devel = " \
 cargo \
 rust-x11rb+render-devel \
 rust-x11rb+resource_manager-devel \
 rust-x11rb+xcursor-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+damage-devel = " \
 cargo \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+damage-devel \
 "
RDEPENDS:rust-x11rb+dbe-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dbe-devel \
 "
RDEPENDS:rust-x11rb+default-devel = " \
 cargo \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+dl-libxcb-devel = " \
 cargo \
 rust-x11rb+allow-unsafe-code-devel \
 rust-x11rb+libloading-devel \
 rust-x11rb+once_cell-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+dpms-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dpms-devel \
 "
RDEPENDS:rust-x11rb+dri2-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dri2-devel \
 "
RDEPENDS:rust-x11rb+dri3-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+dri3-devel \
 "
RDEPENDS:rust-x11rb+extra-traits-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+extra-traits-devel \
 "
RDEPENDS:rust-x11rb+glx-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+glx-devel \
 "
RDEPENDS:rust-x11rb+image-devel = " \
 cargo \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+libloading-devel = " \
 cargo \
 rust-libloading+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+once_cell-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+present-devel = " \
 cargo \
 rust-x11rb+randr-devel \
 rust-x11rb+sync-devel \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+present-devel \
 "
RDEPENDS:rust-x11rb+randr-devel = " \
 cargo \
 rust-x11rb+render-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+randr-devel \
 "
RDEPENDS:rust-x11rb+raw-window-handle-devel = " \
 cargo \
 rust-raw-window-handle0.5+default-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+record-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+record-devel \
 "
RDEPENDS:rust-x11rb+render-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+render-devel \
 "
RDEPENDS:rust-x11rb+request-parsing-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+request-parsing-devel \
 "
RDEPENDS:rust-x11rb+res-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+res-devel \
 "
RDEPENDS:rust-x11rb+resource_manager-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+resource_manager-devel \
 "
RDEPENDS:rust-x11rb+screensaver-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+screensaver-devel \
 "
RDEPENDS:rust-x11rb+shape-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+shape-devel \
 "
RDEPENDS:rust-x11rb+shm-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+shm-devel \
 "
RDEPENDS:rust-x11rb+sync-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+sync-devel \
 "
RDEPENDS:rust-x11rb+tracing-devel = " \
 cargo \
 rust-tracing-devel \
 rust-x11rb-devel \
 "
RDEPENDS:rust-x11rb+xcursor-devel:x86_64_v2 = " \
 cargo \
 rust-x11rb-devel \
"
RDEPENDS:rust-x11rb+xcursor-devel:aarch64 = " \
 cargo \
 rust-x11rb-devel \
 rust-xcursor+default-devel \
"
RDEPENDS:rust-x11rb+xevie-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xevie-devel \
 "
RDEPENDS:rust-x11rb+xf86dri-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xf86dri-devel \
 "
RDEPENDS:rust-x11rb+xf86vidmode-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xf86vidmode-devel \
 "
RDEPENDS:rust-x11rb+xfixes-devel = " \
 cargo \
 rust-x11rb+render-devel \
 rust-x11rb+shape-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xfixes-devel \
 "
RDEPENDS:rust-x11rb+xinerama-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xinerama-devel \
 "
RDEPENDS:rust-x11rb+xinput-devel = " \
 cargo \
 rust-x11rb+xfixes-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xinput-devel \
 "
RDEPENDS:rust-x11rb+xkb-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xkb-devel \
 "
RDEPENDS:rust-x11rb+xprint-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xprint-devel \
 "
RDEPENDS:rust-x11rb+xselinux-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xselinux-devel \
 "
RDEPENDS:rust-x11rb+xtest-devel = " \
 cargo \
 rust-x11rb-devel \
 rust-x11rb-protocol+xtest-devel \
 "
RDEPENDS:rust-x11rb+xv-devel = " \
 cargo \
 rust-x11rb+shm-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xv-devel \
 "
RDEPENDS:rust-x11rb+xvmc-devel = " \
 cargo \
 rust-x11rb+xv-devel \
 rust-x11rb-devel \
 rust-x11rb-protocol+xvmc-devel \
 "
RDEPENDS:rust-x11rb-devel = " \
 cargo \
 rust \
 rust-gethostname+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+std-devel \
 rust-rustix+system-devel \
 rust-rustix-devel \
 rust-x11rb-protocol+std-devel \
 rust-x11rb-protocol-devel \
 "
