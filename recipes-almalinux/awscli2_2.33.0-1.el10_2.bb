# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awscli2"
PV = "2.33.0"
PR = "1.el10_2"
PACKAGES = " \
 awscli2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/awscli2-2.33.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a58cfde06e90c5425d63a7ddffeb7c5a3432082de06e48a1c267cb13c650427"

URI_x86_64_v2_awscli2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/awscli2-2.33.0-1.el10_2.noarch.rpm;name=x86_64_v2_awscli2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awscli2}"
SRC_URI[x86_64_v2_awscli2.sha256sum] = "084cdf66ae20cbc1f76698fc721fceb69726011cac2662da5b38bcd3b9c05f41"

URI_aarch64_awscli2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/awscli2-2.33.0-1.el10_2.noarch.rpm;name=aarch64_awscli2;unpack=0"
SRC_URI:append = " ${URI_aarch64_awscli2}"
SRC_URI[aarch64_awscli2.sha256sum] = "084cdf66ae20cbc1f76698fc721fceb69726011cac2662da5b38bcd3b9c05f41"

RDEPENDS:awscli2 = " \
 python3 \
 python3-awscrt \
 python3-colorama \
 python3-dateutil \
 python3-distro \
 python3-docutils \
 python3-jmespath \
 python3-prompt-toolkit \
 python3-ruamel-yaml \
 python3-ruamel-yaml-clib \
 python3-urllib3 \
 "
