# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "file"
PV = "5.45"
PR = "8.el10"
PACKAGES = " \
 file \
 file-devel \
 file-libs \
 python3-file-magic \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/file-5.45-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c06e9150e236161e191689ddcc44a6a1ae50b09ab51d2d5b04c350d1d053227d"

URI_x86_64_v2_file = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/file-5.45-8.el10.x86_64_v2.rpm;name=x86_64_v2_file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_file}"
SRC_URI[x86_64_v2_file.sha256sum] = "795b9eb7df558ddc9df381a2d14dbbba8de4131af3f41f5fa38d85da09c9ce15"

URI_x86_64_v2_file-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/file-devel-5.45-8.el10.x86_64_v2.rpm;name=x86_64_v2_file-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_file-devel}"
SRC_URI[x86_64_v2_file-devel.sha256sum] = "0806df654a0bd5f26cebb60b766e688f1f4528262c9ac1f047f9528f16b61d3c"

URI_x86_64_v2_file-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/file-libs-5.45-8.el10.x86_64_v2.rpm;name=x86_64_v2_file-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_file-libs}"
SRC_URI[x86_64_v2_file-libs.sha256sum] = "a5a175dc3410c1cbffc18047064e59e32695e6fc4cbab66c6e8c207388889464"

URI_x86_64_v2_python3-file-magic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-file-magic-5.45-8.el10.noarch.rpm;name=x86_64_v2_python3-file-magic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-file-magic}"
SRC_URI[x86_64_v2_python3-file-magic.sha256sum] = "deb4398a2eefb8ae6f77abad35f8b8a534415b0303b1f5dbde8147085967d01e"

URI_aarch64_file = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/file-5.45-8.el10.aarch64.rpm;name=aarch64_file;unpack=0"
SRC_URI:append = " ${URI_aarch64_file}"
SRC_URI[aarch64_file.sha256sum] = "a8dc16b9e32b488408f8ba0c422fc35f065bc7f34477d28165849e53b1e05354"

URI_aarch64_file-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/file-devel-5.45-8.el10.aarch64.rpm;name=aarch64_file-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_file-devel}"
SRC_URI[aarch64_file-devel.sha256sum] = "7f1114239bf0d2ec5160988cf347e1f47ae4634a1586075a7767423ad093a5b4"

URI_aarch64_file-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/file-libs-5.45-8.el10.aarch64.rpm;name=aarch64_file-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_file-libs}"
SRC_URI[aarch64_file-libs.sha256sum] = "6b610634de438c658e8224929dfcc801c1a0921e016c7c6f4e9d3a82daeac5e1"

URI_aarch64_python3-file-magic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-file-magic-5.45-8.el10.noarch.rpm;name=aarch64_python3-file-magic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-file-magic}"
SRC_URI[aarch64_python3-file-magic.sha256sum] = "deb4398a2eefb8ae6f77abad35f8b8a534415b0303b1f5dbde8147085967d01e"

RDEPENDS:file = " \
 file-libs \
 glibc \
 "
RDEPENDS:file-devel = " \
 file-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:file-libs = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:python3-file-magic = " \
 file-libs \
 python3 \
 "
