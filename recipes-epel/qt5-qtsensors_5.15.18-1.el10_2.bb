# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtsensors"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtsensors \
 qt5-qtsensors-devel \
 qt5-qtsensors-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtsensors-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71c462f60f850fb864e8bb230a295749f8fae4b232ca206eb01da60b2d9d6468"

URI_x86_64_v2_qt5-qtsensors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors}"
SRC_URI[x86_64_v2_qt5-qtsensors.sha256sum] = "8f0378a33df808781e471e51a01e2aebb2f3450bacde557733100a8aff8578ea"

URI_x86_64_v2_qt5-qtsensors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors-devel}"
SRC_URI[x86_64_v2_qt5-qtsensors-devel.sha256sum] = "cdecf4914bcf81202d45b697b3087468c6130d0e87bda5b74283d557f685db65"

URI_x86_64_v2_qt5-qtsensors-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtsensors-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtsensors-examples}"
SRC_URI[x86_64_v2_qt5-qtsensors-examples.sha256sum] = "2cb30cb3eae578e4ef94396726c2dfdea9661a49e0bd9bdd0af6281a188c199c"

URI_aarch64_qt5-qtsensors = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtsensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors}"
SRC_URI[aarch64_qt5-qtsensors.sha256sum] = "4f2827867cca05d6ccf1ffeacd4e45c11f41d1d82a1e659c534a555a1579a17b"

URI_aarch64_qt5-qtsensors-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtsensors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors-devel}"
SRC_URI[aarch64_qt5-qtsensors-devel.sha256sum] = "eeb0aa724eafb4f167e599dc13178042e604d1bb31e7db8d039e10f413a2ed54"

URI_aarch64_qt5-qtsensors-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtsensors-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtsensors-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtsensors-examples}"
SRC_URI[aarch64_qt5-qtsensors-examples.sha256sum] = "38ee8d2b5f25f15f1c7ca1feffcc9851f17e35fd23a98cbf6c610ad5c8843b42"

RDEPENDS:qt5-qtsensors = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtsensors-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtsensors \
 "
RDEPENDS:qt5-qtsensors-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtsensors \
 "
