# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libblockdev"
PV = "3.2.0"
PR = "4.el10_0"
PACKAGES = " \
 libblockdev \
 libblockdev-crypto \
 libblockdev-dm \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-lvm \
 libblockdev-lvm-dbus \
 libblockdev-mdraid \
 libblockdev-mpath \
 libblockdev-nvdimm \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-plugins-all \
 libblockdev-smart \
 libblockdev-smartmontools \
 libblockdev-swap \
 libblockdev-tools \
 libblockdev-utils \
 python3-blockdev \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libblockdev-3.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe11b9378ff419e4d7de11641a8a825c795ae9093a775651661e1dba9f97a7cd"

URI_x86_64_v2_libblockdev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev}"
SRC_URI[x86_64_v2_libblockdev.sha256sum] = "63fc5e5dd95ae1fd145a77a75110296cee1a6efd2fd619e616b42bc503823a2b"

URI_x86_64_v2_libblockdev-crypto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-crypto-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-crypto}"
SRC_URI[x86_64_v2_libblockdev-crypto.sha256sum] = "5ba5aab620d3c2a23349f36b07fe8f786fa12c8e03d98af3c64115c16ba240ca"

URI_x86_64_v2_libblockdev-dm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-dm-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-dm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-dm}"
SRC_URI[x86_64_v2_libblockdev-dm.sha256sum] = "9e07e0e7d85feaac9a463cbdeb9cfd1ca2de7abc2ef6803a272eba8457bba0cb"

URI_x86_64_v2_libblockdev-fs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-fs-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-fs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-fs}"
SRC_URI[x86_64_v2_libblockdev-fs.sha256sum] = "c4a05060d3ae71cdd443ce664042b73263d74b0a89fb6a0f426ec1167b8f97fd"

URI_x86_64_v2_libblockdev-loop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-loop-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-loop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-loop}"
SRC_URI[x86_64_v2_libblockdev-loop.sha256sum] = "188c4c4c0faa1c1152fdb426ecad3abfcbe1b95d63261ef635dd0637c680eec9"

URI_x86_64_v2_libblockdev-lvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-lvm-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-lvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-lvm}"
SRC_URI[x86_64_v2_libblockdev-lvm.sha256sum] = "56090f1c94ef0c91e80b00911c85fb3393f043c248f1e54d0d2445a290ebf761"

URI_x86_64_v2_libblockdev-lvm-dbus = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-lvm-dbus-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-lvm-dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-lvm-dbus}"
SRC_URI[x86_64_v2_libblockdev-lvm-dbus.sha256sum] = "d1d7d3bef0a69123434a5d7f0a5818670c17aea8f4a34521164ab25cbb75fde4"

URI_x86_64_v2_libblockdev-mdraid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-mdraid-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-mdraid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-mdraid}"
SRC_URI[x86_64_v2_libblockdev-mdraid.sha256sum] = "0fc83662a9923500eb84b439062c5a8d665b0ca2da9387cba869f76808e96d63"

URI_x86_64_v2_libblockdev-mpath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-mpath-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-mpath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-mpath}"
SRC_URI[x86_64_v2_libblockdev-mpath.sha256sum] = "350e00bd922104eb55a53a9ffe317c031520a89b7101260c045c40c6191ac520"

URI_x86_64_v2_libblockdev-nvdimm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-nvdimm-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-nvdimm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-nvdimm}"
SRC_URI[x86_64_v2_libblockdev-nvdimm.sha256sum] = "3cb207e279103d38c5c6009d8fdc2dac8de79ece24a0abc10b411998e63b33ed"

URI_x86_64_v2_libblockdev-nvme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-nvme-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-nvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-nvme}"
SRC_URI[x86_64_v2_libblockdev-nvme.sha256sum] = "e0da6f0ea35d39e7c769b4c7c11bd440b20372a327e71dcaa36746952265bd6a"

URI_x86_64_v2_libblockdev-part = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-part-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-part;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-part}"
SRC_URI[x86_64_v2_libblockdev-part.sha256sum] = "4c6cc9c11dfc933e50856f26dcca6080a5fe03ecae5d9fcdf8962a8298806f9f"

URI_x86_64_v2_libblockdev-plugins-all = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-plugins-all-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-plugins-all;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-plugins-all}"
SRC_URI[x86_64_v2_libblockdev-plugins-all.sha256sum] = "6f46596471e19e6e1f64ca3726b5bda8e9e7f9dd047b617668a192f0bdab88c0"

URI_x86_64_v2_libblockdev-smart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-smart-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-smart}"
SRC_URI[x86_64_v2_libblockdev-smart.sha256sum] = "4df1a233e73cb54ea3c4e97d06e9dc289576320e878c9af826d38d54402d988e"

URI_x86_64_v2_libblockdev-smartmontools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-smartmontools-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-smartmontools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-smartmontools}"
SRC_URI[x86_64_v2_libblockdev-smartmontools.sha256sum] = "92e736813495be9102ee8d3f50f3022cbac38d7ba87fe78684e9781f252fbac6"

URI_x86_64_v2_libblockdev-swap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-swap-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-swap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-swap}"
SRC_URI[x86_64_v2_libblockdev-swap.sha256sum] = "caa0efd6e822c6fdc84a30a55d108216deb1c4fe2af40d278a42a146e547847d"

URI_x86_64_v2_libblockdev-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-tools-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-tools}"
SRC_URI[x86_64_v2_libblockdev-tools.sha256sum] = "b6548a361d7251dd79d679950f62ee3d17ba60ecede4c41e02a350724fae9c09"

URI_x86_64_v2_libblockdev-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblockdev-utils-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_libblockdev-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblockdev-utils}"
SRC_URI[x86_64_v2_libblockdev-utils.sha256sum] = "eb052609b3b0c4f5b229846643001629f6680d5d6d7994a1cf7748f983b34c79"

URI_x86_64_v2_python3-blockdev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-blockdev-3.2.0-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-blockdev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-blockdev}"
SRC_URI[x86_64_v2_python3-blockdev.sha256sum] = "97d6b4892fab7fb46a7093780c8c53a99f657f879b0a188659e6bae899a49739"

URI_aarch64_libblockdev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev}"
SRC_URI[aarch64_libblockdev.sha256sum] = "3b1c7cb4d7f45c15af9719988502cf21fb047319de1dc0ed43af33ec51a2ca27"

URI_aarch64_libblockdev-crypto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-crypto-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-crypto}"
SRC_URI[aarch64_libblockdev-crypto.sha256sum] = "a091913dc998c82a9df963f90a4454f26313c1e76452c98f57738f060a42b039"

URI_aarch64_libblockdev-dm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-dm-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-dm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-dm}"
SRC_URI[aarch64_libblockdev-dm.sha256sum] = "671fced5b5d77b4abba28580d8fc12c6fa130968c0762b02f47c1e857ddb1e91"

URI_aarch64_libblockdev-fs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-fs-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-fs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-fs}"
SRC_URI[aarch64_libblockdev-fs.sha256sum] = "87e64aaa102f036dfc57c1a4f043ef719ffe13dc9a7b0ae483e507c2f1e28377"

URI_aarch64_libblockdev-loop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-loop-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-loop;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-loop}"
SRC_URI[aarch64_libblockdev-loop.sha256sum] = "2c29f15f6c8806ebf8ffd51be2480262b70fa4ec60ce20d358c5c20f7216828c"

URI_aarch64_libblockdev-lvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-lvm-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-lvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-lvm}"
SRC_URI[aarch64_libblockdev-lvm.sha256sum] = "4b54ea7a0d3c518182f285a9a6c539329bea729869b17710543b588cab8e1355"

URI_aarch64_libblockdev-lvm-dbus = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-lvm-dbus-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-lvm-dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-lvm-dbus}"
SRC_URI[aarch64_libblockdev-lvm-dbus.sha256sum] = "c9a0e36e45b059ab3dec1d575020cafef582ec7fd69301f8de9e555d5635ed99"

URI_aarch64_libblockdev-mdraid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-mdraid-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-mdraid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-mdraid}"
SRC_URI[aarch64_libblockdev-mdraid.sha256sum] = "dc217892be4ca2668b06c0a5bac8e5a215770c1737de6513ec3187f8ccffccbd"

URI_aarch64_libblockdev-mpath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-mpath-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-mpath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-mpath}"
SRC_URI[aarch64_libblockdev-mpath.sha256sum] = "2de61f5c7f691fe3f0e1060a536f23c23d1dae8fd1a5b2e5b03ab4b8b54fb89d"

URI_aarch64_libblockdev-nvdimm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-nvdimm-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-nvdimm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-nvdimm}"
SRC_URI[aarch64_libblockdev-nvdimm.sha256sum] = "c08bdf66aeeba0ca249cc26521279d4c83cb09e84d9a316745b412c7e6ff0654"

URI_aarch64_libblockdev-nvme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-nvme-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-nvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-nvme}"
SRC_URI[aarch64_libblockdev-nvme.sha256sum] = "0504b4dd4b041899bcef726aaacb14b04382ab1830cc360aa93483335ce197c0"

URI_aarch64_libblockdev-part = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-part-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-part;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-part}"
SRC_URI[aarch64_libblockdev-part.sha256sum] = "90bde11c568192f600c08c406c0eb648d40ed5e78eba3514d7a772ac9153c6ed"

URI_aarch64_libblockdev-plugins-all = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-plugins-all-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-plugins-all;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-plugins-all}"
SRC_URI[aarch64_libblockdev-plugins-all.sha256sum] = "853864f8ad26413ec16cb1873bbd5b0d3996ac9b4ddde31c644764394fbec158"

URI_aarch64_libblockdev-smart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-smart-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-smart}"
SRC_URI[aarch64_libblockdev-smart.sha256sum] = "8ac124eb759e32c046884c883ab63babacbc4490c5ee1abe2a527b6f030891b3"

URI_aarch64_libblockdev-smartmontools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-smartmontools-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-smartmontools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-smartmontools}"
SRC_URI[aarch64_libblockdev-smartmontools.sha256sum] = "f02b91e27bf48164e88ed1c0786f787fd070816a53e6f0b298c1b82b3d7f71bb"

URI_aarch64_libblockdev-swap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-swap-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-swap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-swap}"
SRC_URI[aarch64_libblockdev-swap.sha256sum] = "76e108b279035943eea5ab70cf8f947d5217da8f8d85aa12c7e3b4477f88b65e"

URI_aarch64_libblockdev-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-tools-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-tools}"
SRC_URI[aarch64_libblockdev-tools.sha256sum] = "356949d9373cafbc7a9514af903dcf018cd1e32a0d7cb90f7cc2fc6009680b4b"

URI_aarch64_libblockdev-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblockdev-utils-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_libblockdev-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblockdev-utils}"
SRC_URI[aarch64_libblockdev-utils.sha256sum] = "0b65220768c48a855de54cf074c8a9c01a2fe72b9f436d405335d36af3d4fc6a"

URI_aarch64_python3-blockdev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-blockdev-3.2.0-4.el10_0.aarch64.rpm;name=aarch64_python3-blockdev;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-blockdev}"
SRC_URI[aarch64_python3-blockdev.sha256sum] = "1f17123a6789122120a90ef0d174f96d1e9b7541703da245fa07ec980cf1fed9"

RDEPENDS:libblockdev = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-crypto = " \
 cryptsetup-libs \
 glib2 \
 glibc \
 keyutils-libs \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 libgcc \
 nspr \
 nss \
 nss-util \
 systemd-libs \
 volume_key-libs \
 "
RDEPENDS:libblockdev-dm = " \
 device-mapper \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-fs = " \
 e2fsprogs-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 libgcc \
 libmount \
 libuuid \
 systemd-libs \
 "
RDEPENDS:libblockdev-loop = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libgcc \
 systemd-libs \
 "
RDEPENDS:libblockdev-lvm = " \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libgcc \
 libyaml \
 lvm2 \
 systemd-libs \
 "
RDEPENDS:libblockdev-lvm-dbus = " \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libgcc \
 libyaml \
 lvm2-dbusd \
 systemd-libs \
 "
RDEPENDS:libblockdev-mdraid = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libbytesize \
 libgcc \
 mdadm \
 systemd-libs \
 "
RDEPENDS:libblockdev-mpath = " \
 device-mapper-libs \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-nvdimm = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libuuid \
 ndctl \
 ndctl-libs \
 systemd-libs \
 "
RDEPENDS:libblockdev-nvme = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libnvme \
 systemd-libs \
 "
RDEPENDS:libblockdev-part = " \
 glib2 \
 glibc \
 kmod-libs \
 libblockdev-utils \
 libfdisk \
 systemd-libs \
 util-linux \
 "
RDEPENDS:libblockdev-plugins-all = " \
 libblockdev \
 libblockdev-crypto \
 libblockdev-dm \
 libblockdev-fs \
 libblockdev-loop \
 libblockdev-lvm \
 libblockdev-mdraid \
 libblockdev-mpath \
 libblockdev-nvdimm \
 libblockdev-nvme \
 libblockdev-part \
 libblockdev-smart \
 libblockdev-smartmontools \
 libblockdev-swap \
 "
RDEPENDS:libblockdev-smart = " \
 glib2 \
 glibc \
 kmod-libs \
 libatasmart \
 libblockdev-utils \
 systemd-libs \
 "
RDEPENDS:libblockdev-smartmontools = " \
 glib2 \
 glibc \
 json-glib \
 kmod-libs \
 libblockdev-utils \
 smartmontools \
 systemd-libs \
 "
RDEPENDS:libblockdev-swap = " \
 glib2 \
 glibc \
 kmod-libs \
 libblkid \
 libblockdev-utils \
 libgcc \
 libuuid \
 systemd-libs \
 util-linux \
 "
RDEPENDS:libblockdev-tools = " \
 glib2 \
 glibc \
 libblockdev \
 libblockdev-lvm \
 libbytesize \
 parted \
 "
RDEPENDS:libblockdev-utils = " \
 glib2 \
 glibc \
 kmod-libs \
 systemd-libs \
 "
RDEPENDS:python3-blockdev = " \
 libblockdev \
 python3 \
 python3-bytesize \
 python3-gobject-base \
 "
