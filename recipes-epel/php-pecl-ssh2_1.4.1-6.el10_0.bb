# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-ssh2"
PV = "1.4.1"
PR = "6.el10_0"
PACKAGES = " \
 php-pecl-ssh2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-ssh2-1.4.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3de2bbe8850e81e29acadac2bea2f2af8fc8fbbdad7bf65c3cea94c26b7c25da"

URI_x86_64_v2_php-pecl-ssh2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-ssh2-1.4.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-ssh2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-ssh2}"
SRC_URI[x86_64_v2_php-pecl-ssh2.sha256sum] = "7dcf1104aa4619a801c7d618dc28c077c5dbb106f434f81f700d6148d8c1b57f"

URI_aarch64_php-pecl-ssh2 = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-ssh2-1.4.1-6.el10_0.aarch64.rpm;name=aarch64_php-pecl-ssh2;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-ssh2}"
SRC_URI[aarch64_php-pecl-ssh2.sha256sum] = "85c64fd86fc137cb77b5a86774acf92f8b039dedbe80b20b71933d5c47d66426"

RDEPENDS:php-pecl-ssh2 = " \
 glibc \
 libssh2 \
 php-common \
 "
