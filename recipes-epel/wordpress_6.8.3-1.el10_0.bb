# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wordpress"
PV = "6.8.3"
PR = "1.el10_0"
PACKAGES = " \
 wordpress \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wordpress-6.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34704e0f711c7636d20c1db5f747d476db5ac3be7f000809e1cf1d5c645b2eed"

URI_x86_64_v2_wordpress = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wordpress-6.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_wordpress;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wordpress}"
SRC_URI[x86_64_v2_wordpress.sha256sum] = "6b3a35f02779532974b70d15fa0ac0bfd409406f17ad3c458ba3ca23e29e9eea"

URI_aarch64_wordpress = "${EPEL_MIRROR}/aarch64/Packages/w/wordpress-6.8.3-1.el10_0.noarch.rpm;name=aarch64_wordpress;unpack=0"
SRC_URI:append = " ${URI_aarch64_wordpress}"
SRC_URI[aarch64_wordpress.sha256sum] = "027b76f8e67577561e8f80bd51837fba2bb1e2fbfa3107a16caa535c6bef524a"

RDEPENDS:wordpress = " \
 ca-certificates \
 httpd \
 httpd-filesystem \
 nginx-filesystem \
 php-common \
 php-fpm \
 php-gd \
 php-intl \
 php-mbstring \
 php-mysqlnd \
 php-pecl-zip \
 php-sodium \
 php-xml \
 virtual/webserver \
 "
