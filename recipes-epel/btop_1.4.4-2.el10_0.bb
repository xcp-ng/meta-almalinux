# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "btop"
PV = "1.4.4"
PR = "2.el10_0"
PACKAGES = " \
 btop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/btop-1.4.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f21339bcdafaf6cd46c24784504f06c4d525a0c8a9698cbfe5e37b61cdd036f2"

URI_x86_64_v2_btop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/btop-1.4.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_btop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_btop}"
SRC_URI[x86_64_v2_btop.sha256sum] = "7d9025172462ec1f3ffcd92fc1eb2b2f2a1012b00c15f0b606e8b4984297caee"

URI_aarch64_btop = "${EPEL_MIRROR}/aarch64/Packages/b/btop-1.4.4-2.el10_0.aarch64.rpm;name=aarch64_btop;unpack=0"
SRC_URI:append = " ${URI_aarch64_btop}"
SRC_URI[aarch64_btop.sha256sum] = "fe7b48495c7fd5988d783de93a758786c11566433ef53c21f105abe98ddfaaf3"

RDEPENDS:btop = " \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 "
