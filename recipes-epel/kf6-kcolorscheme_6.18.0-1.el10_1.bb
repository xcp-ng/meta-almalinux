# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcolorscheme"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kcolorscheme \
 kf6-kcolorscheme-devel \
 kf6-kcolorscheme-doc \
 kf6-kcolorscheme-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kcolorscheme-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9425953dcf45445c0fa90ef87be15bf2b0236180b88277201de77ada391153e6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme;unpack=0"
SRC_URI[x86_64_v2_kf6-kcolorscheme.sha256sum] = "466f839d257dcb1c4b52a177f17dc6043a4eddb771f68e199686d9907295382e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kcolorscheme-devel.sha256sum] = "20335849e6f46a2a37949fc778a05de412c68ea93c7ab3949c0d82722edc3d1b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcolorscheme-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kcolorscheme-doc.sha256sum] = "798495b1468fbe037f3e5fd10ebe7a2e02f1e7aac054d207c5e9f3f2b0411a54"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcolorscheme-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kcolorscheme-html.sha256sum] = "ab0564c9901128d28bc19a8e0b7dd0d52726ba8c6bc5a0a1d0d32834e042d72e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcolorscheme;unpack=0"
SRC_URI[aarch64_kf6-kcolorscheme.sha256sum] = "e3b226b221b40f118f6cf05355b88ce9093fbb286b060a83815715717bc66008"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcolorscheme-devel;unpack=0"
SRC_URI[aarch64_kf6-kcolorscheme-devel.sha256sum] = "078cafe010409d20dc71576c2d19cbc6c33f579dd598a6d26aba4f37c0d65116"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcolorscheme-doc;unpack=0"
SRC_URI[aarch64_kf6-kcolorscheme-doc.sha256sum] = "25ca76f20c1e1da6e842cf390a20492d6e658e2712053f48e3e7fdb9e43051f3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcolorscheme-html;unpack=0"
SRC_URI[aarch64_kf6-kcolorscheme-html.sha256sum] = "1b12c0bca52c9176b45d8ebeb89c599c0a7d722e43ca6acad359d485893df844"

RDEPENDS:kf6-kcolorscheme = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcolorscheme-devel = " \
 cmake-filesystem \
 kf6-kcolorscheme \
 "
RDEPENDS:kf6-kcolorscheme-doc = " \
 "
RDEPENDS:kf6-kcolorscheme-html = " \
 "
