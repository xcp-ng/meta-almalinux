# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ecb0.1"
PV = "0.1.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-ecb0.1+alloc-devel \
 rust-ecb0.1+block-padding-devel \
 rust-ecb0.1+default-devel \
 rust-ecb0.1+std-devel \
 rust-ecb0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ecb0.1-0.1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fae64e596f067c1744e62193e1dcc1c2fc65e09e7a01c7f78354fa19d79aa579"

URI_x86_64_v2_rust-ecb0.1+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb0.1+alloc-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb0.1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb0.1+alloc-devel}"
SRC_URI[x86_64_v2_rust-ecb0.1+alloc-devel.sha256sum] = "5ae8d7f9cb47b1be4163bd2cd3c927a9fc09856effa9d0f86cceb92b7c694cb0"

URI_x86_64_v2_rust-ecb0.1+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb0.1+block-padding-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb0.1+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb0.1+block-padding-devel}"
SRC_URI[x86_64_v2_rust-ecb0.1+block-padding-devel.sha256sum] = "8d3ac5560f4435437f714fad59e37c66edf5e885b83a3c3b3e93d81a83ba532f"

URI_x86_64_v2_rust-ecb0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb0.1+default-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb0.1+default-devel}"
SRC_URI[x86_64_v2_rust-ecb0.1+default-devel.sha256sum] = "08eee88d715539fb7879741ee74df30cf3775956fa55d31a109c490535b588ab"

URI_x86_64_v2_rust-ecb0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb0.1+std-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb0.1+std-devel}"
SRC_URI[x86_64_v2_rust-ecb0.1+std-devel.sha256sum] = "fb480f2400cb1e1cf8a561919f66ed5e82a9b4bfa8fa4ff0139f62e8ee05c907"

URI_x86_64_v2_rust-ecb0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb0.1-devel-0.1.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb0.1-devel}"
SRC_URI[x86_64_v2_rust-ecb0.1-devel.sha256sum] = "2cf8837421fbbd9457649afef5b17f58672e4c330e314e2068e7cfe6f66e4bbe"

URI_aarch64_rust-ecb0.1+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb0.1+alloc-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-ecb0.1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb0.1+alloc-devel}"
SRC_URI[aarch64_rust-ecb0.1+alloc-devel.sha256sum] = "3a0a359965bdbb61a4b6ae8fc3eaaec5090259036e50da52daefff56b0ede72f"

URI_aarch64_rust-ecb0.1+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb0.1+block-padding-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-ecb0.1+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb0.1+block-padding-devel}"
SRC_URI[aarch64_rust-ecb0.1+block-padding-devel.sha256sum] = "5f445e95c47888da73f5640f67d3a635b1ebcacf74252b57506e45ba896a93e7"

URI_aarch64_rust-ecb0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb0.1+default-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-ecb0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb0.1+default-devel}"
SRC_URI[aarch64_rust-ecb0.1+default-devel.sha256sum] = "a7550f09913f61c44bc25e3f85aa126cba9d440d0fe3d95ffa4c22146adb7db2"

URI_aarch64_rust-ecb0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb0.1+std-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-ecb0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb0.1+std-devel}"
SRC_URI[aarch64_rust-ecb0.1+std-devel.sha256sum] = "82f99d47f8217733ef12f0d66f200ff219809cf2a953fef6bec389241ca4b9f6"

URI_aarch64_rust-ecb0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb0.1-devel-0.1.2-1.el10_3.noarch.rpm;name=aarch64_rust-ecb0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb0.1-devel}"
SRC_URI[aarch64_rust-ecb0.1-devel.sha256sum] = "cb7d7b93daa06422b95f4ea7b514f9c3c7fa0a2c83a9a313d4c68e2caa03580d"

RDEPENDS:rust-ecb0.1+alloc-devel = " \
 cargo \
 rust-cipher0.4+alloc-devel \
 rust-ecb0.1-devel \
 "
RDEPENDS:rust-ecb0.1+block-padding-devel = " \
 cargo \
 rust-cipher0.4+block-padding-devel \
 rust-ecb0.1-devel \
 "
RDEPENDS:rust-ecb0.1+default-devel = " \
 cargo \
 rust-ecb0.1+block-padding-devel \
 rust-ecb0.1-devel \
 "
RDEPENDS:rust-ecb0.1+std-devel = " \
 cargo \
 rust-cipher0.4+std-devel \
 rust-ecb0.1+alloc-devel \
 rust-ecb0.1-devel \
 "
RDEPENDS:rust-ecb0.1-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
