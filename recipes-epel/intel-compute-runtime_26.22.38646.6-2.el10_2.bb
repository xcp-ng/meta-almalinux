# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-compute-runtime"
PV = "26.22.38646.6"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 intel-compute-runtime \
 intel-level-zero \
 intel-level-zero-devel \
 intel-ocloc \
 intel-ocloc-devel \
 intel-opencl \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-compute-runtime-26.22.38646.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1f1c2e86ad50bff62970ee77685e28753cffe119074b8ad242efed1d855a27d"

URI_x86_64_v2_intel-compute-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-compute-runtime-26.22.38646.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-compute-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-compute-runtime}"
SRC_URI[x86_64_v2_intel-compute-runtime.sha256sum] = "fa9ed992f6aed47703447164a5abd4080a63f8752e5b1911c098f3f2afd1bf31"

URI_x86_64_v2_intel-level-zero = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-level-zero-26.22.38646.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-level-zero;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-level-zero}"
SRC_URI[x86_64_v2_intel-level-zero.sha256sum] = "feb2c9e9817c50bbb4c550b69967a887cb633346c0903ee0148620a5eae9d7f3"

URI_x86_64_v2_intel-level-zero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-level-zero-devel-26.22.38646.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-level-zero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-level-zero-devel}"
SRC_URI[x86_64_v2_intel-level-zero-devel.sha256sum] = "ff94f86756ce02f2945d711ca3001f089d3da0f65edae403994e7881b8184286"

URI_x86_64_v2_intel-ocloc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-ocloc-26.22.38646.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-ocloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-ocloc}"
SRC_URI[x86_64_v2_intel-ocloc.sha256sum] = "ade4ee571ee9cbb41e63410df39cc37e68de47156ef26f2ffacd4f4c132a9f95"

URI_x86_64_v2_intel-ocloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-ocloc-devel-26.22.38646.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-ocloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-ocloc-devel}"
SRC_URI[x86_64_v2_intel-ocloc-devel.sha256sum] = "b992e95819a02c5ffbaf684db6bce62b6be039904247ecd24db5cc56740ee044"

URI_x86_64_v2_intel-opencl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-opencl-26.22.38646.6-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-opencl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-opencl}"
SRC_URI[x86_64_v2_intel-opencl.sha256sum] = "c81e220ad2e3412becb8a0a3fab6dbcd736b1120d91f720ac3d7b2fe8c8e8a94"

RDEPENDS:intel-compute-runtime = " \
 intel-igc \
 intel-level-zero \
 intel-ocloc \
 intel-opencl \
 "
RDEPENDS:intel-level-zero = " \
 glibc \
 intel-gmmlib \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-level-zero-devel = " \
 intel-level-zero \
 "
RDEPENDS:intel-ocloc = " \
 bash \
 glibc \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-ocloc-devel = " \
 intel-ocloc \
 "
RDEPENDS:intel-opencl = " \
 glibc \
 intel-gmmlib \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
