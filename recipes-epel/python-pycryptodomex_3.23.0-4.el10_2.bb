# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pycryptodomex"
PV = "3.23.0"
PR = "4.el10_2"
PACKAGES = " \
 python3-pycryptodomex \
 python3-pycryptodomex-selftest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pycryptodomex-3.23.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b70573d5a8853443ab1e5178224e2bc3735f3108ad8c0ef888b7d44ca2223be2"

URI_x86_64_v2_python3-pycryptodomex = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pycryptodomex-3.23.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pycryptodomex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pycryptodomex}"
SRC_URI[x86_64_v2_python3-pycryptodomex.sha256sum] = "f980b88cc8231857ff9f8350130865a3ed83c5f9cecc62aa05cd938bf711a952"

URI_x86_64_v2_python3-pycryptodomex-selftest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pycryptodomex-selftest-3.23.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pycryptodomex-selftest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pycryptodomex-selftest}"
SRC_URI[x86_64_v2_python3-pycryptodomex-selftest.sha256sum] = "d6baad412bd959e2709f39ac8fc19c6f08b23244e3de1df90d4d33591bff2c5c"

URI_aarch64_python3-pycryptodomex = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pycryptodomex-3.23.0-4.el10_2.aarch64.rpm;name=aarch64_python3-pycryptodomex;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pycryptodomex}"
SRC_URI[aarch64_python3-pycryptodomex.sha256sum] = "80954d84a7ad90aa9cf77423eed7fc852c0f4df43958597baea0d6590bbb3e23"

URI_aarch64_python3-pycryptodomex-selftest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pycryptodomex-selftest-3.23.0-4.el10_2.aarch64.rpm;name=aarch64_python3-pycryptodomex-selftest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pycryptodomex-selftest}"
SRC_URI[aarch64_python3-pycryptodomex-selftest.sha256sum] = "578336927fe6c29a2dd3944f101ca8bc3ce20840994f13e7e47cb4c768be9c80"

RDEPENDS:python3-pycryptodomex = " \
 glibc \
 gmp \
 libtomcrypt \
 python3 \
 "
RDEPENDS:python3-pycryptodomex-selftest = " \
 python3 \
 python3-pycryptodomex \
 "
