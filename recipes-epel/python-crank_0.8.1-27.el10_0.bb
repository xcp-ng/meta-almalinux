# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-crank"
PV = "0.8.1"
PR = "27.el10_0"
PACKAGES = " \
 python3-crank \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-crank-0.8.1-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "079082dbaf65f7c250b7435187c136232b87197213f84ff237b2d6df451fa481"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-crank-0.8.1-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-crank;unpack=0"
SRC_URI[x86_64_v2_python3-crank.sha256sum] = "8a2fe58472db752482ff18666a106218c93ba5d465c80c44c8f26b389d26d1e4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-crank-0.8.1-27.el10_0.noarch.rpm;name=aarch64_python3-crank;unpack=0"
SRC_URI[aarch64_python3-crank.sha256sum] = "f18fdec8aef6e95f7257348e4d877ca04b51f9035fbc0b09a8b3cf0c629436d2"

RDEPENDS:python3-crank = " \
 python3 \
 "
