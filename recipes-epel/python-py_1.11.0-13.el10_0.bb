# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-py"
PV = "1.11.0"
PR = "13.el10_0"
PACKAGES = " \
 python3-py \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-py-1.11.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06f5c24fed2ef7ebe8fa204fd0c88aa2ad27479a5d790c18b2ae9a783a1658a1"

URI_x86_64_v2_python3-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-py-1.11.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-py}"
SRC_URI[x86_64_v2_python3-py.sha256sum] = "56ccf6182a40786d4cb1382df3786191841ddff48a327c8030e58a79f19b29bd"

URI_aarch64_python3-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-py-1.11.0-13.el10_0.noarch.rpm;name=aarch64_python3-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-py}"
SRC_URI[aarch64_python3-py.sha256sum] = "44bff6ae3261970673e664f6624f2b0fc9a9420b417c1613e05e3a046245048b"

RDEPENDS:python3-py = " \
 python3 \
 python3-setuptools \
 "
