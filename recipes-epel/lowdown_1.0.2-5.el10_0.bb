# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lowdown"
PV = "1.0.2"
PR = "5.el10_0"
PACKAGES = " \
 lowdown \
 lowdown-devel \
 lowdown-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lowdown-1.0.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d62740cf87987d724c71b1ffd9816c55da87d3ca18b21453812faff2903b5629"

URI_x86_64_v2_lowdown = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lowdown-1.0.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lowdown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lowdown}"
SRC_URI[x86_64_v2_lowdown.sha256sum] = "845941cee1346330275b3b0c1a3a0f0199957e130df03c31418d2492e0d7fb1b"

URI_x86_64_v2_lowdown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lowdown-devel-1.0.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lowdown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lowdown-devel}"
SRC_URI[x86_64_v2_lowdown-devel.sha256sum] = "21b9018fd63d2faddbadb469cf21d1d616645bdfa6654ac0bc5a993e1609a726"

URI_x86_64_v2_lowdown-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lowdown-libs-1.0.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lowdown-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lowdown-libs}"
SRC_URI[x86_64_v2_lowdown-libs.sha256sum] = "bd7b21323f8d04d27df04f8f0d72d6d72b4898a7a32fda6cca09ce097781b2bc"

URI_aarch64_lowdown = "${EPEL_MIRROR}/aarch64/Packages/l/lowdown-1.0.2-5.el10_0.aarch64.rpm;name=aarch64_lowdown;unpack=0"
SRC_URI:append = " ${URI_aarch64_lowdown}"
SRC_URI[aarch64_lowdown.sha256sum] = "e559b52fb0cb3288a6b726bc15bb010fa2a30f9b89026c6d9460bd7604797862"

URI_aarch64_lowdown-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lowdown-devel-1.0.2-5.el10_0.aarch64.rpm;name=aarch64_lowdown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lowdown-devel}"
SRC_URI[aarch64_lowdown-devel.sha256sum] = "6b281a6f5f858c4fc48f2915734b3b523d342300cb1eacb433cae741f964b3ac"

URI_aarch64_lowdown-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lowdown-libs-1.0.2-5.el10_0.aarch64.rpm;name=aarch64_lowdown-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lowdown-libs}"
SRC_URI[aarch64_lowdown-libs.sha256sum] = "290214d5ae8a50001b6eced49bb5b466c88148ee5e28a0b592e636a8dc408972"

RDEPENDS:lowdown = " \
 glibc \
 lowdown-libs \
 "
RDEPENDS:lowdown-devel = " \
 lowdown-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:lowdown-libs = " \
 glibc \
 "
