# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-errors"
PV = "1.1.1"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-errors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-errors-1.1.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bc829e3994a951888fa702cea1df1dcb0b5afc1afdd26c1cf621c73cc1e3240"

URI_x86_64_v2_golang-github-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-errors-devel-1.1.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-errors-devel}"
SRC_URI[x86_64_v2_golang-github-errors-devel.sha256sum] = "f51017a2542e71f9b6195bd7518d8d18672a022988e01d6c190006956d0f9a2d"

URI_aarch64_golang-github-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-errors-devel-1.1.1-14.el10_0.noarch.rpm;name=aarch64_golang-github-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-errors-devel}"
SRC_URI[aarch64_golang-github-errors-devel.sha256sum] = "e5345f06fcaa3d6ed4452241e8fa83a3746ffb1653acdee3e112cfa583ee2d83"

RDEPENDS:golang-github-errors-devel = " \
 go-filesystem \
 "
