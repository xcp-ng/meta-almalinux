# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "msktutil"
PV = "1.2.2"
PR = "2.el10_1"
PACKAGES = " \
 msktutil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/msktutil-1.2.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f679f5d257ca0bc5a0767e8af3d1ec79c42c139b81a06588ec7ad030e58c4cda"

URI_x86_64_v2_msktutil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/msktutil-1.2.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_msktutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msktutil}"
SRC_URI[x86_64_v2_msktutil.sha256sum] = "2d347b7bde9224b2f0be9c59d6a456d7aa2b6c1b81e2a69c7ffd4d8acb646c14"

URI_aarch64_msktutil = "${EPEL_MIRROR}/aarch64/Packages/m/msktutil-1.2.2-2.el10_1.aarch64.rpm;name=aarch64_msktutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_msktutil}"
SRC_URI[aarch64_msktutil.sha256sum] = "a8f33c2055b5e183803232e149df314198d1aa7cb44585eba1b006891bbbd3c0"

RDEPENDS:msktutil = " \
 cyrus-sasl-gssapi \
 glibc \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 openldap \
 "
