# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-openssl"
PV = "0.6.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-tokio-openssl+default-devel \
 rust-tokio-openssl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-openssl-0.6.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "717ca8fb6a6ab388a34fc900c74f4d9c7ef025586eab61e47f6989589c26531b"

URI_x86_64_v2_rust-tokio-openssl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-openssl+default-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-openssl+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-openssl+default-devel.sha256sum] = "62f4c318a143d4f70e4c3f5e9fb53f980cd5f9fa4c7fa642eeef1bc1c49d62f8"

URI_x86_64_v2_rust-tokio-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-openssl-devel-0.6.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-openssl-devel}"
SRC_URI[x86_64_v2_rust-tokio-openssl-devel.sha256sum] = "dc7755f7879b06cba7cd60f7d2518ebd0ba09f60dca9b259c87f566fe5a6237c"

URI_aarch64_rust-tokio-openssl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-openssl+default-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-openssl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-openssl+default-devel}"
SRC_URI[aarch64_rust-tokio-openssl+default-devel.sha256sum] = "71a4ecfc8755b7d785aad63037f20d9a893db5274ae20071eca534582dd9638e"

URI_aarch64_rust-tokio-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-openssl-devel-0.6.5-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-openssl-devel}"
SRC_URI[aarch64_rust-tokio-openssl-devel.sha256sum] = "48bc6aa8e00074e0658b9d117a31c202aa0485c62cb2c2a3630b30099e9ead36"

RDEPENDS:rust-tokio-openssl+default-devel = " \
 cargo \
 rust-tokio-openssl-devel \
 "
RDEPENDS:rust-tokio-openssl-devel = " \
 cargo \
 rust-openssl+default-devel \
 rust-openssl-sys+default-devel \
 rust-tokio+default-devel \
 "
