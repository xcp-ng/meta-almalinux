# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtwebview"
PV = "6.10.1"
PR = "1.el10_2"
PACKAGES = " \
 qt6-qtwebview \
 qt6-qtwebview-devel \
 qt6-qtwebview-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtwebview-6.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8eae29eeb2ef8f69ffa469316e747b624331c27fa6530870e3472994cb86f2d"

URI_x86_64_v2_qt6-qtwebview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebview-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebview}"
SRC_URI[x86_64_v2_qt6-qtwebview.sha256sum] = "e99e9b97f8431d3ffaa92b879043a367e8a2ea639055fda94681e50a0b321aa9"

URI_x86_64_v2_qt6-qtwebview-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebview-devel-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebview-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebview-devel}"
SRC_URI[x86_64_v2_qt6-qtwebview-devel.sha256sum] = "f32409724c819abb3121ea822b9a40d47521b7e7997af727349717ff891521a0"

URI_x86_64_v2_qt6-qtwebview-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtwebview-examples-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtwebview-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtwebview-examples}"
SRC_URI[x86_64_v2_qt6-qtwebview-examples.sha256sum] = "92fbd6eaf5fc3760495d26e2972c3be5f5feee693ec7a508d29c136e27616085"

URI_aarch64_qt6-qtwebview = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebview-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtwebview;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebview}"
SRC_URI[aarch64_qt6-qtwebview.sha256sum] = "668cafe81438f77d82eb210f2d48345795ca8c2eeae3862af36e018c1492d57c"

URI_aarch64_qt6-qtwebview-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebview-devel-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtwebview-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebview-devel}"
SRC_URI[aarch64_qt6-qtwebview-devel.sha256sum] = "255469acb240f261e129d2a73c98c74182371976d08dca875f027ce2a998fd13"

URI_aarch64_qt6-qtwebview-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtwebview-examples-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtwebview-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtwebview-examples}"
SRC_URI[aarch64_qt6-qtwebview-examples.sha256sum] = "58855c6386b7d5416525407850251a1e53df2e55b59ed4685921576fd9b36b62"

RDEPENDS:qt6-qtwebview = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
RDEPENDS:qt6-qtwebview-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtwebview \
 "
RDEPENDS:qt6-qtwebview-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebview \
 "
