# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-OpenGLRaw"
PV = "3.3.4.1"
PR = "9.el10_0"
PACKAGES = " \
 ghc-OpenGLRaw \
 ghc-OpenGLRaw-devel \
 ghc-OpenGLRaw-doc \
 ghc-OpenGLRaw-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-OpenGLRaw-3.3.4.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "971eb19dff986712cd10f14fe47953d08758b5afc26f1c516c1ab1265589ef24"

URI_x86_64_v2_ghc-OpenGLRaw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-OpenGLRaw-3.3.4.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-OpenGLRaw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-OpenGLRaw}"
SRC_URI[x86_64_v2_ghc-OpenGLRaw.sha256sum] = "b61c346d9828e8b85da14826514b3934349636c77898e66dcc6a7a5b572cd9bd"

URI_x86_64_v2_ghc-OpenGLRaw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-OpenGLRaw-devel-3.3.4.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-OpenGLRaw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-OpenGLRaw-devel}"
SRC_URI[x86_64_v2_ghc-OpenGLRaw-devel.sha256sum] = "9f1a2eb52fb604b1ee3e25cfe776d63229de049544c3f0ed07be62ef807e0558"

URI_x86_64_v2_ghc-OpenGLRaw-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-OpenGLRaw-doc-3.3.4.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-OpenGLRaw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-OpenGLRaw-doc}"
SRC_URI[x86_64_v2_ghc-OpenGLRaw-doc.sha256sum] = "01565def40f8f33eabb67470d621765420316148b8d635bf5e1af6f43ac6e611"

URI_x86_64_v2_ghc-OpenGLRaw-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-OpenGLRaw-prof-3.3.4.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-OpenGLRaw-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-OpenGLRaw-prof}"
SRC_URI[x86_64_v2_ghc-OpenGLRaw-prof.sha256sum] = "f5c7ca3b03990ad446ebe90c7f1be108ee156a14515adfc3d18254b927282106"

URI_aarch64_ghc-OpenGLRaw = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-OpenGLRaw-3.3.4.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-OpenGLRaw;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-OpenGLRaw}"
SRC_URI[aarch64_ghc-OpenGLRaw.sha256sum] = "de0191748f20f2ab84c2a77bbfdcdb3de041eb0d2688b890b7d498da40601e51"

URI_aarch64_ghc-OpenGLRaw-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-OpenGLRaw-devel-3.3.4.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-OpenGLRaw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-OpenGLRaw-devel}"
SRC_URI[aarch64_ghc-OpenGLRaw-devel.sha256sum] = "77ae189b7c14d810d6eed9508659f1012d894bda3addb528726183dd0291ad5e"

URI_aarch64_ghc-OpenGLRaw-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-OpenGLRaw-doc-3.3.4.1-9.el10_0.noarch.rpm;name=aarch64_ghc-OpenGLRaw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-OpenGLRaw-doc}"
SRC_URI[aarch64_ghc-OpenGLRaw-doc.sha256sum] = "f6b32d3f533f7196c4ef75ead26b0824ed6139836773149c74ba2cbd5ea5372c"

URI_aarch64_ghc-OpenGLRaw-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-OpenGLRaw-prof-3.3.4.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-OpenGLRaw-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-OpenGLRaw-prof}"
SRC_URI[aarch64_ghc-OpenGLRaw-prof.sha256sum] = "37b63ca4ab90f4f7508635737bb6ec10648f497bb3f46f0404cb22e5121bf772"

RDEPENDS:ghc-OpenGLRaw = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-fixed \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-half \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 libglvnd-glx \
 "
RDEPENDS:ghc-OpenGLRaw-devel = " \
 ghc-OpenGLRaw \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-fixed-devel \
 ghc-half-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 libglvnd-devel \
 "
RDEPENDS:ghc-OpenGLRaw-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-OpenGLRaw-prof = " \
 ghc-OpenGLRaw-devel \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-fixed-prof \
 ghc-half-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 "
