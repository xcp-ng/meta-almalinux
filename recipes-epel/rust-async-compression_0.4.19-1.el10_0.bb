# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-compression"
PV = "0.4.19"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-compression+all-algorithms-devel \
 rust-async-compression+all-devel \
 rust-async-compression+all-implementations-devel \
 rust-async-compression+brotli-devel \
 rust-async-compression+bzip2-devel \
 rust-async-compression+default-devel \
 rust-async-compression+deflate-devel \
 rust-async-compression+deflate64-devel \
 rust-async-compression+flate2-devel \
 rust-async-compression+futures-io-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+libzstd-devel \
 rust-async-compression+lzma-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+xz-devel \
 rust-async-compression+xz2-devel \
 rust-async-compression+zlib-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression+zstd-safe-devel \
 rust-async-compression+zstdmt-devel \
 rust-async-compression-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-compression-0.4.19-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a743bd9c929489a42a8e509acd8b15cb774310981e43e35f93a68607a63613f7"

URI_x86_64_v2_rust-async-compression+all-algorithms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+all-algorithms-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+all-algorithms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+all-algorithms-devel}"
SRC_URI[x86_64_v2_rust-async-compression+all-algorithms-devel.sha256sum] = "67a09b0f89b15b779766c23f9d904508111f7c67b8db6f90a754563cab36400e"

URI_x86_64_v2_rust-async-compression+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+all-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+all-devel}"
SRC_URI[x86_64_v2_rust-async-compression+all-devel.sha256sum] = "9411cd70bb8c4c273c5d4257b8086e7733e2b7b1d8641e206b8d682e90c8c418"

URI_x86_64_v2_rust-async-compression+all-implementations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+all-implementations-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+all-implementations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+all-implementations-devel}"
SRC_URI[x86_64_v2_rust-async-compression+all-implementations-devel.sha256sum] = "cee2b4d24a107b7f3de4c5e914217fb3c4d9688a1e089bd38099f4af2d9e561b"

URI_x86_64_v2_rust-async-compression+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+brotli-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+brotli-devel}"
SRC_URI[x86_64_v2_rust-async-compression+brotli-devel.sha256sum] = "1707ee04cad381a83b61e0f378eab9246e701b2a8de4e144b24b72acb84c41eb"

URI_x86_64_v2_rust-async-compression+bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+bzip2-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+bzip2-devel}"
SRC_URI[x86_64_v2_rust-async-compression+bzip2-devel.sha256sum] = "7508ba6b4fc04d866d8925c45174e4f8a9503f104b7f88263cf9162540f57299"

URI_x86_64_v2_rust-async-compression+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+default-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+default-devel}"
SRC_URI[x86_64_v2_rust-async-compression+default-devel.sha256sum] = "19f5aac48b5d3a4ef93c8882cb89a0cd53918bc2654b7f1bc2ffb9b3824bdf1a"

URI_x86_64_v2_rust-async-compression+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+deflate-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+deflate-devel}"
SRC_URI[x86_64_v2_rust-async-compression+deflate-devel.sha256sum] = "9f3e7f91fd4016074add19f260987f73916b25c7d804c30f1a163b19096a8b55"

URI_x86_64_v2_rust-async-compression+deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+deflate64-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+deflate64-devel}"
SRC_URI[x86_64_v2_rust-async-compression+deflate64-devel.sha256sum] = "638a4fe8be9bee4bfdb3245ea344006fefa639e9e72b51d1866a673760cc7921"

URI_x86_64_v2_rust-async-compression+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+flate2-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+flate2-devel}"
SRC_URI[x86_64_v2_rust-async-compression+flate2-devel.sha256sum] = "5ad2b7b29c2cc1f907f647fd17390e23ed303749bfec5cf00abc31c1033d4bd3"

URI_x86_64_v2_rust-async-compression+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+futures-io-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+futures-io-devel}"
SRC_URI[x86_64_v2_rust-async-compression+futures-io-devel.sha256sum] = "6e21ec5c83e62e37690b473305fe3f2b7cf35ff53f5aab1051d20b854776e0a9"

URI_x86_64_v2_rust-async-compression+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+gzip-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+gzip-devel}"
SRC_URI[x86_64_v2_rust-async-compression+gzip-devel.sha256sum] = "a9b40df8700af44ce66f7ba35254d4a6d083c98b64b00e1c02e22c6909e32819"

URI_x86_64_v2_rust-async-compression+libzstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+libzstd-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+libzstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+libzstd-devel}"
SRC_URI[x86_64_v2_rust-async-compression+libzstd-devel.sha256sum] = "f80a621d3f2cb2ad9372f70d96154a2c8c5098f6db307991f1c5998edd3b9bf1"

URI_x86_64_v2_rust-async-compression+lzma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+lzma-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+lzma-devel}"
SRC_URI[x86_64_v2_rust-async-compression+lzma-devel.sha256sum] = "f02e058dd1e0e7122e7d8a54c5323851b678979aeea0f2e5f2cfbcd640039037"

URI_x86_64_v2_rust-async-compression+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+tokio-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+tokio-devel}"
SRC_URI[x86_64_v2_rust-async-compression+tokio-devel.sha256sum] = "9a6f512971f7d67fae33c6071f1f331212d823ab5695546c61e708171dc0112b"

URI_x86_64_v2_rust-async-compression+xz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+xz-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+xz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+xz-devel}"
SRC_URI[x86_64_v2_rust-async-compression+xz-devel.sha256sum] = "44d8798f2bcd29af9b36026555561ab126229a7b749ea515e0e702a7cd380f1a"

URI_x86_64_v2_rust-async-compression+xz2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+xz2-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+xz2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+xz2-devel}"
SRC_URI[x86_64_v2_rust-async-compression+xz2-devel.sha256sum] = "9cb9f2e614105f08e09eea2487a8e077bcbdfbf564d99db21bf9204f56890802"

URI_x86_64_v2_rust-async-compression+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zlib-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zlib-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zlib-devel.sha256sum] = "08d3e5de80f7ec686a77ee167551d146ece9b163e878f2f0c1b2fb0ccf35f465"

URI_x86_64_v2_rust-async-compression+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zstd-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zstd-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zstd-devel.sha256sum] = "4c0ecc5db1094e0cc38d56507aacc1ad88b11e57e79404c234e0e1089b891dfd"

URI_x86_64_v2_rust-async-compression+zstd-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zstd-safe-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zstd-safe-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zstd-safe-devel.sha256sum] = "a44579015464e77c196e332dc469c7c9243c23bebf72d0e3a13d205bd19daa6c"

URI_x86_64_v2_rust-async-compression+zstdmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression+zstdmt-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression+zstdmt-devel}"
SRC_URI[x86_64_v2_rust-async-compression+zstdmt-devel.sha256sum] = "50631c56998979757c801f9628dc61ad72cb851098f2a09ff589562f0289713c"

URI_x86_64_v2_rust-async-compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-compression-devel-0.4.19-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-compression-devel}"
SRC_URI[x86_64_v2_rust-async-compression-devel.sha256sum] = "4a65f35503007b22200409c5a18b66088f60085f70957237f7f0763ee2b0061d"

URI_aarch64_rust-async-compression+all-algorithms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+all-algorithms-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+all-algorithms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+all-algorithms-devel}"
SRC_URI[aarch64_rust-async-compression+all-algorithms-devel.sha256sum] = "2e73387e13c61f6d97d3ab40d53baaa13a8eef8a88cacf534f7bfb3de64b4550"

URI_aarch64_rust-async-compression+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+all-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+all-devel}"
SRC_URI[aarch64_rust-async-compression+all-devel.sha256sum] = "648926b94322bddf6efe773917f244a3435f6b8931573ee087728b12178fad25"

URI_aarch64_rust-async-compression+all-implementations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+all-implementations-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+all-implementations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+all-implementations-devel}"
SRC_URI[aarch64_rust-async-compression+all-implementations-devel.sha256sum] = "4d57556201391784cf665a66c95972b3655dc3d0ffd9da249962d4c9d70f9ed0"

URI_aarch64_rust-async-compression+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+brotli-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+brotli-devel}"
SRC_URI[aarch64_rust-async-compression+brotli-devel.sha256sum] = "be8c041cf2640e4ffd0bfb6256837c4b283805b6922d7e45bfe1e00b1265446e"

URI_aarch64_rust-async-compression+bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+bzip2-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+bzip2-devel}"
SRC_URI[aarch64_rust-async-compression+bzip2-devel.sha256sum] = "3d72126a4c88eccf9efb8aacc2541eec398e4c35b78da884b631c7605845e3a6"

URI_aarch64_rust-async-compression+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+default-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+default-devel}"
SRC_URI[aarch64_rust-async-compression+default-devel.sha256sum] = "8a4b7c5f114b4bcc4d21d196ba22a701aa1d5c8655eeaf14e9801496075d4718"

URI_aarch64_rust-async-compression+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+deflate-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+deflate-devel}"
SRC_URI[aarch64_rust-async-compression+deflate-devel.sha256sum] = "257e09aa0ee941c863e6366839923ff4617b77f1e616cc631645c4aac17182de"

URI_aarch64_rust-async-compression+deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+deflate64-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+deflate64-devel}"
SRC_URI[aarch64_rust-async-compression+deflate64-devel.sha256sum] = "dcf19649d2b81ea9a4a81692c382889cd5fe4e7f5fc49be2ec428b54e7919ec5"

URI_aarch64_rust-async-compression+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+flate2-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+flate2-devel}"
SRC_URI[aarch64_rust-async-compression+flate2-devel.sha256sum] = "a2e5e4d48599870c079ae3b08005fc4f65e1655df8235c96d8634604aa165fd3"

URI_aarch64_rust-async-compression+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+futures-io-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+futures-io-devel}"
SRC_URI[aarch64_rust-async-compression+futures-io-devel.sha256sum] = "95e9e47d43efad79cbf5fa58109dd7e32f467b2c6d41e6c3a0332f33a0d13423"

URI_aarch64_rust-async-compression+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+gzip-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+gzip-devel}"
SRC_URI[aarch64_rust-async-compression+gzip-devel.sha256sum] = "6ec466eee2ef26142bbfefdf7a721422df0ce3b4e6efb981a005f6f62a16ef5f"

URI_aarch64_rust-async-compression+libzstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+libzstd-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+libzstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+libzstd-devel}"
SRC_URI[aarch64_rust-async-compression+libzstd-devel.sha256sum] = "20732284170ac56562957dacc33ba25f96b7f96f5b8c48cd785ef34614d854de"

URI_aarch64_rust-async-compression+lzma-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+lzma-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+lzma-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+lzma-devel}"
SRC_URI[aarch64_rust-async-compression+lzma-devel.sha256sum] = "ba04dcaf06dd50c53190a8f780dd0bf600879c9b9c2fdfd386e5ebbd753c7936"

URI_aarch64_rust-async-compression+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+tokio-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+tokio-devel}"
SRC_URI[aarch64_rust-async-compression+tokio-devel.sha256sum] = "38c49930ae1616ba0b5c3055c773c4915bf93862063414e09f1d76a452bf75bf"

URI_aarch64_rust-async-compression+xz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+xz-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+xz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+xz-devel}"
SRC_URI[aarch64_rust-async-compression+xz-devel.sha256sum] = "9e86a3eda4230873b22edf12434fd292f41fed7db8f367ec6ea3f52c3fb6bdc1"

URI_aarch64_rust-async-compression+xz2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+xz2-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+xz2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+xz2-devel}"
SRC_URI[aarch64_rust-async-compression+xz2-devel.sha256sum] = "0bfc2720d593bd7e9e440d5048e2fc64da4170a1e12a90ee65e52988c78f645c"

URI_aarch64_rust-async-compression+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zlib-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zlib-devel}"
SRC_URI[aarch64_rust-async-compression+zlib-devel.sha256sum] = "ff68f1c24e69593502fe2ab02e0e95c442ee6ba8a2ba4723e61aedbd80cd4116"

URI_aarch64_rust-async-compression+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zstd-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zstd-devel}"
SRC_URI[aarch64_rust-async-compression+zstd-devel.sha256sum] = "a87cc99c210928352be76ca05b56c68b1f567636b99fe4b898f76e4511324db6"

URI_aarch64_rust-async-compression+zstd-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zstd-safe-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+zstd-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zstd-safe-devel}"
SRC_URI[aarch64_rust-async-compression+zstd-safe-devel.sha256sum] = "5fc9f5461aea0190cfd8a04558158f8181fc30fa826a1bfe54d027462be2b2ef"

URI_aarch64_rust-async-compression+zstdmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression+zstdmt-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression+zstdmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression+zstdmt-devel}"
SRC_URI[aarch64_rust-async-compression+zstdmt-devel.sha256sum] = "6d95afdf8490ee7b899e8097893de77d642572919ec6fe4893691269d38b6da8"

URI_aarch64_rust-async-compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-compression-devel-0.4.19-1.el10_0.noarch.rpm;name=aarch64_rust-async-compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-compression-devel}"
SRC_URI[aarch64_rust-async-compression-devel.sha256sum] = "aff80d767ac929e26d29e0a9522a8992e5a675008251b7efc51edd39e713ab82"

RDEPENDS:rust-async-compression+all-algorithms-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+bzip2-devel \
 rust-async-compression+deflate-devel \
 rust-async-compression+deflate64-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+lzma-devel \
 rust-async-compression+xz-devel \
 rust-async-compression+zlib-devel \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+all-devel = " \
 cargo \
 rust-async-compression+all-algorithms-devel \
 rust-async-compression+all-implementations-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+all-implementations-devel = " \
 cargo \
 rust-async-compression+futures-io-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+brotli-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-brotli+default-devel \
 "
RDEPENDS:rust-async-compression+bzip2-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-bzip2+default-devel \
 "
RDEPENDS:rust-async-compression+default-devel = " \
 cargo \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+deflate-devel = " \
 cargo \
 rust-async-compression+flate2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+deflate64-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-deflate64+default-devel \
 "
RDEPENDS:rust-async-compression+flate2-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-flate2+default-devel \
 "
RDEPENDS:rust-async-compression+futures-io-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 "
RDEPENDS:rust-async-compression+gzip-devel = " \
 cargo \
 rust-async-compression+flate2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+libzstd-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-zstd-devel \
 "
RDEPENDS:rust-async-compression+lzma-devel = " \
 cargo \
 rust-async-compression+xz2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+tokio-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-async-compression+xz-devel = " \
 cargo \
 rust-async-compression+xz2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+xz2-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-xz2+default-devel \
 "
RDEPENDS:rust-async-compression+zlib-devel = " \
 cargo \
 rust-async-compression+flate2-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+zstd-devel = " \
 cargo \
 rust-async-compression+libzstd-devel \
 rust-async-compression+zstd-safe-devel \
 rust-async-compression-devel \
 "
RDEPENDS:rust-async-compression+zstd-safe-devel = " \
 cargo \
 rust-async-compression-devel \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-async-compression+zstdmt-devel = " \
 cargo \
 rust-async-compression+zstd-devel \
 rust-async-compression-devel \
 rust-zstd-safe+zstdmt-devel \
 rust-zstd-safe-devel \
 "
RDEPENDS:rust-async-compression-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-memchr+default-devel \
 rust-pin-project-lite+default-devel \
 "
