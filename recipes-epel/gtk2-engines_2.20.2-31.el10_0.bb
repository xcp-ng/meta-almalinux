# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtk2-engines"
PV = "2.20.2"
PR = "31.el10_0"
PACKAGES = " \
 gtk2-engines \
 gtk2-engines-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gtk2-engines-2.20.2-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4c16d88a22433eedce357b20b85bd5e302f1114134d6a1a3969bfbd157b63aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk2-engines-2.20.2-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtk2-engines;unpack=0"
SRC_URI[x86_64_v2_gtk2-engines.sha256sum] = "887cdda12595061f59570d8a5b935f235bda23ab2c8aa2ee7697c740218e93ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtk2-engines-devel-2.20.2-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtk2-engines-devel;unpack=0"
SRC_URI[x86_64_v2_gtk2-engines-devel.sha256sum] = "20ddd294c7f88e0e0880fdcbedae90fceba0cc19d38ee4c09e78ba9a6cad9ebf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gtk2-engines-2.20.2-31.el10_0.aarch64.rpm;name=aarch64_gtk2-engines;unpack=0"
SRC_URI[aarch64_gtk2-engines.sha256sum] = "a811639733030ede6f7b489c05a2d01df6b6b8ef1abea23e47c51e8e066ac5c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gtk2-engines-devel-2.20.2-31.el10_0.aarch64.rpm;name=aarch64_gtk2-engines-devel;unpack=0"
SRC_URI[aarch64_gtk2-engines-devel.sha256sum] = "305cd1bd139227e88b247a77d74e04c15a196f802b759942b9c77f1db76a7c4d"

RDEPENDS:gtk2-engines = " \
 atk \
 cairo \
 fontconfig \
 freetype \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk2 \
 harfbuzz \
 pango \
 "
RDEPENDS:gtk2-engines-devel = " \
 gtk2-devel \
 gtk2-engines \
 pkgconf-pkg-config \
 "
