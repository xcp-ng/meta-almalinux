# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plotutils"
PV = "2.6"
PR = "37.el10"
PACKAGES = " \
 plotutils \
 plotutils-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/plotutils-2.6-37.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d35224387c4f6d60c09abafbc2fdf7ed33105426ca6228f17e38e4e02149ffac"

URI_x86_64_v2_plotutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/plotutils-2.6-37.el10.x86_64_v2.rpm;name=x86_64_v2_plotutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plotutils}"
SRC_URI[x86_64_v2_plotutils.sha256sum] = "a3c5f58232f661879363d3ebf019652bde925cea3b7056c3f5c8232190c25635"

URI_x86_64_v2_plotutils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/plotutils-devel-2.6-37.el10.x86_64_v2.rpm;name=x86_64_v2_plotutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plotutils-devel}"
SRC_URI[x86_64_v2_plotutils-devel.sha256sum] = "b5b8f075853e73827cb2dd2616a18f63896f66c91dba587ea6fb48352a99301c"

URI_aarch64_plotutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/plotutils-2.6-37.el10.aarch64.rpm;name=aarch64_plotutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_plotutils}"
SRC_URI[aarch64_plotutils.sha256sum] = "f9f3de32fba19735257afcf9b0391aa7ea5293a3bcb7a53a066c46ef3c4cc8da"

URI_aarch64_plotutils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/plotutils-devel-2.6-37.el10.aarch64.rpm;name=aarch64_plotutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plotutils-devel}"
SRC_URI[aarch64_plotutils-devel.sha256sum] = "0ca5339f55f33b4c006c26dd2d736f7602a9673e707ffe0d776de421aeb8b0ad"

RDEPENDS:plotutils = " \
 glibc \
 libICE \
 libSM \
 libX11 \
 libXaw \
 libXext \
 libXmu \
 libXt \
 libgcc \
 libpng \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:plotutils-devel = " \
 plotutils \
 "
