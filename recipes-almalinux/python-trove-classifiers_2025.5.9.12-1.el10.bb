# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-trove-classifiers"
PV = "2025.5.9.12"
PR = "1.el10"
PACKAGES = " \
 python3-trove-classifiers \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-trove-classifiers-2025.5.9.12-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fb0783143c0b337a272bcd7375b11b408d97fd7b037874b964b04cc087dc6f6"

URI_x86_64_v2_python3-trove-classifiers = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-trove-classifiers-2025.5.9.12-1.el10.noarch.rpm;name=x86_64_v2_python3-trove-classifiers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-trove-classifiers}"
SRC_URI[x86_64_v2_python3-trove-classifiers.sha256sum] = "0c85b2e29c4e66d978f001231a53965f0c20d22f9566b47c82878e09aa44f48c"

URI_aarch64_python3-trove-classifiers = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-trove-classifiers-2025.5.9.12-1.el10.noarch.rpm;name=aarch64_python3-trove-classifiers;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-trove-classifiers}"
SRC_URI[aarch64_python3-trove-classifiers.sha256sum] = "0c85b2e29c4e66d978f001231a53965f0c20d22f9566b47c82878e09aa44f48c"

RDEPENDS:python3-trove-classifiers = " \
 python3 \
 "
