# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-ro"
PV = "3.3.6"
PR = "29.el10"
PACKAGES = " \
 hyphen-ro \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-ro-3.3.6-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f105152f8055f4417dbf9d22c9e6165d6fddf6734a2cac2d428e8cf8232e6693"

URI_x86_64_v2_hyphen-ro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-ro-3.3.6-29.el10.noarch.rpm;name=x86_64_v2_hyphen-ro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-ro}"
SRC_URI[x86_64_v2_hyphen-ro.sha256sum] = "da7cc008803f2a7d1b2d830e209ce7cd7f7d33f74f23545febfa443f89b375bd"

URI_aarch64_hyphen-ro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-ro-3.3.6-29.el10.noarch.rpm;name=aarch64_hyphen-ro;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-ro}"
SRC_URI[aarch64_hyphen-ro.sha256sum] = "da7cc008803f2a7d1b2d830e209ce7cd7f7d33f74f23545febfa443f89b375bd"

RDEPENDS:hyphen-ro = " \
 hyphen \
 "
