# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-opentracing"
PV = "1.2.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-opentracing-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-opentracing-1.2.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9673734e05c6eaaa86a0501c4bb7b29c89f39d206847c721714907ce2697914"

URI_x86_64_v2_golang-github-opentracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-opentracing-devel-1.2.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-opentracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-opentracing-devel}"
SRC_URI[x86_64_v2_golang-github-opentracing-devel.sha256sum] = "f34bd21c2037e5d5c5ab5b830639cf3ad5fd1fd955ee34ea2a8956b13e93d72f"

URI_aarch64_golang-github-opentracing-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-opentracing-devel-1.2.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-opentracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-opentracing-devel}"
SRC_URI[aarch64_golang-github-opentracing-devel.sha256sum] = "9e7c7683570f4ff43da570eda2f06dcc006e4197466eb497e3484cc84e6ee7e3"

RDEPENDS:golang-github-opentracing-devel = " \
 go-filesystem \
 golang-github-stretchr-testify-devel \
 "
