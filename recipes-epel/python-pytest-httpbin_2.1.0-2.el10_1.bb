# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-httpbin"
PV = "2.1.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-pytest-httpbin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-httpbin-2.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4478ee4f46307f1cdd9b54bb71fe62de4d32e4d907da970281be8c81d518c41"

URI_x86_64_v2_python3-pytest-httpbin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-httpbin-2.1.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-httpbin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-httpbin}"
SRC_URI[x86_64_v2_python3-pytest-httpbin.sha256sum] = "ee49cddc18b18954e6a83d49d0163ea09e41a784deba54b5e99593be3486ce6f"

URI_aarch64_python3-pytest-httpbin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-httpbin-2.1.0-2.el10_1.noarch.rpm;name=aarch64_python3-pytest-httpbin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-httpbin}"
SRC_URI[aarch64_python3-pytest-httpbin.sha256sum] = "e52f23d6e13d71b5abb362b41b17aff5f1e4f3ba784472ca0c49a962ebbb3bd0"

RDEPENDS:python3-pytest-httpbin = " \
 python3 \
 python3-httpbin \
 "
