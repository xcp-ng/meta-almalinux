# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "httpcomponents-core"
PV = "4.4.16"
PR = "9.el10"
PACKAGES = " \
 httpcomponents-core \
 httpcomponents-core-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/httpcomponents-core-4.4.16-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1fe74aa31c49f4808f021a3a28d57cb3136537fe5694853939fdb612ed204e87"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpcomponents-core-4.4.16-9.el10.noarch.rpm;name=x86_64_v2_httpcomponents-core;unpack=0"
SRC_URI[x86_64_v2_httpcomponents-core.sha256sum] = "478e147259d1ec9a5bf9eea6e7e111a16ce41b34a91bf68d2b898cf56741065c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/httpcomponents-core-javadoc-4.4.16-9.el10.noarch.rpm;name=x86_64_v2_httpcomponents-core-javadoc;unpack=0"
SRC_URI[x86_64_v2_httpcomponents-core-javadoc.sha256sum] = "5499b31b7f25b83012465a249eef33403c5ac1e43d8ecb65372dbf418b233592"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpcomponents-core-4.4.16-9.el10.noarch.rpm;name=aarch64_httpcomponents-core;unpack=0"
SRC_URI[aarch64_httpcomponents-core.sha256sum] = "478e147259d1ec9a5bf9eea6e7e111a16ce41b34a91bf68d2b898cf56741065c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/httpcomponents-core-javadoc-4.4.16-9.el10.noarch.rpm;name=aarch64_httpcomponents-core-javadoc;unpack=0"
SRC_URI[aarch64_httpcomponents-core-javadoc.sha256sum] = "5499b31b7f25b83012465a249eef33403c5ac1e43d8ecb65372dbf418b233592"

RDEPENDS:httpcomponents-core = " \
 javapackages-filesystem \
 "
RDEPENDS:httpcomponents-core-javadoc = " \
 javapackages-filesystem \
 "
