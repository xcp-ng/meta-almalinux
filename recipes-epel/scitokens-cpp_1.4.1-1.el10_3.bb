# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scitokens-cpp"
PV = "1.4.1"
PR = "1.el10_3"
PACKAGES = " \
 scitokens-cpp \
 scitokens-cpp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scitokens-cpp-1.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5bb5fd03f375c88bdfdab07b1bc2bd0a46a89495faa14cb614f952994ab062e"

URI_x86_64_v2_scitokens-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scitokens-cpp-1.4.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scitokens-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scitokens-cpp}"
SRC_URI[x86_64_v2_scitokens-cpp.sha256sum] = "75758ef7c843d24bc56ebb28f4822fe4f0f409cd38270ed83afad6d5bbc3bbdc"

URI_x86_64_v2_scitokens-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scitokens-cpp-devel-1.4.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scitokens-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scitokens-cpp-devel}"
SRC_URI[x86_64_v2_scitokens-cpp-devel.sha256sum] = "feba41bf1967c692e7cc3cc999403355a9e759e1f9d03b3bd108d1971cf5d6d8"

URI_aarch64_scitokens-cpp = "${EPEL_MIRROR}/aarch64/Packages/s/scitokens-cpp-1.4.1-1.el10_3.aarch64.rpm;name=aarch64_scitokens-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_scitokens-cpp}"
SRC_URI[aarch64_scitokens-cpp.sha256sum] = "980e09faae4643b3429bad70961db30c409800d133a2cbb25f967d4886fe2b38"

URI_aarch64_scitokens-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/s/scitokens-cpp-devel-1.4.1-1.el10_3.aarch64.rpm;name=aarch64_scitokens-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_scitokens-cpp-devel}"
SRC_URI[aarch64_scitokens-cpp-devel.sha256sum] = "7a71f7455460e12e675c5e5f1c4c8386199e92180ebdb06c5b11842dca1830ff"

RDEPENDS:scitokens-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 libuuid \
 openssl-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:scitokens-cpp-devel = " \
 scitokens-cpp \
 "
