# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kapman"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kapman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kapman-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d17bbaec6d4813125452b80d0b4bb4b9b57f9440fb8e8ad11a528870505079e8"

URI_x86_64_v2_kapman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kapman-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kapman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kapman}"
SRC_URI[x86_64_v2_kapman.sha256sum] = "ccfa159f2db154688459101085f30a705b958e6471aae5fbb9e2ca115b537ddc"

URI_aarch64_kapman = "${EPEL_MIRROR}/aarch64/Packages/k/kapman-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kapman;unpack=0"
SRC_URI:append = " ${URI_aarch64_kapman}"
SRC_URI[aarch64_kapman.sha256sum] = "5401667b9db469f60603b1e25972cbc0c8fef5fba2c23787043a2203819cbf5d"

RDEPENDS:kapman = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
