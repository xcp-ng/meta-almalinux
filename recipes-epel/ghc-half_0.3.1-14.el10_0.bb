# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-half"
PV = "0.3.1"
PR = "14.el10_0"
PACKAGES = " \
 ghc-half \
 ghc-half-devel \
 ghc-half-doc \
 ghc-half-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-half-0.3.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f9429aeabc7961a3dff374a9a6c837bf9b4116817f2c204c3c2d087abe5bf1a"

URI_x86_64_v2_ghc-half = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-half-0.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-half;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-half}"
SRC_URI[x86_64_v2_ghc-half.sha256sum] = "027e39c087f7ef390a19c88bea5d1f40413c4b8dbbcc55a2c0cac6b3ea5c2314"

URI_x86_64_v2_ghc-half-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-half-devel-0.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-half-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-half-devel}"
SRC_URI[x86_64_v2_ghc-half-devel.sha256sum] = "8a35ee9af780d9ef3562f18e0fbba51469b9d7aa941f7e210132adc9abc46099"

URI_x86_64_v2_ghc-half-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-half-doc-0.3.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-half-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-half-doc}"
SRC_URI[x86_64_v2_ghc-half-doc.sha256sum] = "4bdc5222cbfd8027717b591c4a835be280eace8b811b0d0b5521f78c4ab9155b"

URI_x86_64_v2_ghc-half-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-half-prof-0.3.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-half-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-half-prof}"
SRC_URI[x86_64_v2_ghc-half-prof.sha256sum] = "8a5936bbb19fd1789084b888b1f36e66b5c234b06293da2d0482b8739623682d"

URI_aarch64_ghc-half = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-half-0.3.1-14.el10_0.aarch64.rpm;name=aarch64_ghc-half;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-half}"
SRC_URI[aarch64_ghc-half.sha256sum] = "fb5d4e549addf2d5a0a7dac3fa314c8e024e43a199d3d11934c19d08d0adef48"

URI_aarch64_ghc-half-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-half-devel-0.3.1-14.el10_0.aarch64.rpm;name=aarch64_ghc-half-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-half-devel}"
SRC_URI[aarch64_ghc-half-devel.sha256sum] = "61bb01f8a56d4f10dce31d12248911c6f91b3f5a3fd9e59b5549bd04c0e15183"

URI_aarch64_ghc-half-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-half-doc-0.3.1-14.el10_0.noarch.rpm;name=aarch64_ghc-half-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-half-doc}"
SRC_URI[aarch64_ghc-half-doc.sha256sum] = "d39bdfcff3fefcfbce6991f794a2839a35c783e67ab71776fb86c230aabaa13e"

URI_aarch64_ghc-half-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-half-prof-0.3.1-14.el10_0.aarch64.rpm;name=aarch64_ghc-half-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-half-prof}"
SRC_URI[aarch64_ghc-half-prof.sha256sum] = "bba3f0f55eeb7f5e596c1f092bf39e6c93839e4f29c5f0930c2bf11e088f2160"

RDEPENDS:ghc-half = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-half-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-half \
 ghc-template-haskell-devel \
 "
RDEPENDS:ghc-half-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-half-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-deepseq-prof \
 ghc-half-devel \
 ghc-template-haskell-prof \
 "
