# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libguestfs-winsupport"
PV = "10.0"
PR = "5.el10"
PACKAGES = " \
 libguestfs-winsupport \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libguestfs-winsupport-10.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da1af870102f51ccab3ffa07ae941180514eb6d49d7a035fb6048f2ebdc8f5b6"

URI_x86_64_v2_libguestfs-winsupport = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-winsupport-10.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libguestfs-winsupport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-winsupport}"
SRC_URI[x86_64_v2_libguestfs-winsupport.sha256sum] = "c82de9d22bb8a5f47ab2d566b0d133efd77d57417caec3cb9b93dc2c4e7e8a00"

URI_aarch64_libguestfs-winsupport = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-winsupport-10.0-5.el10.aarch64.rpm;name=aarch64_libguestfs-winsupport;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-winsupport}"
SRC_URI[aarch64_libguestfs-winsupport.sha256sum] = "196888533a2d818e83cda023355fc66a623d0232f211dc472e5cdff44f29f419"

RDEPENDS:libguestfs-winsupport = " \
 fuse-libs \
 libguestfs \
 "
