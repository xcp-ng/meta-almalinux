# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-catkin_pkg"
PV = "1.1.1"
PR = "1.el10_3"
PACKAGES = " \
 python-catkin_pkg-doc \
 python3-catkin_pkg \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-catkin_pkg-1.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9a1668b8192584121aecb6fc6a0effcd1db4dd3671e4437d4c522658cd84c5ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-catkin_pkg-doc-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-catkin_pkg-doc;unpack=0"
SRC_URI[x86_64_v2_python-catkin_pkg-doc.sha256sum] = "afff14a1008fdc4f3e60658856b5e112f6b09ddef35b5578a9f008c550c65e5f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-catkin_pkg-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-catkin_pkg;unpack=0"
SRC_URI[x86_64_v2_python3-catkin_pkg.sha256sum] = "92db6aa62ff45be5744a54cd6596b2abe21face302dfb0c82d2725e59ad0d21e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-catkin_pkg-doc-1.1.1-1.el10_3.noarch.rpm;name=aarch64_python-catkin_pkg-doc;unpack=0"
SRC_URI[aarch64_python-catkin_pkg-doc.sha256sum] = "0abea6e3a2f0baafd5f34a1ffc0448f17afe749cbe3d5827f5297c93202c8235"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-catkin_pkg-1.1.1-1.el10_3.noarch.rpm;name=aarch64_python3-catkin_pkg;unpack=0"
SRC_URI[aarch64_python3-catkin_pkg.sha256sum] = "ebbf0e45d6a897eed778c8690590aea42592f602578e0ca5c4f08409ce5d55b2"

RDEPENDS:python-catkin_pkg-doc = " \
 "
RDEPENDS:python3-catkin_pkg = " \
 python3 \
 python3-dateutil \
 python3-docutils \
 python3-packaging \
 python3-pyparsing \
 "
