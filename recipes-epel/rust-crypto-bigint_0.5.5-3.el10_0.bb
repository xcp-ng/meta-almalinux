# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crypto-bigint"
PV = "0.5.5"
PR = "3.el10_0"
PACKAGES = " \
 rust-crypto-bigint+alloc-devel \
 rust-crypto-bigint+default-devel \
 rust-crypto-bigint+der-devel \
 rust-crypto-bigint+extra-sizes-devel \
 rust-crypto-bigint+generic-array-devel \
 rust-crypto-bigint+rand-devel \
 rust-crypto-bigint+rand_core-devel \
 rust-crypto-bigint+serde-devel \
 rust-crypto-bigint+zeroize-devel \
 rust-crypto-bigint-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crypto-bigint-0.5.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f87c5cf05c3a3eb86e0622138503be1188bcae9ec2e27670a74f0572ba11e867"

URI_x86_64_v2_rust-crypto-bigint+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+alloc-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+alloc-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+alloc-devel.sha256sum] = "b2c893ff998c39fccb028d3180b8d92c432b69e14d9ada099eac517f7163a83f"

URI_x86_64_v2_rust-crypto-bigint+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+default-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+default-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+default-devel.sha256sum] = "df69cf2acc7e829415d4eeabe8a478a98dbb5c9bb2731a4ae66fa2b883e95343"

URI_x86_64_v2_rust-crypto-bigint+der-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+der-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+der-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+der-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+der-devel.sha256sum] = "52e8b11b953c6261d41f882a43047360d76c8b8011d87c2e9e5d0f4b3235a65f"

URI_x86_64_v2_rust-crypto-bigint+extra-sizes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+extra-sizes-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+extra-sizes-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+extra-sizes-devel.sha256sum] = "3952170e5657068ca757f5ab7b4a73188b457636931125a7acd14997b6ae8333"

URI_x86_64_v2_rust-crypto-bigint+generic-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+generic-array-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+generic-array-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+generic-array-devel.sha256sum] = "caf99df9db9b3f877adf503ca9b3c824df517493895d48989ad6360ee1f980e0"

URI_x86_64_v2_rust-crypto-bigint+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+rand-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+rand-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+rand-devel.sha256sum] = "4d153462b34e6483778a32529c18365834cf6deeb22835d8592d8b6f4f0a5dc6"

URI_x86_64_v2_rust-crypto-bigint+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+rand_core-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+rand_core-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+rand_core-devel.sha256sum] = "4dfeda1b2de073549a8701c04e7f9996892de5541706d99d9f07f5b5c1de2536"

URI_x86_64_v2_rust-crypto-bigint+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+serde-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+serde-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+serde-devel.sha256sum] = "1f4af81c2455a857a95145c35e7ff41c542228a399737874beb782dde5373658"

URI_x86_64_v2_rust-crypto-bigint+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint+zeroize-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint+zeroize-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint+zeroize-devel.sha256sum] = "6a58d9a00f79dc1b253b9b09cbd76b1160292b52affe31314bd84537dbc99343"

URI_x86_64_v2_rust-crypto-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crypto-bigint-devel-0.5.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crypto-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crypto-bigint-devel}"
SRC_URI[x86_64_v2_rust-crypto-bigint-devel.sha256sum] = "57d2e54e3e88bb4f9f5975cbf056c09f8e89a180e68e7f4ced9d43d773abce80"

URI_aarch64_rust-crypto-bigint+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+alloc-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+alloc-devel}"
SRC_URI[aarch64_rust-crypto-bigint+alloc-devel.sha256sum] = "7dddc6e80ecd1bab3b991245bbc10c5bafbe34e2a815e2592ee765e38ff8fea7"

URI_aarch64_rust-crypto-bigint+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+default-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+default-devel}"
SRC_URI[aarch64_rust-crypto-bigint+default-devel.sha256sum] = "0c688c698b6d1ddd61716b7197c66fd89402dba81acc0421f3a632d0eb9fbdb7"

URI_aarch64_rust-crypto-bigint+der-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+der-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint+der-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+der-devel}"
SRC_URI[aarch64_rust-crypto-bigint+der-devel.sha256sum] = "c7711fb598e734de59e2d2a4ad686395cc7d5f650ad9e1d238c1fc76c8cfaf17"

URI_aarch64_rust-crypto-bigint+extra-sizes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+extra-sizes-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint+extra-sizes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+extra-sizes-devel}"
SRC_URI[aarch64_rust-crypto-bigint+extra-sizes-devel.sha256sum] = "e48b8f52a3f0cd1d38f897949bb235951a7720e5f837123c3c740a2b8355aff8"

URI_aarch64_rust-crypto-bigint+generic-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+generic-array-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint+generic-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+generic-array-devel}"
SRC_URI[aarch64_rust-crypto-bigint+generic-array-devel.sha256sum] = "bc4e19fa2049eb1ea023ae3bfae19a5c7d4cb05e99cd1ee1d0441b9a93bb45e5"

URI_aarch64_rust-crypto-bigint+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+rand-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+rand-devel}"
SRC_URI[aarch64_rust-crypto-bigint+rand-devel.sha256sum] = "f4b5f830c64cda96c7ea890751d622eec85d2c345a6bb059545fa3eb57373835"

URI_aarch64_rust-crypto-bigint+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+rand_core-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+rand_core-devel}"
SRC_URI[aarch64_rust-crypto-bigint+rand_core-devel.sha256sum] = "6b4a46c512972bf2f92eae5ef89ef7b7f5f7f97b2f16aedcf232d50ed3a3e403"

URI_aarch64_rust-crypto-bigint+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+serde-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+serde-devel}"
SRC_URI[aarch64_rust-crypto-bigint+serde-devel.sha256sum] = "abaec3648d55829c3115c2cb33fca987d320efaa55d89631b2f5b9268dc7beb4"

URI_aarch64_rust-crypto-bigint+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint+zeroize-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint+zeroize-devel}"
SRC_URI[aarch64_rust-crypto-bigint+zeroize-devel.sha256sum] = "82149c3eb0b1144c665e10a1c16c4d6e020d457b0a5df15c42bd30b194907dcb"

URI_aarch64_rust-crypto-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crypto-bigint-devel-0.5.5-3.el10_0.noarch.rpm;name=aarch64_rust-crypto-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crypto-bigint-devel}"
SRC_URI[aarch64_rust-crypto-bigint-devel.sha256sum] = "736a73dbc918d89742183eeb80b30f3fd6ee634d271964f2df974974d6d826f4"

RDEPENDS:rust-crypto-bigint+alloc-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-serdect+alloc-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-crypto-bigint+default-devel = " \
 cargo \
 rust-crypto-bigint+rand-devel \
 rust-crypto-bigint-devel \
 "
RDEPENDS:rust-crypto-bigint+der-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-der-devel \
 "
RDEPENDS:rust-crypto-bigint+extra-sizes-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 "
RDEPENDS:rust-crypto-bigint+generic-array-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-generic-array+default-devel \
 "
RDEPENDS:rust-crypto-bigint+rand-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-rand_core0.6+default-devel \
 rust-rand_core0.6+std-devel \
 "
RDEPENDS:rust-crypto-bigint+rand_core-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-rand_core0.6+default-devel \
 "
RDEPENDS:rust-crypto-bigint+serde-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-serdect-devel \
 "
RDEPENDS:rust-crypto-bigint+zeroize-devel = " \
 cargo \
 rust-crypto-bigint-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-crypto-bigint-devel = " \
 cargo \
 rust \
 rust-subtle-devel \
 "
