# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono-tz"
PV = "0.10.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-chrono-tz+arbitrary-devel \
 rust-chrono-tz+case-insensitive-devel \
 rust-chrono-tz+default-devel \
 rust-chrono-tz+filter-by-regex-devel \
 rust-chrono-tz+serde-devel \
 rust-chrono-tz+std-devel \
 rust-chrono-tz-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-tz-0.10.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c52cdcf06a14aa09224e349555b22fa4e8ae76346871ab02129b84c1f971ce50"

URI_x86_64_v2_rust-chrono-tz+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+arbitrary-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+arbitrary-devel.sha256sum] = "d35908b808a60d7a6cae73bbbce57af48d416691644308763b2398cd65da0367"

URI_x86_64_v2_rust-chrono-tz+case-insensitive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+case-insensitive-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+case-insensitive-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+case-insensitive-devel.sha256sum] = "f8463fc0e46b0747863955b15680856ce5b2e6d2d4980203bfc8c23ce5cb071d"

URI_x86_64_v2_rust-chrono-tz+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+default-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+default-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+default-devel.sha256sum] = "b2540dfb0a7580c69ba3ca2f8b60912a18c6dcdd2d69e1111d42fd946693904b"

URI_x86_64_v2_rust-chrono-tz+filter-by-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+filter-by-regex-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+filter-by-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+filter-by-regex-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+filter-by-regex-devel.sha256sum] = "dbe57d2f11fe2d041e6524266cd9997c96d35216b40fd0e35d5c0b24fe10e4ec"

URI_x86_64_v2_rust-chrono-tz+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+serde-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+serde-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+serde-devel.sha256sum] = "f5b8d4bcd389f406d110818df90a08f30255cb1330ccd4ae15dabe78385786b9"

URI_x86_64_v2_rust-chrono-tz+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz+std-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz+std-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz+std-devel.sha256sum] = "09b889b374f3b36e22f6df19fd69db0db5c48824dd55379f4981ecf0f5ec7937"

URI_x86_64_v2_rust-chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-tz-devel-0.10.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-chrono-tz-devel.sha256sum] = "bc121fd7e0242735f173c059761634371bc499acb7b1a08f644a05dd042e3ec7"

URI_aarch64_rust-chrono-tz+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+arbitrary-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+arbitrary-devel}"
SRC_URI[aarch64_rust-chrono-tz+arbitrary-devel.sha256sum] = "712af91c932cb76ad3ee9791735ec9b99d3013c82c6f2e399976bb094a31fa3c"

URI_aarch64_rust-chrono-tz+case-insensitive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+case-insensitive-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz+case-insensitive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+case-insensitive-devel}"
SRC_URI[aarch64_rust-chrono-tz+case-insensitive-devel.sha256sum] = "0832a023306d9c74754fb2ce703e381417571931af43b87cf847bc61bc9dfa01"

URI_aarch64_rust-chrono-tz+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+default-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+default-devel}"
SRC_URI[aarch64_rust-chrono-tz+default-devel.sha256sum] = "7c1e2759993ba362153baa9b88533dfc7e30782b29e45d36f084d19ce2c8419f"

URI_aarch64_rust-chrono-tz+filter-by-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+filter-by-regex-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz+filter-by-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+filter-by-regex-devel}"
SRC_URI[aarch64_rust-chrono-tz+filter-by-regex-devel.sha256sum] = "12f6f4e79e451fd119dd78105772c9d1cd8b53e26e9a0e137112e4ba09650b69"

URI_aarch64_rust-chrono-tz+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+serde-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+serde-devel}"
SRC_URI[aarch64_rust-chrono-tz+serde-devel.sha256sum] = "ac7c0fa38235f9bb307ff646ea39f4bd3767c0f2843382656b72aad2692a62b1"

URI_aarch64_rust-chrono-tz+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz+std-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz+std-devel}"
SRC_URI[aarch64_rust-chrono-tz+std-devel.sha256sum] = "d4cfd233dd669e32373fe9ec548f20599977224f157b80e4fc989fa381d4b4f1"

URI_aarch64_rust-chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-tz-devel-0.10.3-1.el10_1.noarch.rpm;name=aarch64_rust-chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-tz-devel}"
SRC_URI[aarch64_rust-chrono-tz-devel.sha256sum] = "97ff07b0ea1f0aa2aa8b2201806cdaacb9a000406f1f8bfa87e1e7c55dc6269e"

RDEPENDS:rust-chrono-tz+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono-tz-devel \
 "
RDEPENDS:rust-chrono-tz+case-insensitive-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-phf+uncased-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-chrono-tz+default-devel = " \
 cargo \
 rust-chrono-tz+std-devel \
 rust-chrono-tz-devel \
 "
RDEPENDS:rust-chrono-tz+filter-by-regex-devel = " \
 cargo \
 rust-chrono-tz-devel \
 "
RDEPENDS:rust-chrono-tz+serde-devel = " \
 cargo \
 rust-chrono-tz-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-chrono-tz+std-devel = " \
 cargo \
 rust-chrono-tz-devel \
 "
RDEPENDS:rust-chrono-tz-devel = " \
 cargo \
 rust \
 rust-chrono-devel \
 rust-chrono-tz-build+default-devel \
 rust-phf-devel \
 "
