# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-stestr"
PV = "4.2.1"
PR = "4.el10_3"
PACKAGES = " \
 python-stestr-doc \
 python3-stestr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-stestr-4.2.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f83bde1daf367f22a919a67bd5ddb8b5062e479f2eef2d0e624727163be1857"

URI_x86_64_v2_python-stestr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-stestr-doc-4.2.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-stestr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-stestr-doc}"
SRC_URI[x86_64_v2_python-stestr-doc.sha256sum] = "1826744efd4abcd5a1c3bb09059a4894b28d1d064dd5f794ad6cd0e04a1b57df"

URI_x86_64_v2_python3-stestr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-stestr-4.2.1-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-stestr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-stestr}"
SRC_URI[x86_64_v2_python3-stestr.sha256sum] = "510026c761b7b305e26f4dcc7e3f96c18017f2ca7939847f830c541fccedec4e"

URI_aarch64_python-stestr-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-stestr-doc-4.2.1-4.el10_3.noarch.rpm;name=aarch64_python-stestr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-stestr-doc}"
SRC_URI[aarch64_python-stestr-doc.sha256sum] = "7d17fc0f99b536d175af73566006ef0d54ab6b9b5874a20364a4cb24da4efdc8"

URI_aarch64_python3-stestr = "${EPEL_MIRROR}/aarch64/Packages/p/python3-stestr-4.2.1-4.el10_3.noarch.rpm;name=aarch64_python3-stestr;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-stestr}"
SRC_URI[aarch64_python3-stestr.sha256sum] = "149470769728c66ea1f4abca193073254cab2d736c5272261297080a7cbab6c4"

RDEPENDS:python-stestr-doc = " \
 "
RDEPENDS:python3-stestr = " \
 python3 \
 python3-cliff \
 python3-fixtures \
 python3-pyyaml \
 python3-subunit \
 python3-testtools \
 python3-tomlkit \
 python3-voluptuous \
 "
