# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arpwatch"
PE = "14"
PV = "3.9"
PR = "11.el10_3"
PACKAGES = " \
 arpwatch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/arpwatch-3.9-11.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1ec4b5e35d8c418a7be2c18dbee17d507589f057a1ecc5d68827976322794a97"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arpwatch-3.9-11.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arpwatch;unpack=0"
SRC_URI[x86_64_v2_arpwatch.sha256sum] = "9bc1314763c054d935a0a80087f9f8e947c8158a1105631600727b5aee762bcc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/arpwatch-3.9-11.el10_3.aarch64.rpm;name=aarch64_arpwatch;unpack=0"
SRC_URI[aarch64_arpwatch.sha256sum] = "e64bde1bea7bad0b0b4891ca5956b67d5732a4d7bddd17f0ef23164f16b29f51"

RDEPENDS:arpwatch = " \
 bash \
 glibc \
 libpcap \
 python3 \
 shadow-utils \
 virtual//usr/sbin/sendmail \
 "
