# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tog-pegasus"
PE = "2"
PV = "2.14.1"
PR = "79.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tog-pegasus-2.14.1-79.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db343dd4fca19f04513a0193b53064cdecb51aac7c5e676e8cb7f505908ba149"

