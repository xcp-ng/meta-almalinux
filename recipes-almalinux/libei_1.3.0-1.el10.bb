# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libei"
PV = "1.3.0"
PR = "1.el10"
PACKAGES = " \
 libei \
 libei-devel \
 libeis \
 libeis-devel \
 liboeffis \
 liboeffis-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libei-1.3.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62b2302a452eded16da606d1eeb212bb70257232e83b266f883fe07945f21ca5"

URI_x86_64_v2_libei = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libei-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libei;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libei}"
SRC_URI[x86_64_v2_libei.sha256sum] = "0c1657049e027887abf44c36aabb0ae47309c37c4774eb907f051f3a9b19ddce"

URI_x86_64_v2_libei-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libei-devel-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libei-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libei-devel}"
SRC_URI[x86_64_v2_libei-devel.sha256sum] = "ca24de50a0f3e0c95db90c0c182158600d375e17d8890dde7866077860e65f71"

URI_x86_64_v2_libeis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libeis-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libeis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libeis}"
SRC_URI[x86_64_v2_libeis.sha256sum] = "29829309f7d09fa39b9f4d381807695340fb9236f5fcd7564a5663632af51723"

URI_x86_64_v2_libeis-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libeis-devel-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libeis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libeis-devel}"
SRC_URI[x86_64_v2_libeis-devel.sha256sum] = "c42edb5dffba652410a2fcdfa4d242c18265c11b6577b6e324facc37f166e72f"

URI_x86_64_v2_liboeffis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/liboeffis-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_liboeffis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboeffis}"
SRC_URI[x86_64_v2_liboeffis.sha256sum] = "f55312c2c7000da89c6f5b97c9cf6fb22cdc439159a0e72a9df1d046573daf69"

URI_x86_64_v2_liboeffis-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/liboeffis-devel-1.3.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_liboeffis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liboeffis-devel}"
SRC_URI[x86_64_v2_liboeffis-devel.sha256sum] = "2875aaa7ed8f8037748508856a3e9c5966ba7b8c0fabbc1f415fa64690067e94"

URI_aarch64_libei = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libei-1.3.0-1.el10.aarch64.rpm;name=aarch64_libei;unpack=0"
SRC_URI:append = " ${URI_aarch64_libei}"
SRC_URI[aarch64_libei.sha256sum] = "aba34fcd4393dac1aace5add3fd9bc7730028c2a42732df40713cdfab04f0e3b"

URI_aarch64_libei-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libei-devel-1.3.0-1.el10.aarch64.rpm;name=aarch64_libei-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libei-devel}"
SRC_URI[aarch64_libei-devel.sha256sum] = "0289e6da39e08a5284f357d61386bbde5c8925b7aa8ff48563fd1e06e3e92ae1"

URI_aarch64_libeis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libeis-1.3.0-1.el10.aarch64.rpm;name=aarch64_libeis;unpack=0"
SRC_URI:append = " ${URI_aarch64_libeis}"
SRC_URI[aarch64_libeis.sha256sum] = "1f8751061cb320c6da6697aa0afc8663e9ec6b27ba0336bd35eee81baa3bedc0"

URI_aarch64_libeis-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libeis-devel-1.3.0-1.el10.aarch64.rpm;name=aarch64_libeis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libeis-devel}"
SRC_URI[aarch64_libeis-devel.sha256sum] = "ec4c1667af0047b30731e7d156a24123a64173ce269c4a5e286b15f9f192fbfc"

URI_aarch64_liboeffis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/liboeffis-1.3.0-1.el10.aarch64.rpm;name=aarch64_liboeffis;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboeffis}"
SRC_URI[aarch64_liboeffis.sha256sum] = "cb67dca432cd44861090a4af4e2493f57c7dc445393ffd3448cbc05a4e00c7f6"

URI_aarch64_liboeffis-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/liboeffis-devel-1.3.0-1.el10.aarch64.rpm;name=aarch64_liboeffis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liboeffis-devel}"
SRC_URI[aarch64_liboeffis-devel.sha256sum] = "1843ca242d3aa8c3e89dce16a72f728d9dd774e4779dfc84b549a6e99a18553c"

RDEPENDS:libei = " \
 glibc \
 libgcc \
 "
RDEPENDS:libei-devel = " \
 libei \
 pkgconf-pkg-config \
 "
RDEPENDS:libeis = " \
 glibc \
 libgcc \
 "
RDEPENDS:libeis-devel = " \
 libeis \
 pkgconf-pkg-config \
 "
RDEPENDS:liboeffis = " \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:liboeffis-devel = " \
 liboeffis \
 pkgconf-pkg-config \
 systemd-devel \
 "
