# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "double-conversion"
PV = "3.4.0"
PR = "1.el10_2"
PACKAGES = " \
 double-conversion \
 double-conversion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/double-conversion-3.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1704e7a9759568e8e850f9472e2a7d70fc3a4450dce9ce9af98640cd608432b5"

URI_x86_64_v2_double-conversion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/double-conversion-3.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_double-conversion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_double-conversion}"
SRC_URI[x86_64_v2_double-conversion.sha256sum] = "d0baa1b003784be05d5e097c6e5c63dcfcd384515ce0504f59e80d7ff5d29acf"

URI_x86_64_v2_double-conversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/double-conversion-devel-3.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_double-conversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_double-conversion-devel}"
SRC_URI[x86_64_v2_double-conversion-devel.sha256sum] = "2c32e9dcb5987fc347ca75876fc96e3b7668b42d9891b37f9ceb6730595eea90"

URI_aarch64_double-conversion = "${EPEL_MIRROR}/aarch64/Packages/d/double-conversion-3.4.0-1.el10_2.aarch64.rpm;name=aarch64_double-conversion;unpack=0"
SRC_URI:append = " ${URI_aarch64_double-conversion}"
SRC_URI[aarch64_double-conversion.sha256sum] = "2ddb9e71f2a579caac1d487ab869ade6677dd69f2df195fefe33d2eb043ecba6"

URI_aarch64_double-conversion-devel = "${EPEL_MIRROR}/aarch64/Packages/d/double-conversion-devel-3.4.0-1.el10_2.aarch64.rpm;name=aarch64_double-conversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_double-conversion-devel}"
SRC_URI[aarch64_double-conversion-devel.sha256sum] = "de90480224425095c224c5f48b060ace7797748a7cd2716a9165d1c287b47c43"

RDEPENDS:double-conversion = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:double-conversion-devel = " \
 cmake-filesystem \
 double-conversion \
 pkgconf-pkg-config \
 "
