# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "httpd"
PV = "2.4.63"
PR = "14.el10"
PACKAGES = " \
 httpd \
 httpd-core \
 httpd-devel \
 httpd-filesystem \
 httpd-manual \
 httpd-tools \
 mod_ldap \
 mod_lua \
 mod_proxy_html \
 mod_session \
 mod_ssl \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/httpd-2.4.63-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "212a24324b2c47d603ecf941156b14179fe76580d7d12653eb7b9ae64e606979"

URI_x86_64_v2_httpd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-2.4.63-14.el10.x86_64_v2.rpm;name=x86_64_v2_httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd}"
SRC_URI[x86_64_v2_httpd.sha256sum] = "6bbd56c55d756353304a79b33006909c7e8430bdedc59398c37156f8a11678b9"
RPROVIDES:httpd:x86_64_v2 = "virtual/httpd_or_nginx virtual/webserver"

URI_x86_64_v2_httpd-core = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-core-2.4.63-14.el10.x86_64_v2.rpm;name=x86_64_v2_httpd-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-core}"
SRC_URI[x86_64_v2_httpd-core.sha256sum] = "361e6321278c2b633d49f772cdd4860aa34282093dbdb674d1431a25d10ae0e8"

URI_x86_64_v2_httpd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-devel-2.4.63-14.el10.x86_64_v2.rpm;name=x86_64_v2_httpd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-devel}"
SRC_URI[x86_64_v2_httpd-devel.sha256sum] = "96a25350d079aa4684d1276cb1fa525e7daedbbb448fe1bf3f3b26a7482faaf2"

URI_x86_64_v2_httpd-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-filesystem-2.4.63-14.el10.noarch.rpm;name=x86_64_v2_httpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-filesystem}"
SRC_URI[x86_64_v2_httpd-filesystem.sha256sum] = "4f75b1c567a461cc6d480559b1d5521e17c12c6c9338c1eb1bfba4761616aada"

URI_x86_64_v2_httpd-manual = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-manual-2.4.63-14.el10.noarch.rpm;name=x86_64_v2_httpd-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-manual}"
SRC_URI[x86_64_v2_httpd-manual.sha256sum] = "105c36f65d07d31db150738ca84385259fda7eb7a5ee82f0c9b3e24a6f361320"

URI_x86_64_v2_httpd-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/httpd-tools-2.4.63-14.el10.x86_64_v2.rpm;name=x86_64_v2_httpd-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_httpd-tools}"
SRC_URI[x86_64_v2_httpd-tools.sha256sum] = "fd5d2735e1da51dfc068ced1acdb122cba8d875633c8710f57901f4b849a995b"

URI_x86_64_v2_mod_ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ldap-2.4.63-14.el10.x86_64_v2.rpm;name=x86_64_v2_mod_ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_ldap}"
SRC_URI[x86_64_v2_mod_ldap.sha256sum] = "181cf30e9cd9b96503147015a00dfb8efc48a3887b0e7c3762f77db0cba4ec85"

URI_x86_64_v2_mod_lua = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_lua-2.4.63-14.el10.x86_64_v2.rpm;name=x86_64_v2_mod_lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_lua}"
SRC_URI[x86_64_v2_mod_lua.sha256sum] = "4c7b72ca14bd799917a7d014c055433b943d4c34260b8c93ce23fd70bc9f5bda"

URI_x86_64_v2_mod_proxy_html = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_proxy_html-2.4.63-14.el10.x86_64_v2.rpm;name=x86_64_v2_mod_proxy_html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_proxy_html}"
SRC_URI[x86_64_v2_mod_proxy_html.sha256sum] = "d37eca93153c54df9d8ca5002b37a7b2bc3cd4e41ff7774e7db7dcb81825ee09"

URI_x86_64_v2_mod_session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_session-2.4.63-14.el10.x86_64_v2.rpm;name=x86_64_v2_mod_session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_session}"
SRC_URI[x86_64_v2_mod_session.sha256sum] = "b847af7daa05a5b8597a9a21f002bf9b63b58b7d690c5d5cfac68a588dbb01c2"

URI_x86_64_v2_mod_ssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_ssl-2.4.63-14.el10.x86_64_v2.rpm;name=x86_64_v2_mod_ssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_ssl}"
SRC_URI[x86_64_v2_mod_ssl.sha256sum] = "edac02261d883f28c1abfafbff2c7b9bfe16366a431454a7f5f6f4fcd4304d1f"

URI_aarch64_httpd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-2.4.63-14.el10.aarch64.rpm;name=aarch64_httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd}"
SRC_URI[aarch64_httpd.sha256sum] = "28de5df760f8bb11fb744e92d210f495cd42d589fe6d66b871122f5cad2ea4a4"
RPROVIDES:httpd:aarch64 = "virtual/httpd_or_nginx virtual/webserver"

URI_aarch64_httpd-core = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-core-2.4.63-14.el10.aarch64.rpm;name=aarch64_httpd-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-core}"
SRC_URI[aarch64_httpd-core.sha256sum] = "9128170c1ccfd674425d3c1c08af9de1268b590285186d2cc1d7be5c77d88e97"

URI_aarch64_httpd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-devel-2.4.63-14.el10.aarch64.rpm;name=aarch64_httpd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-devel}"
SRC_URI[aarch64_httpd-devel.sha256sum] = "5ad600721ff732105aea8b0ca7d25387d6e7df0fd5a7354b5b9800fa857c9bf1"

URI_aarch64_httpd-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-filesystem-2.4.63-14.el10.noarch.rpm;name=aarch64_httpd-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-filesystem}"
SRC_URI[aarch64_httpd-filesystem.sha256sum] = "4f75b1c567a461cc6d480559b1d5521e17c12c6c9338c1eb1bfba4761616aada"

URI_aarch64_httpd-manual = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-manual-2.4.63-14.el10.noarch.rpm;name=aarch64_httpd-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-manual}"
SRC_URI[aarch64_httpd-manual.sha256sum] = "105c36f65d07d31db150738ca84385259fda7eb7a5ee82f0c9b3e24a6f361320"

URI_aarch64_httpd-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/httpd-tools-2.4.63-14.el10.aarch64.rpm;name=aarch64_httpd-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_httpd-tools}"
SRC_URI[aarch64_httpd-tools.sha256sum] = "2d7256d7508537d2a92308fa5531b5cb1a2a522a8348fd57b9ea8bd310af1e10"

URI_aarch64_mod_ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ldap-2.4.63-14.el10.aarch64.rpm;name=aarch64_mod_ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_ldap}"
SRC_URI[aarch64_mod_ldap.sha256sum] = "1f066d7107adb32bf49c1e92577e55952628f5bcc77e6a11796b23d47bc64dc3"

URI_aarch64_mod_lua = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_lua-2.4.63-14.el10.aarch64.rpm;name=aarch64_mod_lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_lua}"
SRC_URI[aarch64_mod_lua.sha256sum] = "3b4602ddff7a79c86d3e1e11e14501653129ab5f1021eb2cc1b0cb612afd56e7"

URI_aarch64_mod_proxy_html = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_proxy_html-2.4.63-14.el10.aarch64.rpm;name=aarch64_mod_proxy_html;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_proxy_html}"
SRC_URI[aarch64_mod_proxy_html.sha256sum] = "d08ff9ba3104a1607a83892629e25f40c3848e0e72410b7b6b27bf9e0cfd909f"

URI_aarch64_mod_session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_session-2.4.63-14.el10.aarch64.rpm;name=aarch64_mod_session;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_session}"
SRC_URI[aarch64_mod_session.sha256sum] = "5f634150cbbe7545e77b8994cdd633d1400b2820021a190c349cab0510f28df8"

URI_aarch64_mod_ssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_ssl-2.4.63-14.el10.aarch64.rpm;name=aarch64_mod_ssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_ssl}"
SRC_URI[aarch64_mod_ssl.sha256sum] = "45b94dac23615e6a4e2a63ec1ca5cdb5c03ab227e426e90ce16e4fe5fb9d2004"

RDEPENDS:httpd = " \
 almalinux-logos-httpd \
 bash \
 glibc \
 httpd-core \
 libbrotli \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:httpd-core = " \
 apr \
 apr-util \
 apr-util-lmdb \
 bash \
 glibc \
 httpd-filesystem \
 httpd-tools \
 mailcap \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:httpd-devel = " \
 apr-devel \
 apr-util-devel \
 bash \
 httpd-core \
 libtool \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:httpd-filesystem = " \
 bash \
 shadow-utils \
 "
RDEPENDS:httpd-manual = " \
 httpd-core \
 "
RDEPENDS:httpd-tools = " \
 apr \
 apr-util \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:mod_ldap = " \
 apr-util-ldap \
 glibc \
 httpd-core \
 openldap \
 "
RDEPENDS:mod_lua = " \
 glibc \
 httpd-core \
 libxcrypt \
 lua-libs \
 "
RDEPENDS:mod_proxy_html = " \
 glibc \
 httpd-core \
 libxml2 \
 "
RDEPENDS:mod_session = " \
 glibc \
 httpd-core \
 "
RDEPENDS:mod_ssl = " \
 bash \
 glibc \
 hostname \
 httpd-core \
 httpd-filesystem \
 openssl-libs \
 sscg \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"

PROVIDES:append:aarch64 = " rpm/virtual/httpd_or_nginx rpm/virtual/webserver"
