# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sereal"
PV = "5.004"
PR = "1.el10_0"
PACKAGES = " \
 perl-Sereal \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Sereal-5.004-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f7eed214c9042c31e772f0fcff664045e89f075ad64d36eab50c18153e67d7c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sereal-5.004-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sereal;unpack=0"
SRC_URI[x86_64_v2_perl-Sereal.sha256sum] = "91cc174ade261cf424cc0bf688db2eee03bff70ff34a640db9e64a950e7b786a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Sereal-5.004-1.el10_0.noarch.rpm;name=aarch64_perl-Sereal;unpack=0"
SRC_URI[aarch64_perl-Sereal.sha256sum] = "0c5b1a7498e65f5606daf7b0b0d4f0bf31e539c9e7648191e9c9122d185b6f75"

RDEPENDS:perl-Sereal = " \
 perl-Exporter \
 perl-Sereal-Decoder \
 perl-Sereal-Encoder \
 perl-libs \
 "
