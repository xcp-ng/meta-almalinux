# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fixtures"
PV = "4.3.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-fixtures \
 python3-fixtures+streams \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fixtures-4.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a2a22cb2ffe5888b102dcded161fd711b2d72dc1e6fac5f5bf02ecf0f4c6221"

URI_x86_64_v2_python3-fixtures = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fixtures-4.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fixtures;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fixtures}"
SRC_URI[x86_64_v2_python3-fixtures.sha256sum] = "70ef8967cdb876b849a7006e620b0d28e4ba3f5f390d6c5ad53d94058219e110"

URI_x86_64_v2_python3-fixtures+streams = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fixtures+streams-4.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fixtures+streams;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fixtures+streams}"
SRC_URI[x86_64_v2_python3-fixtures+streams.sha256sum] = "9db88346ddc6465296b1f0857087f701042b8773de61332d391535b5deb1e267"

URI_aarch64_python3-fixtures = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fixtures-4.3.2-1.el10_2.noarch.rpm;name=aarch64_python3-fixtures;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fixtures}"
SRC_URI[aarch64_python3-fixtures.sha256sum] = "524ab750fdcec0d4897124d813da0aeca0ea778a504e15b1cf522653426ee009"

URI_aarch64_python3-fixtures+streams = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fixtures+streams-4.3.2-1.el10_2.noarch.rpm;name=aarch64_python3-fixtures+streams;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fixtures+streams}"
SRC_URI[aarch64_python3-fixtures+streams.sha256sum] = "d0dbdb74ab42e75e383a658e7e5ffb481e3848432bc50278c4187263507fb10e"

RDEPENDS:python3-fixtures = " \
 python3 \
 "
RDEPENDS:python3-fixtures+streams = " \
 python3 \
 python3-fixtures \
 python3-testtools \
 "
