# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rmtfs"
PV = "1.3"
PR = "1.el10_3"
PACKAGES = " \
 rmtfs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rmtfs-1.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ddb18661ce49d4d71788b28ba9d4ca5034f172148b9d042284831b9425baf6b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rmtfs-1.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rmtfs;unpack=0"
SRC_URI[x86_64_v2_rmtfs.sha256sum] = "fd05fd5dbbf58ed3a42abea64002cd9bec59b6f839529d146a07b0f1ff04d34d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rmtfs-1.3-1.el10_3.aarch64.rpm;name=aarch64_rmtfs;unpack=0"
SRC_URI[aarch64_rmtfs.sha256sum] = "2dd336602198642a9834b7054c86cc9a8c75d5855d222f805d0888ce95875f06"

RDEPENDS:rmtfs = " \
 bash \
 glibc \
 qrtr \
 qrtr-libs \
 systemd-libs \
 "
