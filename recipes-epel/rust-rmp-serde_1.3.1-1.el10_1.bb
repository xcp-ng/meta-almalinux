# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rmp-serde"
PV = "1.3.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-rmp-serde+default-devel \
 rust-rmp-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rmp-serde-1.3.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b5f89b5967ae6e1213309193429587972264ff0fc18fbf71b4a72e178d0f197"

URI_x86_64_v2_rust-rmp-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp-serde+default-devel-1.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp-serde+default-devel}"
SRC_URI[x86_64_v2_rust-rmp-serde+default-devel.sha256sum] = "5da185df71d1783606fa1d189d4f5105c6cf1a87d680d7e629622337d3873e83"

URI_x86_64_v2_rust-rmp-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rmp-serde-devel-1.3.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rmp-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rmp-serde-devel}"
SRC_URI[x86_64_v2_rust-rmp-serde-devel.sha256sum] = "a0a6ce781d255482520914f683aa510e57220819898d6085cdd3c36b031198cd"

URI_aarch64_rust-rmp-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp-serde+default-devel-1.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rmp-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp-serde+default-devel}"
SRC_URI[aarch64_rust-rmp-serde+default-devel.sha256sum] = "47668c0d585b71f1954ccbf17ffb3e0c0648c9ca4a320e9ab90486126ab5eaa3"

URI_aarch64_rust-rmp-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rmp-serde-devel-1.3.1-1.el10_1.noarch.rpm;name=aarch64_rust-rmp-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rmp-serde-devel}"
SRC_URI[aarch64_rust-rmp-serde-devel.sha256sum] = "3aca17626190e82d2316ac5cff86ee036b4aab75b0fa0bfd348b179abb54fb36"

RDEPENDS:rust-rmp-serde+default-devel = " \
 cargo \
 rust-rmp-serde-devel \
 "
RDEPENDS:rust-rmp-serde-devel = " \
 cargo \
 rust \
 rust-rmp+default-devel \
 rust-serde+default-devel \
 "
