# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nasm-rs"
PV = "0.3.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-nasm-rs+default-devel \
 rust-nasm-rs+jobserver-devel \
 rust-nasm-rs+parallel-devel \
 rust-nasm-rs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nasm-rs-0.3.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15f4259828aeefe1d3f38a2fe94c360a4a9e1191398008538076b2280f259c8f"

URI_x86_64_v2_rust-nasm-rs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nasm-rs+default-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nasm-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nasm-rs+default-devel}"
SRC_URI[x86_64_v2_rust-nasm-rs+default-devel.sha256sum] = "30f7b8627ce50773c07724d975d19b6fb93f1d6457e54f8535fa6ff1198f2c5e"

URI_x86_64_v2_rust-nasm-rs+jobserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nasm-rs+jobserver-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nasm-rs+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nasm-rs+jobserver-devel}"
SRC_URI[x86_64_v2_rust-nasm-rs+jobserver-devel.sha256sum] = "71c62b8bf24ad01ba31192a7a8918799c0ad5cbe7f4b2db02e3da9cd95a68620"

URI_x86_64_v2_rust-nasm-rs+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nasm-rs+parallel-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nasm-rs+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nasm-rs+parallel-devel}"
SRC_URI[x86_64_v2_rust-nasm-rs+parallel-devel.sha256sum] = "c6c39cb4b5a235ffebd25524e6598ea87cf7d9858c44c7cc800d392c0ab82ec2"

URI_x86_64_v2_rust-nasm-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nasm-rs-devel-0.3.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nasm-rs-devel}"
SRC_URI[x86_64_v2_rust-nasm-rs-devel.sha256sum] = "7b1824d766f6019d7981458943c1752600d85970dd4c628e28727237801e9208"

URI_aarch64_rust-nasm-rs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nasm-rs+default-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-nasm-rs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nasm-rs+default-devel}"
SRC_URI[aarch64_rust-nasm-rs+default-devel.sha256sum] = "c218e425a9598c097efe27bf71e3f15ab8853264a517d5efa775c44b29a76f0c"

URI_aarch64_rust-nasm-rs+jobserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nasm-rs+jobserver-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-nasm-rs+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nasm-rs+jobserver-devel}"
SRC_URI[aarch64_rust-nasm-rs+jobserver-devel.sha256sum] = "a970387b9688d5d2e1b531111b710c51a974110503e026bf133e7cd0179932b6"

URI_aarch64_rust-nasm-rs+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nasm-rs+parallel-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-nasm-rs+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nasm-rs+parallel-devel}"
SRC_URI[aarch64_rust-nasm-rs+parallel-devel.sha256sum] = "be2ea26e471fe8a922fbf9d00ca053077c9627d79dc67e1fc84e4526471fa881"

URI_aarch64_rust-nasm-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nasm-rs-devel-0.3.2-1.el10_2.noarch.rpm;name=aarch64_rust-nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nasm-rs-devel}"
SRC_URI[aarch64_rust-nasm-rs-devel.sha256sum] = "62e1f1f5d10de61cc599c58e95b1d64fafefa01a09e0ca9937fec76b53603f0c"

RDEPENDS:rust-nasm-rs+default-devel = " \
 cargo \
 rust-nasm-rs-devel \
 "
RDEPENDS:rust-nasm-rs+jobserver-devel = " \
 cargo \
 rust-jobserver+default-devel \
 rust-nasm-rs-devel \
 "
RDEPENDS:rust-nasm-rs+parallel-devel = " \
 cargo \
 rust-nasm-rs+jobserver-devel \
 rust-nasm-rs-devel \
 "
RDEPENDS:rust-nasm-rs-devel = " \
 cargo \
 nasm \
 rust-log+default-devel \
 "
