# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipsolver"
PV = "7.1.0"
PR = "4.el10_2"
PACKAGES:x86_64_v2 = " \
 hipsolver \
 hipsolver-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipsolver-7.1.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e89611ed657c9e2c8e7bf5fadee9cfa376517a9155f0156c03b6b148d3ba615c"

URI_x86_64_v2_hipsolver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsolver-7.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsolver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsolver}"
SRC_URI[x86_64_v2_hipsolver.sha256sum] = "94a25410bd1b377dd05411d2e12c033b58fe85a7d3488b3537816ab74a475c68"

URI_x86_64_v2_hipsolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsolver-devel-7.1.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsolver-devel}"
SRC_URI[x86_64_v2_hipsolver-devel.sha256sum] = "e251d15884ddef0b4f2bd7eac8ade5774f71b121b84f9e96fde8724420024221"

RDEPENDS:hipsolver = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocm-hip \
 rocsolver \
 "
RDEPENDS:hipsolver-devel = " \
 cmake-filesystem \
 hipsolver \
 "
