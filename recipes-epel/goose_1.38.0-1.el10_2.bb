# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goose"
PV = "1.38.0"
PR = "1.el10_2"
PACKAGES = " \
 goose \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/goose-1.38.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbda1f443c583a41f146ec02273492bc94763c8db2896fd7db9d2e31cfddbca4"

URI_x86_64_v2_goose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goose-1.38.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_goose}"
SRC_URI[x86_64_v2_goose.sha256sum] = "4f00b7e576170e5b70ee830b2e5e8d9b759e61273fba3d9f0fbf81c86967bd81"

URI_aarch64_goose = "${EPEL_MIRROR}/aarch64/Packages/g/goose-1.38.0-1.el10_2.aarch64.rpm;name=aarch64_goose;unpack=0"
SRC_URI:append = " ${URI_aarch64_goose}"
SRC_URI[aarch64_goose.sha256sum] = "5f3696b9c07e8a7656ce01a86e99eba27dfa06e241a002b3f272b78c9ef038a0"

RDEPENDS:goose = " \
 dbus-libs \
 glibc \
 libgcc \
 libzstd \
 oniguruma \
 openssl-libs \
 sqlite-libs \
 "
