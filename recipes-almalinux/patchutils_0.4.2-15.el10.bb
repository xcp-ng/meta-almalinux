# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "patchutils"
PV = "0.4.2"
PR = "15.el10"
PACKAGES = " \
 patchutils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/patchutils-0.4.2-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c8f5fbe7f7a1268886285cabc033f9e62a1dca77ce5c5f484f2e8e13262950d"

URI_x86_64_v2_patchutils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/patchutils-0.4.2-15.el10.x86_64_v2.rpm;name=x86_64_v2_patchutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_patchutils}"
SRC_URI[x86_64_v2_patchutils.sha256sum] = "84ffe0bab083bbfcd17ba7bdd76c46397e8df0170ed0597bfec9cc9c83ece60a"

URI_aarch64_patchutils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/patchutils-0.4.2-15.el10.aarch64.rpm;name=aarch64_patchutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_patchutils}"
SRC_URI[aarch64_patchutils.sha256sum] = "f582f6605c9288dc4a4a86b842cab98bc9de88b034e83040be54db8df330b586"

RDEPENDS:patchutils = " \
 bash \
 glibc \
 patch \
 perl-Getopt-Std \
 perl-interpreter \
 python3 \
 "
