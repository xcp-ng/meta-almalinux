# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "redir"
PV = "3.3"
PR = "12.el10_1"
PACKAGES = " \
 redir \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/redir-3.3-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21b0b98f45021ddb58bd9f0d06a0bc8628e16e360246dc36e2a5de7cc8a2bafb"

URI_x86_64_v2_redir = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/redir-3.3-12.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_redir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redir}"
SRC_URI[x86_64_v2_redir.sha256sum] = "48447832b87560154454d05819a95b19d41b99974ab4031686800fdfd6878f86"

URI_aarch64_redir = "${EPEL_MIRROR}/aarch64/Packages/r/redir-3.3-12.el10_1.aarch64.rpm;name=aarch64_redir;unpack=0"
SRC_URI:append = " ${URI_aarch64_redir}"
SRC_URI[aarch64_redir.sha256sum] = "6ca0d6e06888433b4c6f5af21fcb9b96317f981a98e22aab4a42d773e067aaa5"

RDEPENDS:redir = " \
 glibc \
 "
