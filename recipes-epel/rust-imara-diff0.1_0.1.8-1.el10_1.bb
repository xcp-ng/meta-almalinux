# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imara-diff0.1"
PV = "0.1.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-imara-diff0.1+default-devel \
 rust-imara-diff0.1+unified_diff-devel \
 rust-imara-diff0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imara-diff0.1-0.1.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7395d0fc89059a824c5b9302517d1d1b6dc555187f5eefa7dd2d7ecec5a49c0b"

URI_x86_64_v2_rust-imara-diff0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imara-diff0.1+default-devel-0.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imara-diff0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imara-diff0.1+default-devel}"
SRC_URI[x86_64_v2_rust-imara-diff0.1+default-devel.sha256sum] = "8c6c00f6efc8bd3da950c55c9b509e2714fa7381f7432626ebc5fb7e314f4aef"

URI_x86_64_v2_rust-imara-diff0.1+unified_diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imara-diff0.1+unified_diff-devel-0.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imara-diff0.1+unified_diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imara-diff0.1+unified_diff-devel}"
SRC_URI[x86_64_v2_rust-imara-diff0.1+unified_diff-devel.sha256sum] = "1d7da951e70896d765b858914cc46a4673d80a332ac5161860c87d2b6752e370"

URI_x86_64_v2_rust-imara-diff0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imara-diff0.1-devel-0.1.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imara-diff0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imara-diff0.1-devel}"
SRC_URI[x86_64_v2_rust-imara-diff0.1-devel.sha256sum] = "661424a75d0e47c1d3fd9b4fec288f754274abe574c12e04573550da2af86a40"

URI_aarch64_rust-imara-diff0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imara-diff0.1+default-devel-0.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-imara-diff0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imara-diff0.1+default-devel}"
SRC_URI[aarch64_rust-imara-diff0.1+default-devel.sha256sum] = "61cd782bc007af59419170e436d5e637c08edb4b929ae1d25a4cd69e5f01cb45"

URI_aarch64_rust-imara-diff0.1+unified_diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imara-diff0.1+unified_diff-devel-0.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-imara-diff0.1+unified_diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imara-diff0.1+unified_diff-devel}"
SRC_URI[aarch64_rust-imara-diff0.1+unified_diff-devel.sha256sum] = "4d8f7860ea62fac516837202d52b1c48c1d270924a5874cff951a944247784f8"

URI_aarch64_rust-imara-diff0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imara-diff0.1-devel-0.1.8-1.el10_1.noarch.rpm;name=aarch64_rust-imara-diff0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imara-diff0.1-devel}"
SRC_URI[aarch64_rust-imara-diff0.1-devel.sha256sum] = "bc1b55e0e3781234bb97afca7446236b68f166b914de468c2beb5fb349d6bd5d"

RDEPENDS:rust-imara-diff0.1+default-devel = " \
 cargo \
 rust-imara-diff0.1+unified_diff-devel \
 rust-imara-diff0.1-devel \
 "
RDEPENDS:rust-imara-diff0.1+unified_diff-devel = " \
 cargo \
 rust-imara-diff0.1-devel \
 "
RDEPENDS:rust-imara-diff0.1-devel = " \
 cargo \
 rust \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 "
