# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ko"
PV = "0.7.0"
PR = "21.el10"
PACKAGES = " \
 hunspell-ko \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ko-0.7.0-21.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53d69df68a8c629987fcc792bcc973fb030653497e89854f74ee26d2bbe068e4"

URI_x86_64_v2_hunspell-ko = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ko-0.7.0-21.el10.noarch.rpm;name=x86_64_v2_hunspell-ko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ko}"
SRC_URI[x86_64_v2_hunspell-ko.sha256sum] = "5a7e24be9b90c98216c0870e883f9297c1dddc4cc9f0b6d3b48064a138ee8381"

URI_aarch64_hunspell-ko = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ko-0.7.0-21.el10.noarch.rpm;name=aarch64_hunspell-ko;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ko}"
SRC_URI[aarch64_hunspell-ko.sha256sum] = "5a7e24be9b90c98216c0870e883f9297c1dddc4cc9f0b6d3b48064a138ee8381"

RDEPENDS:hunspell-ko = " \
 hunspell-filesystem \
 "
