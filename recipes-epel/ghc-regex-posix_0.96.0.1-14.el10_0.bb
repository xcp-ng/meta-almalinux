# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-regex-posix"
PV = "0.96.0.1"
PR = "14.el10_0"
PACKAGES = " \
 ghc-regex-posix \
 ghc-regex-posix-devel \
 ghc-regex-posix-doc \
 ghc-regex-posix-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-regex-posix-0.96.0.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c05aadbfcbe6091f8e209b25b86661ed971591c319bbe972e1a3a38e39d11f9"

URI_x86_64_v2_ghc-regex-posix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-posix-0.96.0.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-posix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-posix}"
SRC_URI[x86_64_v2_ghc-regex-posix.sha256sum] = "d4439e0526d535bd39b81ae592484af3a7d0e2e3fe468a6ef8e93a1fb9bc5786"

URI_x86_64_v2_ghc-regex-posix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-posix-devel-0.96.0.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-posix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-posix-devel}"
SRC_URI[x86_64_v2_ghc-regex-posix-devel.sha256sum] = "ab535825e48f9bc76ccb60e99bea9b59820b4205f45a2e929746eb376d7df4fb"

URI_x86_64_v2_ghc-regex-posix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-posix-doc-0.96.0.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-regex-posix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-posix-doc}"
SRC_URI[x86_64_v2_ghc-regex-posix-doc.sha256sum] = "b8077efcb211081347794dd96adf0dbe8070c8d80a8a0c4fba5e2972e07b6a0d"

URI_x86_64_v2_ghc-regex-posix-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-posix-prof-0.96.0.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-posix-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-posix-prof}"
SRC_URI[x86_64_v2_ghc-regex-posix-prof.sha256sum] = "167c9a230a064a57a5c7ca82fc1330bff4d258dd1f6baa0c7e7a07b347ab6cf7"

URI_aarch64_ghc-regex-posix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-posix-0.96.0.1-14.el10_0.aarch64.rpm;name=aarch64_ghc-regex-posix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-posix}"
SRC_URI[aarch64_ghc-regex-posix.sha256sum] = "9f39fdc17e110c7ea844ddc793cd354d7016bbd54a892f3d0efabf8cfcb6bf46"

URI_aarch64_ghc-regex-posix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-posix-devel-0.96.0.1-14.el10_0.aarch64.rpm;name=aarch64_ghc-regex-posix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-posix-devel}"
SRC_URI[aarch64_ghc-regex-posix-devel.sha256sum] = "52c5fb1fc8ef430528acba8ad88810741345e727a30b39f99e723c9886daf3ae"

URI_aarch64_ghc-regex-posix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-posix-doc-0.96.0.1-14.el10_0.noarch.rpm;name=aarch64_ghc-regex-posix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-posix-doc}"
SRC_URI[aarch64_ghc-regex-posix-doc.sha256sum] = "71d1eeee3776c9ec25ea9ce99409e9cc3e3a5d36dab9366c1a4dccce4b3fef32"

URI_aarch64_ghc-regex-posix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-posix-prof-0.96.0.1-14.el10_0.aarch64.rpm;name=aarch64_ghc-regex-posix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-posix-prof}"
SRC_URI[aarch64_ghc-regex-posix-prof.sha256sum] = "d1021d09025d846297d8bd1a9507901c2e66f029a9bd91d3033364a5072256e7"

RDEPENDS:ghc-regex-posix = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-regex-base \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-regex-posix-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-regex-base-devel \
 ghc-regex-posix \
 "
RDEPENDS:ghc-regex-posix-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-regex-posix-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-regex-base-prof \
 ghc-regex-posix-devel \
 "
