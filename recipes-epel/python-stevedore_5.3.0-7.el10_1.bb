# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-stevedore"
PV = "5.3.0"
PR = "7.el10_1"
PACKAGES = " \
 python3-stevedore \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-stevedore-5.3.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23d6bad0b281da2e7a2b82be3588fced921b4bd2519fa3577faf9d98ce4d17d9"

URI_x86_64_v2_python3-stevedore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-stevedore-5.3.0-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-stevedore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-stevedore}"
SRC_URI[x86_64_v2_python3-stevedore.sha256sum] = "299edf1b29821e43417465d4c00131846a5be0dc8a9b444a26a61ba063982109"

URI_aarch64_python3-stevedore = "${EPEL_MIRROR}/aarch64/Packages/p/python3-stevedore-5.3.0-7.el10_1.noarch.rpm;name=aarch64_python3-stevedore;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-stevedore}"
SRC_URI[aarch64_python3-stevedore.sha256sum] = "b84c66dbf52ed068cc9346d53451448875110aaa7b914e783af11b4996202a88"

RDEPENDS:python3-stevedore = " \
 python3 \
 python3-pbr \
 "
