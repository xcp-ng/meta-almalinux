# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-objc"
PV = "3.0.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-objc+default-devel \
 rust-tree-sitter-objc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-objc-3.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65c088ff2d61fb35f2d4a5e470306cb240f4dc125966611b241c4bbec4fda75b"

URI_x86_64_v2_rust-tree-sitter-objc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-objc+default-devel-3.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-objc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-objc+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-objc+default-devel.sha256sum] = "f48ab98048f7bf17232e1d64d5e67efd69b28b97c2c6face61050861c756b83a"

URI_x86_64_v2_rust-tree-sitter-objc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-objc-devel-3.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-objc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-objc-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-objc-devel.sha256sum] = "0ff88b4b243dd531d2a18e11c140ae39ec912b0464dad5adb15f49ff5d55ee39"

URI_aarch64_rust-tree-sitter-objc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-objc+default-devel-3.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-objc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-objc+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-objc+default-devel.sha256sum] = "2d0e4854f71714b9fb952b7496580cac362750cf8e9e35d9ecebce08c926acca"

URI_aarch64_rust-tree-sitter-objc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-objc-devel-3.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-objc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-objc-devel}"
SRC_URI[aarch64_rust-tree-sitter-objc-devel.sha256sum] = "bc6f576fa1c51bf0e57fc463bfd5e92b4f4d2bc6a952a4a86cb0a8cf5fa980eb"

RDEPENDS:rust-tree-sitter-objc+default-devel = " \
 cargo \
 rust-tree-sitter-objc-devel \
 "
RDEPENDS:rust-tree-sitter-objc-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
