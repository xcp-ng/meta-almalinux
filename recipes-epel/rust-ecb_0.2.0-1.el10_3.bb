# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ecb"
PV = "0.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-ecb+alloc-devel \
 rust-ecb+block-padding-devel \
 rust-ecb+default-devel \
 rust-ecb+zeroize-devel \
 rust-ecb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ecb-0.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35d0bfb8394c749989c422dd5bfa8e1ac4ac532232e9149577a3498039ee9314"

URI_x86_64_v2_rust-ecb+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+alloc-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb+alloc-devel}"
SRC_URI[x86_64_v2_rust-ecb+alloc-devel.sha256sum] = "426b617a3da3445d095519683d33b4eb5f015bf5863496924f595b5765dadfd6"

URI_x86_64_v2_rust-ecb+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+block-padding-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb+block-padding-devel}"
SRC_URI[x86_64_v2_rust-ecb+block-padding-devel.sha256sum] = "f081b9cec1e95da459b1d98d7ccaedcfd32a1f840ad29514011fa951cf12954a"

URI_x86_64_v2_rust-ecb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+default-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb+default-devel}"
SRC_URI[x86_64_v2_rust-ecb+default-devel.sha256sum] = "6c4405c7e80bd7f500f3a18a6e215fd02f42a014c9051642534147f95ca40c21"

URI_x86_64_v2_rust-ecb+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb+zeroize-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb+zeroize-devel}"
SRC_URI[x86_64_v2_rust-ecb+zeroize-devel.sha256sum] = "62bdaaade22e8f13fa1707d0c2370ce9a761b618a56d938ea1704fab339303ca"

URI_x86_64_v2_rust-ecb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ecb-devel-0.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ecb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ecb-devel}"
SRC_URI[x86_64_v2_rust-ecb-devel.sha256sum] = "0e711204938513036c2329d5c5007a5d99ef8458ca459d1231d9fa4c937493b4"

URI_aarch64_rust-ecb+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+alloc-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ecb+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb+alloc-devel}"
SRC_URI[aarch64_rust-ecb+alloc-devel.sha256sum] = "a26ddfb3bbe0a14f17d5d4d7ca6672e9b4d7fe21ce1a0a986ffab59d08c2a0ba"

URI_aarch64_rust-ecb+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+block-padding-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ecb+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb+block-padding-devel}"
SRC_URI[aarch64_rust-ecb+block-padding-devel.sha256sum] = "73ad8e28e3521e924daf0e037d9c369fd78b1a8519408ced01abe2fc385b04cf"

URI_aarch64_rust-ecb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+default-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ecb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb+default-devel}"
SRC_URI[aarch64_rust-ecb+default-devel.sha256sum] = "3d9c9e22649e21d538731ce4620dab51773bde23d5a296aac0d21a95e2d57074"

URI_aarch64_rust-ecb+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb+zeroize-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ecb+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb+zeroize-devel}"
SRC_URI[aarch64_rust-ecb+zeroize-devel.sha256sum] = "3b829579ac00aae1ebf7af7da729955f58ed237d26fb1f202eaa37d9b0d39975"

URI_aarch64_rust-ecb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ecb-devel-0.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-ecb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ecb-devel}"
SRC_URI[aarch64_rust-ecb-devel.sha256sum] = "43303274daed1f56ed90c1072f19f8ee734efadb2155da79bc6091ebbd3680d0"

RDEPENDS:rust-ecb+alloc-devel = " \
 cargo \
 rust-cipher+alloc-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb+block-padding-devel = " \
 cargo \
 rust-cipher+block-padding-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb+default-devel = " \
 cargo \
 rust-ecb+block-padding-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb+zeroize-devel = " \
 cargo \
 rust-cipher+zeroize-devel \
 rust-ecb-devel \
 "
RDEPENDS:rust-ecb-devel = " \
 cargo \
 rust \
 rust-cipher+default-devel \
 "
