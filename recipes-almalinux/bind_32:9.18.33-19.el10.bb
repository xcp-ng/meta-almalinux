# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bind"
PE = "32"
PV = "9.18.33"
PR = "19.el10"
PACKAGES = " \
 bind \
 bind-chroot \
 bind-devel \
 bind-dnssec-utils \
 bind-doc \
 bind-libs \
 bind-license \
 bind-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bind-9.18.33-19.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb8879fcd8820ab90e350830127733f1d9ecd4e6a71d27a61dd8078dc16616f9"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - bind-devel: libcap-devel(aarch-64)
# - bind: libcap.so.2()(64bit)

URI_x86_64_v2_bind = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-9.18.33-19.el10.x86_64_v2.rpm;name=x86_64_v2_bind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind}"
SRC_URI[x86_64_v2_bind.sha256sum] = "4833dca877ce5446dd3f0b3fcba1123e75b6658be5a705f5a15348a7ef4a6e44"

URI_x86_64_v2_bind-chroot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-chroot-9.18.33-19.el10.x86_64_v2.rpm;name=x86_64_v2_bind-chroot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-chroot}"
SRC_URI[x86_64_v2_bind-chroot.sha256sum] = "00d9d05f903297afd8a404fac1f7f97d6cc06a59dfb7b17f22a29ab532fa2119"

URI_x86_64_v2_bind-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-devel-9.18.33-19.el10.x86_64_v2.rpm;name=x86_64_v2_bind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-devel}"
SRC_URI[x86_64_v2_bind-devel.sha256sum] = "37e90926209c2d49e1f54943b9206ac5f3bd2fd5d1970fdcc6176386532a26dc"

URI_x86_64_v2_bind-dnssec-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-dnssec-utils-9.18.33-19.el10.x86_64_v2.rpm;name=x86_64_v2_bind-dnssec-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-dnssec-utils}"
SRC_URI[x86_64_v2_bind-dnssec-utils.sha256sum] = "7ec1d4f11052ea0f908d5b4ae2d762ee4ad9f9939f6c499110f73aea7e6a4b15"

URI_x86_64_v2_bind-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bind-doc-9.18.33-19.el10.noarch.rpm;name=x86_64_v2_bind-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-doc}"
SRC_URI[x86_64_v2_bind-doc.sha256sum] = "731dbec343e76c7d2e2357a484c368496d6cc2864e48810621302db7934f5609"

URI_x86_64_v2_bind-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-libs-9.18.33-19.el10.x86_64_v2.rpm;name=x86_64_v2_bind-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-libs}"
SRC_URI[x86_64_v2_bind-libs.sha256sum] = "9f5d6152eedeee1fee99a95e6126ff64680b9a2bc019d7a14e8b46888e8b5c79"

URI_x86_64_v2_bind-license = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-license-9.18.33-19.el10.noarch.rpm;name=x86_64_v2_bind-license;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-license}"
SRC_URI[x86_64_v2_bind-license.sha256sum] = "0fd2d3e9b2700ec19443114404bb8a95b9d9f3d757276f38f763cf601b02a7ce"

URI_x86_64_v2_bind-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bind-utils-9.18.33-19.el10.x86_64_v2.rpm;name=x86_64_v2_bind-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bind-utils}"
SRC_URI[x86_64_v2_bind-utils.sha256sum] = "848db888f6dfd0787d1c5fd618f394579145a842ca27ef0ff51d3bf6a10d690f"

URI_aarch64_bind = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-9.18.33-19.el10.aarch64.rpm;name=aarch64_bind;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind}"
SRC_URI[aarch64_bind.sha256sum] = "acbba8635d0c7c419c01df291939550c819fafc75acd2515eb34e45539d6a976"

URI_aarch64_bind-chroot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-chroot-9.18.33-19.el10.aarch64.rpm;name=aarch64_bind-chroot;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-chroot}"
SRC_URI[aarch64_bind-chroot.sha256sum] = "32acb7b8add95767c789212072ec371895528d8799ac8b86fe3725c1217fe1f7"

URI_aarch64_bind-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-devel-9.18.33-19.el10.aarch64.rpm;name=aarch64_bind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-devel}"
SRC_URI[aarch64_bind-devel.sha256sum] = "4594834b1dbfd830c46f9a48e1c87e4c8de73458cbe190c2f73838e92caeb10c"

URI_aarch64_bind-dnssec-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-dnssec-utils-9.18.33-19.el10.aarch64.rpm;name=aarch64_bind-dnssec-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-dnssec-utils}"
SRC_URI[aarch64_bind-dnssec-utils.sha256sum] = "aae6480f553f9ba2b6caf7a61967e53ff33d585ab62ed04767a00ea0283b4f41"

URI_aarch64_bind-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bind-doc-9.18.33-19.el10.noarch.rpm;name=aarch64_bind-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-doc}"
SRC_URI[aarch64_bind-doc.sha256sum] = "731dbec343e76c7d2e2357a484c368496d6cc2864e48810621302db7934f5609"

URI_aarch64_bind-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-libs-9.18.33-19.el10.aarch64.rpm;name=aarch64_bind-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-libs}"
SRC_URI[aarch64_bind-libs.sha256sum] = "4cad08c0ffcf4034522bde9ebaf176cf510bd333940dea9b1ebe0dd3def1c688"

URI_aarch64_bind-license = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-license-9.18.33-19.el10.noarch.rpm;name=aarch64_bind-license;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-license}"
SRC_URI[aarch64_bind-license.sha256sum] = "0fd2d3e9b2700ec19443114404bb8a95b9d9f3d757276f38f763cf601b02a7ce"

URI_aarch64_bind-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bind-utils-9.18.33-19.el10.aarch64.rpm;name=aarch64_bind-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_bind-utils}"
SRC_URI[aarch64_bind-utils.sha256sum] = "da658a280f9aa2cc182cc4fe92fe142e5a657a0063844c3993620544def7f64a"

RDEPENDS:bind:x86_64_v2 = " \
 bash \
 bind-libs \
 fstrm \
 glibc \
 glibc-common \
 grep \
 json-c \
 libcap \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 shadow-utils \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:bind:aarch64 = " \
 bash \
 bind-libs \
 fstrm \
 glibc \
 glibc-common \
 grep \
 json-c \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 shadow-utils \
 virtual/coreutils \
 zlib-ng-compat \
"
RDEPENDS:bind-chroot = " \
 bash \
 bind \
 grep \
 "
RDEPENDS:bind-devel:x86_64_v2 = " \
 bind-libs \
 fstrm-devel \
 json-c-devel \
 krb5-devel \
 libcap-devel \
 libmaxminddb-devel \
 libxml2-devel \
 lmdb-devel \
 openssl-devel \
 protobuf-c-devel \
"
RDEPENDS:bind-devel:aarch64 = " \
 bind-libs \
 fstrm-devel \
 json-c-devel \
 krb5-devel \
 libmaxminddb-devel \
 libxml2-devel \
 lmdb-devel \
 openssl-devel \
 protobuf-c-devel \
"
RDEPENDS:bind-dnssec-utils = " \
 bind-libs \
 glibc \
 "
RDEPENDS:bind-doc = " \
 bind-license \
 python3-sphinx_rtd_theme \
 "
RDEPENDS:bind-libs = " \
 bind-license \
 fstrm \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libmaxminddb \
 libnghttp2 \
 libuv \
 libxml2 \
 lmdb-libs \
 openssl-libs \
 protobuf-c \
 zlib-ng-compat \
 "
RDEPENDS:bind-license = " \
 "
RDEPENDS:bind-utils = " \
 bind-libs \
 glibc \
 krb5-libs \
 libidn2 \
 lmdb-libs \
 protobuf-c \
 "
