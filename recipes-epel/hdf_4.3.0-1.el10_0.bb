# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hdf"
PV = "4.3.0"
PR = "1.el10_0"
PACKAGES = " \
 hdf \
 hdf-devel \
 hdf-examples \
 hdf-libs \
 hdf-static \
 java-hdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hdf-4.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dd260fc3fb0df020bbcb280f8a8174b2624ab8d1e8bc35113a0788c60522965"

URI_x86_64_v2_hdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf-4.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf}"
SRC_URI[x86_64_v2_hdf.sha256sum] = "ebbb2513706ebebf2a21a4d052577ed580f5179055ef96428c39a9180d6f493c"
RPROVIDES:hdf:append:x86_64_v2 = " virtual/libdf.so.0___64bit_ virtual/libmfhdf.so.0___64bit_"

URI_x86_64_v2_hdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf-devel-4.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf-devel}"
SRC_URI[x86_64_v2_hdf-devel.sha256sum] = "264330f615e57d6fc2b99b9da9f0244b7b23510ac42bc477a9636c77f731a2b0"

URI_x86_64_v2_hdf-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf-examples-4.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_hdf-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf-examples}"
SRC_URI[x86_64_v2_hdf-examples.sha256sum] = "f241519e771b43b0ebb431dbb25b317f97cb89080c3898bc1292ac81c9995f8c"

URI_x86_64_v2_hdf-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf-libs-4.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf-libs}"
SRC_URI[x86_64_v2_hdf-libs.sha256sum] = "d49068e12a1a404e8653e8add12bfdd4de7a6e3ca55fc2e678c9f1bbc5bfc53a"
RPROVIDES:hdf-libs:append:x86_64_v2 = " virtual/libdf.so.0___64bit_ virtual/libmfhdf.so.0___64bit_"

URI_x86_64_v2_hdf-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hdf-static-4.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hdf-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hdf-static}"
SRC_URI[x86_64_v2_hdf-static.sha256sum] = "b7bb1c1216eef64384d840f2d366ac635181438029dfd255741651b7f20fa67e"

URI_x86_64_v2_java-hdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/java-hdf-4.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_java-hdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_java-hdf}"
SRC_URI[x86_64_v2_java-hdf.sha256sum] = "ffb830587b39e82439597018ce4176da1531859bc030dff1eaadfd1226922ad5"

URI_aarch64_hdf = "${EPEL_MIRROR}/aarch64/Packages/h/hdf-4.3.0-1.el10_0.aarch64.rpm;name=aarch64_hdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf}"
SRC_URI[aarch64_hdf.sha256sum] = "3f07fed2593a71326aa887c57bb07ede5006d37319f5d4e9aebd2649285072ea"
RPROVIDES:hdf:append:aarch64 = " virtual/libdf.so.0___64bit_ virtual/libmfhdf.so.0___64bit_"

URI_aarch64_hdf-devel = "${EPEL_MIRROR}/aarch64/Packages/h/hdf-devel-4.3.0-1.el10_0.aarch64.rpm;name=aarch64_hdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf-devel}"
SRC_URI[aarch64_hdf-devel.sha256sum] = "a0113510dbab54bd4d08ef4dd3805157b9528e7a2fcfb851ce5dd681144b9fa7"

URI_aarch64_hdf-examples = "${EPEL_MIRROR}/aarch64/Packages/h/hdf-examples-4.3.0-1.el10_0.noarch.rpm;name=aarch64_hdf-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf-examples}"
SRC_URI[aarch64_hdf-examples.sha256sum] = "e2af78db666d1a59f23b7edacaff79641cbc9cb9a507f80a7564d1b192f99915"

URI_aarch64_hdf-libs = "${EPEL_MIRROR}/aarch64/Packages/h/hdf-libs-4.3.0-1.el10_0.aarch64.rpm;name=aarch64_hdf-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf-libs}"
SRC_URI[aarch64_hdf-libs.sha256sum] = "67880717603211056d6f269ddde2dbd3f9113b6f10a8fd88192044e6a92f33cc"
RPROVIDES:hdf-libs:append:aarch64 = " virtual/libdf.so.0___64bit_ virtual/libmfhdf.so.0___64bit_"

URI_aarch64_hdf-static = "${EPEL_MIRROR}/aarch64/Packages/h/hdf-static-4.3.0-1.el10_0.aarch64.rpm;name=aarch64_hdf-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_hdf-static}"
SRC_URI[aarch64_hdf-static.sha256sum] = "02b054def34c4c93b9b665a0f6f9e5ae7ff21fc211e326c9dbb0acc5c4b07321"

URI_aarch64_java-hdf = "${EPEL_MIRROR}/aarch64/Packages/j/java-hdf-4.3.0-1.el10_0.aarch64.rpm;name=aarch64_java-hdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_java-hdf}"
SRC_URI[aarch64_java-hdf.sha256sum] = "d6dd5f1aa2fa65254952e290a4edd98d5e403569c5c1ee3ff65f987546b3d8c5"

RDEPENDS:hdf = " \
 bash \
 glibc \
 hdf-libs \
 libaec \
 libjpeg-turbo \
 libtirpc \
 zlib-ng-compat \
 "
RDEPENDS:hdf-devel = " \
 bash \
 hdf-libs \
 libjpeg-turbo-devel \
 libtirpc-devel \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 zlib-ng-compat-devel \
 "
RDEPENDS:hdf-examples = " \
 "
RDEPENDS:hdf-libs = " \
 glibc \
 libaec \
 libjpeg-turbo \
 libtirpc \
 zlib-ng-compat \
 "
RDEPENDS:hdf-static = " \
 hdf-devel \
 "
RDEPENDS:java-hdf = " \
 glibc \
 libaec \
 libjpeg-turbo \
 libtirpc \
 slf4j \
 virtual/libdf.so.0___64bit_ \
 virtual/libmfhdf.so.0___64bit_ \
 zlib-ng-compat \
 "
