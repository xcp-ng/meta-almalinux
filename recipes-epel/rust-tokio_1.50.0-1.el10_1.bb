# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio"
PV = "1.50.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-tokio+bytes-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+full-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+libc-devel \
 rust-tokio+macros-devel \
 rust-tokio+mio-devel \
 rust-tokio+net-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio+socket2-devel \
 rust-tokio+sync-devel \
 rust-tokio+test-util-devel \
 rust-tokio+time-devel \
 rust-tokio+tokio-macros-devel \
 rust-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-1.50.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0eb0ca941160c5523c4ae103fce43dd12ad297c51979b11bb2dbbbfd0e3413b"

URI_x86_64_v2_rust-tokio+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+bytes-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+bytes-devel}"
SRC_URI[x86_64_v2_rust-tokio+bytes-devel.sha256sum] = "8399b47c5da9a7704bd50285090717c002bc38d5b9cd70c54268e7726c0e7ee6"

URI_x86_64_v2_rust-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+default-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-tokio+default-devel.sha256sum] = "7302d2fa2983d7e207a4ae5f1675c2843c8b02e1d47b8dc53cbc6995d0e72e0f"

URI_x86_64_v2_rust-tokio+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+fs-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+fs-devel}"
SRC_URI[x86_64_v2_rust-tokio+fs-devel.sha256sum] = "192b6cababbdcf84cdf57b490342effe897c44299c6e4759264acc25201b5073"

URI_x86_64_v2_rust-tokio+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+full-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+full-devel}"
SRC_URI[x86_64_v2_rust-tokio+full-devel.sha256sum] = "527789dd053ca156fdf569410f9fbe05bff12b55e2d0ae2a266aee4718f5b41b"

URI_x86_64_v2_rust-tokio+io-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+io-std-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+io-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+io-std-devel}"
SRC_URI[x86_64_v2_rust-tokio+io-std-devel.sha256sum] = "1f4da9ff1e3d64dc8bb00da6655ae06a64a8963d295ec1d997acf00d2e9a6efa"

URI_x86_64_v2_rust-tokio+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+io-util-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio+io-util-devel.sha256sum] = "b0787c9a58e4d314c6da59b1a2c64178c0653f43efc455d57e8ae272bef6878c"

URI_x86_64_v2_rust-tokio+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+libc-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+libc-devel}"
SRC_URI[x86_64_v2_rust-tokio+libc-devel.sha256sum] = "c1b20bb49ad0a03cb44e839e0540a1ff18eb69fd356aa37d291a98f8f3da9e84"

URI_x86_64_v2_rust-tokio+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+macros-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+macros-devel}"
SRC_URI[x86_64_v2_rust-tokio+macros-devel.sha256sum] = "03ff2ae0d5eee85be673dd3bde6cf1d96f3ada784eabb10101641773aee77b57"

URI_x86_64_v2_rust-tokio+mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+mio-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+mio-devel}"
SRC_URI[x86_64_v2_rust-tokio+mio-devel.sha256sum] = "4868191ad8ecb3a4b0b90cd38fde377ecdc39ac134c9c18ebfb8a0903838c895"

URI_x86_64_v2_rust-tokio+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+net-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+net-devel}"
SRC_URI[x86_64_v2_rust-tokio+net-devel.sha256sum] = "58d9695a032011ac2c5dd0133ecaae38cb11fd52f28a78fedc60c2c2155cbe20"

URI_x86_64_v2_rust-tokio+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+parking_lot-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-tokio+parking_lot-devel.sha256sum] = "a12d43888450b2fe0f872243849be50df2423adccaa425ace91f1fe78a7a4f30"

URI_x86_64_v2_rust-tokio+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+process-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+process-devel}"
SRC_URI[x86_64_v2_rust-tokio+process-devel.sha256sum] = "5be23f0c5bbfdd110aefa91381ea826aa87cfd222aa502cabbfb788ca8ac4820"

URI_x86_64_v2_rust-tokio+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+rt-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio+rt-devel.sha256sum] = "edb3ac00d7b2447ae314262882f6576abb12407e4bd4e811674066239cb6505f"

URI_x86_64_v2_rust-tokio+rt-multi-thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+rt-multi-thread-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+rt-multi-thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+rt-multi-thread-devel}"
SRC_URI[x86_64_v2_rust-tokio+rt-multi-thread-devel.sha256sum] = "626b3d3905c3d721d559fca932f6b0729b93df22275fefe9f3b17d9fba930181"

URI_x86_64_v2_rust-tokio+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+signal-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+signal-devel}"
SRC_URI[x86_64_v2_rust-tokio+signal-devel.sha256sum] = "018e6ce3b4b73806be3717d4ec52cc42c66fc8c861d1a8ca4ad7dee370513cef"

URI_x86_64_v2_rust-tokio+signal-hook-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+signal-hook-registry-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+signal-hook-registry-devel}"
SRC_URI[x86_64_v2_rust-tokio+signal-hook-registry-devel.sha256sum] = "ff8b8bb0b6ce1436c37b57f44f27479bc5080e76053be707bf32782741cdd1e2"

URI_x86_64_v2_rust-tokio+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+socket2-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+socket2-devel}"
SRC_URI[x86_64_v2_rust-tokio+socket2-devel.sha256sum] = "9b17644b6e2a6dcd4b9619ecefae12bc09e530bcdc28d07996ba08ef5b23376c"

URI_x86_64_v2_rust-tokio+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+sync-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+sync-devel}"
SRC_URI[x86_64_v2_rust-tokio+sync-devel.sha256sum] = "59f37288225cb3f87caa34c135395ceb3bdcfa2317bb38ed8f4843de3b5c419b"

URI_x86_64_v2_rust-tokio+test-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+test-util-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+test-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+test-util-devel}"
SRC_URI[x86_64_v2_rust-tokio+test-util-devel.sha256sum] = "15fa2e4b389f430ecc9259c8bb7b984b5d341045903bedb502a50da0cae9abe1"

URI_x86_64_v2_rust-tokio+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+time-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+time-devel}"
SRC_URI[x86_64_v2_rust-tokio+time-devel.sha256sum] = "eb594d6f3a124bb9d58349002bd8e23db7281a0405ce14db5a1b3f1f09f6cec5"

URI_x86_64_v2_rust-tokio+tokio-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+tokio-macros-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+tokio-macros-devel}"
SRC_URI[x86_64_v2_rust-tokio+tokio-macros-devel.sha256sum] = "70f0dd72173a8449c175930651769419eb945758d63f1d284b82780779705dd3"

URI_x86_64_v2_rust-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-devel-1.50.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-devel}"
SRC_URI[x86_64_v2_rust-tokio-devel.sha256sum] = "c5deb5375096f44f29c3bbc25efd6ff56e791835f2df73f46852e2f9f2b2efda"

URI_aarch64_rust-tokio+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+bytes-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+bytes-devel}"
SRC_URI[aarch64_rust-tokio+bytes-devel.sha256sum] = "bddb0ee4debeaf9eb65ca082eda6a6b797d2ce0244290bb6f5aa0214e218613b"

URI_aarch64_rust-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+default-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+default-devel}"
SRC_URI[aarch64_rust-tokio+default-devel.sha256sum] = "6510023713efa4945c008e4ceddf36603346febe73b2bad1ed5db304b0e0655f"

URI_aarch64_rust-tokio+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+fs-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+fs-devel}"
SRC_URI[aarch64_rust-tokio+fs-devel.sha256sum] = "c9512ff1cb126b641a8464871d465c5e4847246c6d862f8fb623479d473ae43e"

URI_aarch64_rust-tokio+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+full-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+full-devel}"
SRC_URI[aarch64_rust-tokio+full-devel.sha256sum] = "fcbeeb063a69291cd19047477b3c0f8a743df88132915b14a29354e1198f63d2"

URI_aarch64_rust-tokio+io-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+io-std-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+io-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+io-std-devel}"
SRC_URI[aarch64_rust-tokio+io-std-devel.sha256sum] = "b9ce5305ba57e735c4680bb7a04c852da3ab1b508facb844cf5568799a9f8737"

URI_aarch64_rust-tokio+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+io-util-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+io-util-devel}"
SRC_URI[aarch64_rust-tokio+io-util-devel.sha256sum] = "91d2cffcbdc75b5a5e707490cb899333165d2888e888a3300a4af7e4333ddb76"

URI_aarch64_rust-tokio+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+libc-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+libc-devel}"
SRC_URI[aarch64_rust-tokio+libc-devel.sha256sum] = "adcbe6be4d1999cee7714c25febc5166ef062162013b895936af30afa82c78a6"

URI_aarch64_rust-tokio+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+macros-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+macros-devel}"
SRC_URI[aarch64_rust-tokio+macros-devel.sha256sum] = "a3ae71b9562f443b329856b99b5bf6329c5c42e84b340e2c05103f8704e7cb47"

URI_aarch64_rust-tokio+mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+mio-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+mio-devel}"
SRC_URI[aarch64_rust-tokio+mio-devel.sha256sum] = "6c08c08e9567f8f8d135d550f54d4da139c9991515ff2429d75d56ad77cb14e0"

URI_aarch64_rust-tokio+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+net-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+net-devel}"
SRC_URI[aarch64_rust-tokio+net-devel.sha256sum] = "ead45a446250d7993e3917322f6838e35e893a05f19182b8e1ee32b956d4609b"

URI_aarch64_rust-tokio+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+parking_lot-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+parking_lot-devel}"
SRC_URI[aarch64_rust-tokio+parking_lot-devel.sha256sum] = "1527c312d96face17fe3a5020fa1b5eab4393cc0f09cd637c40398b706740e26"

URI_aarch64_rust-tokio+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+process-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+process-devel}"
SRC_URI[aarch64_rust-tokio+process-devel.sha256sum] = "228e3d0f0a9f17a1e8519fe84be7f6c69a5724b5b622735e765eefbd99bc053b"

URI_aarch64_rust-tokio+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+rt-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+rt-devel}"
SRC_URI[aarch64_rust-tokio+rt-devel.sha256sum] = "5cfbdc68da6b1b866f75f113dcb48b61383228b789553037f0ae37c86b8ab48f"

URI_aarch64_rust-tokio+rt-multi-thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+rt-multi-thread-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+rt-multi-thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+rt-multi-thread-devel}"
SRC_URI[aarch64_rust-tokio+rt-multi-thread-devel.sha256sum] = "aa2645ed0e6d5c0876f360011f2c86bc23cca884dd0192b90164159c0b2ecde0"

URI_aarch64_rust-tokio+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+signal-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+signal-devel}"
SRC_URI[aarch64_rust-tokio+signal-devel.sha256sum] = "7d50dcc1e0549095fdf761cb4a74e9f1117a296c8dac0d66e1f735a017737681"

URI_aarch64_rust-tokio+signal-hook-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+signal-hook-registry-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+signal-hook-registry-devel}"
SRC_URI[aarch64_rust-tokio+signal-hook-registry-devel.sha256sum] = "b690497919808c1f443fcb898905266eea337f8512e10cd4465fc7a604945099"

URI_aarch64_rust-tokio+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+socket2-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+socket2-devel}"
SRC_URI[aarch64_rust-tokio+socket2-devel.sha256sum] = "2ec0f176a1a8153a029c9e9ee905c6da4ddf752b1471fccf330bd9ec97430d1f"

URI_aarch64_rust-tokio+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+sync-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+sync-devel}"
SRC_URI[aarch64_rust-tokio+sync-devel.sha256sum] = "76aa77428d6d7124643e7bec3de6702c47323574d6133a3e640fde069da95b1c"

URI_aarch64_rust-tokio+test-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+test-util-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+test-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+test-util-devel}"
SRC_URI[aarch64_rust-tokio+test-util-devel.sha256sum] = "7ad8e1d3428362fdb282809ab2828a028d2fa0ff01c31535d21956237ccaa645"

URI_aarch64_rust-tokio+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+time-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+time-devel}"
SRC_URI[aarch64_rust-tokio+time-devel.sha256sum] = "b77347f2a1e7b931f7de9f4a5453b47dce7d984f15501dd1372a25d86d536cfb"

URI_aarch64_rust-tokio+tokio-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+tokio-macros-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio+tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+tokio-macros-devel}"
SRC_URI[aarch64_rust-tokio+tokio-macros-devel.sha256sum] = "821cd1e92c0c615ad152ec2184d956a3efed7c295ec5bdb4d285b48f7ee707ae"

URI_aarch64_rust-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-devel-1.50.0-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-devel}"
SRC_URI[aarch64_rust-tokio-devel.sha256sum] = "fed4c03cd3682e59e76a3b9308d0f0b744565f17caf3777d10c39d5eeaf9ad60"

RDEPENDS:rust-tokio+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+default-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+fs-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+full-devel = " \
 cargo \
 rust-tokio+fs-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+io-std-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+io-util-devel = " \
 cargo \
 rust-tokio+bytes-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+macros-devel = " \
 cargo \
 rust-tokio+tokio-macros-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+mio-devel = " \
 cargo \
 rust-mio-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+net-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+libc-devel \
 rust-tokio+socket2-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+process-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+bytes-devel \
 rust-tokio+libc-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+rt-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+rt-multi-thread-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+signal-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+libc-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+signal-hook-registry-devel = " \
 cargo \
 rust-signal-hook-registry+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+socket2-devel = " \
 cargo \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+sync-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+test-util-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+time-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+tokio-macros-devel = " \
 cargo \
 rust-tokio-devel \
 rust-tokio-macros+default-devel \
 "
RDEPENDS:rust-tokio-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 "
