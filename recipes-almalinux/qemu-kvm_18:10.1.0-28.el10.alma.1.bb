# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qemu-kvm"
PE = "18"
PV = "10.1.0"
PR = "28.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"
PACKAGES:aarch64 = " \
 qemu-guest-agent \
 qemu-img \
 qemu-kvm \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-curl \
 qemu-kvm-block-rbd \
 qemu-kvm-common \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qemu-kvm-10.1.0-28.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "862dbbf0c7cb17b0896921024b1137551f16ad5a9c5ad748f3d0dc7ff10f7f90"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-guest-agent-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-guest-agent;unpack=0"
SRC_URI[x86_64_v2_qemu-guest-agent.sha256sum] = "d45166760437c03cdc7f98f5eb4b61986a78e5fcf2c309db730a779ae0f46f21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-img-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-img;unpack=0"
SRC_URI[x86_64_v2_qemu-img.sha256sum] = "9d748a38da2ed8cac4501974e8c0ec0fd699e38da1f93d62aa20f73514c7170c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm.sha256sum] = "7aaf70f3693cc7a8ba28a3fc22e73b86587f37c684b68e67e0fb817df1364a02"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-audio-pa-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-audio-pa;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-audio-pa.sha256sum] = "bca83e7494c43e2cfc616f403d3354cd26a562955bdb6713686cac45c6651ba6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-blkio-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-blkio;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-block-blkio.sha256sum] = "3653e29efb779ec4d5130f9f33a7bd18576e81417564167fc21caf6233b296ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-curl-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-curl;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-block-curl.sha256sum] = "d8aa5593cdd5899f15c30fd8db7f6f9a459db0e8de7541aeb8a2cfa8761c6607"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-block-rbd-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-block-rbd;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-block-rbd.sha256sum] = "8dbaab48296d5a6683727ebf99c4de9448327a6d5825add8a4b6b39a76bc0558"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-common-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-common;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-common.sha256sum] = "67ffe93fb20fbe7be62f546c060f37df8cca72794e7f137a518744ff07b0b83d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-core-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-core;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-core.sha256sum] = "b118af43a5a00d031a1c159f7da520299dc77ab63ec63f7efbb1056f457073a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu.sha256sum] = "508b8b722af132bbfa34dda9355847a2749e8eaf160eb9e41f5cb26397352339"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "34676b09549fa49834b46c916b27b95f471a605c807ac49ce400971a3ccd706c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-display-virtio-vga-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-display-virtio-vga;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-display-virtio-vga.sha256sum] = "a3691b24760c27980748223a9c5b441aca34863ddf79ed519b9e89cd31ab01df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-host-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-host;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-host.sha256sum] = "ad9c8225cde00ed0895eb75d0e63500e12e37f1f591b2918ebaaec35c15dd285"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-device-usb-redirect-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-device-usb-redirect.sha256sum] = "f37b2370e1cc30cffb3ed7a12126f7c20aabaa90616e246a34215c7f4be4991e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-docs-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-docs;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-docs.sha256sum] = "fd8b086803ef26ab1cb0d562d74199a9c6e4b9a20b692d79b105b30b66ff9f1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-tools-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-tools;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-tools.sha256sum] = "eb4435bdc684840729cc5ca6903036df95a7d9a30e79023d7c6b971472b741ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-egl-headless-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-egl-headless;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-ui-egl-headless.sha256sum] = "15f9fb457b94f812b8bc5e4e6d720049b4eb330fe7132c02830124e146ca5395"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-opengl-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-opengl;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-ui-opengl.sha256sum] = "f36799de19513de9907a4c0b543ea9f5e5a78ffb8e8709d91fe54752c07c6f0d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-kvm-ui-spice-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-kvm-ui-spice;unpack=0"
SRC_URI[x86_64_v2_qemu-kvm-ui-spice.sha256sum] = "19e35cf122d845c17cb778fbbfaa3f9fb5a5ac6da0e3c591d6216ab29752d84d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qemu-pr-helper-10.1.0-28.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_qemu-pr-helper;unpack=0"
SRC_URI[x86_64_v2_qemu-pr-helper.sha256sum] = "34a9ccc3c020b82fad7c433dc0e698bf95d9eb067643358d6b0129bac0a7e599"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-guest-agent-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-guest-agent;unpack=0"
SRC_URI[aarch64_qemu-guest-agent.sha256sum] = "14a2acacedc73de61099306d6eeba5ae416ac38802f553726b71d8145e868334"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-img-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-img;unpack=0"
SRC_URI[aarch64_qemu-img.sha256sum] = "7116f24e9edbb3c2b5ad9ecea63e324748ec21776688dccb7211d4926dfcdfb3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm;unpack=0"
SRC_URI[aarch64_qemu-kvm.sha256sum] = "05a5008628c7daec96a8f81a6b1a343918acd4666fb13f10f3d71c3516187a30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-audio-pa-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-audio-pa;unpack=0"
SRC_URI[aarch64_qemu-kvm-audio-pa.sha256sum] = "907b61fabe246cd7eb1f05fe2935bdef1b01fbded9e5c8bddbf2fa0dbea22bf8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-blkio-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-blkio;unpack=0"
SRC_URI[aarch64_qemu-kvm-block-blkio.sha256sum] = "58193706473925bb96d20a51f5281f95b0f4c065912742004e0720ac21cb4bcd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-curl-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-curl;unpack=0"
SRC_URI[aarch64_qemu-kvm-block-curl.sha256sum] = "1cf57332e797e063051f15e9d6c1676ed06521f3768150025d754c8bc0e434de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-block-rbd-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-block-rbd;unpack=0"
SRC_URI[aarch64_qemu-kvm-block-rbd.sha256sum] = "b66f0637ebcfd4a4946c2d07830e760f6addb658a355fdbea060398bb1aa9968"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-common-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-common;unpack=0"
SRC_URI[aarch64_qemu-kvm-common.sha256sum] = "e5d52b81413eb159b64640a7137c993b21cfd3d27c6f0486320e8704bd0183df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-core-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-core;unpack=0"
SRC_URI[aarch64_qemu-kvm-core.sha256sum] = "ea58240ad3ace638ef0ffb50cfa9e7c26a4b2cb59888b2bbb1ac91ad161de181"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu;unpack=0"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu.sha256sum] = "8b8965c9e819ab0a071317b020fbdeb63f3fad7f7d3984d13a0753634bd671fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-display-virtio-gpu-pci-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-display-virtio-gpu-pci;unpack=0"
SRC_URI[aarch64_qemu-kvm-device-display-virtio-gpu-pci.sha256sum] = "019f0b391970cc61b1a1a2ce70f6f6402734d5d3d59bcb1392bf461d5d8cb0ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-host-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-host;unpack=0"
SRC_URI[aarch64_qemu-kvm-device-usb-host.sha256sum] = "3231a1e048c0b0d3ebdf772d45be2292cc5f8e86fc032e5f4af1f98e2ca414ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-device-usb-redirect-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-device-usb-redirect;unpack=0"
SRC_URI[aarch64_qemu-kvm-device-usb-redirect.sha256sum] = "eeed0faa57957963642c2c9c187c7ed93d562fc04eafbc2c95ba91fd1053bfb5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-docs-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-docs;unpack=0"
SRC_URI[aarch64_qemu-kvm-docs.sha256sum] = "96f561043a4810a8a8c29cbd9e783e026a10d64fb3db58184fe05fcb00c30ea7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-tools-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-tools;unpack=0"
SRC_URI[aarch64_qemu-kvm-tools.sha256sum] = "fa42cec8a2495af39d01caf82f5a0e095438e9a618cbac2fb41c2536302ccd8c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-kvm-ui-spice-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-kvm-ui-spice;unpack=0"
SRC_URI[aarch64_qemu-kvm-ui-spice.sha256sum] = "b5dfa4cfb0eb0d49d05d2a3e583768e1be3152f0b79fa692ab864498898e3b66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qemu-pr-helper-10.1.0-28.el10.alma.1.aarch64.rpm;name=aarch64_qemu-pr-helper;unpack=0"
SRC_URI[aarch64_qemu-pr-helper.sha256sum] = "887b8a3fec4f0b94c5b71e2952f5082062ca5cc1df9defd5716c41ce505e5003"

RDEPENDS:qemu-guest-agent = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 liburing \
 numactl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:qemu-img = " \
 glib2 \
 glibc \
 gnutls \
 libaio \
 libgcc \
 libselinux \
 liburing \
 libzstd \
 numactl-libs \
 zlib-ng-compat \
 "
RDEPENDS:qemu-kvm:x86_64_v2 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-display-virtio-vga \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-egl-headless \
 qemu-kvm-ui-opengl \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm:aarch64 = " \
 qemu-kvm-audio-pa \
 qemu-kvm-block-blkio \
 qemu-kvm-block-rbd \
 qemu-kvm-core \
 qemu-kvm-device-display-virtio-gpu \
 qemu-kvm-device-display-virtio-gpu-pci \
 qemu-kvm-device-usb-host \
 qemu-kvm-device-usb-redirect \
 qemu-kvm-docs \
 qemu-kvm-tools \
 qemu-kvm-ui-spice \
 qemu-pr-helper \
 virtiofsd \
"
RDEPENDS:qemu-kvm-audio-pa = " \
 glibc \
 pulseaudio-libs \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-blkio = " \
 glibc \
 libblkio \
 libgcc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-block-curl = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-block-rbd = " \
 glibc \
 libgcc \
 librados2 \
 librbd1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-common:x86_64_v2 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 ipxe-roms-qemu \
 libcap-ng \
 libgcc \
 seabios-bin \
 seavgabios-bin \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-common:aarch64 = " \
 bash \
 glib2 \
 glibc \
 glibc-common \
 gnutls \
 libcap-ng \
 libgcc \
 shadow-utils \
 systemd \
"
RDEPENDS:qemu-kvm-core:x86_64_v2 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-ovmf \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-core:aarch64 = " \
 capstone \
 cyrus-sasl-lib \
 edk2-aarch64 \
 glib2 \
 glibc \
 gnutls \
 keyutils-libs \
 libaio \
 libfdt \
 libgcc \
 libpng \
 libseccomp \
 libslirp \
 liburing \
 libusb1 \
 libzstd \
 lzo \
 numactl-libs \
 pixman \
 qemu-img \
 qemu-kvm-common \
 snappy \
 zlib-ng-compat \
"
RDEPENDS:qemu-kvm-device-display-virtio-gpu = " \
 glibc \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-display-virtio-gpu-pci = " \
 glibc \
 qemu-kvm-common \
 qemu-kvm-device-display-virtio-gpu \
 "
RDEPENDS:qemu-kvm-device-display-virtio-vga = " \
 glibc \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-host = " \
 glibc \
 libusb1 \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-device-usb-redirect = " \
 glibc \
 libgcc \
 qemu-kvm-common \
 usbredir \
 "
RDEPENDS:qemu-kvm-docs = " \
 "
RDEPENDS:qemu-kvm-tools = " \
 glib2 \
 glibc \
 libgcc \
 libxkbcommon \
 python3 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:qemu-kvm-ui-egl-headless = " \
 glibc \
 libepoxy \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 "
RDEPENDS:qemu-kvm-ui-opengl = " \
 glibc \
 libepoxy \
 libgcc \
 mesa-dri-drivers \
 mesa-libEGL \
 mesa-libGL \
 mesa-libgbm \
 pixman \
 qemu-kvm-common \
 "
RDEPENDS:qemu-kvm-ui-spice:x86_64_v2 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 qemu-kvm-ui-opengl \
 spice-server \
"
RDEPENDS:qemu-kvm-ui-spice:aarch64 = " \
 glibc \
 libgcc \
 pixman \
 qemu-kvm-common \
 spice-server \
"
RDEPENDS:qemu-pr-helper = " \
 device-mapper-multipath-libs \
 glib2 \
 glibc \
 gnutls \
 libcap-ng \
 libgcc \
 liburing \
 numactl-libs \
 systemd-libs \
 "
