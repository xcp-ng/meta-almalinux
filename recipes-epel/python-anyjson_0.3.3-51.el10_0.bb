# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-anyjson"
PV = "0.3.3"
PR = "51.el10_0"
PACKAGES = " \
 python3-anyjson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-anyjson-0.3.3-51.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ddf32abde461daff55d75d8ad475e3917504e0f00d85d71068ed3004f1b49a1"

URI_x86_64_v2_python3-anyjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-anyjson-0.3.3-51.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-anyjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-anyjson}"
SRC_URI[x86_64_v2_python3-anyjson.sha256sum] = "46e39dce76ec83da54903e62ab8ed73a88ae93e62eb51823a5d4e702b2c2dd5d"

URI_aarch64_python3-anyjson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-anyjson-0.3.3-51.el10_0.noarch.rpm;name=aarch64_python3-anyjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-anyjson}"
SRC_URI[aarch64_python3-anyjson.sha256sum] = "1c9fe221b12ed51fcb91fae7dcb55853f33f3d0ea2df80678c1a73aadfd7fcb8"

RDEPENDS:python3-anyjson = " \
 python3 \
 "
