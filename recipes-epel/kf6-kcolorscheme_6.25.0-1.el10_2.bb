# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcolorscheme"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kcolorscheme \
 kf6-kcolorscheme-devel \
 kf6-kcolorscheme-doc \
 kf6-kcolorscheme-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcolorscheme-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8b8785204866c530f37a2d261f0818a7caaf8a73c6b4f60cc8aa7ddc5999b1a"

URI_x86_64_v2_kf6-kcolorscheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme}"
SRC_URI[x86_64_v2_kf6-kcolorscheme.sha256sum] = "a71f2f900168d090c0439bb5c6c8f200911bdc8b459b07669a5b5eb1b0d26dac"

URI_x86_64_v2_kf6-kcolorscheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcolorscheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme-devel}"
SRC_URI[x86_64_v2_kf6-kcolorscheme-devel.sha256sum] = "ebe801950c8a5ad3e70adc3641aa8499dd83ce7d8e48110c7b933ed25d2e0055"

URI_x86_64_v2_kf6-kcolorscheme-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcolorscheme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme-doc}"
SRC_URI[x86_64_v2_kf6-kcolorscheme-doc.sha256sum] = "6fd890c9a62c9fad3f0f61736bad613439f6011ca310d3e04ba5df57efe991e8"

URI_x86_64_v2_kf6-kcolorscheme-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcolorscheme-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcolorscheme-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcolorscheme-html}"
SRC_URI[x86_64_v2_kf6-kcolorscheme-html.sha256sum] = "80c74c4860cd9b8191a3416b255711c4cd83bb4907eeaf83ecd8a8e765cbc113"

URI_aarch64_kf6-kcolorscheme = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcolorscheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme}"
SRC_URI[aarch64_kf6-kcolorscheme.sha256sum] = "5a7fb1b113e5974e12e9d94135e9c5c58ef298e7e6938bbc483cf81999c4c93e"

URI_aarch64_kf6-kcolorscheme-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcolorscheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme-devel}"
SRC_URI[aarch64_kf6-kcolorscheme-devel.sha256sum] = "727f6da371fe47db4d39dac0abd4e3c58f5dc39756dc9c8cc80e3874cf800f52"

URI_aarch64_kf6-kcolorscheme-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcolorscheme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme-doc}"
SRC_URI[aarch64_kf6-kcolorscheme-doc.sha256sum] = "8ba5cc9de341b371c7b568c0f4d415e36ccaef75938c91250c9f879f754b0059"

URI_aarch64_kf6-kcolorscheme-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcolorscheme-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcolorscheme-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcolorscheme-html}"
SRC_URI[aarch64_kf6-kcolorscheme-html.sha256sum] = "6c707bbf9453c84b4e56ebf0d84e4e2545c56cdcec3880a151fef8feeda6a0d3"

RDEPENDS:kf6-kcolorscheme = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcolorscheme-devel = " \
 cmake-filesystem \
 kf6-kcolorscheme \
 "
RDEPENDS:kf6-kcolorscheme-doc = " \
 "
RDEPENDS:kf6-kcolorscheme-html = " \
 "
