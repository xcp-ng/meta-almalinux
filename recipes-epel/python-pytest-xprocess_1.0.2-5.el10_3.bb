# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-xprocess"
PV = "1.0.2"
PR = "5.el10_3"
PACKAGES = " \
 python3-pytest-xprocess \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-xprocess-1.0.2-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e4519b96ccb5d7d93800684471242209017edad6a5e2912179e8508e9065955"

URI_x86_64_v2_python3-pytest-xprocess = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-xprocess-1.0.2-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-xprocess;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-xprocess}"
SRC_URI[x86_64_v2_python3-pytest-xprocess.sha256sum] = "93a6448a4dcf11bc7cafbe61e2204e0ea0be19d33d39c523adcb00a56619a199"

URI_aarch64_python3-pytest-xprocess = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-xprocess-1.0.2-5.el10_3.noarch.rpm;name=aarch64_python3-pytest-xprocess;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-xprocess}"
SRC_URI[aarch64_python3-pytest-xprocess.sha256sum] = "091cb4e8fbeb542e3051550f650a0ab0862c0247ffd533435e51f80fe40e2fa2"

RDEPENDS:python3-pytest-xprocess = " \
 python3 \
 python3-psutil \
 python3-pytest \
 python3-setuptools \
 "
