# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-difflib"
PV = "0.4.0"
PR = "8.el10_0"
PACKAGES = " \
 rust-difflib+default-devel \
 rust-difflib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-difflib-0.4.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e046030e68236d1d0bd1b3fd91037d7adb761f119bc9a3374e66065aea8dcf84"

URI_x86_64_v2_rust-difflib+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-difflib+default-devel-0.4.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-difflib+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-difflib+default-devel}"
SRC_URI[x86_64_v2_rust-difflib+default-devel.sha256sum] = "5300a1eee01d07654077a2d478a1e55f838d22b3a09de7f56aece330199b85e4"

URI_x86_64_v2_rust-difflib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-difflib-devel-0.4.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-difflib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-difflib-devel}"
SRC_URI[x86_64_v2_rust-difflib-devel.sha256sum] = "b31a56f97ee519b60708adcb2ccc90458228b49e07df7c45c7368d6f8aa68c65"

URI_aarch64_rust-difflib+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-difflib+default-devel-0.4.0-8.el10_0.noarch.rpm;name=aarch64_rust-difflib+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-difflib+default-devel}"
SRC_URI[aarch64_rust-difflib+default-devel.sha256sum] = "1a9d9ba160de488a238e1a130e4b1890511245e19991205d88fe63614c6b298f"

URI_aarch64_rust-difflib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-difflib-devel-0.4.0-8.el10_0.noarch.rpm;name=aarch64_rust-difflib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-difflib-devel}"
SRC_URI[aarch64_rust-difflib-devel.sha256sum] = "e76e6570b7cd677f128107e913d60286c20e60a30ce5915a0b1023d6b813d01b"

RDEPENDS:rust-difflib+default-devel = " \
 cargo \
 rust-difflib-devel \
 "
RDEPENDS:rust-difflib-devel = " \
 cargo \
 "
