# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-contacts"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 akonadi-contacts \
 akonadi-contacts-devel \
 akonadi-contacts-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-contacts-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9a4d32faaaf6368c942da189529f51b55d97e787765a8b259b24c048e92852e"

URI_x86_64_v2_akonadi-contacts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts}"
SRC_URI[x86_64_v2_akonadi-contacts.sha256sum] = "d990db16d45ea0c9b3843e407a5f8222295c9ac832fea156e1f0054df0da41e8"

URI_x86_64_v2_akonadi-contacts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-contacts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts-devel}"
SRC_URI[x86_64_v2_akonadi-contacts-devel.sha256sum] = "29bef2f5cd76dc460e57e4a83f1fb5ec69b4953211269e067c7007e20bc348d5"

URI_x86_64_v2_akonadi-contacts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-contacts-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-contacts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-contacts-doc}"
SRC_URI[x86_64_v2_akonadi-contacts-doc.sha256sum] = "2ba890bcb48b5724f1da75a2c31f49adf7f53e09077ee20a91cf1f1d6b85e1b8"

URI_aarch64_akonadi-contacts = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-contacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts}"
SRC_URI[aarch64_akonadi-contacts.sha256sum] = "38bd591d1b602798b5863b0e52da10777608a70696ec73f824a6a6757725c577"

URI_aarch64_akonadi-contacts-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_akonadi-contacts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts-devel}"
SRC_URI[aarch64_akonadi-contacts-devel.sha256sum] = "a68bdc3edaa7cbf8209696c8f473ab9fa7e2c17b86cee324a34abe08722210cf"

URI_aarch64_akonadi-contacts-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-contacts-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_akonadi-contacts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-contacts-doc}"
SRC_URI[aarch64_akonadi-contacts-doc.sha256sum] = "d2d5a486b05671ddb5f8b95e7f62f94db69a9156951f1a9425af98fb5dba359e"

RDEPENDS:akonadi-contacts = " \
 akonadi-server \
 glibc \
 grantleetheme \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-prison \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-contacts-devel = " \
 akonadi-contacts \
 akonadi-server-devel \
 cmake-filesystem \
 grantleetheme-devel \
 kf6-kcontacts-devel \
 "
RDEPENDS:akonadi-contacts-doc = " \
 "
