# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-scheduler-event-generator"
PV = "6.6"
PR = "1.el10_2"
PACKAGES = " \
 globus-scheduler-event-generator \
 globus-scheduler-event-generator-devel \
 globus-scheduler-event-generator-doc \
 globus-scheduler-event-generator-progs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/globus-scheduler-event-generator-6.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "47bd3df9a50629561ca42ab418c9404a5197880182c2701ec87e4f28a81966e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-6.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-scheduler-event-generator;unpack=0"
SRC_URI[x86_64_v2_globus-scheduler-event-generator.sha256sum] = "66d1f7e8a8cd3ba095bf754daafacf30a3e3021c30154589fd2bba59f1b8aec1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-devel-6.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-scheduler-event-generator-devel;unpack=0"
SRC_URI[x86_64_v2_globus-scheduler-event-generator-devel.sha256sum] = "4da6897827ad0a1cc6ad0cd2c627047bfb45346b3e8ab45635a83ea4a83a111b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-doc-6.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_globus-scheduler-event-generator-doc;unpack=0"
SRC_URI[x86_64_v2_globus-scheduler-event-generator-doc.sha256sum] = "355820a80eb3c8866efbfb34626691dd1ad015e3d16650bff7b510fcdc4d3633"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-scheduler-event-generator-progs-6.6-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-scheduler-event-generator-progs;unpack=0"
SRC_URI[x86_64_v2_globus-scheduler-event-generator-progs.sha256sum] = "10f3b3e5f914cd1afd94781578d7dba9beec74ac9b5d7dc5911c83ea7d851bcb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-6.6-1.el10_2.aarch64.rpm;name=aarch64_globus-scheduler-event-generator;unpack=0"
SRC_URI[aarch64_globus-scheduler-event-generator.sha256sum] = "812324d47134e46ce48a7f7491d0c6e2fb5d0eb3fc7c1899af686c0decf94450"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-devel-6.6-1.el10_2.aarch64.rpm;name=aarch64_globus-scheduler-event-generator-devel;unpack=0"
SRC_URI[aarch64_globus-scheduler-event-generator-devel.sha256sum] = "459910376b9bf2c656da84978af785d7d2fcfd28337f096c132794cf58f8b1cd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-doc-6.6-1.el10_2.noarch.rpm;name=aarch64_globus-scheduler-event-generator-doc;unpack=0"
SRC_URI[aarch64_globus-scheduler-event-generator-doc.sha256sum] = "65999d61dc55398084af656efc001ec95eb9f4a1c23aa7166fb181283072d730"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-scheduler-event-generator-progs-6.6-1.el10_2.aarch64.rpm;name=aarch64_globus-scheduler-event-generator-progs;unpack=0"
SRC_URI[aarch64_globus-scheduler-event-generator-progs.sha256sum] = "32d46fe6ced2d67f5c86d8a3122672285234cf1f963fbcdd9f1b1973e96013f3"

RDEPENDS:globus-scheduler-event-generator = " \
 glibc \
 globus-common \
 globus-xio-gsi-driver \
 "
RDEPENDS:globus-scheduler-event-generator-devel = " \
 globus-common-devel \
 globus-gram-protocol-devel \
 globus-scheduler-event-generator \
 globus-xio-devel \
 globus-xio-gsi-driver-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-scheduler-event-generator-doc = " \
 "
RDEPENDS:globus-scheduler-event-generator-progs = " \
 bash \
 glibc \
 globus-common \
 globus-scheduler-event-generator \
 globus-xio \
 systemd \
 "
