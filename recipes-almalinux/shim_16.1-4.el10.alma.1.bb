# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shim"
PV = "16.1"
PR = "4.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 shim-x64 \
"
PACKAGES:aarch64 = " \
 shim-aa64 \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/shim-16.1-4.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5536669b9e97885b3f4c9778c31068544164e599780bb1c8b7375cd6ef9f4e29"

URI_x86_64_v2_shim-x64 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shim-x64-16.1-4.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_shim-x64;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shim-x64}"
SRC_URI[x86_64_v2_shim-x64.sha256sum] = "4f28c033ab34f2784d59162af1ee3b6781b0a806ccf57da8ae0e8c5f6b5559aa"

URI_aarch64_shim-aa64 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shim-aa64-16.1-4.el10.alma.1.aarch64.rpm;name=aarch64_shim-aa64;unpack=0"
SRC_URI:append = " ${URI_aarch64_shim-aa64}"
SRC_URI[aarch64_shim-aa64.sha256sum] = "820acaec71183edd2e618cc9232a3f5381865a2709d1091d380a36837e2b3cc0"

RDEPENDS:shim-x64 = " \
 efi-filesystem \
 fwupd \
 mokutil \
 "
RDEPENDS:shim-aa64 = " \
 efi-filesystem \
 fwupd \
 mokutil \
 "
