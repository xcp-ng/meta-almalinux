# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-metrics-exporter-prometheus"
PV = "0.18.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-metrics-exporter-prometheus+_hyper-client-devel \
 rust-metrics-exporter-prometheus+_hyper-server-devel \
 rust-metrics-exporter-prometheus+_push-gateway-common-devel \
 rust-metrics-exporter-prometheus+async-runtime-devel \
 rust-metrics-exporter-prometheus+default-devel \
 rust-metrics-exporter-prometheus+http-body-util-devel \
 rust-metrics-exporter-prometheus+http-listener-devel \
 rust-metrics-exporter-prometheus+hyper-devel \
 rust-metrics-exporter-prometheus+hyper-rustls-devel \
 rust-metrics-exporter-prometheus+hyper-util-devel \
 rust-metrics-exporter-prometheus+ipnet-devel \
 rust-metrics-exporter-prometheus+mime-devel \
 rust-metrics-exporter-prometheus+prost-build-devel \
 rust-metrics-exporter-prometheus+prost-devel \
 rust-metrics-exporter-prometheus+prost-types-devel \
 rust-metrics-exporter-prometheus+push-gateway-devel \
 rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel \
 rust-metrics-exporter-prometheus+rustls-devel \
 rust-metrics-exporter-prometheus+tokio-devel \
 rust-metrics-exporter-prometheus+tracing-devel \
 rust-metrics-exporter-prometheus+uds-listener-devel \
 rust-metrics-exporter-prometheus-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-metrics-exporter-prometheus-0.18.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2487f07f2624bfe14313dc195099f641ff8941ca8eb3f92d15cbbd393b21194b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+_hyper-client-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+_hyper-client-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+_hyper-client-devel.sha256sum] = "653baf994ec854f994f5c39ba59b0816e35ab4821abd0453b476dddbace94c87"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+_hyper-server-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+_hyper-server-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+_hyper-server-devel.sha256sum] = "c4c21c99e9f63888c7984be1c42469ff8cac96074b66bdc753a38eb997a65161"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+_push-gateway-common-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+_push-gateway-common-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+_push-gateway-common-devel.sha256sum] = "ec957bac654afbcbe4d334ad68b1ecae610b2f0379d0d0d9ccd5626421368817"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+async-runtime-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+async-runtime-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+async-runtime-devel.sha256sum] = "32daaa8108e6753e963d29231570d57cc2ddff1e1d00b1a08df1d3bfcef02b55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+default-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+default-devel.sha256sum] = "634b6fac32d0b9856d16ebb0bc0153e9256d69c10b0d169c416c0e064c148706"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+http-body-util-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+http-body-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+http-body-util-devel.sha256sum] = "8821828daa8bf685bdb0f9d7ff6e4f0c19b272675e6703ad1daa24c410e646ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+http-listener-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+http-listener-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+http-listener-devel.sha256sum] = "e0a41c10d3bbcab88f19b9cb86905b281a358ae5d5cb0d9632bfab408a79c681"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+hyper-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+hyper-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+hyper-devel.sha256sum] = "002c05bdf5ce8e05b31d96459a2c05da46ea68fb8dd8deeb1c7a61a15ca4b013"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+hyper-rustls-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+hyper-rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+hyper-rustls-devel.sha256sum] = "527aebfc5d1721eee8a6b03e31f3f7baccee4ca0e37e4d09f920d9924794b233"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+hyper-util-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+hyper-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+hyper-util-devel.sha256sum] = "b67d09a5e6d8198e7508e8e22cab2fd57a26bd4baf365ec23cfce85e61eba746"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+ipnet-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+ipnet-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+ipnet-devel.sha256sum] = "77e2e69d6457a301561de00877dd77a2142c3906db46a052b2d389e2a4f511ea"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+mime-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+mime-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+mime-devel.sha256sum] = "508e490defa29bbeab7772c839f3f612724af0752d19bba0b880001c0e28f8b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+prost-build-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+prost-build-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+prost-build-devel.sha256sum] = "7aada6cdcdd456b27168c09ff29335a58a29f6ed57debb0c30eb5de4f634ecd6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+prost-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+prost-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+prost-devel.sha256sum] = "7ed99e9d7ecc8160ac74aac037e9e4b005811822e31ba87b278fa83d6c666677"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+prost-types-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+prost-types-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+prost-types-devel.sha256sum] = "6961d48187b68533d150d8cba039e8ab867b49cde89b7c9cba85aef708f04cd0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+push-gateway-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-devel.sha256sum] = "ff7804efa8e8b9f32d89015d3e84621159ae6d7695931b02c3b43d591e978c0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel.sha256sum] = "87641de08633815b76ed41ce8fb28e04299034db276513ba7570c4aa7cfc7500"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+rustls-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+rustls-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+rustls-devel.sha256sum] = "a32b9088fd78aed43e0687ea0edc8fb1e473ab0b9c15560644413f951246ebed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+tokio-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+tokio-devel.sha256sum] = "de82e593e542bc46fc25a07d8e5b29723f59793215202e60fc05c093178894b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+tracing-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+tracing-devel.sha256sum] = "d8fd357a515c606161cf901f71fbe9e1fcff9667b1cd501f4c090b517c15997f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus+uds-listener-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus+uds-listener-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus+uds-listener-devel.sha256sum] = "b3e4ce6d84267324bf77d22087414d3585a15b7b0deebee3e5257f316b217f44"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-metrics-exporter-prometheus-devel-0.18.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-metrics-exporter-prometheus-devel;unpack=0"
SRC_URI[x86_64_v2_rust-metrics-exporter-prometheus-devel.sha256sum] = "ccfa044c51600de909351cdbaabf41b24b74162b21798beeee5224775eb1dc49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+_hyper-client-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+_hyper-client-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+_hyper-client-devel.sha256sum] = "69212358101f6896f0b3ee80cca6084ee05499aa14ba3b66eef48bf94b6562cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+_hyper-server-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+_hyper-server-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+_hyper-server-devel.sha256sum] = "2585aa1cf5163e7f9f7ee7d0f800c9d15ba0d6351af3664441860641114f0b3e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+_push-gateway-common-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+_push-gateway-common-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+_push-gateway-common-devel.sha256sum] = "15a10ba694769a7a5f328b373f80f26be819519558aff7ab4d2818733c0a9801"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+async-runtime-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+async-runtime-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+async-runtime-devel.sha256sum] = "4ebadd520c3de839a513afcf311443fa1d4ecb8dfe327ecd6d2710cb1e798d0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+default-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+default-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+default-devel.sha256sum] = "e397beee04d8db0b196dfdc99033e84e81c4a8dfd536f5be0dd2be9647b2cba0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+http-body-util-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+http-body-util-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+http-body-util-devel.sha256sum] = "62bf26cba24565910f9043e16995caf70bfa5081676e303f4dc37b5fa670b77f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+http-listener-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+http-listener-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+http-listener-devel.sha256sum] = "7bbad23e57b3b2467e76e8bea246a5e424c7ed69e370148e7fb55768bdfcbb94"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+hyper-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+hyper-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+hyper-devel.sha256sum] = "5d89cb7679dfadbeedfd620d693bd8c6821009957617c27955627723f3c76b6e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+hyper-rustls-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+hyper-rustls-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+hyper-rustls-devel.sha256sum] = "df3af18346b2aac003799cc07b7b5b8d88148682d06fb59f7f364e1ef795abbc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+hyper-util-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+hyper-util-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+hyper-util-devel.sha256sum] = "18df1d61128c4494b5f13e492b720104e54c296f30e2628aca0e140da066335a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+ipnet-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+ipnet-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+ipnet-devel.sha256sum] = "ececd6b79d9f9b9af29b2440da675d4a237512bfc21648c81b0be3a787565741"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+mime-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+mime-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+mime-devel.sha256sum] = "7aaa9bbd6687f053d242dca1cb8dac31c8b0e04a78159aa2726c0cf7a40f4eed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+prost-build-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+prost-build-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+prost-build-devel.sha256sum] = "ae324818102cb8084571bcb1975f9d4c303149e5066ac1c0a2a9604de86c1eaa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+prost-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+prost-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+prost-devel.sha256sum] = "30c734a8276a6c043753c9b4d6d408d174a446e0bfe6b4c887250a5e8d981e7b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+prost-types-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+prost-types-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+prost-types-devel.sha256sum] = "baf76476f67de2a13d3c8b26d2edbc304629a0156c92d80f62a8ce68e536ff9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+push-gateway-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+push-gateway-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+push-gateway-devel.sha256sum] = "4e494ecf7243eaa115f2f711bd8bbeeec0c642891a8c6367f8a4316d849c4074"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel.sha256sum] = "a4c197481296aac1e46ae2fd7625c1fd8949439b4b6a8711c8d50f7ba4ff9dc8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+rustls-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+rustls-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+rustls-devel.sha256sum] = "e7b4a430adbade1f1f81f5095381e49b6bc7d5a9edcc856f533f994f2fbf8b47"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+tokio-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+tokio-devel.sha256sum] = "19c66e036e6238b2df1ec6e475a611528d87136e2dd834c98ea88f2b589ea84a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+tracing-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+tracing-devel.sha256sum] = "ea17bd3ff6dc6796c6670661335900a7101a0be57f3b8b805806cd892b20712f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus+uds-listener-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus+uds-listener-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus+uds-listener-devel.sha256sum] = "edfbf4af9ab3dcf8618c863f66a74b6121a70ced1b6f374f8d0d84e6f9d81afa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-metrics-exporter-prometheus-devel-0.18.3-1.el10_3.noarch.rpm;name=aarch64_rust-metrics-exporter-prometheus-devel;unpack=0"
SRC_URI[aarch64_rust-metrics-exporter-prometheus-devel.sha256sum] = "dae1251b52f06de5333671726a45714f0fb60db37b28f6f325a08203ebbb2624"

RDEPENDS:rust-metrics-exporter-prometheus+_hyper-client-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-metrics-exporter-prometheus+http-body-util-devel \
 rust-metrics-exporter-prometheus+hyper-rustls-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+_hyper-server-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+server-auto-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-metrics-exporter-prometheus+http-body-util-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+_push-gateway-common-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+_hyper-client-devel \
 rust-metrics-exporter-prometheus+async-runtime-devel \
 rust-metrics-exporter-prometheus+rustls-devel \
 rust-metrics-exporter-prometheus+tracing-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+async-runtime-devel = " \
 cargo \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-metrics-exporter-prometheus+tokio-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+default-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+http-listener-devel \
 rust-metrics-exporter-prometheus+push-gateway-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+http-body-util-devel = " \
 cargo \
 rust-http-body-util-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+http-listener-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+_hyper-server-devel \
 rust-metrics-exporter-prometheus+async-runtime-devel \
 rust-metrics-exporter-prometheus+ipnet-devel \
 rust-metrics-exporter-prometheus+tracing-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+hyper-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+hyper-rustls-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+hyper-util-devel = " \
 cargo \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+service-devel \
 rust-hyper-util+tokio-devel \
 rust-hyper-util-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+ipnet-devel = " \
 cargo \
 rust-ipnet+std-devel \
 rust-ipnet-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+mime-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-mime+default-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+prost-build-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-prost-build-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+prost-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-prost+derive-devel \
 rust-prost-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+prost-types-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-prost-types-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+push-gateway-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+rustls-native-certs-devel \
 rust-hyper-rustls-devel \
 rust-metrics-exporter-prometheus+_push-gateway-common-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+push-gateway-no-tls-provider-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+_push-gateway-common-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+rustls-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-rustls-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+tokio-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+tracing-devel = " \
 cargo \
 rust-metrics-exporter-prometheus-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus+uds-listener-devel = " \
 cargo \
 rust-metrics-exporter-prometheus+http-listener-devel \
 rust-metrics-exporter-prometheus-devel \
 "
RDEPENDS:rust-metrics-exporter-prometheus-devel = " \
 cargo \
 rust \
 rust-base64_0.22+std-devel \
 rust-base64_0.22-devel \
 rust-evmap+default-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-metrics+default-devel \
 rust-metrics-util+recency-devel \
 rust-metrics-util+registry-devel \
 rust-metrics-util+storage-devel \
 rust-metrics-util-devel \
 rust-quanta-devel \
 rust-thiserror-devel \
 "
