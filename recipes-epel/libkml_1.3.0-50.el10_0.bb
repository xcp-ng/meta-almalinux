# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkml"
PV = "1.3.0"
PR = "50.el10_0"
PACKAGES = " \
 libkml \
 libkml-devel \
 python3-libkml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkml-1.3.0-50.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aff72dbba9db03b9816728158dcfbe92eb0400b17f4989a21696c67a67a309e1"

URI_x86_64_v2_libkml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkml-1.3.0-50.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkml}"
SRC_URI[x86_64_v2_libkml.sha256sum] = "a7416e0d881bd6b3ccd9ba4231c7c61ab587be51f04a9eb8ef20174c1c722abd"

URI_x86_64_v2_libkml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkml-devel-1.3.0-50.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkml-devel}"
SRC_URI[x86_64_v2_libkml-devel.sha256sum] = "09c0f23d17967c061ecc0e340d814bb08a93339eb1728d3731b37bfe3c4c7244"

URI_x86_64_v2_python3-libkml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-libkml-1.3.0-50.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-libkml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libkml}"
SRC_URI[x86_64_v2_python3-libkml.sha256sum] = "0fe62091dc67b69b18a0f0f376da39971d10af8d35bf445f523c65cbfea956d6"

URI_aarch64_libkml = "${EPEL_MIRROR}/aarch64/Packages/l/libkml-1.3.0-50.el10_0.aarch64.rpm;name=aarch64_libkml;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkml}"
SRC_URI[aarch64_libkml.sha256sum] = "f0a46df836ca5041ede417626897c635398edabee16122d9c3bba01f3cb6b009"

URI_aarch64_libkml-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkml-devel-1.3.0-50.el10_0.aarch64.rpm;name=aarch64_libkml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkml-devel}"
SRC_URI[aarch64_libkml-devel.sha256sum] = "e96a9cc23963d2a736a2c3d9a8bf87025b0175e87d19e721ff1c5334ba81e63d"

URI_aarch64_python3-libkml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-libkml-1.3.0-50.el10_0.aarch64.rpm;name=aarch64_python3-libkml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libkml}"
SRC_URI[aarch64_python3-libkml.sha256sum] = "b49e5b291cae3eb2cc474c4a0aa7d0e800cb6826c28843922ed28738e8732f6d"

RDEPENDS:libkml = " \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 uriparser \
 zlib-ng-compat \
 "
RDEPENDS:libkml-devel = " \
 boost-devel \
 cmake-filesystem \
 expat-devel \
 libkml \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libkml = " \
 glibc \
 libgcc \
 libkml \
 libstdc++ \
 python3 \
 python3-libs \
 "
