# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-polling"
PV = "3.11.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-polling+default-devel \
 rust-polling+tracing-devel \
 rust-polling-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-polling-3.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91a3824f3bfa326662cc49b27cd493e2728af03cb2850c55f2e4b86ebd311903"

URI_x86_64_v2_rust-polling+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polling+default-devel-3.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polling+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polling+default-devel}"
SRC_URI[x86_64_v2_rust-polling+default-devel.sha256sum] = "fc2ac35721b62e06bb33a6fc365bc48a0306894ec0430a343c7cf488d404c040"

URI_x86_64_v2_rust-polling+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polling+tracing-devel-3.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polling+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polling+tracing-devel}"
SRC_URI[x86_64_v2_rust-polling+tracing-devel.sha256sum] = "770b9a3c6d253b0c732e2fe5e21cf8f2520fc15f9dca9f8d92ee1f4b5c2e539d"

URI_x86_64_v2_rust-polling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-polling-devel-3.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-polling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-polling-devel}"
SRC_URI[x86_64_v2_rust-polling-devel.sha256sum] = "abc8fec13266ae259d039614feb55825c1437506fdbc077dffab8d68a8813676"

URI_aarch64_rust-polling+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polling+default-devel-3.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-polling+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polling+default-devel}"
SRC_URI[aarch64_rust-polling+default-devel.sha256sum] = "277c2eaa3bdf77526cc9bdef0a5905d0e1e3db3588fafdbbccd80d7cadee5d6e"

URI_aarch64_rust-polling+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polling+tracing-devel-3.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-polling+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polling+tracing-devel}"
SRC_URI[aarch64_rust-polling+tracing-devel.sha256sum] = "616563ed563522bf44d1f4e73e41b14d42cb20e45bee69eece721a8ceb34aa4f"

URI_aarch64_rust-polling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-polling-devel-3.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-polling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-polling-devel}"
SRC_URI[aarch64_rust-polling-devel.sha256sum] = "15711f04f07a8d0b98eb9a2e3c3cd9c7fa6fc1f0aedbf7b3c744c4ce38f0056a"

RDEPENDS:rust-polling+default-devel = " \
 cargo \
 rust-polling-devel \
 "
RDEPENDS:rust-polling+tracing-devel = " \
 cargo \
 rust-polling-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-polling-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+pipe-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix+time-devel \
 rust-rustix-devel \
 "
