# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ffmpeg"
PV = "7.1.2"
PR = "1.el10_2"
PACKAGES = " \
 ffmpeg-free \
 ffmpeg-free-devel \
 libavcodec-free \
 libavcodec-free-devel \
 libavdevice-free \
 libavdevice-free-devel \
 libavfilter-free \
 libavfilter-free-devel \
 libavformat-free \
 libavformat-free-devel \
 libavutil-free \
 libavutil-free-devel \
 libpostproc-free \
 libpostproc-free-devel \
 libswresample-free \
 libswresample-free-devel \
 libswscale-free \
 libswscale-free-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/ffmpeg-7.1.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cd0cfd9bc79d1c13fe7300825f27330cf946c088487fe6983a8910df00804b7"

URI_x86_64_v2_ffmpeg-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpeg-free-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpeg-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpeg-free}"
SRC_URI[x86_64_v2_ffmpeg-free.sha256sum] = "e87810985edf68235d62a16d8fc839292ac4ab60ff9d6cb193cfa611b98bf61b"

URI_x86_64_v2_ffmpeg-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ffmpeg-free-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ffmpeg-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ffmpeg-free-devel}"
SRC_URI[x86_64_v2_ffmpeg-free-devel.sha256sum] = "ac2de953a0c84ae7f51f4dbedae4b3f2a87ebf7421894ad07c6714ac1e33d19e"

URI_x86_64_v2_libavcodec-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavcodec-free-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavcodec-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavcodec-free}"
SRC_URI[x86_64_v2_libavcodec-free.sha256sum] = "617c0e7d2062d868b35d5c8b781170d2224db4b93f1d3633ca48238c816e9da2"

URI_x86_64_v2_libavcodec-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavcodec-free-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavcodec-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavcodec-free-devel}"
SRC_URI[x86_64_v2_libavcodec-free-devel.sha256sum] = "eb54249eda41aa554f8645e578a888a1881c42ff585e58f65f5150bf10d45d4a"

URI_x86_64_v2_libavdevice-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavdevice-free-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavdevice-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavdevice-free}"
SRC_URI[x86_64_v2_libavdevice-free.sha256sum] = "1551e252d6dfd23e33603d39f570e5bb6c1cc4c0187c90e3d9e428eadb3136d4"

URI_x86_64_v2_libavdevice-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavdevice-free-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavdevice-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavdevice-free-devel}"
SRC_URI[x86_64_v2_libavdevice-free-devel.sha256sum] = "ad09afb95ffdae12bb98d7e309a90dc4e5a5484b5a03bb3e61a50778e4ffd309"

URI_x86_64_v2_libavfilter-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavfilter-free-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavfilter-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavfilter-free}"
SRC_URI[x86_64_v2_libavfilter-free.sha256sum] = "3ae10b49051f7929dca379d27ac46f05b54839b723f0fbd15f600ae000d0df94"

URI_x86_64_v2_libavfilter-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavfilter-free-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavfilter-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavfilter-free-devel}"
SRC_URI[x86_64_v2_libavfilter-free-devel.sha256sum] = "341999e439917b9e4ae4b8beff5e08988c6e3f2011cde26305fec3f318725bc4"

URI_x86_64_v2_libavformat-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavformat-free-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavformat-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavformat-free}"
SRC_URI[x86_64_v2_libavformat-free.sha256sum] = "b98b6ad5ba792d9a9e772893ec6e9272e4f2b78c46cc6847bea65b8e804265ac"

URI_x86_64_v2_libavformat-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavformat-free-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavformat-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavformat-free-devel}"
SRC_URI[x86_64_v2_libavformat-free-devel.sha256sum] = "c95704a47bfad17f79d40f89f4d9b74bea246df5a65b4c781965c0f352fbcb99"

URI_x86_64_v2_libavutil-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavutil-free-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavutil-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavutil-free}"
SRC_URI[x86_64_v2_libavutil-free.sha256sum] = "228dcea918967df1e9bf99b4862fe8ba38cbbed3b1e4331905b59b41ca8725ab"

URI_x86_64_v2_libavutil-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libavutil-free-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libavutil-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libavutil-free-devel}"
SRC_URI[x86_64_v2_libavutil-free-devel.sha256sum] = "f7f30be45a11293f5f8dbca487e4bb222d9adda634c967b4360004df9289deec"

URI_x86_64_v2_libpostproc-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpostproc-free-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpostproc-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpostproc-free}"
SRC_URI[x86_64_v2_libpostproc-free.sha256sum] = "6ca30f224ab0d324ee49c82b4d5e56e0f354c012dbb33c1f0ef848bc41fee132"

URI_x86_64_v2_libpostproc-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libpostproc-free-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libpostproc-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpostproc-free-devel}"
SRC_URI[x86_64_v2_libpostproc-free-devel.sha256sum] = "e4d11f708e248c0774cfd66ea9cd6f22d1ed3c062e3db4a5eb4b537391f14331"

URI_x86_64_v2_libswresample-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libswresample-free-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libswresample-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libswresample-free}"
SRC_URI[x86_64_v2_libswresample-free.sha256sum] = "78a08ca56cccce6f658082f118a7f3a6ab58601cc65b3767280c23890f6bc040"

URI_x86_64_v2_libswresample-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libswresample-free-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libswresample-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libswresample-free-devel}"
SRC_URI[x86_64_v2_libswresample-free-devel.sha256sum] = "e3c9a8ce0a9a118e10af72415b29fdf671bc5a43c795fe5d0ae8c9d91df025a8"

URI_x86_64_v2_libswscale-free = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libswscale-free-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libswscale-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libswscale-free}"
SRC_URI[x86_64_v2_libswscale-free.sha256sum] = "8f8a131451d184a681c73aacec60c22bf7099618ac5272e919002635bacd983e"

URI_x86_64_v2_libswscale-free-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libswscale-free-devel-7.1.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libswscale-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libswscale-free-devel}"
SRC_URI[x86_64_v2_libswscale-free-devel.sha256sum] = "ec4023645e98aa6c06cfb7e93a76ec07ad475c8fcbe58efcd9f2173a91ac6b67"

URI_aarch64_ffmpeg-free = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpeg-free-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_ffmpeg-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpeg-free}"
SRC_URI[aarch64_ffmpeg-free.sha256sum] = "e77f6be804d39d38639dfbfee00608d29dc86952e494be3340db0627d8d80ea7"

URI_aarch64_ffmpeg-free-devel = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpeg-free-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_ffmpeg-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpeg-free-devel}"
SRC_URI[aarch64_ffmpeg-free-devel.sha256sum] = "242229a705ecc6a0556ef5c465f7afc3d0f3068e99549d23065a135559a100ec"

URI_aarch64_libavcodec-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavcodec-free-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavcodec-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavcodec-free}"
SRC_URI[aarch64_libavcodec-free.sha256sum] = "43706174332b3e70a1feaeb51a7729c95565c7dbd1aac232586c82f79f89c4d6"

URI_aarch64_libavcodec-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavcodec-free-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavcodec-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavcodec-free-devel}"
SRC_URI[aarch64_libavcodec-free-devel.sha256sum] = "3d6198b67f373dbcad476670f4a028dc2cb145a270c58d63df792b724c846467"

URI_aarch64_libavdevice-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavdevice-free-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavdevice-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavdevice-free}"
SRC_URI[aarch64_libavdevice-free.sha256sum] = "3c84433cfeb440cf73199287e6cce7491ab991e75771da7c006b15df600f895e"

URI_aarch64_libavdevice-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavdevice-free-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavdevice-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavdevice-free-devel}"
SRC_URI[aarch64_libavdevice-free-devel.sha256sum] = "c564247dac3de5f4134c2dbb5844416ea9e9fbc85e54241c1f24a8c2bbed6319"

URI_aarch64_libavfilter-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavfilter-free-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavfilter-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavfilter-free}"
SRC_URI[aarch64_libavfilter-free.sha256sum] = "80d9854a7a9b877765fc010c1ef4b027ba049dc210c6e92f60c959b037d56813"

URI_aarch64_libavfilter-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavfilter-free-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavfilter-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavfilter-free-devel}"
SRC_URI[aarch64_libavfilter-free-devel.sha256sum] = "7fc22e745522823c040c1ae437ecb92b94a5f56f5dbf50cbd92ecb4097301b8f"

URI_aarch64_libavformat-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavformat-free-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavformat-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavformat-free}"
SRC_URI[aarch64_libavformat-free.sha256sum] = "bde92b0db53cb0d6aa93bb82e556aaee64b0afb3ac9070dcefb481b93eab059c"

URI_aarch64_libavformat-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavformat-free-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavformat-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavformat-free-devel}"
SRC_URI[aarch64_libavformat-free-devel.sha256sum] = "9da7721ea611c9eb00b7764df5bb57c700f2896cec245ef271d57cee226261b5"

URI_aarch64_libavutil-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavutil-free-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavutil-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavutil-free}"
SRC_URI[aarch64_libavutil-free.sha256sum] = "7a4e6044d6ba47cc3333d9cb23307a990ea8ff2b32a8d3d1e23abb54ae934985"

URI_aarch64_libavutil-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavutil-free-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libavutil-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavutil-free-devel}"
SRC_URI[aarch64_libavutil-free-devel.sha256sum] = "0445ddf0ac51663c9d988f6e7fd3375917991d490f22e0bcf995020c37e757f1"

URI_aarch64_libpostproc-free = "${EPEL_MIRROR}/aarch64/Packages/l/libpostproc-free-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libpostproc-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpostproc-free}"
SRC_URI[aarch64_libpostproc-free.sha256sum] = "b9c91b3568277460f1126b6226fa6553a7f859a117dfe7f05bccf78fe37be3aa"

URI_aarch64_libpostproc-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libpostproc-free-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libpostproc-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpostproc-free-devel}"
SRC_URI[aarch64_libpostproc-free-devel.sha256sum] = "acbc893a9b6386e81fc02a5f701e9c82faa070d1275193531ed3a3a534782fcd"

URI_aarch64_libswresample-free = "${EPEL_MIRROR}/aarch64/Packages/l/libswresample-free-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libswresample-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libswresample-free}"
SRC_URI[aarch64_libswresample-free.sha256sum] = "f5ff15960ddbd4619e89e798c5f28ac49ef362792fff0e1a5287e8337db567b8"

URI_aarch64_libswresample-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libswresample-free-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libswresample-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libswresample-free-devel}"
SRC_URI[aarch64_libswresample-free-devel.sha256sum] = "573533b54f4f15112f98db8db2d61483073de3ae5c6f7b407b32b10001b8526f"

URI_aarch64_libswscale-free = "${EPEL_MIRROR}/aarch64/Packages/l/libswscale-free-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libswscale-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libswscale-free}"
SRC_URI[aarch64_libswscale-free.sha256sum] = "c6fb95574c19eb1f3cf71eefd1702da2302e0bd7dc452d3c7122dd77eac96a2b"

URI_aarch64_libswscale-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libswscale-free-devel-7.1.2-1.el10_2.aarch64.rpm;name=aarch64_libswscale-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libswscale-free-devel}"
SRC_URI[aarch64_libswscale-free-devel.sha256sum] = "c1d30e94a54a898953d892c76141f06c6488090c4b6a209570ac809b7161642d"

RDEPENDS:ffmpeg-free = " \
 glibc \
 libavcodec-free \
 libavdevice-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libplacebo \
 libpostproc-free \
 libswresample-free \
 libswscale-free \
 sdl2-compat \
 "
RDEPENDS:ffmpeg-free-devel = " \
 libavcodec-free-devel \
 libavdevice-free-devel \
 libavfilter-free-devel \
 libavformat-free-devel \
 libavutil-free-devel \
 libpostproc-free-devel \
 libswresample-free-devel \
 libswscale-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavcodec-free:x86_64_v2 = " \
 aribb24 \
 cairo \
 codec2 \
 fdk-aac-free \
 glib2 \
 glibc \
 gsm \
 ilbc \
 lame-libs \
 lcms2 \
 libaom \
 libaribcaption \
 libavutil-free \
 libdav1d \
 libjxl \
 librsvg2 \
 libswresample-free \
 libtheora \
 libva \
 libvorbis \
 libvpl \
 libvpx \
 libwebp \
 noopenh264 \
 opencore-amr \
 openjpeg2 \
 opus \
 rav1e-libs \
 snappy \
 speex \
 svt-av1-libs \
 twolame-libs \
 vo-amrwbenc \
 xvidcore \
 xz-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:libavcodec-free:aarch64 = " \
 aribb24 \
 cairo \
 codec2 \
 fdk-aac-free \
 glib2 \
 glibc \
 gsm \
 ilbc \
 lame-libs \
 lcms2 \
 libaom \
 libaribcaption \
 libavutil-free \
 libdav1d \
 libjxl \
 librsvg2 \
 libswresample-free \
 libtheora \
 libva \
 libvorbis \
 libvpx \
 libwebp \
 noopenh264 \
 opencore-amr \
 openjpeg2 \
 opus \
 rav1e-libs \
 snappy \
 speex \
 svt-av1-libs \
 twolame-libs \
 vo-amrwbenc \
 xvidcore \
 xz-libs \
 zlib-ng-compat \
 zvbi \
"
RDEPENDS:libavcodec-free-devel = " \
 libavcodec-free \
 libavutil-free-devel \
 libswresample-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavdevice-free = " \
 alsa-lib \
 glibc \
 libX11 \
 libXext \
 libXv \
 libavc1394 \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libcaca \
 libcdio-paranoia \
 libdc1394 \
 libdrm \
 libglvnd-glx \
 libiec61883 \
 libraw1394 \
 libv4l \
 libxcb \
 openal-soft \
 pipewire-jack-audio-connection-kit-libs \
 pulseaudio-libs \
 sdl2-compat \
 "
RDEPENDS:libavdevice-free-devel = " \
 libavcodec-free-devel \
 libavdevice-free \
 libavfilter-free-devel \
 libavformat-free-devel \
 libavutil-free-devel \
 libpostproc-free-devel \
 libswresample-free-devel \
 libswscale-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavfilter-free:x86_64_v2 = " \
 fontconfig \
 freetype \
 fribidi \
 glibc \
 harfbuzz \
 lcms2 \
 libass \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbs2b \
 libmysofa \
 libplacebo \
 libpostproc-free \
 libshaderc \
 libswresample-free \
 libswscale-free \
 libva \
 libvmaf \
 libvpl \
 lilv-libs \
 ocl-icd \
 qrencode-libs \
 rubberband \
 tesseract \
 vid.stab \
 zeromq \
 zimg \
"
RDEPENDS:libavfilter-free:aarch64 = " \
 fontconfig \
 freetype \
 fribidi \
 glibc \
 harfbuzz \
 lcms2 \
 libass \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbs2b \
 libmysofa \
 libplacebo \
 libpostproc-free \
 libshaderc \
 libswresample-free \
 libswscale-free \
 libva \
 lilv-libs \
 ocl-icd \
 qrencode-libs \
 rubberband \
 tesseract \
 vid.stab \
 zeromq \
 zimg \
"
RDEPENDS:libavfilter-free-devel = " \
 libavcodec-free-devel \
 libavfilter-free \
 libavformat-free-devel \
 libavutil-free-devel \
 libpostproc-free-devel \
 libswresample-free-devel \
 libswscale-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavformat-free = " \
 bzip2-libs \
 game-music-emu \
 glibc \
 gmp \
 gnutls \
 libavcodec-free \
 libavutil-free \
 libbluray \
 libdvdnav \
 libdvdread \
 libmodplug \
 libopenmpt \
 librabbitmq \
 librist \
 libsmbclient \
 libssh \
 libxml2 \
 srt-libs \
 zeromq \
 zlib-ng-compat \
 "
RDEPENDS:libavformat-free-devel = " \
 libavcodec-free-devel \
 libavformat-free \
 libavutil-free-devel \
 libswresample-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavutil-free:x86_64_v2 = " \
 glibc \
 libX11 \
 libdrm \
 libgcrypt \
 libva \
 libvdpau \
 libvpl \
 ocl-icd \
"
RDEPENDS:libavutil-free:aarch64 = " \
 glibc \
 libX11 \
 libdrm \
 libgcrypt \
 libva \
 libvdpau \
 ocl-icd \
"
RDEPENDS:libavutil-free-devel = " \
 libavutil-free \
 pkgconf-pkg-config \
 "
RDEPENDS:libpostproc-free = " \
 glibc \
 libavutil-free \
 "
RDEPENDS:libpostproc-free-devel = " \
 libavutil-free-devel \
 libpostproc-free \
 pkgconf-pkg-config \
 "
RDEPENDS:libswresample-free = " \
 glibc \
 libavutil-free \
 soxr \
 "
RDEPENDS:libswresample-free-devel = " \
 libavutil-free-devel \
 libswresample-free \
 pkgconf-pkg-config \
 "
RDEPENDS:libswscale-free = " \
 glibc \
 libavutil-free \
 "
RDEPENDS:libswscale-free-devel = " \
 libavutil-free-devel \
 libswscale-free \
 pkgconf-pkg-config \
 "
