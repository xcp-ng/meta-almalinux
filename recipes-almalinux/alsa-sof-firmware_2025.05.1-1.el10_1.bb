# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alsa-sof-firmware"
PV = "2025.05.1"
PR = "1.el10_1"
PACKAGES = " \
 alsa-sof-firmware \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/alsa-sof-firmware-2025.05.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9b6f96a60ef304df275517348315280d7922cadc423e714e4d6d775a5bd30e34"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/alsa-sof-firmware-2025.05.1-1.el10_1.noarch.rpm;name=x86_64_v2_alsa-sof-firmware;unpack=0"
SRC_URI[x86_64_v2_alsa-sof-firmware.sha256sum] = "34c69e7d95b5e0a8780b98f025e36b522a90dc1113f24e3a1cd03a9a4ff89c3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/alsa-sof-firmware-2025.05.1-1.el10_1.noarch.rpm;name=aarch64_alsa-sof-firmware;unpack=0"
SRC_URI[aarch64_alsa-sof-firmware.sha256sum] = "34c69e7d95b5e0a8780b98f025e36b522a90dc1113f24e3a1cd03a9a4ff89c3c"

RDEPENDS:alsa-sof-firmware = " \
 "
