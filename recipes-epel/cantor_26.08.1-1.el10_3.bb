# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cantor"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 cantor \
 cantor-devel \
 cantor-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/cantor-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "32ebb79091a3071c1c9376632ba5a87940b79f0ba635c02689dc15d5c4c14009"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cantor-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cantor;unpack=0"
SRC_URI[x86_64_v2_cantor.sha256sum] = "8db572bd60e30a13924283d239737ded0c3dc4e39cd9c218e98632a911aa5e1b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cantor-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cantor-devel;unpack=0"
SRC_URI[x86_64_v2_cantor-devel.sha256sum] = "1447dc62d865c22c3c6a9cf748aa7f3cc84533b2f3966d656ddb5721c7f7ccf4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cantor-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cantor-libs;unpack=0"
SRC_URI[x86_64_v2_cantor-libs.sha256sum] = "e65f5f71cc3274ada44743c608176c12f963c49cda037ce04967dfba4d140297"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cantor-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_cantor;unpack=0"
SRC_URI[aarch64_cantor.sha256sum] = "30634d8b2e435015f643e50aecf4bc7de29b1526417c44350aa7c874586528cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cantor-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_cantor-devel;unpack=0"
SRC_URI[aarch64_cantor-devel.sha256sum] = "008e56a98b3d1f29d1017a4b3173f27f013f613f7345dbb182ec347f8fc15030"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/cantor-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_cantor-libs;unpack=0"
SRC_URI[aarch64_cantor-libs.sha256sum] = "c646a356f84682c88a9393a4c36e86f80a6d06b00dcdf95190ff73a898c8fa10"

RDEPENDS:cantor = " \
 cantor-libs \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libgcc \
 libstdc++ \
 python3-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:cantor-devel = " \
 cantor-libs \
 cmake-filesystem \
 "
RDEPENDS:cantor-libs = " \
 analitza \
 cantor \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libgcc \
 libqalculate \
 libstdc++ \
 libxml2 \
 libxslt \
 luajit \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 "
