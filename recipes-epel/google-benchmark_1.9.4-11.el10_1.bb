# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-benchmark"
PV = "1.9.4"
PR = "11.el10_1"
PACKAGES = " \
 google-benchmark \
 google-benchmark-devel \
 google-benchmark-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/google-benchmark-1.9.4-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3aef30814b917edbde31af7e4bff421568ba3cdd1fbb77cf85252029b612ddd5"

URI_x86_64_v2_google-benchmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-benchmark-1.9.4-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-benchmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-benchmark}"
SRC_URI[x86_64_v2_google-benchmark.sha256sum] = "60f33624e0c259949b645615eeb193097a093fd6b59ef0ef7f455b0b7d03b35e"

URI_x86_64_v2_google-benchmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-benchmark-devel-1.9.4-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_google-benchmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-benchmark-devel}"
SRC_URI[x86_64_v2_google-benchmark-devel.sha256sum] = "12aaebf092d00e132b2396b8e700bf0e1e8cad8db3bf24669cd2eb6f2654b645"

URI_x86_64_v2_google-benchmark-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/google-benchmark-doc-1.9.4-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_google-benchmark-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-benchmark-doc}"
SRC_URI[x86_64_v2_google-benchmark-doc.sha256sum] = "5440bcd39916a7f625113dcf24b34b67ed4d72613ab6db4d44ccdd2f868eef70"

URI_aarch64_google-benchmark = "${EPEL_MIRROR}/aarch64/Packages/g/google-benchmark-1.9.4-11.el10_1.aarch64.rpm;name=aarch64_google-benchmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-benchmark}"
SRC_URI[aarch64_google-benchmark.sha256sum] = "58ffe2247c58569c3a80578d3023cca06eee4741f1f082fca4b93b446a7c375e"

URI_aarch64_google-benchmark-devel = "${EPEL_MIRROR}/aarch64/Packages/g/google-benchmark-devel-1.9.4-11.el10_1.aarch64.rpm;name=aarch64_google-benchmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-benchmark-devel}"
SRC_URI[aarch64_google-benchmark-devel.sha256sum] = "b2ce97ed543f50a34197ac3054dd84234767e112beb5279cf218252472728fb1"

URI_aarch64_google-benchmark-doc = "${EPEL_MIRROR}/aarch64/Packages/g/google-benchmark-doc-1.9.4-11.el10_1.noarch.rpm;name=aarch64_google-benchmark-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-benchmark-doc}"
SRC_URI[aarch64_google-benchmark-doc.sha256sum] = "870049613683548b5873b4694db29d52dd39c4409a462c03d158558330fbe5c6"

RDEPENDS:google-benchmark = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:google-benchmark-devel = " \
 cmake-filesystem \
 google-benchmark \
 google-benchmark-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:google-benchmark-doc = " \
 google-benchmark \
 "
