# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-nikic-php-parser5"
PV = "5.8.0"
PR = "1.el10_3"
PACKAGES = " \
 php-nikic-php-parser5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-nikic-php-parser5-5.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4b78f9263fbc2801eb5c9fdf46993b1e027bebbafe58de8c3808831216f76ce"

URI_x86_64_v2_php-nikic-php-parser5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-nikic-php-parser5-5.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_php-nikic-php-parser5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-nikic-php-parser5}"
SRC_URI[x86_64_v2_php-nikic-php-parser5.sha256sum] = "1e77a37264761f9669d3c17a56321a5e37bf449833729a971ad974076e90dae2"

URI_aarch64_php-nikic-php-parser5 = "${EPEL_MIRROR}/aarch64/Packages/p/php-nikic-php-parser5-5.8.0-1.el10_3.noarch.rpm;name=aarch64_php-nikic-php-parser5;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-nikic-php-parser5}"
SRC_URI[aarch64_php-nikic-php-parser5.sha256sum] = "255e21f45a8e1098e41f5ebb3d5c62872c2159c00e1acf477f653c7620fa613e"

RDEPENDS:php-nikic-php-parser5 = " \
 php-fedora-autoloader \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-json \
 virtual/php-tokenizer \
 virtual/php_language__ge_7.4 \
 "
