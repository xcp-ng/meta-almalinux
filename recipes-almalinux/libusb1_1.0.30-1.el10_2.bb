# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libusb1"
PV = "1.0.30"
PR = "1.el10_2"
PACKAGES = " \
 libusb1 \
 libusb1-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libusb1-1.0.30-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd6ebded61ecf30ee3c1d71f1369c642877c302acf6f722715e3574d3c537ec3"

URI_x86_64_v2_libusb1 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libusb1-1.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libusb1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb1}"
SRC_URI[x86_64_v2_libusb1.sha256sum] = "39a85df46ac7bacce066d1e357854e38146ba59a363ffe5cab16ef201da0ec17"

URI_x86_64_v2_libusb1-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libusb1-devel-1.0.30-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_libusb1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb1-devel}"
SRC_URI[x86_64_v2_libusb1-devel.sha256sum] = "cfada5f3515925da241bd8c48cd6b1dbad6641f5449ab0483e3493730cdc9ecc"

URI_aarch64_libusb1 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libusb1-1.0.30-1.el10_2.aarch64.rpm;name=aarch64_libusb1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb1}"
SRC_URI[aarch64_libusb1.sha256sum] = "af444342b798030c4f15d2f1d2f987dba39e1475ba8ebef52fb986682f7a5e19"

URI_aarch64_libusb1-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libusb1-devel-1.0.30-1.el10_2.aarch64.rpm;name=aarch64_libusb1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb1-devel}"
SRC_URI[aarch64_libusb1-devel.sha256sum] = "73577443a728ce2030ba66fc000d38f46162ed27f8cbd01d62c901709aee3983"

RDEPENDS:libusb1 = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:libusb1-devel = " \
 libusb1 \
 pkgconf-pkg-config \
 "
