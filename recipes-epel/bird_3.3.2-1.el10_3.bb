# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bird"
PV = "3.3.2"
PR = "1.el10_3"
PACKAGES = " \
 bird \
 bird-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bird-3.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5252b92872217b049874608c59bc8dbb76367fa046acb888f11a1bf68a63d785"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bird-3.3.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bird;unpack=0"
SRC_URI[x86_64_v2_bird.sha256sum] = "5753887549550311d2d1872abe78828d85d459195d247c9ef4e10a2eff779880"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bird-doc-3.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_bird-doc;unpack=0"
SRC_URI[x86_64_v2_bird-doc.sha256sum] = "64059f9cc0bcffde85573a5b78ac0f91859715892f67b1f9a570ce909163533a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bird-3.3.2-1.el10_3.aarch64.rpm;name=aarch64_bird;unpack=0"
SRC_URI[aarch64_bird.sha256sum] = "3056ef94c4eaea402fc58488d70ae624951f02249b249fcd308004cacb8d6c63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bird-doc-3.3.2-1.el10_3.noarch.rpm;name=aarch64_bird-doc;unpack=0"
SRC_URI[aarch64_bird-doc.sha256sum] = "11086b921b3159e0c93a011d693b934a3d938c7f14cdeecc992dd178dfa37cc4"

RDEPENDS:bird = " \
 bash \
 glibc \
 libgcc \
 libssh \
 ncurses-libs \
 readline \
 shadow-utils \
 systemd \
 "
RDEPENDS:bird-doc = " \
 "
