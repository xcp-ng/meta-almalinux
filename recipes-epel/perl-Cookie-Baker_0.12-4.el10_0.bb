# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Cookie-Baker"
PV = "0.12"
PR = "4.el10_0"
PACKAGES = " \
 perl-Cookie-Baker \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Cookie-Baker-0.12-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e3bfe6af0894fbeb35b18bbc3761adda79d4da0d385867736ada5feea4f1b9b"

URI_x86_64_v2_perl-Cookie-Baker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Cookie-Baker-0.12-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Cookie-Baker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Cookie-Baker}"
SRC_URI[x86_64_v2_perl-Cookie-Baker.sha256sum] = "5a1615383593fb0c7fa7d52884b6db6d8b007ff8ff0201c60a202de790b0ac47"

URI_aarch64_perl-Cookie-Baker = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Cookie-Baker-0.12-4.el10_0.noarch.rpm;name=aarch64_perl-Cookie-Baker;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Cookie-Baker}"
SRC_URI[aarch64_perl-Cookie-Baker.sha256sum] = "9c46183d4eb31fa1337a663ce9fab89491922ce5d5b4dbe68f132c2a6fecaa79"

RDEPENDS:perl-Cookie-Baker = " \
 perl-Exporter \
 perl-URI \
 perl-base \
 perl-libs \
 "
