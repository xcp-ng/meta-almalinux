# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cython-cmake"
PV = "0.2.2"
PR = "1.el10_3"
PACKAGES = " \
 cython-cmake \
 python3-cython-cmake \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cython-cmake-0.2.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9e5886da18d5e69e9b6cf10fee2d6b39155b748cd73c1d4429123966d06feb6"

URI_x86_64_v2_cython-cmake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cython-cmake-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_cython-cmake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cython-cmake}"
SRC_URI[x86_64_v2_cython-cmake.sha256sum] = "b04dd83de4c704aff36597a3531a6ecd7ee733f0fbb8517c5628a3b4acdc022d"

URI_x86_64_v2_python3-cython-cmake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cython-cmake-0.2.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cython-cmake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cython-cmake}"
SRC_URI[x86_64_v2_python3-cython-cmake.sha256sum] = "8780cceb6498de840f25f93af41afcec212ccd61466921f38054cf47293f7996"

URI_aarch64_cython-cmake = "${EPEL_MIRROR}/aarch64/Packages/c/cython-cmake-0.2.2-1.el10_3.noarch.rpm;name=aarch64_cython-cmake;unpack=0"
SRC_URI:append = " ${URI_aarch64_cython-cmake}"
SRC_URI[aarch64_cython-cmake.sha256sum] = "dc10f58977b11659a61f1482f1039235a5e255ee49c18c8a36ead722346c56ec"

URI_aarch64_python3-cython-cmake = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cython-cmake-0.2.2-1.el10_3.noarch.rpm;name=aarch64_python3-cython-cmake;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cython-cmake}"
SRC_URI[aarch64_python3-cython-cmake.sha256sum] = "261737e37f7c5fecfdbe996617be6d9493953b99ef893139265f248e9c9058a9"

RDEPENDS:cython-cmake = " \
 cmake \
 python3-cython \
 python3-devel \
 "
RDEPENDS:python3-cython-cmake = " \
 cython-cmake \
 python3 \
 python3-cython \
 "
