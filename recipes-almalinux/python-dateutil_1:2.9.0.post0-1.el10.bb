# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dateutil"
PE = "1"
PV = "2.9.0.post0"
PR = "1.el10"
PACKAGES = " \
 python-dateutil-doc \
 python3-dateutil \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-dateutil-2.9.0.post0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ba1213a950c93b3dd9d42116980ff03d54ef733f44527a474b52f2678bf37b1"

URI_x86_64_v2_python-dateutil-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python-dateutil-doc-2.9.0.post0-1.el10.noarch.rpm;name=x86_64_v2_python-dateutil-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-dateutil-doc}"
SRC_URI[x86_64_v2_python-dateutil-doc.sha256sum] = "e6c8a88c4de130b024b76f4574ea75c6df616dbbf7a1bddb92b932e7d7c29e7e"

URI_x86_64_v2_python3-dateutil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-dateutil-2.9.0.post0-1.el10.noarch.rpm;name=x86_64_v2_python3-dateutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dateutil}"
SRC_URI[x86_64_v2_python3-dateutil.sha256sum] = "9a147b0ca3ff59b68596e328aeac702967e7a10ab54bd08fc421d392f6a73a3d"

URI_aarch64_python-dateutil-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python-dateutil-doc-2.9.0.post0-1.el10.noarch.rpm;name=aarch64_python-dateutil-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-dateutil-doc}"
SRC_URI[aarch64_python-dateutil-doc.sha256sum] = "e6c8a88c4de130b024b76f4574ea75c6df616dbbf7a1bddb92b932e7d7c29e7e"

URI_aarch64_python3-dateutil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-dateutil-2.9.0.post0-1.el10.noarch.rpm;name=aarch64_python3-dateutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dateutil}"
SRC_URI[aarch64_python3-dateutil.sha256sum] = "9a147b0ca3ff59b68596e328aeac702967e7a10ab54bd08fc421d392f6a73a3d"

RDEPENDS:python-dateutil-doc = " \
 "
RDEPENDS:python3-dateutil = " \
 python3 \
 python3-six \
 tzdata \
 "
