# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "monitorix"
PV = "3.16.0"
PR = "1.el10_0"
PACKAGES = " \
 monitorix \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/monitorix-3.16.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac24d2517c3d96db3a0c3379f66a48baa7f61907cb2a533c1f83f27044f6f445"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/monitorix-3.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_monitorix;unpack=0"
SRC_URI[x86_64_v2_monitorix.sha256sum] = "511a674df73c5b4717289460dcaca8483ba74549657115df7fa4079ed99ba04c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/monitorix-3.16.0-1.el10_0.noarch.rpm;name=aarch64_monitorix;unpack=0"
SRC_URI[aarch64_monitorix.sha256sum] = "62054d4d538d2380bd60495fbd629c2c15825922229a7a5bc948300c2ba30f71"

RDEPENDS:monitorix = " \
 bash \
 logrotate \
 perl-DBD-MySQL \
 perl-DBD-Pg \
 perl-IO-Socket-SSL \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 systemd \
 "
