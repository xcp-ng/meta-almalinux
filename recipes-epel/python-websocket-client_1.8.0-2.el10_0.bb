# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-websocket-client"
PV = "1.8.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-websocket-client \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-websocket-client-1.8.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f3941d8a1b3343dc63ce8b43c07d8ba4376989c629ceba954ee49a75db8810d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-websocket-client-1.8.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-websocket-client;unpack=0"
SRC_URI[x86_64_v2_python3-websocket-client.sha256sum] = "539d42281585888e784342bbbc93d7a73da6e4d130fe5d74d22cba7085a6b16b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-websocket-client-1.8.0-2.el10_0.noarch.rpm;name=aarch64_python3-websocket-client;unpack=0"
SRC_URI[aarch64_python3-websocket-client.sha256sum] = "54e9e5efe5bad1eccf3f0614a23002f0892dcdc78082447f417651724c0f74ea"

RDEPENDS:python3-websocket-client = " \
 python3 \
 "
