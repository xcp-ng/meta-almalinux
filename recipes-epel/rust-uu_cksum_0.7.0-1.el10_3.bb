# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_cksum"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_cksum+default-devel \
 rust-uu_cksum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_cksum-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4d867f017510300b5fbd58fa4e29b592de2acf9b5307b25d74f09f151f92794"

URI_x86_64_v2_rust-uu_cksum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cksum+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cksum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cksum+default-devel}"
SRC_URI[x86_64_v2_rust-uu_cksum+default-devel.sha256sum] = "a926233c9b09b8e74acbdf45deb1f84469836c3c32b17e2fcd10edb4b7f0eee3"

URI_x86_64_v2_rust-uu_cksum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_cksum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_cksum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_cksum-devel}"
SRC_URI[x86_64_v2_rust-uu_cksum-devel.sha256sum] = "6aa591a6ab51c98b8cac0a09e225b8b04b56e142b17eff8148471b613683a29c"

URI_aarch64_rust-uu_cksum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cksum+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_cksum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cksum+default-devel}"
SRC_URI[aarch64_rust-uu_cksum+default-devel.sha256sum] = "09de9e4a90427e501bd295a1a6071ca03200378c801a3a1a3cf01053ea8d78cd"

URI_aarch64_rust-uu_cksum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_cksum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_cksum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_cksum-devel}"
SRC_URI[aarch64_rust-uu_cksum-devel.sha256sum] = "1a0cee84bfe34f8e6bf8ee7af78f2b6ce728cf3834985916a31710ee8a80c499"

RDEPENDS:rust-uu_cksum+default-devel = " \
 cargo \
 rust-uu_cksum-devel \
 "
RDEPENDS:rust-uu_cksum-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uu_checksum_common+default-devel \
 rust-uucore+checksum-devel \
 rust-uucore+default-devel \
 rust-uucore+encoding-devel \
 rust-uucore+hardware-devel \
 rust-uucore+sum-devel \
 "
