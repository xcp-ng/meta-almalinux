# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-google-shlex"
PV = "0"
PR = "0.15.20200727gite7afc7f.el10_0"
PACKAGES = " \
 golang-github-google-shlex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-google-shlex-0-0.15.20200727gite7afc7f.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "610d025e9ca2222d3112ffd088083849e42a1c87bce461848b85f24fb9b1a69a"

URI_aarch64_golang-github-google-shlex-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-shlex-devel-0-0.15.20200727gite7afc7f.el10_0.noarch.rpm;name=aarch64_golang-github-google-shlex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-google-shlex-devel}"
SRC_URI[aarch64_golang-github-google-shlex-devel.sha256sum] = "fc0b70f46cd769cd98b497e1e1f82511723de7c69a827d0aac22bfb96885c004"

RDEPENDS:golang-github-google-shlex-devel = " \
 go-filesystem \
 "
