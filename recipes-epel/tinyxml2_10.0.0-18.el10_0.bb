# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinyxml2"
PV = "10.0.0"
PR = "18.el10_0"
PACKAGES = " \
 tinyxml2 \
 tinyxml2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinyxml2-10.0.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19589991273b57ac7f4d71cbc1844e7bf045b4d630688e1125d9a2192d0e8c1d"

URI_x86_64_v2_tinyxml2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyxml2-10.0.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyxml2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyxml2}"
SRC_URI[x86_64_v2_tinyxml2.sha256sum] = "d3e5b92898febcbebd5261b56f27cafecc39c88ec35b6f1d1b70a5b692d0c074"

URI_x86_64_v2_tinyxml2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyxml2-devel-10.0.0-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyxml2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyxml2-devel}"
SRC_URI[x86_64_v2_tinyxml2-devel.sha256sum] = "bc8d0692f2e8d3cb3975faf2c4bff4503503be2cee1506804fbe5e9300a76cfe"

URI_aarch64_tinyxml2 = "${EPEL_MIRROR}/aarch64/Packages/t/tinyxml2-10.0.0-18.el10_0.aarch64.rpm;name=aarch64_tinyxml2;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyxml2}"
SRC_URI[aarch64_tinyxml2.sha256sum] = "1f845ea76c3fcc717666b98ba7f7921999209adab289f9bfa5075e01389131f7"

URI_aarch64_tinyxml2-devel = "${EPEL_MIRROR}/aarch64/Packages/t/tinyxml2-devel-10.0.0-18.el10_0.aarch64.rpm;name=aarch64_tinyxml2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyxml2-devel}"
SRC_URI[aarch64_tinyxml2-devel.sha256sum] = "1382d6ad8b70d537df737ee2527b189a405875c6be43170c84fa612f1d64d045"

RDEPENDS:tinyxml2 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:tinyxml2-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 tinyxml2 \
 "
