# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "devhelp"
PE = "1"
PV = "43.0"
PR = "7.el10_0"
PACKAGES = " \
 devhelp \
 devhelp-devel \
 devhelp-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/devhelp-43.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba07d6fcc0186dc84e015fb8492c21be5532b4ed54ffd7aa701ebfcef4c22e62"

URI_x86_64_v2_devhelp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/devhelp-43.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_devhelp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_devhelp}"
SRC_URI[x86_64_v2_devhelp.sha256sum] = "21fdfdc566f279e7adc3a4c2465c73636ce5d5c7d26970dfa4febbb047f3e3c8"

URI_x86_64_v2_devhelp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/devhelp-devel-43.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_devhelp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_devhelp-devel}"
SRC_URI[x86_64_v2_devhelp-devel.sha256sum] = "b54aa6e790c435cfa42a598bdf6372ac308aefbd8139a4d66347b328539f4ca2"

URI_x86_64_v2_devhelp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/devhelp-libs-43.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_devhelp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_devhelp-libs}"
SRC_URI[x86_64_v2_devhelp-libs.sha256sum] = "b0089a5561bc1c5731417ff318cb159406b222e08e0cfd72300998d99ba94046"

URI_aarch64_devhelp = "${EPEL_MIRROR}/aarch64/Packages/d/devhelp-43.0-7.el10_0.aarch64.rpm;name=aarch64_devhelp;unpack=0"
SRC_URI:append = " ${URI_aarch64_devhelp}"
SRC_URI[aarch64_devhelp.sha256sum] = "bfe6c4e30dda832bdc8c4d919f39d44a1485b763e7178f6ff42acdede0967f07"

URI_aarch64_devhelp-devel = "${EPEL_MIRROR}/aarch64/Packages/d/devhelp-devel-43.0-7.el10_0.aarch64.rpm;name=aarch64_devhelp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_devhelp-devel}"
SRC_URI[aarch64_devhelp-devel.sha256sum] = "69709236bdbf34c9d8d7f3e0013d12a71cbb456a343be80740be60dab9a08614"

URI_aarch64_devhelp-libs = "${EPEL_MIRROR}/aarch64/Packages/d/devhelp-libs-43.0-7.el10_0.aarch64.rpm;name=aarch64_devhelp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_devhelp-libs}"
SRC_URI[aarch64_devhelp-libs.sha256sum] = "8869a872adc8ab0d880c20b1ec001885474ced3c69f4c93fb195da17d82d05c4"

RDEPENDS:devhelp = " \
 devhelp-libs \
 glib2 \
 glibc \
 gtk3 \
 pango \
 webkit2gtk4.1 \
 "
RDEPENDS:devhelp-devel = " \
 devhelp \
 devhelp-libs \
 glib2-devel \
 gsettings-desktop-schemas-devel \
 gtk3-devel \
 pkgconf-pkg-config \
 webkit2gtk4.1-devel \
 "
RDEPENDS:devhelp-libs = " \
 glib2 \
 glibc \
 gtk3 \
 pango \
 webkit2gtk4.1 \
 "
