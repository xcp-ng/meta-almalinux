# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordermap"
PV = "0.5.12"
PR = "1.el10_1"
PACKAGES = " \
 rust-ordermap+arbitrary-devel \
 rust-ordermap+default-devel \
 rust-ordermap+quickcheck-devel \
 rust-ordermap+rayon-devel \
 rust-ordermap+serde-devel \
 rust-ordermap+std-devel \
 rust-ordermap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordermap-0.5.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "071a3ea47352b38e673c77d362dc9a667f7e8a1be8377beb3860e7a31b336334"

URI_x86_64_v2_rust-ordermap+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+arbitrary-devel-0.5.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-ordermap+arbitrary-devel.sha256sum] = "4154a0c5762e25d1f1c99c86adced2ee2d1331fc63c90f8423c6f6256b9daaa1"

URI_x86_64_v2_rust-ordermap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+default-devel-0.5.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+default-devel}"
SRC_URI[x86_64_v2_rust-ordermap+default-devel.sha256sum] = "3c5441987a86871cb3b0c40aedb6c4beeaf40b9f91feeb299660b29a1782c7f7"

URI_x86_64_v2_rust-ordermap+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+quickcheck-devel-0.5.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-ordermap+quickcheck-devel.sha256sum] = "2823d5723fd46adf4328aca2a20dd88c54df098093fae5387bf7d43ceb653307"

URI_x86_64_v2_rust-ordermap+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+rayon-devel-0.5.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+rayon-devel}"
SRC_URI[x86_64_v2_rust-ordermap+rayon-devel.sha256sum] = "c6d3b88d08ebf2dc9750edcc810bfde28d29becc58a990ac310b851d0f2aa89b"

URI_x86_64_v2_rust-ordermap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+serde-devel-0.5.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+serde-devel}"
SRC_URI[x86_64_v2_rust-ordermap+serde-devel.sha256sum] = "51bb7eef6bda6f20b1f99aef0442c35cb1f7c51bbcd51847fa681bbd88e5b2c3"

URI_x86_64_v2_rust-ordermap+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap+std-devel-0.5.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap+std-devel}"
SRC_URI[x86_64_v2_rust-ordermap+std-devel.sha256sum] = "9bcc4a9c164f8de34d53f7c60a8d8783f8528f79fabdd0c00f0b60b038a2d066"

URI_x86_64_v2_rust-ordermap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordermap-devel-0.5.12-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordermap-devel}"
SRC_URI[x86_64_v2_rust-ordermap-devel.sha256sum] = "18a4ef0b1d59d13007b0939c6e2fc12b08494a7935813d9b2144d7f56d1f9458"

URI_aarch64_rust-ordermap+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+arbitrary-devel-0.5.12-1.el10_1.noarch.rpm;name=aarch64_rust-ordermap+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+arbitrary-devel}"
SRC_URI[aarch64_rust-ordermap+arbitrary-devel.sha256sum] = "cc135634dde0d259f10816017aa7a5621e5291ce07b56283f9e5c7d0115b0475"

URI_aarch64_rust-ordermap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+default-devel-0.5.12-1.el10_1.noarch.rpm;name=aarch64_rust-ordermap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+default-devel}"
SRC_URI[aarch64_rust-ordermap+default-devel.sha256sum] = "97419a154a84e2a391767f7e0be23563d8d58f5b4741abce29173f490ee6813c"

URI_aarch64_rust-ordermap+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+quickcheck-devel-0.5.12-1.el10_1.noarch.rpm;name=aarch64_rust-ordermap+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+quickcheck-devel}"
SRC_URI[aarch64_rust-ordermap+quickcheck-devel.sha256sum] = "db967a7c4fb1fe588ed787d1a91c0c7fc5f28812de78304031274d31ff930266"

URI_aarch64_rust-ordermap+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+rayon-devel-0.5.12-1.el10_1.noarch.rpm;name=aarch64_rust-ordermap+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+rayon-devel}"
SRC_URI[aarch64_rust-ordermap+rayon-devel.sha256sum] = "c1a4e84c8ef731a724cac0025079d13b2fd17c7a415322cfcc098b409f094315"

URI_aarch64_rust-ordermap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+serde-devel-0.5.12-1.el10_1.noarch.rpm;name=aarch64_rust-ordermap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+serde-devel}"
SRC_URI[aarch64_rust-ordermap+serde-devel.sha256sum] = "b6d2d3d060a76ee4f9fcec1bba346e101bb908c9f0bc7dec37b9f045d364d488"

URI_aarch64_rust-ordermap+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap+std-devel-0.5.12-1.el10_1.noarch.rpm;name=aarch64_rust-ordermap+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap+std-devel}"
SRC_URI[aarch64_rust-ordermap+std-devel.sha256sum] = "70d5ad91de70db77034126c35187489a84fbcca11b0938ab4bdba7904a96fe91"

URI_aarch64_rust-ordermap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordermap-devel-0.5.12-1.el10_1.noarch.rpm;name=aarch64_rust-ordermap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordermap-devel}"
SRC_URI[aarch64_rust-ordermap-devel.sha256sum] = "4d130d2f5a494aeea450b574dac99e0688dd1c31040c4cc98f036fcd08ddecaa"

RDEPENDS:rust-ordermap+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-indexmap+arbitrary-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap+default-devel = " \
 cargo \
 rust-ordermap+std-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap+quickcheck-devel = " \
 cargo \
 rust-indexmap+quickcheck-devel \
 rust-ordermap-devel \
 rust-quickcheck-devel \
 "
RDEPENDS:rust-ordermap+rayon-devel = " \
 cargo \
 rust-indexmap+rayon-devel \
 rust-ordermap-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ordermap+serde-devel = " \
 cargo \
 rust-indexmap+serde-devel \
 rust-ordermap-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-ordermap+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-ordermap-devel \
 "
RDEPENDS:rust-ordermap-devel = " \
 cargo \
 rust \
 rust-indexmap-devel \
 "
