# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpmcore"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kpmcore \
 kpmcore-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kpmcore-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "33a936ee553c26959e3b04e4f9a2c26f176a1a11ace50a6f13ca643da30414f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore;unpack=0"
SRC_URI[x86_64_v2_kpmcore.sha256sum] = "8b790e6f5f4216dc6f2919c426c6ac0d492ec5c645fea13819d6e90ab47b6a8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore-devel;unpack=0"
SRC_URI[x86_64_v2_kpmcore-devel.sha256sum] = "833cf44dd6d85eab1e8eca1a3c889ef2b10cac4a5c2ecb171c4cbf3a4df79f36"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kpmcore;unpack=0"
SRC_URI[aarch64_kpmcore.sha256sum] = "28aad5a2f3cac077053f8045232071070167f68d3b41fc532233613d52af5404"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kpmcore-devel;unpack=0"
SRC_URI[aarch64_kpmcore-devel.sha256sum] = "c7c1bae0a64a663db0b56f14056f546fe5d0c3861b2154859604463400c27df3"

RDEPENDS:kpmcore = " \
 e2fsprogs \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libblkid \
 libgcc \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpmcore-devel = " \
 cmake-filesystem \
 kpmcore \
 qt6-qtbase-devel \
 "
