# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_core0.5"
PV = "0.5.1"
PR = "12.el10_0"
PACKAGES = " \
 rust-rand_core0.5+alloc-devel \
 rust-rand_core0.5+default-devel \
 rust-rand_core0.5+getrandom-devel \
 rust-rand_core0.5+serde-devel \
 rust-rand_core0.5+serde1-devel \
 rust-rand_core0.5+std-devel \
 rust-rand_core0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_core0.5-0.5.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "930bef25909f12e8e0648b01d68e0d73e67f58557a8fb26946c5a1b4ac8c9f66"

URI_x86_64_v2_rust-rand_core0.5+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.5+alloc-devel-0.5.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.5+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.5+alloc-devel.sha256sum] = "8a59414d6b6abd5f9b938087fcd05624691205b0b72ae1402a47e4b103e6386a"

URI_x86_64_v2_rust-rand_core0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.5+default-devel-0.5.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.5+default-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.5+default-devel.sha256sum] = "e8813c6c6d7e7c2e7e4f8b971b4088757677d77a7035375d6e3eb02f77ec25d6"

URI_x86_64_v2_rust-rand_core0.5+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.5+getrandom-devel-0.5.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.5+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.5+getrandom-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.5+getrandom-devel.sha256sum] = "745511a08f58c60c392d339721ca0fcc937a5a655eb85ae30cb0f11cbf8c3037"

URI_x86_64_v2_rust-rand_core0.5+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.5+serde-devel-0.5.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.5+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.5+serde-devel.sha256sum] = "aec83320875cd2208c9fae20dfd3e75df905a3ed70f2ca26b550585533980d0d"

URI_x86_64_v2_rust-rand_core0.5+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.5+serde1-devel-0.5.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.5+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.5+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.5+serde1-devel.sha256sum] = "7bc2adfb15074ee559b50f6c49d27a4e5ab261bcc7257a9da6530109df8e59da"

URI_x86_64_v2_rust-rand_core0.5+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.5+std-devel-0.5.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.5+std-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.5+std-devel.sha256sum] = "2717cf30554110d27b992c9ef03eea2dc1a068f0334585c93b632491cd50d616"

URI_x86_64_v2_rust-rand_core0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core0.5-devel-0.5.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core0.5-devel}"
SRC_URI[x86_64_v2_rust-rand_core0.5-devel.sha256sum] = "b1ecefaaf4e301c9e5d78945aaf67a789b7d41148297c7fd127d855f6b37a333"

URI_aarch64_rust-rand_core0.5+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.5+alloc-devel-0.5.1-12.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.5+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.5+alloc-devel}"
SRC_URI[aarch64_rust-rand_core0.5+alloc-devel.sha256sum] = "23d7ffd45ca40053d05048e435ea34cec6343883975a4cd4aa0fd16a70bbcf7e"

URI_aarch64_rust-rand_core0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.5+default-devel-0.5.1-12.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.5+default-devel}"
SRC_URI[aarch64_rust-rand_core0.5+default-devel.sha256sum] = "ea3153001329c757776c7b5fcbac26605c164afe5aa81bf56e323f5d98da04e8"

URI_aarch64_rust-rand_core0.5+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.5+getrandom-devel-0.5.1-12.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.5+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.5+getrandom-devel}"
SRC_URI[aarch64_rust-rand_core0.5+getrandom-devel.sha256sum] = "f57d1e47e20919a64338ad5530791bb41bad6f4c470bb32f98326509488e4eb0"

URI_aarch64_rust-rand_core0.5+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.5+serde-devel-0.5.1-12.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.5+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.5+serde-devel}"
SRC_URI[aarch64_rust-rand_core0.5+serde-devel.sha256sum] = "cf838936f00b92f49ce8eeaf64c8f19507f64323aba603864ef64cce95964ade"

URI_aarch64_rust-rand_core0.5+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.5+serde1-devel-0.5.1-12.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.5+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.5+serde1-devel}"
SRC_URI[aarch64_rust-rand_core0.5+serde1-devel.sha256sum] = "a986b0df4214492ade859c5010faa53ee08ca4f8a68e99a23d0705ad3b5bebf4"

URI_aarch64_rust-rand_core0.5+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.5+std-devel-0.5.1-12.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.5+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.5+std-devel}"
SRC_URI[aarch64_rust-rand_core0.5+std-devel.sha256sum] = "bd0f036604b63b0b68d4ff18e1b4528f1e531fa2f5d4ab57e23d3e7e06ce6a83"

URI_aarch64_rust-rand_core0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core0.5-devel-0.5.1-12.el10_0.noarch.rpm;name=aarch64_rust-rand_core0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core0.5-devel}"
SRC_URI[aarch64_rust-rand_core0.5-devel.sha256sum] = "a810fbab9da16efde1d85479dcdabeebbd3d280d5fa7fe8187e57b43d54d5c8f"

RDEPENDS:rust-rand_core0.5+alloc-devel = " \
 cargo \
 rust-rand_core0.5-devel \
 "
RDEPENDS:rust-rand_core0.5+default-devel = " \
 cargo \
 rust-rand_core0.5-devel \
 "
RDEPENDS:rust-rand_core0.5+getrandom-devel = " \
 cargo \
 rust-getrandom0.1+default-devel \
 rust-rand_core0.5-devel \
 "
RDEPENDS:rust-rand_core0.5+serde-devel = " \
 cargo \
 rust-rand_core0.5-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_core0.5+serde1-devel = " \
 cargo \
 rust-rand_core0.5+serde-devel \
 rust-rand_core0.5-devel \
 "
RDEPENDS:rust-rand_core0.5+std-devel = " \
 cargo \
 rust-getrandom0.1+default-devel \
 rust-getrandom0.1+std-devel \
 rust-rand_core0.5+alloc-devel \
 rust-rand_core0.5+getrandom-devel \
 rust-rand_core0.5-devel \
 "
RDEPENDS:rust-rand_core0.5-devel = " \
 cargo \
 "
