# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-jcmturner-dnsutils-1"
PV = "1.0.1"
PR = "14.el10_0"
PACKAGES = " \
 golang-gopkg-jcmturner-dnsutils-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-jcmturner-dnsutils-1-1.0.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3dea51c1026939af98baeb4287f98bbbbe846e0066c2b1819fa4d6910de11d5"

URI_x86_64_v2_golang-gopkg-jcmturner-dnsutils-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-jcmturner-dnsutils-1-devel-1.0.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-jcmturner-dnsutils-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-jcmturner-dnsutils-1-devel}"
SRC_URI[x86_64_v2_golang-gopkg-jcmturner-dnsutils-1-devel.sha256sum] = "004dcb8cbad7641d8956bd1fd49d5bf78dca47d8de4ccfdc97acda0786ece60d"

URI_aarch64_golang-gopkg-jcmturner-dnsutils-1-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-jcmturner-dnsutils-1-devel-1.0.1-14.el10_0.noarch.rpm;name=aarch64_golang-gopkg-jcmturner-dnsutils-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-jcmturner-dnsutils-1-devel}"
SRC_URI[aarch64_golang-gopkg-jcmturner-dnsutils-1-devel.sha256sum] = "634cc2fe5c9b8b1523eb04a8b9105fe17186f6dc7a9980fbccb741e081f8897c"

RDEPENDS:golang-gopkg-jcmturner-dnsutils-1-devel = " \
 go-filesystem \
 "
