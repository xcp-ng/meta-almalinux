# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mhash"
PV = "0.9.9.9"
PR = "35.el10_2"
PACKAGES = " \
 mhash \
 mhash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mhash-0.9.9.9-35.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c096d68f3e3a8d41db998d67946103d04461e7aa9bb673e3d3d373ee7a5ce2b9"

URI_x86_64_v2_mhash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mhash-0.9.9.9-35.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mhash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mhash}"
SRC_URI[x86_64_v2_mhash.sha256sum] = "cccb70f66b363f7a7c232c6d6a131782300e49f1cccc682c0a8c34121f2026fc"

URI_x86_64_v2_mhash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mhash-devel-0.9.9.9-35.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mhash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mhash-devel}"
SRC_URI[x86_64_v2_mhash-devel.sha256sum] = "a40863ee83e56bf7ecd29c0fdeb453b03419403892fb2badc70aa614f210353b"

URI_aarch64_mhash = "${EPEL_MIRROR}/aarch64/Packages/m/mhash-0.9.9.9-35.el10_2.aarch64.rpm;name=aarch64_mhash;unpack=0"
SRC_URI:append = " ${URI_aarch64_mhash}"
SRC_URI[aarch64_mhash.sha256sum] = "8b79b129141641b11d5129a91f73006078f923dfad8f0a8e037c92c12a28e222"

URI_aarch64_mhash-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mhash-devel-0.9.9.9-35.el10_2.aarch64.rpm;name=aarch64_mhash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mhash-devel}"
SRC_URI[aarch64_mhash-devel.sha256sum] = "7cae90a1b3569bb6cda90d19b48c564c18c6b82c4237ad648ec1c022dff2f84e"

RDEPENDS:mhash = " \
 glibc \
 "
RDEPENDS:mhash-devel = " \
 mhash \
 "
