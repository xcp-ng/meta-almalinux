# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kubrick"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kubrick \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kubrick-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d00fb712ae72afef31ed7eda2544d50257557de57a9b20d771900e0b547957e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kubrick-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kubrick;unpack=0"
SRC_URI[x86_64_v2_kubrick.sha256sum] = "74b672ec167eadcc416e1d754a5546c16e2f5592bf39ff5d4354cbc797a417c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kubrick-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kubrick;unpack=0"
SRC_URI[aarch64_kubrick.sha256sum] = "ecfa3c16c2a74392c127711ebbfd730ed3e7045457c60d30883e5505ae0b36b3"

RDEPENDS:kubrick = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libglvnd-opengl \
 libkdegames \
 libstdc++ \
 mesa-libGLU \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
