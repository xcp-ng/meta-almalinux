# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ref-cast"
PV = "1.0.27"
PR = "1.el10_3"
PACKAGES = " \
 rust-ref-cast+default-devel \
 rust-ref-cast-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ref-cast-1.0.27-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d8c2eac4908f7c0bfb6170be3f42b6687e9fbe07dfed0637e57f1c250a2f4c55"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast+default-devel-1.0.27-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ref-cast+default-devel.sha256sum] = "c27c06cfadaf599b36892a44300b7e3eb8217f22e40f93ad252046db3e0ea356"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-devel-1.0.27-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ref-cast-devel.sha256sum] = "9a96a75fa84ca280fe6c8bd1252c28e202cb1a3dd963b4dc7c145354c82f84e8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast+default-devel-1.0.27-1.el10_3.noarch.rpm;name=aarch64_rust-ref-cast+default-devel;unpack=0"
SRC_URI[aarch64_rust-ref-cast+default-devel.sha256sum] = "eb7369a1cd3fc27c394630943b4f8002629cd457f62b28fb10853f574d00f8dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-devel-1.0.27-1.el10_3.noarch.rpm;name=aarch64_rust-ref-cast-devel;unpack=0"
SRC_URI[aarch64_rust-ref-cast-devel.sha256sum] = "33b12b90b636e271b4405d784b48f6b172c1633135565f039018e76f7c5cebea"

RDEPENDS:rust-ref-cast+default-devel = " \
 cargo \
 rust-ref-cast-devel \
 "
RDEPENDS:rust-ref-cast-devel = " \
 cargo \
 rust \
 rust-ref-cast-impl+default-devel \
 "
