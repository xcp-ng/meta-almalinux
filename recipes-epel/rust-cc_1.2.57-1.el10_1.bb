# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cc"
PV = "1.2.57"
PR = "1.el10_1"
PACKAGES = " \
 rust-cc+default-devel \
 rust-cc+jobserver-devel \
 rust-cc+parallel-devel \
 rust-cc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cc-1.2.57-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d45fffdb8cab71a9e10d121117ee537695b38b0a3240fa2bd2fee0bc57b045c5"

URI_x86_64_v2_rust-cc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+default-devel-1.2.57-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+default-devel}"
SRC_URI[x86_64_v2_rust-cc+default-devel.sha256sum] = "815c8fd90d43e7fb04645f2607ec0db9a70a1c6ed141e75baa2788f2f2952450"

URI_x86_64_v2_rust-cc+jobserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+jobserver-devel-1.2.57-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+jobserver-devel}"
SRC_URI[x86_64_v2_rust-cc+jobserver-devel.sha256sum] = "08f18fbd06531e39658465802730acbbb33299d71d52878348f168c15d21d76e"

URI_x86_64_v2_rust-cc+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc+parallel-devel-1.2.57-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc+parallel-devel}"
SRC_URI[x86_64_v2_rust-cc+parallel-devel.sha256sum] = "c2e112e3a8116e17e3f914098445fe83f6d9749ac7b246522252f99e1938cc9b"

URI_x86_64_v2_rust-cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cc-devel-1.2.57-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cc-devel}"
SRC_URI[x86_64_v2_rust-cc-devel.sha256sum] = "6aefb5f8f2f3b420853884d267b1fd7d3f846b9915e127c2150fa8816b5b013a"

URI_aarch64_rust-cc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+default-devel-1.2.57-1.el10_1.noarch.rpm;name=aarch64_rust-cc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+default-devel}"
SRC_URI[aarch64_rust-cc+default-devel.sha256sum] = "d9d72a5ec8696520338864256e13c43e5995c5338fa7f16ea4db1798940cc9e9"

URI_aarch64_rust-cc+jobserver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+jobserver-devel-1.2.57-1.el10_1.noarch.rpm;name=aarch64_rust-cc+jobserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+jobserver-devel}"
SRC_URI[aarch64_rust-cc+jobserver-devel.sha256sum] = "c614d9e6faf4b86261b3f351d4bbc8cc82df9c4d872aeb8f2045b85bfe64520b"

URI_aarch64_rust-cc+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc+parallel-devel-1.2.57-1.el10_1.noarch.rpm;name=aarch64_rust-cc+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc+parallel-devel}"
SRC_URI[aarch64_rust-cc+parallel-devel.sha256sum] = "d8f48fc8a9b6d1a093986cbdabd8d5e4fbb23e99d5535b517228993076e6123e"

URI_aarch64_rust-cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cc-devel-1.2.57-1.el10_1.noarch.rpm;name=aarch64_rust-cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cc-devel}"
SRC_URI[aarch64_rust-cc-devel.sha256sum] = "f24ece930084cc44f483e5eadfbe728e705c923394b10179ee20b5dbc35610fd"

RDEPENDS:rust-cc+default-devel = " \
 cargo \
 rust-cc-devel \
 "
RDEPENDS:rust-cc+jobserver-devel = " \
 cargo \
 rust-cc-devel \
 "
RDEPENDS:rust-cc+parallel-devel = " \
 cargo \
 rust-cc-devel \
 rust-jobserver-devel \
 rust-libc-devel \
 "
RDEPENDS:rust-cc-devel = " \
 cargo \
 gcc \
 gcc-c++ \
 rust \
 rust-find-msvc-tools+default-devel \
 rust-shlex+default-devel \
 "
