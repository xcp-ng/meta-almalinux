# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-prefix-trie"
PV = "0.8.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-prefix-trie+default-devel \
 rust-prefix-trie+ipnet-devel \
 rust-prefix-trie+ipnetwork-devel \
 rust-prefix-trie+serde-devel \
 rust-prefix-trie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-prefix-trie-0.8.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3aa07eae4983db79271bda326a8bdea2103404c02bd72b148a768ad91c54f16"

URI_x86_64_v2_rust-prefix-trie+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prefix-trie+default-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prefix-trie+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prefix-trie+default-devel}"
SRC_URI[x86_64_v2_rust-prefix-trie+default-devel.sha256sum] = "d456a1e9f2112d6fe164e0fc9707558358319ae67b7b54515a6209ff52b6591c"

URI_x86_64_v2_rust-prefix-trie+ipnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prefix-trie+ipnet-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prefix-trie+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prefix-trie+ipnet-devel}"
SRC_URI[x86_64_v2_rust-prefix-trie+ipnet-devel.sha256sum] = "24ef9166006dde0ea57fa29a004de95cc56701940f8a2d63360c301ab6879958"

URI_x86_64_v2_rust-prefix-trie+ipnetwork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prefix-trie+ipnetwork-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prefix-trie+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prefix-trie+ipnetwork-devel}"
SRC_URI[x86_64_v2_rust-prefix-trie+ipnetwork-devel.sha256sum] = "9190f5959b5c94573b74bbb8dd468bb1c6a05f0b59d0b922c450c7bcd424efd1"

URI_x86_64_v2_rust-prefix-trie+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prefix-trie+serde-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prefix-trie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prefix-trie+serde-devel}"
SRC_URI[x86_64_v2_rust-prefix-trie+serde-devel.sha256sum] = "537d76276ff8ccfdc92f7d3cb820488954ce4db61a3b623ac601a628c9b52439"

URI_x86_64_v2_rust-prefix-trie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-prefix-trie-devel-0.8.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-prefix-trie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-prefix-trie-devel}"
SRC_URI[x86_64_v2_rust-prefix-trie-devel.sha256sum] = "9f39c6b96ddaa99794d0435152e2c2efd68146d71c297d4f8be0de7470a95da8"

URI_aarch64_rust-prefix-trie+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prefix-trie+default-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-prefix-trie+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prefix-trie+default-devel}"
SRC_URI[aarch64_rust-prefix-trie+default-devel.sha256sum] = "1d432d8ee77b72cf10f266c425e57b9db6379fcbcf4ecb3e99469eae1cfaf881"

URI_aarch64_rust-prefix-trie+ipnet-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prefix-trie+ipnet-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-prefix-trie+ipnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prefix-trie+ipnet-devel}"
SRC_URI[aarch64_rust-prefix-trie+ipnet-devel.sha256sum] = "750e1afda70214de8559d83a6a2a26cef2b30e5bd5f1ad8782016334d7dd99fe"

URI_aarch64_rust-prefix-trie+ipnetwork-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prefix-trie+ipnetwork-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-prefix-trie+ipnetwork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prefix-trie+ipnetwork-devel}"
SRC_URI[aarch64_rust-prefix-trie+ipnetwork-devel.sha256sum] = "6d5b8733e34744b5926f0d38a4077fd9ba981c875c8969c9433cc754d48fd442"

URI_aarch64_rust-prefix-trie+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prefix-trie+serde-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-prefix-trie+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prefix-trie+serde-devel}"
SRC_URI[aarch64_rust-prefix-trie+serde-devel.sha256sum] = "623c201324fe6f4d65d7c867d64de01ff3b4778665a5d8c90e2f2d767aefeb44"

URI_aarch64_rust-prefix-trie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-prefix-trie-devel-0.8.4-1.el10_3.noarch.rpm;name=aarch64_rust-prefix-trie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-prefix-trie-devel}"
SRC_URI[aarch64_rust-prefix-trie-devel.sha256sum] = "fa93d2b437317d7841e8ad6fce2c878b99096af61c62af37eb2713d17a78db64"

RDEPENDS:rust-prefix-trie+default-devel = " \
 cargo \
 rust-prefix-trie+ipnet-devel \
 rust-prefix-trie-devel \
 "
RDEPENDS:rust-prefix-trie+ipnet-devel = " \
 cargo \
 rust-ipnet+default-devel \
 rust-prefix-trie-devel \
 "
RDEPENDS:rust-prefix-trie+ipnetwork-devel = " \
 cargo \
 rust-ipnetwork+default-devel \
 rust-prefix-trie-devel \
 "
RDEPENDS:rust-prefix-trie+serde-devel = " \
 cargo \
 rust-ipnet+default-devel \
 rust-ipnet+serde-devel \
 rust-ipnetwork+default-devel \
 rust-ipnetwork+serde-devel \
 rust-prefix-trie-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-prefix-trie-devel = " \
 cargo \
 rust \
 rust-either+default-devel \
 rust-num-traits+default-devel \
 "
