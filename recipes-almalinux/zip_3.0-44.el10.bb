# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zip"
PV = "3.0"
PR = "44.el10"
PACKAGES = " \
 zip \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/zip-3.0-44.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f01b88116f312e0da03ae38bc7cf104456a92eea727a95a39268900fa667dc73"

URI_x86_64_v2_zip = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/zip-3.0-44.el10.x86_64_v2.rpm;name=x86_64_v2_zip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zip}"
SRC_URI[x86_64_v2_zip.sha256sum] = "43cf9aa11f8915560368ed371776c6017695f7985c64c8ce66a595f4c1bfdc34"

URI_aarch64_zip = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/zip-3.0-44.el10.aarch64.rpm;name=aarch64_zip;unpack=0"
SRC_URI:append = " ${URI_aarch64_zip}"
SRC_URI[aarch64_zip.sha256sum] = "8c4473deafaa3c785839104047992e07ab80b52b3c949a151d2f38991de0baa6"

RDEPENDS:zip = " \
 bzip2-libs \
 glibc \
 unzip \
 "
