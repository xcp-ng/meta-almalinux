# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rootfiles"
PV = "8.1"
PR = "54.el10"
PACKAGES = " \
 rootfiles \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rootfiles-8.1-54.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57007cb0b804966704f60e2bdd71bb2b333e66be150e47578097522da581261d"

URI_x86_64_v2_rootfiles = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rootfiles-8.1-54.el10.noarch.rpm;name=x86_64_v2_rootfiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rootfiles}"
SRC_URI[x86_64_v2_rootfiles.sha256sum] = "d5ad82249e644cefb1e8c8ce64ff717a06df68e121183650ef13a104a220795d"

URI_aarch64_rootfiles = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rootfiles-8.1-54.el10.noarch.rpm;name=aarch64_rootfiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_rootfiles}"
SRC_URI[aarch64_rootfiles.sha256sum] = "d5ad82249e644cefb1e8c8ce64ff717a06df68e121183650ef13a104a220795d"

RDEPENDS:rootfiles = " \
 bash \
 "
