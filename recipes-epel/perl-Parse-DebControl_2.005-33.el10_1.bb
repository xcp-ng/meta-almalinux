# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parse-DebControl"
PV = "2.005"
PR = "33.el10_1"
PACKAGES = " \
 perl-Parse-DebControl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Parse-DebControl-2.005-33.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91e6b820f57bcfc2d345c89fdc84f167bca4707ee784b7f83355846f0426287e"

URI_x86_64_v2_perl-Parse-DebControl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Parse-DebControl-2.005-33.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Parse-DebControl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parse-DebControl}"
SRC_URI[x86_64_v2_perl-Parse-DebControl.sha256sum] = "33c6a1aa11f2a8f72d0cbf3088c7c2df2053bc44d14296a2e9c4a5900074d32d"

URI_aarch64_perl-Parse-DebControl = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Parse-DebControl-2.005-33.el10_1.noarch.rpm;name=aarch64_perl-Parse-DebControl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parse-DebControl}"
SRC_URI[aarch64_perl-Parse-DebControl.sha256sum] = "1ac5a1cfb703cd9b96e5a411067d55acb51d1182c582fdefb51e45d5e34e171d"

RDEPENDS:perl-Parse-DebControl = " \
 perl-IO-Compress \
 perl-IO-stringy \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 "
