# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-gen"
PV = "0.7.197"
PR = "1.el10_2"
PACKAGES = " \
 rust-cxx-gen+default-devel \
 rust-cxx-gen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-gen-0.7.197-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc0866805eddeb8c598be3da5b9c00c87312a35ce4153ff067f3704ff8dd98d2"

URI_x86_64_v2_rust-cxx-gen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen+default-devel-0.7.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-gen+default-devel}"
SRC_URI[x86_64_v2_rust-cxx-gen+default-devel.sha256sum] = "f4995b15aeedaee532d690a4d0fc9c03e94143465b32b1781c8dc0f409fc0249"

URI_x86_64_v2_rust-cxx-gen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-gen-devel-0.7.197-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-gen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-gen-devel}"
SRC_URI[x86_64_v2_rust-cxx-gen-devel.sha256sum] = "af6b7150f9e4366cb47ec8fde8f2cba09fa2954092aa87f46baf9342651f2f57"

URI_aarch64_rust-cxx-gen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen+default-devel-0.7.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx-gen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-gen+default-devel}"
SRC_URI[aarch64_rust-cxx-gen+default-devel.sha256sum] = "a5b7c71aaeb6e06b236df25ec9e81aa3b68010274985fbc5d08dc7eba7f1dd37"

URI_aarch64_rust-cxx-gen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-gen-devel-0.7.197-1.el10_2.noarch.rpm;name=aarch64_rust-cxx-gen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-gen-devel}"
SRC_URI[aarch64_rust-cxx-gen-devel.sha256sum] = "d93aeeed66e084ff4165f6274103c46aba7205f975d9823f8a5db04cafcbb250"

RDEPENDS:rust-cxx-gen+default-devel = " \
 cargo \
 rust-cxx-gen-devel \
 "
RDEPENDS:rust-cxx-gen-devel = " \
 cargo \
 rust \
 rust-codespan-reporting+default-devel \
 rust-indexmap+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
