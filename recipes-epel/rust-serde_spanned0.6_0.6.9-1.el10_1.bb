# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_spanned0.6"
PV = "0.6.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_spanned0.6+default-devel \
 rust-serde_spanned0.6+serde-devel \
 rust-serde_spanned0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_spanned0.6-0.6.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef0bc3547ca61859e23a84d328d719c3e0090448bf146e553613b9c5548d99dc"

URI_x86_64_v2_rust-serde_spanned0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned0.6+default-devel-0.6.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned0.6+default-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned0.6+default-devel.sha256sum] = "1449f98a46d184cb03a0a139fa0b2a71c9987d965d0e2bc8ad231e2383c36320"

URI_x86_64_v2_rust-serde_spanned0.6+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned0.6+serde-devel-0.6.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned0.6+serde-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned0.6+serde-devel.sha256sum] = "05ed3d8fb6342ff542cc84dbe66d0be2a06fbf2747c775046d7a9c9a1bfc3e95"

URI_x86_64_v2_rust-serde_spanned0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned0.6-devel-0.6.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned0.6-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned0.6-devel.sha256sum] = "f3a67827a965779a4e38730157fdd2ef9dc947b2e716c16c0c3cf23f63271827"

URI_aarch64_rust-serde_spanned0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned0.6+default-devel-0.6.9-1.el10_1.noarch.rpm;name=aarch64_rust-serde_spanned0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned0.6+default-devel}"
SRC_URI[aarch64_rust-serde_spanned0.6+default-devel.sha256sum] = "29a1c1ca6c3f70a54e881a4721fa0813ccab8282a753d63cee5cf34185721a52"

URI_aarch64_rust-serde_spanned0.6+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned0.6+serde-devel-0.6.9-1.el10_1.noarch.rpm;name=aarch64_rust-serde_spanned0.6+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned0.6+serde-devel}"
SRC_URI[aarch64_rust-serde_spanned0.6+serde-devel.sha256sum] = "99a472fd95d8247d0bb76946bfeb5a59288b890e02e07f58f534768984e5d5d4"

URI_aarch64_rust-serde_spanned0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned0.6-devel-0.6.9-1.el10_1.noarch.rpm;name=aarch64_rust-serde_spanned0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned0.6-devel}"
SRC_URI[aarch64_rust-serde_spanned0.6-devel.sha256sum] = "32929afde1c9051566c71b64cc57eea12449274cb97e295afc71b5194458dbb9"

RDEPENDS:rust-serde_spanned0.6+default-devel = " \
 cargo \
 rust-serde_spanned0.6-devel \
 "
RDEPENDS:rust-serde_spanned0.6+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde_spanned0.6-devel \
 "
RDEPENDS:rust-serde_spanned0.6-devel = " \
 cargo \
 rust \
 "
