# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-write16"
PV = "1.0.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-write16+alloc-devel \
 rust-write16+arrayvec-devel \
 rust-write16+default-devel \
 rust-write16+smallvec-devel \
 rust-write16-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-write16-1.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "922434733f081cb765ea63b44eb22f91b7460c135478a7041c784adee13b075e"

URI_x86_64_v2_rust-write16+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16+alloc-devel-1.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16+alloc-devel}"
SRC_URI[x86_64_v2_rust-write16+alloc-devel.sha256sum] = "9a6521de1c1b5f095950c7cdcc2c97cb5f8d8ff6c40c115080dadf5f2d891dd2"

URI_x86_64_v2_rust-write16+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16+arrayvec-devel-1.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-write16+arrayvec-devel.sha256sum] = "d82d19cb773ec74d132d7f8ab21b6df1d837a77a700b65486aaa1df24e893023"

URI_x86_64_v2_rust-write16+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16+default-devel-1.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16+default-devel}"
SRC_URI[x86_64_v2_rust-write16+default-devel.sha256sum] = "7a057eb300fa24cca40e95b69a0d4407a4779c9e78d0ff87fc18fd78480a85e6"

URI_x86_64_v2_rust-write16+smallvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16+smallvec-devel-1.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16+smallvec-devel}"
SRC_URI[x86_64_v2_rust-write16+smallvec-devel.sha256sum] = "84947a0dfa571a8cd7daa83f61d5b17ab203dfff82ceffc118b503976949d734"

URI_x86_64_v2_rust-write16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-write16-devel-1.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-write16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-write16-devel}"
SRC_URI[x86_64_v2_rust-write16-devel.sha256sum] = "78ad70626f07c6adee9d4154bd91b61fa1de6e7193e6fb0892ead3f5596a06c9"

URI_aarch64_rust-write16+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16+alloc-devel-1.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-write16+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16+alloc-devel}"
SRC_URI[aarch64_rust-write16+alloc-devel.sha256sum] = "0499540f9011cec2428f81424d263e45f93e69f22dfa9f8a4294a87872985ef2"

URI_aarch64_rust-write16+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16+arrayvec-devel-1.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-write16+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16+arrayvec-devel}"
SRC_URI[aarch64_rust-write16+arrayvec-devel.sha256sum] = "a419019818f807ba3f6aa94d56992705de3e480045cb8f74456f84f0eab34f2e"

URI_aarch64_rust-write16+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16+default-devel-1.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-write16+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16+default-devel}"
SRC_URI[aarch64_rust-write16+default-devel.sha256sum] = "06aa074e7cfe8bde708d529fa10e23b0db99270dda7050e67a434360b44364c2"

URI_aarch64_rust-write16+smallvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16+smallvec-devel-1.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-write16+smallvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16+smallvec-devel}"
SRC_URI[aarch64_rust-write16+smallvec-devel.sha256sum] = "e6b9c84d240587c5c5a53a51d93bd5c2a9c325a06fb8ada406ab93dad1f5c819"

URI_aarch64_rust-write16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-write16-devel-1.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-write16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-write16-devel}"
SRC_URI[aarch64_rust-write16-devel.sha256sum] = "12966e5c24b41f17a3030374cdeb1af0e1269402280181db572e059a9c84750a"

RDEPENDS:rust-write16+alloc-devel = " \
 cargo \
 rust-write16-devel \
 "
RDEPENDS:rust-write16+arrayvec-devel = " \
 cargo \
 rust-arrayvec+default-devel \
 rust-write16-devel \
 "
RDEPENDS:rust-write16+default-devel = " \
 cargo \
 rust-write16-devel \
 "
RDEPENDS:rust-write16+smallvec-devel = " \
 cargo \
 rust-smallvec+default-devel \
 rust-write16-devel \
 "
RDEPENDS:rust-write16-devel = " \
 cargo \
 "
