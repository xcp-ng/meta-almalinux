# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-silently"
PV = "1.2.5.3"
PR = "7.el10_0"
PACKAGES = " \
 ghc-silently \
 ghc-silently-devel \
 ghc-silently-doc \
 ghc-silently-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-silently-1.2.5.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d05dfc76155df9f52a971ff98b2611f5d2f9f3d88ac0933aedec9b841edeb656"

URI_x86_64_v2_ghc-silently = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-silently-1.2.5.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-silently;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-silently}"
SRC_URI[x86_64_v2_ghc-silently.sha256sum] = "42385f0965b5ecbf5f68245dac6389999848ee835facbe1e2538e874ceb8f69d"

URI_x86_64_v2_ghc-silently-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-silently-devel-1.2.5.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-silently-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-silently-devel}"
SRC_URI[x86_64_v2_ghc-silently-devel.sha256sum] = "1388a765590007f60d1e611de91417cab64f7623b7271a491d0ea5498c6e156c"

URI_x86_64_v2_ghc-silently-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-silently-doc-1.2.5.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-silently-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-silently-doc}"
SRC_URI[x86_64_v2_ghc-silently-doc.sha256sum] = "32c794136537ea7a6b1ae355ead2ff57c901bbd2ddfd6c31f60eb816657ab173"

URI_x86_64_v2_ghc-silently-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-silently-prof-1.2.5.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-silently-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-silently-prof}"
SRC_URI[x86_64_v2_ghc-silently-prof.sha256sum] = "0dfcab9f1b9422b4b96952f76f28bc88cc67f44a86418aed5dc93aa04b953713"

URI_aarch64_ghc-silently = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-silently-1.2.5.3-7.el10_0.aarch64.rpm;name=aarch64_ghc-silently;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-silently}"
SRC_URI[aarch64_ghc-silently.sha256sum] = "e139c23ef233c89d2dab301f6c0db9a3e05e768ff803ef3e4de174ce34b81c39"

URI_aarch64_ghc-silently-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-silently-devel-1.2.5.3-7.el10_0.aarch64.rpm;name=aarch64_ghc-silently-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-silently-devel}"
SRC_URI[aarch64_ghc-silently-devel.sha256sum] = "ede62646b25d6536eee8074d3f999a5ad8845f397ee95402e0a6b1f68d7af2ea"

URI_aarch64_ghc-silently-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-silently-doc-1.2.5.3-7.el10_0.noarch.rpm;name=aarch64_ghc-silently-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-silently-doc}"
SRC_URI[aarch64_ghc-silently-doc.sha256sum] = "1694017b2444ee2eb9dded98798d92643a764263b362b2b116693d7c230fbec6"

URI_aarch64_ghc-silently-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-silently-prof-1.2.5.3-7.el10_0.aarch64.rpm;name=aarch64_ghc-silently-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-silently-prof}"
SRC_URI[aarch64_ghc-silently-prof.sha256sum] = "4d06727993d6e82562a20c0fa38b05359c63a278c3cfed941de009748929f1ce"

RDEPENDS:ghc-silently = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-silently-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-directory-devel \
 ghc-silently \
 "
RDEPENDS:ghc-silently-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-silently-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-directory-prof \
 ghc-silently-devel \
 "
