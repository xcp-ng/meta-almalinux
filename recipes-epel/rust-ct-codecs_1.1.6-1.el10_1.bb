# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ct-codecs"
PV = "1.1.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-ct-codecs+default-devel \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ct-codecs-1.1.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b738378eb7df0e2b4e67427a17a1679c9f34287bcea33eaa2a85fa2556d5b409"

URI_x86_64_v2_rust-ct-codecs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+default-devel-1.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs+default-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs+default-devel.sha256sum] = "4fdd5fa83bcc54dfd751baa1e861c5ff1a90ccd05829002ca1e666e6b8e9db40"

URI_x86_64_v2_rust-ct-codecs+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs+std-devel-1.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs+std-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs+std-devel.sha256sum] = "942759d03642041fabc05f29c02509d4cefd5d83e2cb907f8102227de4f2530c"

URI_x86_64_v2_rust-ct-codecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ct-codecs-devel-1.1.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ct-codecs-devel}"
SRC_URI[x86_64_v2_rust-ct-codecs-devel.sha256sum] = "732f2a25bb6c4b5fcfcd8892f3408bd2012da06e1d20ddf08f15134975673df9"

URI_aarch64_rust-ct-codecs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+default-devel-1.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-ct-codecs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs+default-devel}"
SRC_URI[aarch64_rust-ct-codecs+default-devel.sha256sum] = "0210c2bf5790515589b20e76a6f0fd742d2b0d5ff872b682653caec9f0db11db"

URI_aarch64_rust-ct-codecs+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs+std-devel-1.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-ct-codecs+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs+std-devel}"
SRC_URI[aarch64_rust-ct-codecs+std-devel.sha256sum] = "200ce17386a60c6d2cab5288760bb371f30f952eca04f93bb51c73a379a3af83"

URI_aarch64_rust-ct-codecs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ct-codecs-devel-1.1.6-1.el10_1.noarch.rpm;name=aarch64_rust-ct-codecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ct-codecs-devel}"
SRC_URI[aarch64_rust-ct-codecs-devel.sha256sum] = "57a0435480dd20907291ff25e952180084a7a31dc3cd040265580c3f24bdf34c"

RDEPENDS:rust-ct-codecs+default-devel = " \
 cargo \
 rust-ct-codecs+std-devel \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs+std-devel = " \
 cargo \
 rust-ct-codecs-devel \
 "
RDEPENDS:rust-ct-codecs-devel = " \
 cargo \
 "
