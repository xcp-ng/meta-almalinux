# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lesspipe"
PV = "2.24"
PR = "3.el10_1"
PACKAGES = " \
 lesspipe \
 lesspipe-profile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lesspipe-2.24-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f13a09dcd7222a93ea9746272a1dd7adb3513ddd7eabf9316101f701381e091d"

URI_x86_64_v2_lesspipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lesspipe-2.24-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lesspipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lesspipe}"
SRC_URI[x86_64_v2_lesspipe.sha256sum] = "46cc70827d22db78f993b38a13e933708eef1af70ae724163b25a7bb83536ab1"

URI_x86_64_v2_lesspipe-profile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lesspipe-profile-2.24-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lesspipe-profile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lesspipe-profile}"
SRC_URI[x86_64_v2_lesspipe-profile.sha256sum] = "235b6bffb46ce66c4dee985201394ea642c9ded96ed7cfa6652aee5e9c7895e8"

URI_aarch64_lesspipe = "${EPEL_MIRROR}/aarch64/Packages/l/lesspipe-2.24-3.el10_1.noarch.rpm;name=aarch64_lesspipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_lesspipe}"
SRC_URI[aarch64_lesspipe.sha256sum] = "0ac392f40139796622c07aa8756c87fe738484c207131487c15b7cdd7a89c3cf"

URI_aarch64_lesspipe-profile = "${EPEL_MIRROR}/aarch64/Packages/l/lesspipe-profile-2.24-3.el10_1.noarch.rpm;name=aarch64_lesspipe-profile;unpack=0"
SRC_URI:append = " ${URI_aarch64_lesspipe-profile}"
SRC_URI[aarch64_lesspipe-profile.sha256sum] = "b0823bd47eed5be9b23da4420b4d1b0e7ecd652fb5afbc529713a7f23fa7dcad"

RDEPENDS:lesspipe = " \
 bash \
 file \
 glibc-common \
 procps-ng \
 virtual//usr/bin/head \
 "
RDEPENDS:lesspipe-profile = " \
 lesspipe \
 setup \
 "
