# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kget"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kget \
 kget-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kget-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a512cad364fad250fc0b2d912c343a5d7b1a2df3e2685e51f6261c78574e559e"

URI_x86_64_v2_kget = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kget}"
SRC_URI[x86_64_v2_kget.sha256sum] = "8d3fa9f09b89d86000f2ec8d04dc91afc07e40835fac1badf20b26b4f5575636"

URI_x86_64_v2_kget-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kget-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kget-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kget-libs}"
SRC_URI[x86_64_v2_kget-libs.sha256sum] = "6c21d96cb97cdae7b8db498c106e108a03f50419df5d7f5e2c215e7d1bd57e52"

URI_aarch64_kget = "${EPEL_MIRROR}/aarch64/Packages/k/kget-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kget;unpack=0"
SRC_URI:append = " ${URI_aarch64_kget}"
SRC_URI[aarch64_kget.sha256sum] = "da79fb0cd422c064f67e8d057f9bd93b1bd40b4fedb3bd5c467974369a8dbd0f"

URI_aarch64_kget-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kget-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kget-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kget-libs}"
SRC_URI[aarch64_kget-libs.sha256sum] = "0e617d7a4f07df58474355021034995f6e3b7b98887dd0484848bc9fc9f24d56"

RDEPENDS:kget = " \
 glibc \
 gpgmepp \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knotifyconfig \
 kf6-kstatusnotifieritem \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kget-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kget-libs = " \
 glibc \
 gpgmepp \
 kf6-kcmutils \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kget \
 libgcc \
 libktorrent \
 libmms \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
