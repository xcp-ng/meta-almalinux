# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-RecordParser"
PV = "1.6.5"
PR = "34.el10_2"
PACKAGES = " \
 perl-Text-RecordParser \
 perl-Text-RecordParser-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-RecordParser-1.6.5-34.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56214f6ee64e3dc8a4828601a90b9853efdf3a5ee7e4f84ccf85162bfba59d0f"

URI_x86_64_v2_perl-Text-RecordParser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-RecordParser-1.6.5-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-RecordParser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-RecordParser}"
SRC_URI[x86_64_v2_perl-Text-RecordParser.sha256sum] = "42fe10d6e49ef7781c9a5892174a2a6abc25a64a535d9b8040928977e7e9858b"

URI_x86_64_v2_perl-Text-RecordParser-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-RecordParser-tools-1.6.5-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-RecordParser-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-RecordParser-tools}"
SRC_URI[x86_64_v2_perl-Text-RecordParser-tools.sha256sum] = "4850ba786e54164b334dc1a3b27fdcc2c680713ad09c1fb18a52cfcb38eca564"

URI_aarch64_perl-Text-RecordParser = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-RecordParser-1.6.5-34.el10_2.noarch.rpm;name=aarch64_perl-Text-RecordParser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-RecordParser}"
SRC_URI[aarch64_perl-Text-RecordParser.sha256sum] = "eedb6ea961718fd75f8dc4046086a303cbcc0de4639b9f412f2d53cb88f177f2"

URI_aarch64_perl-Text-RecordParser-tools = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-RecordParser-tools-1.6.5-34.el10_2.noarch.rpm;name=aarch64_perl-Text-RecordParser-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-RecordParser-tools}"
SRC_URI[aarch64_perl-Text-RecordParser-tools.sha256sum] = "bf49a8226478b88a1aafdbd07597ffb75cd8f55105a802e80a758e59315ab260"

RDEPENDS:perl-Text-RecordParser = " \
 perl-Carp \
 perl-Class-Accessor \
 perl-IO-stringy \
 perl-List-MoreUtils \
 perl-Readonly \
 perl-Text-ParseWords \
 perl-Text-RecordParser \
 perl-base \
 perl-libs \
 perl-version \
 "
RDEPENDS:perl-Text-RecordParser-tools = " \
 perl-English \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-GraphViz \
 perl-Pod-Usage \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-Text-Autoformat \
 perl-Text-RecordParser \
 perl-Text-TabularDisplay \
 perl-interpreter \
 perl-libs \
 perl-version \
 "
