# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-matcher"
PV = "0.1.7"
PR = "3.el10_0"
PACKAGES = " \
 rust-grep-matcher+default-devel \
 rust-grep-matcher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-matcher-0.1.7-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28cfd092b797d094b3e580ca3b31ffb9022d54d4e1398ff95452c96c0d4a0f3b"

URI_x86_64_v2_rust-grep-matcher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-matcher+default-devel-0.1.7-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-matcher+default-devel}"
SRC_URI[x86_64_v2_rust-grep-matcher+default-devel.sha256sum] = "d78213c7cffaeb6e8e3b07c11efc071d9f92c3024226ab0ec1219b377a258775"

URI_x86_64_v2_rust-grep-matcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-matcher-devel-0.1.7-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-matcher-devel}"
SRC_URI[x86_64_v2_rust-grep-matcher-devel.sha256sum] = "a6cb66b515bc7ccd665b7d37c3c0d0516e6bf065eae70348a580f2c1b27c56dd"

URI_aarch64_rust-grep-matcher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-matcher+default-devel-0.1.7-3.el10_0.noarch.rpm;name=aarch64_rust-grep-matcher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-matcher+default-devel}"
SRC_URI[aarch64_rust-grep-matcher+default-devel.sha256sum] = "0902da9666bca3fcb8fa746e5b029e42e1c65f8ec108fa0956421235c71931a5"

URI_aarch64_rust-grep-matcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-matcher-devel-0.1.7-3.el10_0.noarch.rpm;name=aarch64_rust-grep-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-matcher-devel}"
SRC_URI[aarch64_rust-grep-matcher-devel.sha256sum] = "493c21a49550f65c5f0bb186d1d8ded86b8197e1d8065ba47c34c61ebbb8136a"

RDEPENDS:rust-grep-matcher+default-devel = " \
 cargo \
 rust-grep-matcher-devel \
 "
RDEPENDS:rust-grep-matcher-devel = " \
 cargo \
 rust-memchr+default-devel \
 "
