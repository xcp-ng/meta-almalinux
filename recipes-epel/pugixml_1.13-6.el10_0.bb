# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pugixml"
PV = "1.13"
PR = "6.el10_0"
PACKAGES = " \
 pugixml \
 pugixml-devel \
 pugixml-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pugixml-1.13-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fb3eb7cfc674052cb56bd9f2eea1e2ebf683f934207f1b194446fec459b881bd"

URI_x86_64_v2_pugixml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pugixml-1.13-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pugixml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pugixml}"
SRC_URI[x86_64_v2_pugixml.sha256sum] = "35f42c176f0cf9ee7315e6ab4cbaedd173c3237358ca52e3e6393bec33af8c1d"

URI_x86_64_v2_pugixml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pugixml-devel-1.13-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pugixml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pugixml-devel}"
SRC_URI[x86_64_v2_pugixml-devel.sha256sum] = "0c1fae82eb0862e07efed9001c6f7eb466e8dc56e9bcd705b16d189237edd2e1"

URI_x86_64_v2_pugixml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pugixml-doc-1.13-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pugixml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pugixml-doc}"
SRC_URI[x86_64_v2_pugixml-doc.sha256sum] = "ed8b88ca791b2a3e24db3507d6c7bbcd7c97ce946596566f4a9241097839e025"

URI_aarch64_pugixml = "${EPEL_MIRROR}/aarch64/Packages/p/pugixml-1.13-6.el10_0.aarch64.rpm;name=aarch64_pugixml;unpack=0"
SRC_URI:append = " ${URI_aarch64_pugixml}"
SRC_URI[aarch64_pugixml.sha256sum] = "f943b52023d40a8994b33de4cadf72c113dc577759253460289aecaebd118828"

URI_aarch64_pugixml-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pugixml-devel-1.13-6.el10_0.aarch64.rpm;name=aarch64_pugixml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pugixml-devel}"
SRC_URI[aarch64_pugixml-devel.sha256sum] = "ad8d6ee8e29e6ffc5c0b20e3c480822128eabf6443a291e513ad489c6303e22b"

URI_aarch64_pugixml-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pugixml-doc-1.13-6.el10_0.aarch64.rpm;name=aarch64_pugixml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pugixml-doc}"
SRC_URI[aarch64_pugixml-doc.sha256sum] = "3dfdcaa0a681643057141671bc1c3befbc7f3ee4af0e91ed7d551c0d2d9e585b"

RDEPENDS:pugixml = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:pugixml-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pugixml \
 "
RDEPENDS:pugixml-doc = " \
 pugixml \
 "
