# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-lpmd"
PV = "0.1.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 intel-lpmd \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/intel-lpmd-0.1.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5645c727293dfb3e417df96af899f85c4ded8af445e96043e89aee8975ca1ed7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/intel-lpmd-0.1.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_intel-lpmd;unpack=0"
SRC_URI[x86_64_v2_intel-lpmd.sha256sum] = "fde497627d45c2faf5bfb3a2eafbfea040b83f2f5df2caa9dc0065f46301690a"

RDEPENDS:intel-lpmd = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 libnl3 \
 libxml2 \
 systemd-libs \
 upower-libs \
 "
