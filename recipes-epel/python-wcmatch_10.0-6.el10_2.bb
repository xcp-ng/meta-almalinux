# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wcmatch"
PV = "10.0"
PR = "6.el10_2"
PACKAGES = " \
 python3-wcmatch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-wcmatch-10.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70980c4d8e88354ac11e5627e2a54bbf03bdfe45e14a7b7c8368fc01ac03f615"

URI_x86_64_v2_python3-wcmatch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wcmatch-10.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-wcmatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wcmatch}"
SRC_URI[x86_64_v2_python3-wcmatch.sha256sum] = "450916bf64b3eb9061eb4e31e3272620f42b1e3714166603495bea7ed3aeb463"

URI_aarch64_python3-wcmatch = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wcmatch-10.0-6.el10_2.noarch.rpm;name=aarch64_python3-wcmatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wcmatch}"
SRC_URI[aarch64_python3-wcmatch.sha256sum] = "ff958944ea997a913314b4aa51671d63699a793a267e463e42442d25d0f759ff"

RDEPENDS:python3-wcmatch = " \
 python3 \
 python3-bracex \
 "
