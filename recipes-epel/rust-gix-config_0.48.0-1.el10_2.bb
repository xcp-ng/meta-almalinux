# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-config"
PV = "0.48.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-config+default-devel \
 rust-gix-config+document-features-devel \
 rust-gix-config+serde-devel \
 rust-gix-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-config-0.48.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de8fa3881bdcf633de095cd2385a96ffbf52f1f497b81f2509b53f08f6fec73b"

URI_x86_64_v2_rust-gix-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+default-devel-0.48.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+default-devel}"
SRC_URI[x86_64_v2_rust-gix-config+default-devel.sha256sum] = "a88567fc26b17bcd243dd11464c45adc624489369d644f9188ccb0444850a172"

URI_x86_64_v2_rust-gix-config+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+document-features-devel-0.48.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-config+document-features-devel.sha256sum] = "2b8dcda5c01bcfb19a28be4d25e9df2718e56652315d0b7e947747aab133a04a"

URI_x86_64_v2_rust-gix-config+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config+serde-devel-0.48.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-config+serde-devel.sha256sum] = "ed7ecded81303190ef31a4fb8f07f86d1a314f5349d11430c7d656ae9077b8e4"

URI_x86_64_v2_rust-gix-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-config-devel-0.48.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-config-devel}"
SRC_URI[x86_64_v2_rust-gix-config-devel.sha256sum] = "a78c25db7de3542ef6b19d598259ca6c0b648ae9e66e10496fb39521ff5b3a2d"

URI_aarch64_rust-gix-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+default-devel-0.48.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+default-devel}"
SRC_URI[aarch64_rust-gix-config+default-devel.sha256sum] = "3f67e4c7e715bd08834c1527cf9fb784fb457d7dde77acf60dfd0b8990fcdabf"

URI_aarch64_rust-gix-config+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+document-features-devel-0.48.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-config+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+document-features-devel}"
SRC_URI[aarch64_rust-gix-config+document-features-devel.sha256sum] = "b8d1b19099d17bbcff472877d0ddc82b0f21bd53c62de65983801fca8d2eac0f"

URI_aarch64_rust-gix-config+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config+serde-devel-0.48.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-config+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config+serde-devel}"
SRC_URI[aarch64_rust-gix-config+serde-devel.sha256sum] = "24fc440163a20395ad55ba2306302e3225d76d87376b64e308cb6bfab5295b53"

URI_aarch64_rust-gix-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-config-devel-0.48.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-config-devel}"
SRC_URI[aarch64_rust-gix-config-devel.sha256sum] = "756fe3a34955fa19193fb7976521be4a8a8d707f8389d9fc73e2b476f771d624"

RDEPENDS:rust-gix-config+default-devel = " \
 cargo \
 rust-gix-config-devel \
 "
RDEPENDS:rust-gix-config+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-config-devel \
 "
RDEPENDS:rust-gix-config+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-config-devel \
 rust-gix-config-value+serde-devel \
 rust-gix-glob+serde-devel \
 rust-gix-ref+serde-devel \
 rust-gix-sec+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-config-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-config-value+default-devel \
 rust-gix-features+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-sec+default-devel \
 rust-memchr+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-bom+default-devel \
 rust-winnow+default-devel \
 rust-winnow+simd-devel \
 "
