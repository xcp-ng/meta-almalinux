# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-test"
PV = "0.2.5"
PR = "3.el10_0"
PACKAGES = " \
 rust-tracing-test+default-devel \
 rust-tracing-test+no-env-filter-devel \
 rust-tracing-test-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-test-0.2.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a5bf41747de6a1b4612ab4ddff33af62bd420c4260873771522a31d6fe4161f6"

URI_x86_64_v2_rust-tracing-test+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-test+default-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-test+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-test+default-devel.sha256sum] = "d58e969da9816b4ab0a3844010e7d63e4246ec5980cb13e87b6ac8783b62cc51"

URI_x86_64_v2_rust-tracing-test+no-env-filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-test+no-env-filter-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-test+no-env-filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-test+no-env-filter-devel}"
SRC_URI[x86_64_v2_rust-tracing-test+no-env-filter-devel.sha256sum] = "82d36cf32b5020ccc1355202081498af78772aad096ca5511b927cce1a29e6cf"

URI_x86_64_v2_rust-tracing-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-test-devel-0.2.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-test-devel}"
SRC_URI[x86_64_v2_rust-tracing-test-devel.sha256sum] = "da523b964504925f1edd7ee6b6e9e26f09ff88a0eb964bc000dc56e8ad4972db"

URI_aarch64_rust-tracing-test+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-test+default-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-test+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-test+default-devel}"
SRC_URI[aarch64_rust-tracing-test+default-devel.sha256sum] = "f460ddae5e1d68a6c824edd03160a24409d68627b5ff4113474874d7c726f3a5"

URI_aarch64_rust-tracing-test+no-env-filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-test+no-env-filter-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-test+no-env-filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-test+no-env-filter-devel}"
SRC_URI[aarch64_rust-tracing-test+no-env-filter-devel.sha256sum] = "72e828fc1a68eb930e8549ac5adb213c7e1e510dcadacc2a8cea7697ae841217"

URI_aarch64_rust-tracing-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-test-devel-0.2.5-3.el10_0.noarch.rpm;name=aarch64_rust-tracing-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-test-devel}"
SRC_URI[aarch64_rust-tracing-test-devel.sha256sum] = "3db910fc3b866c9e7b865c466dc8e464a42dad4c368b2e575903fc1b504c56dc"

RDEPENDS:rust-tracing-test+default-devel = " \
 cargo \
 rust-tracing-test-devel \
 "
RDEPENDS:rust-tracing-test+no-env-filter-devel = " \
 cargo \
 rust-tracing-test-devel \
 rust-tracing-test-macro+no-env-filter-devel \
 "
RDEPENDS:rust-tracing-test-devel = " \
 cargo \
 rust-tracing-core+default-devel \
 rust-tracing-subscriber+default-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-test-macro+default-devel \
 "
