# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "killbots"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 killbots \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/killbots-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42164b6136488ce8fac102f843d7e08d51334b4edd2f3e467bd3aa0a23a8b9f2"

URI_x86_64_v2_killbots = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/killbots-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_killbots;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_killbots}"
SRC_URI[x86_64_v2_killbots.sha256sum] = "1dbd04e258829569e41607b1681bf2bebf09982e51aae1c1733bc71e95d40aa1"

URI_aarch64_killbots = "${EPEL_MIRROR}/aarch64/Packages/k/killbots-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_killbots;unpack=0"
SRC_URI:append = " ${URI_aarch64_killbots}"
SRC_URI[aarch64_killbots.sha256sum] = "432dc49f39291f93667e555592d7e5751e75f1b177f8c2eb575dc16f80634cc4"

RDEPENDS:killbots = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
