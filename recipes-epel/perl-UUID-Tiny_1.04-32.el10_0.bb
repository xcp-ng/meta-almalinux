# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-UUID-Tiny"
PV = "1.04"
PR = "32.el10_0"
PACKAGES = " \
 perl-UUID-Tiny \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-UUID-Tiny-1.04-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7594ada1ced55872fbadbefecbe17f5d0b70037c93a21e14c9a3266cb7b16411"

URI_x86_64_v2_perl-UUID-Tiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-UUID-Tiny-1.04-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-UUID-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-UUID-Tiny}"
SRC_URI[x86_64_v2_perl-UUID-Tiny.sha256sum] = "0ed9fc7ee44494408a6df1f479a366a91995313e393fce4439f443c58f17aa3d"

URI_aarch64_perl-UUID-Tiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-UUID-Tiny-1.04-32.el10_0.noarch.rpm;name=aarch64_perl-UUID-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-UUID-Tiny}"
SRC_URI[aarch64_perl-UUID-Tiny.sha256sum] = "77c198ef3b3b0c4a3acbca803e5dc22e345839ec756dd5c215eadd83b0964977"

RDEPENDS:perl-UUID-Tiny = " \
 perl-Carp \
 perl-Digest-MD5 \
 perl-Digest-SHA1 \
 perl-Exporter \
 perl-MIME-Base64 \
 perl-POSIX \
 perl-Time-HiRes \
 perl-libs \
 "
