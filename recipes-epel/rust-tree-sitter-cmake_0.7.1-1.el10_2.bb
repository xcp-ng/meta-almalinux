# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-cmake"
PV = "0.7.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-cmake+default-devel \
 rust-tree-sitter-cmake-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-cmake-0.7.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c12798572a62cd336166f9139dd87f70c013740345e797882a208068455288d"

URI_x86_64_v2_rust-tree-sitter-cmake+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cmake+default-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cmake+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cmake+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cmake+default-devel.sha256sum] = "3112fa58bd9215aa9659d496e4bcb38f3a2bb8f3fd5d166768f2981d090d87a2"

URI_x86_64_v2_rust-tree-sitter-cmake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-cmake-devel-0.7.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-cmake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-cmake-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-cmake-devel.sha256sum] = "77d2ffef44fc02feb9bc97ab1bde8324090684d62a976a233411dfe1441a6440"

URI_aarch64_rust-tree-sitter-cmake+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cmake+default-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-cmake+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cmake+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-cmake+default-devel.sha256sum] = "c0a7796f3511ee003b5999830bae47e03f968f143fe2fa6de4755c5b0955b84b"

URI_aarch64_rust-tree-sitter-cmake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-cmake-devel-0.7.1-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-cmake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-cmake-devel}"
SRC_URI[aarch64_rust-tree-sitter-cmake-devel.sha256sum] = "08589d65c0e6bd1fc90b67878091e082a7973fdca8aff30978ae0814364e38d4"

RDEPENDS:rust-tree-sitter-cmake+default-devel = " \
 cargo \
 rust-tree-sitter-cmake-devel \
 "
RDEPENDS:rust-tree-sitter-cmake-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
