# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-char_str"
PV = "0.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-char_str+arbitrary-devel \
 rust-char_str+default-devel \
 rust-char_str+get-size-devel \
 rust-char_str+serde-devel \
 rust-char_str+std-devel \
 rust-char_str-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-char_str-0.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c8a046734b991c910b2f64a304bc6db00264426b8361603bea865837e4e4143a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-char_str+arbitrary-devel-0.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-char_str+arbitrary-devel;unpack=0"
SRC_URI[x86_64_v2_rust-char_str+arbitrary-devel.sha256sum] = "54b556ab9c50b0ea125d9ba2093e33e3b2d7f17e9d9fa5a3d31910f1e88b862b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-char_str+default-devel-0.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-char_str+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-char_str+default-devel.sha256sum] = "96795478dbc24eb7a13bc66ebb6485ff40e26938fa4cad52f41d421424fd7427"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-char_str+get-size-devel-0.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-char_str+get-size-devel;unpack=0"
SRC_URI[x86_64_v2_rust-char_str+get-size-devel.sha256sum] = "f3d9092f056d1c9b59fb6a417f8af09255c239376401c34cf5b4dcb148cd2370"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-char_str+serde-devel-0.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-char_str+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-char_str+serde-devel.sha256sum] = "44c196cf2fb8a0c4bbb73cc66d5266727922d6f3b82dc2ae37b48439fdbec13e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-char_str+std-devel-0.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-char_str+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-char_str+std-devel.sha256sum] = "1b02839285ddb7bfcb1c25ebfd67fd60d780905d577ec1cc4bddd458f7a4f300"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-char_str-devel-0.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-char_str-devel;unpack=0"
SRC_URI[x86_64_v2_rust-char_str-devel.sha256sum] = "e0bcd86137b79a8d3f27cbf56ad9a0dc124afcd6120f91768dd010a36e9a4ebd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-char_str+arbitrary-devel-0.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-char_str+arbitrary-devel;unpack=0"
SRC_URI[aarch64_rust-char_str+arbitrary-devel.sha256sum] = "934101caf6a1760356172a8848c4f1ae9361db5f7fac502c142782eba749a08d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-char_str+default-devel-0.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-char_str+default-devel;unpack=0"
SRC_URI[aarch64_rust-char_str+default-devel.sha256sum] = "0131184e30e8358a224240e997495882eaf2a84f2ff8a90f3cbb4b400d53246d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-char_str+get-size-devel-0.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-char_str+get-size-devel;unpack=0"
SRC_URI[aarch64_rust-char_str+get-size-devel.sha256sum] = "11437121be7a0974e30996e43733626cd07cf665cb49b94480272be918acedb2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-char_str+serde-devel-0.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-char_str+serde-devel;unpack=0"
SRC_URI[aarch64_rust-char_str+serde-devel.sha256sum] = "d707e7766ab17b994000f4f131106a17a6a30432eaa47218bf7d907817895464"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-char_str+std-devel-0.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-char_str+std-devel;unpack=0"
SRC_URI[aarch64_rust-char_str+std-devel.sha256sum] = "3bae10b80d9809da16e4b6a59c37f2b793cac0b5d286c72b1a632b754fdefc1d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-char_str-devel-0.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-char_str-devel;unpack=0"
SRC_URI[aarch64_rust-char_str-devel.sha256sum] = "8bd28454d7066ccc2c5229edb883c2a7e06b7f24f21ead941a6758089158689c"

RDEPENDS:rust-char_str+arbitrary-devel = " \
 cargo \
 rust-arbitrary-devel \
 rust-char_str-devel \
 "
RDEPENDS:rust-char_str+default-devel = " \
 cargo \
 rust-char_str+std-devel \
 rust-char_str-devel \
 "
RDEPENDS:rust-char_str+get-size-devel = " \
 cargo \
 rust-char_str+std-devel \
 rust-char_str-devel \
 rust-get-size2+default-devel \
 "
RDEPENDS:rust-char_str+serde-devel = " \
 cargo \
 rust-char_str-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-char_str+std-devel = " \
 cargo \
 rust-char_str-devel \
 "
RDEPENDS:rust-char_str-devel = " \
 cargo \
 rust-castaway+alloc-devel \
 rust-castaway-devel \
 rust-itoa+default-devel \
 rust-ryu+default-devel \
 "
