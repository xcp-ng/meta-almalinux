# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "casc"
PV = "1.0.5"
PR = "15.el10_0"
PACKAGES = " \
 casc-devel \
 casc-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/casc-1.0.5-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d91c155142434c0167fb57382b546a188c6e8ceb9d8aa50b1d2364628f49690f"

URI_x86_64_v2_casc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/casc-devel-1.0.5-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_casc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_casc-devel}"
SRC_URI[x86_64_v2_casc-devel.sha256sum] = "f39be4b62ecb0fb28c59c2ff6c3d627ab81d4527fcb36dd9b83eb746b74a27f2"

URI_x86_64_v2_casc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/casc-doc-1.0.5-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_casc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_casc-doc}"
SRC_URI[x86_64_v2_casc-doc.sha256sum] = "70f06dc43c498f176f1e3852766ee58e08863cc02b1b20ca6cfc93044a1a10b3"

URI_aarch64_casc-devel = "${EPEL_MIRROR}/aarch64/Packages/c/casc-devel-1.0.5-15.el10_0.noarch.rpm;name=aarch64_casc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_casc-devel}"
SRC_URI[aarch64_casc-devel.sha256sum] = "4ab174338a337b61891515d4908f516911bcff06c2acac806b50eda825588605"

URI_aarch64_casc-doc = "${EPEL_MIRROR}/aarch64/Packages/c/casc-doc-1.0.5-15.el10_0.noarch.rpm;name=aarch64_casc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_casc-doc}"
SRC_URI[aarch64_casc-doc.sha256sum] = "85741dfb6aa2c252d1dd8c45a08586ab11c110c863d4191ded52d93368c35412"

RDEPENDS:casc-devel = " \
 "
RDEPENDS:casc-doc = " \
 "
