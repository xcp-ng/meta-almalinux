# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string_cache_codegen0.5"
PV = "0.5.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-string_cache_codegen0.5+default-devel \
 rust-string_cache_codegen0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string_cache_codegen0.5-0.5.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0905c53aff2838223952de0e962df243a2b756d51f401ab9816b7378592031ed"

URI_x86_64_v2_rust-string_cache_codegen0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache_codegen0.5+default-devel-0.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache_codegen0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache_codegen0.5+default-devel}"
SRC_URI[x86_64_v2_rust-string_cache_codegen0.5+default-devel.sha256sum] = "512962663fc6e25fea543842bc8060f4dccdb507ea12216b8cd7f873c70178cd"

URI_x86_64_v2_rust-string_cache_codegen0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache_codegen0.5-devel-0.5.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache_codegen0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache_codegen0.5-devel}"
SRC_URI[x86_64_v2_rust-string_cache_codegen0.5-devel.sha256sum] = "339cd73101595f50f3cf0e692d4665926ca6fa7fa9b1a927c5f22d09320318c2"

URI_aarch64_rust-string_cache_codegen0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache_codegen0.5+default-devel-0.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache_codegen0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache_codegen0.5+default-devel}"
SRC_URI[aarch64_rust-string_cache_codegen0.5+default-devel.sha256sum] = "d4903b2398f0e56126ba4966a75a41abce14be7ef3c86bea864d9cea272643a4"

URI_aarch64_rust-string_cache_codegen0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache_codegen0.5-devel-0.5.4-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache_codegen0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache_codegen0.5-devel}"
SRC_URI[aarch64_rust-string_cache_codegen0.5-devel.sha256sum] = "d834b3929388e27e026910c06a4b7e9f33145d85f944f6a3923fa49c3b5b50e9"

RDEPENDS:rust-string_cache_codegen0.5+default-devel = " \
 cargo \
 rust-string_cache_codegen0.5-devel \
 "
RDEPENDS:rust-string_cache_codegen0.5-devel = " \
 cargo \
 rust-phf_generator0.11+default-devel \
 rust-phf_shared0.11+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 "
