# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntfs-3g"
PE = "2"
PV = "2026.2.25"
PR = "2.el10_3"
PACKAGES = " \
 ntfs-3g \
 ntfs-3g-devel \
 ntfs-3g-libs \
 ntfsprogs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntfs-3g-2026.2.25-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9479426e4c2c05feaeb0a3470250c75e1e3a35b4d95504895e9c74af921b4356"

URI_x86_64_v2_ntfs-3g = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-2026.2.25-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g}"
SRC_URI[x86_64_v2_ntfs-3g.sha256sum] = "492f86a853b998fe2693f280af01f1a3b51e11fe4736562825c78470944f18a9"

URI_x86_64_v2_ntfs-3g-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-devel-2026.2.25-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-devel}"
SRC_URI[x86_64_v2_ntfs-3g-devel.sha256sum] = "e78ff3beb4b5b94492a8c4117242932c18651f1f79317defd2f5a75989268010"

URI_x86_64_v2_ntfs-3g-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-libs-2026.2.25-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-libs}"
SRC_URI[x86_64_v2_ntfs-3g-libs.sha256sum] = "8e43ad29f8a858b048484cee218ae80737197a60aae2584ca47e9604d7f880c7"

URI_x86_64_v2_ntfsprogs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfsprogs-2026.2.25-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfsprogs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfsprogs}"
SRC_URI[x86_64_v2_ntfsprogs.sha256sum] = "3b65ede22f12df5d45c38291e8bd5d6a5df24709ff988b7c389458bf0a861d4b"

URI_aarch64_ntfs-3g = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-2026.2.25-2.el10_3.aarch64.rpm;name=aarch64_ntfs-3g;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g}"
SRC_URI[aarch64_ntfs-3g.sha256sum] = "c186669cd8a2ecc58e2a5f8153414a6cd0c9fac3cf5a5edd5b74ddbec6e563d5"

URI_aarch64_ntfs-3g-devel = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-devel-2026.2.25-2.el10_3.aarch64.rpm;name=aarch64_ntfs-3g-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-devel}"
SRC_URI[aarch64_ntfs-3g-devel.sha256sum] = "7fc326538c87279c2e39a6684330123da15e8b57fff1ddc2bd26bda89cb72932"

URI_aarch64_ntfs-3g-libs = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-libs-2026.2.25-2.el10_3.aarch64.rpm;name=aarch64_ntfs-3g-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-libs}"
SRC_URI[aarch64_ntfs-3g-libs.sha256sum] = "70d5d4feebd1eec7d0b29887c940ecedd0e3cc2504b69a1e1d1b72cffb58da1b"

URI_aarch64_ntfsprogs = "${EPEL_MIRROR}/aarch64/Packages/n/ntfsprogs-2026.2.25-2.el10_3.aarch64.rpm;name=aarch64_ntfsprogs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfsprogs}"
SRC_URI[aarch64_ntfsprogs.sha256sum] = "68a9f34c4e3ba0420fd87c1b770432ccfb5b7d86dbaeb94df038757655a16bd6"

RDEPENDS:ntfs-3g = " \
 glibc \
 ntfs-3g-libs \
 "
RDEPENDS:ntfs-3g-devel = " \
 ntfs-3g-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:ntfs-3g-libs = " \
 glibc \
 "
RDEPENDS:ntfsprogs = " \
 glibc \
 gnutls \
 libgcrypt \
 libuuid \
 ntfs-3g-libs \
 "
