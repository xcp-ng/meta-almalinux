# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fwupd-efi"
PV = "1.6"
PR = "6.el10_1.alma.1"
PACKAGES = " \
 fwupd-efi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/fwupd-efi-1.6-6.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9993d7f2d1e18c25e0a69420a2e132d0cd9fddae8308c6344168e83137b47f1d"

URI_x86_64_v2_fwupd-efi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/fwupd-efi-1.6-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_fwupd-efi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwupd-efi}"
SRC_URI[x86_64_v2_fwupd-efi.sha256sum] = "376f3aa39671bd6f3733cba848c66b00938c2774d303480ad4a5e96cc1f26f4e"

URI_aarch64_fwupd-efi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/fwupd-efi-1.6-6.el10_1.alma.1.aarch64.rpm;name=aarch64_fwupd-efi;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwupd-efi}"
SRC_URI[aarch64_fwupd-efi.sha256sum] = "b9c1b365743388fdef52b95c91028afe95063cc76f9bbba166d444038c136f28"

RDEPENDS:fwupd-efi = " \
 pkgconf-pkg-config \
 "
