# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-testfixtures"
PV = "8.3.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-testfixtures \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-testfixtures-8.3.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56ad278bae0518b2a306018d1b093c17ab554c496137819c7054bae9d357f21e"

URI_x86_64_v2_python3-testfixtures = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-testfixtures-8.3.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-testfixtures;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-testfixtures}"
SRC_URI[x86_64_v2_python3-testfixtures.sha256sum] = "0a7425c9842686dd5bb440e9e21ce8649bff45ca5b1220b10cd813a71282da2e"

URI_aarch64_python3-testfixtures = "${EPEL_MIRROR}/aarch64/Packages/p/python3-testfixtures-8.3.0-2.el10_0.noarch.rpm;name=aarch64_python3-testfixtures;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-testfixtures}"
SRC_URI[aarch64_python3-testfixtures.sha256sum] = "7aadb15bc86a3806751bf8b6936fe094a9a7586aafee132855fd19576704893c"

RDEPENDS:python3-testfixtures = " \
 python3 \
 "
