# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-fedora-autoloader"
PV = "1.0.1"
PR = "7.el10_0"
PACKAGES = " \
 php-fedora-autoloader \
 php-fedora-autoloader-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-fedora-autoloader-1.0.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af88a4ccaa77875e82fa0f89c085f4105269c2c56b60580172643fc955b757b7"

URI_x86_64_v2_php-fedora-autoloader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-fedora-autoloader-1.0.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_php-fedora-autoloader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-fedora-autoloader}"
SRC_URI[x86_64_v2_php-fedora-autoloader.sha256sum] = "e362d5c60f7ca82519f4da3a06b24d17f2b63ed9b4c87360f79af6bb341ad8c3"

URI_x86_64_v2_php-fedora-autoloader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-fedora-autoloader-devel-1.0.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_php-fedora-autoloader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-fedora-autoloader-devel}"
SRC_URI[x86_64_v2_php-fedora-autoloader-devel.sha256sum] = "48e6992262979a2fc1ba4a84dc6c7075f28e4077da9840d3a284c5ec6042e08a"

URI_aarch64_php-fedora-autoloader = "${EPEL_MIRROR}/aarch64/Packages/p/php-fedora-autoloader-1.0.1-7.el10_0.noarch.rpm;name=aarch64_php-fedora-autoloader;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-fedora-autoloader}"
SRC_URI[aarch64_php-fedora-autoloader.sha256sum] = "6d8dfae8dfb2ed39e9e394165cedee41916a078018b2b79757cd66ba59daa27d"

URI_aarch64_php-fedora-autoloader-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-fedora-autoloader-devel-1.0.1-7.el10_0.noarch.rpm;name=aarch64_php-fedora-autoloader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-fedora-autoloader-devel}"
SRC_URI[aarch64_php-fedora-autoloader-devel.sha256sum] = "d1ba8c0413c1c95564bc3a1ed69989dd5f2fe226fc81268355442f7420a27510"

RDEPENDS:php-fedora-autoloader = " \
 php-common \
 "
RDEPENDS:php-fedora-autoloader-devel = " \
 php-fedora-autoloader \
 php-theseer-autoload \
 "
