# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Authen-Simple"
PV = "0.5"
PR = "37.el10_0"
PACKAGES = " \
 perl-Authen-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Authen-Simple-0.5-37.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83246a49e421ac7a53bd7c5fa81b3647d8b31bd784fbbb6946e5ea018ec9a41c"

URI_x86_64_v2_perl-Authen-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Authen-Simple-0.5-37.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Authen-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Authen-Simple}"
SRC_URI[x86_64_v2_perl-Authen-Simple.sha256sum] = "a10717073882119a0e2d5be3991d3e067518a8f916b62b28e2760f72d612e5df"

URI_aarch64_perl-Authen-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Authen-Simple-0.5-37.el10_0.noarch.rpm;name=aarch64_perl-Authen-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Authen-Simple}"
SRC_URI[aarch64_perl-Authen-Simple.sha256sum] = "88af8f57a4fd587a383b44f6d34330f2b5d37182d27971f9341eb098019c4bb1"

RDEPENDS:perl-Authen-Simple = " \
 perl-Carp \
 perl-Class-Accessor \
 perl-Class-Data-Inheritable \
 perl-Crypt-PasswdMD5 \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-IO \
 perl-MIME-Base64 \
 perl-Params-Validate \
 perl-base \
 perl-constant \
 perl-libs \
 "
