# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Syntax-Keyword-Try"
PV = "0.29"
PR = "7.el10"
PACKAGES = " \
 perl-Syntax-Keyword-Try \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Syntax-Keyword-Try-0.29-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0254d24402de1f77ecf8a2e1313f55df02266cde2c4cf9499bffb690441321a"

URI_x86_64_v2_perl-Syntax-Keyword-Try = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Syntax-Keyword-Try-0.29-7.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Syntax-Keyword-Try;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Syntax-Keyword-Try}"
SRC_URI[x86_64_v2_perl-Syntax-Keyword-Try.sha256sum] = "886622aefa285454c4f555fd643c3b89c32ad7c6acc9fd306efa0162bd2fc1be"

URI_aarch64_perl-Syntax-Keyword-Try = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Syntax-Keyword-Try-0.29-7.el10.aarch64.rpm;name=aarch64_perl-Syntax-Keyword-Try;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Syntax-Keyword-Try}"
SRC_URI[aarch64_perl-Syntax-Keyword-Try.sha256sum] = "a13fbc87d5c492d5e6440cee314f36816e1bb4a039dab4dfff1033663114431c"

RDEPENDS:perl-Syntax-Keyword-Try = " \
 glibc \
 perl-B \
 perl-Carp \
 perl-XS-Parse-Keyword \
 perl-constant \
 perl-libs \
 "
