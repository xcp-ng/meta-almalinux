# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fxload"
PV = "2008_10_13"
PR = "30.el10"
PACKAGES = " \
 fxload \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/fxload-2008_10_13-30.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ce02771c83db0b3b789755c0509f7c5157024c5a4508f983e56aa01ee959af68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fxload-2008_10_13-30.el10.x86_64_v2.rpm;name=x86_64_v2_fxload;unpack=0"
SRC_URI[x86_64_v2_fxload.sha256sum] = "0faced8d24d150c6b7fb0a006d84a1d46008aef1425349c07b2f6cb7602b92b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fxload-2008_10_13-30.el10.aarch64.rpm;name=aarch64_fxload;unpack=0"
SRC_URI[aarch64_fxload.sha256sum] = "4f4eb5dd0028dab4cf675bf3da26d244c201f27622bdb15dbcfc2fb9fb7911e5"

RDEPENDS:fxload = " \
 glibc \
 systemd-udev \
 "
