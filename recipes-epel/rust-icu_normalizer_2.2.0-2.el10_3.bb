# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_normalizer"
PV = "2.2.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_normalizer+datagen-devel \
 rust-icu_normalizer+default-devel \
 rust-icu_normalizer+harfbuzz_traits-devel \
 rust-icu_normalizer+icu_properties-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_normalizer+utf16_iter-devel \
 rust-icu_normalizer+utf8_iter-devel \
 rust-icu_normalizer+write16-devel \
 rust-icu_normalizer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_normalizer-2.2.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "afb101e3ee37dd3fa6f0763e202638cec494371105da07578901324e9bee09fa"

URI_x86_64_v2_rust-icu_normalizer+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+compiled_data-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+compiled_data-devel.sha256sum] = "68b7a80076f886855f72e025d6b7f6478ec464bac1070e17a37b600302e29432"

URI_x86_64_v2_rust-icu_normalizer+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+datagen-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+datagen-devel.sha256sum] = "8a5ea796bcc88bb0ef21ee44031546186e5a7ec38d4d2bce918523962f0c0994"

URI_x86_64_v2_rust-icu_normalizer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+default-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+default-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+default-devel.sha256sum] = "e62524cf15476b4879ddb5ba4b6053696471300c64c8f9a20438fb5e7fe70bc0"

URI_x86_64_v2_rust-icu_normalizer+harfbuzz_traits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+harfbuzz_traits-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+harfbuzz_traits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+harfbuzz_traits-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+harfbuzz_traits-devel.sha256sum] = "84b159e9fd9acbfd9aa07602bfad6ba2703eb3a01902da8a093e69eaa8d13c06"

URI_x86_64_v2_rust-icu_normalizer+icu_properties-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+icu_properties-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+icu_properties-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+icu_properties-devel.sha256sum] = "e788fceddca51c46895781952427a784a14f8367ba49effb6207897892c637ed"

URI_x86_64_v2_rust-icu_normalizer+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+serde-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+serde-devel.sha256sum] = "5ab67c2cec0b766218c3c67c723060541c5d00155e4f1dca193805cb414eb350"

URI_x86_64_v2_rust-icu_normalizer+utf16_iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+utf16_iter-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+utf16_iter-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+utf16_iter-devel.sha256sum] = "fe3cf89827df27e00b95c92a983e9147cf520ae4a4b9a13b46c0d6cb5c37ca67"

URI_x86_64_v2_rust-icu_normalizer+utf8_iter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+utf8_iter-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+utf8_iter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+utf8_iter-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+utf8_iter-devel.sha256sum] = "667535a4abc30da2b396dfec336a45d84d69b54472cd97da966f1c910b15e042"

URI_x86_64_v2_rust-icu_normalizer+write16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer+write16-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer+write16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer+write16-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer+write16-devel.sha256sum] = "ef2bcc6aeb8f0887f5bbec1c2bb9642d60a9cd533606db0e4e2052befa7daf47"

URI_x86_64_v2_rust-icu_normalizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer-devel-2.2.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer-devel.sha256sum] = "b24eae276c19d5a699a173c7260d1a94f4c1dfb3fa61bb7e116e3bdc3fdeb07b"

URI_aarch64_rust-icu_normalizer+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+compiled_data-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_normalizer+compiled_data-devel.sha256sum] = "a59c512487f20f155e3715eff2fec2365f3d21563ed6a82073be0027ca6f3ad0"

URI_aarch64_rust-icu_normalizer+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+datagen-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+datagen-devel}"
SRC_URI[aarch64_rust-icu_normalizer+datagen-devel.sha256sum] = "f152bdb8de35a69406a7aa2ad4d26ec1432a039732adceb6fd5c8b6988eb50a8"

URI_aarch64_rust-icu_normalizer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+default-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+default-devel}"
SRC_URI[aarch64_rust-icu_normalizer+default-devel.sha256sum] = "6f65f7814937b302a79a577b6934ed0d4b5683186c64633b3e5f1c80296506e9"

URI_aarch64_rust-icu_normalizer+harfbuzz_traits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+harfbuzz_traits-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer+harfbuzz_traits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+harfbuzz_traits-devel}"
SRC_URI[aarch64_rust-icu_normalizer+harfbuzz_traits-devel.sha256sum] = "baf4e73580c76decc3b8523126a9e283154411e8101408df1bcd032777680599"

URI_aarch64_rust-icu_normalizer+icu_properties-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+icu_properties-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer+icu_properties-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+icu_properties-devel}"
SRC_URI[aarch64_rust-icu_normalizer+icu_properties-devel.sha256sum] = "33368088ff84c6c0129713721517c8a4e838a557eaecc117784025825acaf369"

URI_aarch64_rust-icu_normalizer+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+serde-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+serde-devel}"
SRC_URI[aarch64_rust-icu_normalizer+serde-devel.sha256sum] = "ea0ae176615f7dda612e939b51d2a38965343ec47452a957eb56fdbb59306e14"

URI_aarch64_rust-icu_normalizer+utf16_iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+utf16_iter-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer+utf16_iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+utf16_iter-devel}"
SRC_URI[aarch64_rust-icu_normalizer+utf16_iter-devel.sha256sum] = "2a203b9fb2bd7101831cb3f90d28f744539126492653b8a5d2da91ba63e38148"

URI_aarch64_rust-icu_normalizer+utf8_iter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+utf8_iter-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer+utf8_iter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+utf8_iter-devel}"
SRC_URI[aarch64_rust-icu_normalizer+utf8_iter-devel.sha256sum] = "d01751579f6649096342cf64cdebcf1f8d07c2b4291d290d29117de3dbd703a0"

URI_aarch64_rust-icu_normalizer+write16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer+write16-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer+write16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer+write16-devel}"
SRC_URI[aarch64_rust-icu_normalizer+write16-devel.sha256sum] = "71ad09fc1299fb16bb939fa046872a36f25938ae9e4ee3b088ccb45954075462"

URI_aarch64_rust-icu_normalizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer-devel-2.2.0-2.el10_3.noarch.rpm;name=aarch64_rust-icu_normalizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer-devel}"
SRC_URI[aarch64_rust-icu_normalizer-devel.sha256sum] = "85e89859827e74acc210da6865fe807092b4846efa46b1f6d778e9448b645b84"

RDEPENDS:rust-icu_normalizer+compiled_data-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-icu_normalizer_data-devel \
 rust-icu_properties+compiled_data-devel \
 rust-icu_properties-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_normalizer+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections+databake-devel \
 rust-icu_normalizer+icu_properties-devel \
 rust-icu_normalizer+serde-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties+datagen-devel \
 rust-icu_properties-devel \
 rust-icu_provider+export-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_normalizer+default-devel = " \
 cargo \
 rust-icu_normalizer+compiled_data-devel \
 rust-icu_normalizer+utf16_iter-devel \
 rust-icu_normalizer+utf8_iter-devel \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer+harfbuzz_traits-devel = " \
 cargo \
 rust-harfbuzz-traits-devel \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer+icu_properties-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-icu_properties-devel \
 "
RDEPENDS:rust-icu_normalizer+serde-devel = " \
 cargo \
 rust-icu_collections+serde-devel \
 rust-icu_normalizer-devel \
 rust-icu_properties+serde-devel \
 rust-icu_properties-devel \
 rust-icu_provider+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_normalizer+utf16_iter-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-utf16_iter-devel \
 rust-write16+alloc-devel \
 rust-write16-devel \
 "
RDEPENDS:rust-icu_normalizer+utf8_iter-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 rust-utf8_iter-devel \
 "
RDEPENDS:rust-icu_normalizer+write16-devel = " \
 cargo \
 rust-icu_normalizer-devel \
 "
RDEPENDS:rust-icu_normalizer-devel = " \
 cargo \
 rust \
 rust-icu_collections-devel \
 rust-icu_provider-devel \
 rust-smallvec-devel \
 rust-zerovec-devel \
 "
