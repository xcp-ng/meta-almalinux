# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-radium"
PV = "0.7.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-radium+default-devel \
 rust-radium-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-radium-0.7.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8209070ee715915e64cd355fb83fc77125a66cc6e804212026af9871d4dd8a03"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radium+default-devel-0.7.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radium+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-radium+default-devel.sha256sum] = "f55eb07f8dcca7ae97043cba8d69aa8ebf5c4b60f48d4d567fd04fa159e97701"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-radium-devel-0.7.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-radium-devel;unpack=0"
SRC_URI[x86_64_v2_rust-radium-devel.sha256sum] = "a2206155ea8365ffa53e9a45ee161bc76d4c9589178f52efbed23d294650a737"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-radium+default-devel-0.7.0-4.el10_0.noarch.rpm;name=aarch64_rust-radium+default-devel;unpack=0"
SRC_URI[aarch64_rust-radium+default-devel.sha256sum] = "94284d3a63c228e8330fe56937773a4f2d48053f41e61223dde28e7a9cad7de3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-radium-devel-0.7.0-4.el10_0.noarch.rpm;name=aarch64_rust-radium-devel;unpack=0"
SRC_URI[aarch64_rust-radium-devel.sha256sum] = "0d083ed152965caced57892ad9681b7aaa9c2836857c205e9221f117a966b6ac"

RDEPENDS:rust-radium+default-devel = " \
 cargo \
 rust-radium-devel \
 "
RDEPENDS:rust-radium-devel = " \
 cargo \
 "
