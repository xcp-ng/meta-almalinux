# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "blinken"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 blinken \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/blinken-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bb730ebf004c938acd7a3e43ed750afca83697a5fa3e96e4839aae8a42a80ec"

URI_x86_64_v2_blinken = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/blinken-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_blinken;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_blinken}"
SRC_URI[x86_64_v2_blinken.sha256sum] = "ed7354ec5b43a2c020354e86e41f59e4e2c40727f3a52cf231b69dd51cbe5b8d"

URI_aarch64_blinken = "${EPEL_MIRROR}/aarch64/Packages/b/blinken-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_blinken;unpack=0"
SRC_URI:append = " ${URI_aarch64_blinken}"
SRC_URI[aarch64_blinken.sha256sum] = "1fca55c460a33374cbc3ed74ee09afe0212e4d91db16c252fbb3666d3d61b1de"

RDEPENDS:blinken = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 phonon-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 sj-stevehand-fonts \
 "
