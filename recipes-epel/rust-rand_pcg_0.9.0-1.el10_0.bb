# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_pcg"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-rand_pcg+default-devel \
 rust-rand_pcg+os_rng-devel \
 rust-rand_pcg+serde-devel \
 rust-rand_pcg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_pcg-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "476f92a21c392de5c568b5724fe6bb98fada1f207b86b0d8a5427e397b47f622"

URI_x86_64_v2_rust-rand_pcg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg+default-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg+default-devel.sha256sum] = "1e7605584da9614d893c35361b8fae0f510d930e9fd7742396ac617b46826142"

URI_x86_64_v2_rust-rand_pcg+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg+os_rng-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg+os_rng-devel.sha256sum] = "508ce96ac6525980e28f5582e0477352d47d37400845e3d1fe8c6c3c0e5f53cb"

URI_x86_64_v2_rust-rand_pcg+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg+serde-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg+serde-devel.sha256sum] = "4626e7a44a411afee7cf531ea279fe841907a5847bf0323223c13fd146615b24"

URI_x86_64_v2_rust-rand_pcg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg-devel.sha256sum] = "19214e9ab1e9812f8a5bee26c0bea531a07a7ccf1f29087d3ef1f645bc496968"

URI_aarch64_rust-rand_pcg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg+default-devel}"
SRC_URI[aarch64_rust-rand_pcg+default-devel.sha256sum] = "194c8d52ad76a717b86ffbfdf9aaff8ffa7dcada5baa0517125a13a2b293ef1d"

URI_aarch64_rust-rand_pcg+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg+os_rng-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg+os_rng-devel}"
SRC_URI[aarch64_rust-rand_pcg+os_rng-devel.sha256sum] = "d4d541e9c0a9cdb040b611d1f8a396781df00fecad891473221c03a6ef796773"

URI_aarch64_rust-rand_pcg+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg+serde-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg+serde-devel}"
SRC_URI[aarch64_rust-rand_pcg+serde-devel.sha256sum] = "5989ec555b20dc5a4e75f54bf56317d3d395c1e624f6739d398ff6c25443746a"

URI_aarch64_rust-rand_pcg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg-devel}"
SRC_URI[aarch64_rust-rand_pcg-devel.sha256sum] = "2accb33ee08f782f23837a4ce7f65f7a8cff6293cb8536319e5669144a23d8a0"

RDEPENDS:rust-rand_pcg+default-devel = " \
 cargo \
 rust-rand_pcg-devel \
 "
RDEPENDS:rust-rand_pcg+os_rng-devel = " \
 cargo \
 rust-rand_core+os_rng-devel \
 rust-rand_pcg-devel \
 "
RDEPENDS:rust-rand_pcg+serde-devel = " \
 cargo \
 rust-rand_pcg-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_pcg-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
