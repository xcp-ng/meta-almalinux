# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-raw-window-handle0.5"
PV = "0.5.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-raw-window-handle0.5+alloc-devel \
 rust-raw-window-handle0.5+default-devel \
 rust-raw-window-handle0.5+std-devel \
 rust-raw-window-handle0.5-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-raw-window-handle0.5-0.5.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "576020cffc73f4559a594713f4e6b9534fff97642c8d94030ee8d2130f491d46"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-window-handle0.5+alloc-devel-0.5.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-window-handle0.5+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-raw-window-handle0.5+alloc-devel.sha256sum] = "5336aa36cc984d8d3fd2334e8ef4a6455b29b20c1f064620db96ff2590ef8498"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-window-handle0.5+default-devel-0.5.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-window-handle0.5+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-raw-window-handle0.5+default-devel.sha256sum] = "1771589f157f4c9241de85d9042e7ea4f779f2e9f436bd7181da3e3ac9d0ec7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-window-handle0.5+std-devel-0.5.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-window-handle0.5+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-raw-window-handle0.5+std-devel.sha256sum] = "c746ef1d93a4219383f3f4f1b252aad6dc5c31f2cdfeb9ab5a909c6e2e60f12d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-raw-window-handle0.5-devel-0.5.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-raw-window-handle0.5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-raw-window-handle0.5-devel.sha256sum] = "42c2f992cd9d78adf57799fdab8a733aa5f5daf7e5a4f4fe6f52eeef351dbdfd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-window-handle0.5+alloc-devel-0.5.2-3.el10_0.noarch.rpm;name=aarch64_rust-raw-window-handle0.5+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-raw-window-handle0.5+alloc-devel.sha256sum] = "fbde889d41c078e58a4e55fe0e7e1f532dd32aa88d835cc24627d6e5cd0e65b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-window-handle0.5+default-devel-0.5.2-3.el10_0.noarch.rpm;name=aarch64_rust-raw-window-handle0.5+default-devel;unpack=0"
SRC_URI[aarch64_rust-raw-window-handle0.5+default-devel.sha256sum] = "d6cdfd98742bdf5fbb8caea3bbe3007857c865658717c476ea77f8ef302c6d6d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-window-handle0.5+std-devel-0.5.2-3.el10_0.noarch.rpm;name=aarch64_rust-raw-window-handle0.5+std-devel;unpack=0"
SRC_URI[aarch64_rust-raw-window-handle0.5+std-devel.sha256sum] = "ebc7478a5db9f91e3076a2c3a1c4cbd45500d04bedf27bfe4e129578d54ca228"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-raw-window-handle0.5-devel-0.5.2-3.el10_0.noarch.rpm;name=aarch64_rust-raw-window-handle0.5-devel;unpack=0"
SRC_URI[aarch64_rust-raw-window-handle0.5-devel.sha256sum] = "3b230932d0d34116ea289372d0537f32bb64ae8cc047af1807430dc8cd9baa0b"

RDEPENDS:rust-raw-window-handle0.5+alloc-devel = " \
 cargo \
 rust-raw-window-handle0.5-devel \
 "
RDEPENDS:rust-raw-window-handle0.5+default-devel = " \
 cargo \
 rust-raw-window-handle0.5-devel \
 "
RDEPENDS:rust-raw-window-handle0.5+std-devel = " \
 cargo \
 rust-raw-window-handle0.5+alloc-devel \
 rust-raw-window-handle0.5-devel \
 "
RDEPENDS:rust-raw-window-handle0.5-devel = " \
 cargo \
 rust \
 "
