# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Glob"
PV = "0.11"
PR = "26.el10"
PACKAGES = " \
 perl-Text-Glob \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Text-Glob-0.11-26.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b144763484b83865993dadd94e6c013fde23fbc28e5b3e22e72c61226d0e0d51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Glob-0.11-26.el10.noarch.rpm;name=x86_64_v2_perl-Text-Glob;unpack=0"
SRC_URI[x86_64_v2_perl-Text-Glob.sha256sum] = "310cfa9b6f4c386904656354c718e82a8ee8c2b24da4d6822024529409bd05f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Glob-0.11-26.el10.noarch.rpm;name=aarch64_perl-Text-Glob;unpack=0"
SRC_URI[aarch64_perl-Text-Glob.sha256sum] = "310cfa9b6f4c386904656354c718e82a8ee8c2b24da4d6822024529409bd05f6"

RDEPENDS:perl-Text-Glob = " \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-vars \
 "
