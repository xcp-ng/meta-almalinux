# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix"
PV = "0.85.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix+async-network-client-async-std-devel \
 rust-gix+async-network-client-devel \
 rust-gix+async-std-devel \
 rust-gix+attributes-devel \
 rust-gix+auto-chain-error-devel \
 rust-gix+basic-devel \
 rust-gix+blame-devel \
 rust-gix+blob-diff-devel \
 rust-gix+blocking-http-transport-curl-devel \
 rust-gix+blocking-http-transport-curl-openssl-devel \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix+blocking-http-transport-reqwest-native-tls-devel \
 rust-gix+blocking-http-transport-reqwest-rust-tls-devel \
 rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel \
 rust-gix+blocking-network-client-devel \
 rust-gix+cache-efficiency-debug-devel \
 rust-gix+comfort-devel \
 rust-gix+command-devel \
 rust-gix+credentials-devel \
 rust-gix+default-devel \
 rust-gix+dirwalk-devel \
 rust-gix+document-features-devel \
 rust-gix+excludes-devel \
 rust-gix+extras-devel \
 rust-gix+gix-archive-devel \
 rust-gix+gix-status-devel \
 rust-gix+gix-worktree-stream-devel \
 rust-gix+hp-tempfile-registry-devel \
 rust-gix+index-devel \
 rust-gix+interrupt-devel \
 rust-gix+mailmap-devel \
 rust-gix+max-control-devel \
 rust-gix+max-performance-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix+merge-devel \
 rust-gix+need-more-recent-msrv-devel \
 rust-gix+pack-cache-lru-dynamic-devel \
 rust-gix+pack-cache-lru-static-devel \
 rust-gix+parallel-devel \
 rust-gix+prodash-devel \
 rust-gix+progress-tree-devel \
 rust-gix+regex-devel \
 rust-gix+revision-devel \
 rust-gix+revparse-regex-devel \
 rust-gix+serde-devel \
 rust-gix+sha1-devel \
 rust-gix+sha256-devel \
 rust-gix+status-devel \
 rust-gix+tracing-detail-devel \
 rust-gix+tracing-devel \
 rust-gix+tree-editor-devel \
 rust-gix+tree-error-devel \
 rust-gix+worktree-archive-devel \
 rust-gix+worktree-mutation-devel \
 rust-gix+worktree-stream-devel \
 rust-gix+zlib-ng-devel \
 rust-gix+zlib-rs-devel \
 rust-gix+zlib-stock-devel \
 rust-gix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-0.85.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7afde441ce8167686352c6db094983dab6e2f25aad4861c92e1f37de6503832"

URI_x86_64_v2_rust-gix+async-network-client-async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-network-client-async-std-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-network-client-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-network-client-async-std-devel}"
SRC_URI[x86_64_v2_rust-gix+async-network-client-async-std-devel.sha256sum] = "1fb572213761a320405071df981fdcfe68a8a49319c4ae37dbe049eb70bd16a2"

URI_x86_64_v2_rust-gix+async-network-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-network-client-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-network-client-devel}"
SRC_URI[x86_64_v2_rust-gix+async-network-client-devel.sha256sum] = "bf436497602ab59452d08dd4f2cc00b03765b7533b414c0898fe73076c0e3a6e"

URI_x86_64_v2_rust-gix+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-std-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-std-devel}"
SRC_URI[x86_64_v2_rust-gix+async-std-devel.sha256sum] = "1c9d982bea2e176a3f49c208925d16f46982b1f35facf0b4711ea457b8c560fb"

URI_x86_64_v2_rust-gix+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+attributes-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+attributes-devel}"
SRC_URI[x86_64_v2_rust-gix+attributes-devel.sha256sum] = "97156e058739b9457f47bd4890ccc35ba73bf576385126fafd037728f415138c"

URI_x86_64_v2_rust-gix+auto-chain-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+auto-chain-error-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+auto-chain-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+auto-chain-error-devel}"
SRC_URI[x86_64_v2_rust-gix+auto-chain-error-devel.sha256sum] = "74532311935e216828b6a77734b1da4bf102f81742f61311d62e93d39572f1f7"

URI_x86_64_v2_rust-gix+basic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+basic-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+basic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+basic-devel}"
SRC_URI[x86_64_v2_rust-gix+basic-devel.sha256sum] = "fd9104dc45ccec5c1713e26454e0bc09ab08e41ab53a59413614a011aa9d9a68"

URI_x86_64_v2_rust-gix+blame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blame-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blame-devel}"
SRC_URI[x86_64_v2_rust-gix+blame-devel.sha256sum] = "2650293bb39f9bd24fc7689f4ed9435cc4cfdd94ffae4ee69bbd9cadaaf56b3d"

URI_x86_64_v2_rust-gix+blob-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blob-diff-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blob-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blob-diff-devel}"
SRC_URI[x86_64_v2_rust-gix+blob-diff-devel.sha256sum] = "aaa8d5cee5152138c58071ced3703eef5f8fa183643993f0c2ba3cb21d729954"

URI_x86_64_v2_rust-gix+blocking-http-transport-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-curl-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-curl-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-curl-devel.sha256sum] = "631e3275fd5b6059d39f2323b34ec0abf6d017c3919d9e478560480ea160c3cd"

URI_x86_64_v2_rust-gix+blocking-http-transport-curl-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-curl-openssl-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-curl-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-curl-openssl-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-curl-openssl-devel.sha256sum] = "89668564c664eb8d90c6319dffdbc38f389540ddd8d0f7238ff94088fd276b88"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel.sha256sum] = "857017863a4c115efd0aa0028464e1b8be82a7041d3931d3a25360ce76b3de8d"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-native-tls-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel.sha256sum] = "21400ed8174718d217a417eb755ebd596ee7d39f4b244d9e4d02c22e2d4bf950"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-rust-tls-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel.sha256sum] = "5d564a0a3bd15cbce69d2082e2c023815240d10b1708fe3dc83a0d5c46dc9ff6"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel.sha256sum] = "8785b5db582e0af0af3bbbbd62b7f64f492e2c97d58c3fc5cbf12309c5e729e8"

URI_x86_64_v2_rust-gix+blocking-network-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-network-client-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-network-client-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-network-client-devel.sha256sum] = "764afdb936643540d716899883bf8ed4253230305d458bbf7ef8ad64bbf0ac14"

URI_x86_64_v2_rust-gix+cache-efficiency-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+cache-efficiency-debug-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+cache-efficiency-debug-devel}"
SRC_URI[x86_64_v2_rust-gix+cache-efficiency-debug-devel.sha256sum] = "2b368cfe3224eaf1b22a155f2d74aa01f00b645c72b1488bbdd4821c249f1c2f"

URI_x86_64_v2_rust-gix+comfort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+comfort-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+comfort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+comfort-devel}"
SRC_URI[x86_64_v2_rust-gix+comfort-devel.sha256sum] = "c50e6e68e9fd2c470e820bc7a24cb406bfb2cfec73fd89488bcc2f163815da54"

URI_x86_64_v2_rust-gix+command-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+command-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+command-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+command-devel}"
SRC_URI[x86_64_v2_rust-gix+command-devel.sha256sum] = "fba1546963ad11ec67208d8df01a17a0f41c032ea58ee96fa4fdf59d2592a75d"

URI_x86_64_v2_rust-gix+credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+credentials-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+credentials-devel}"
SRC_URI[x86_64_v2_rust-gix+credentials-devel.sha256sum] = "4f93536e7b5a62a83896435f355b88704b470d0519fe604161008175fe31b9a8"

URI_x86_64_v2_rust-gix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+default-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+default-devel}"
SRC_URI[x86_64_v2_rust-gix+default-devel.sha256sum] = "6a5e1c9479d17aaeb177e86e0ef8a8a41a65f857174d483b166c468454cfdc27"

URI_x86_64_v2_rust-gix+dirwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+dirwalk-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+dirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+dirwalk-devel}"
SRC_URI[x86_64_v2_rust-gix+dirwalk-devel.sha256sum] = "95fe2bffcf1cb880001ab6497a8a1045e6a433fc2bee00c2bc4765d1e2768efe"

URI_x86_64_v2_rust-gix+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+document-features-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix+document-features-devel.sha256sum] = "a7077a9a8f03018a0dc53145276208b4cf31d12871e3934634f210f14a0a724f"

URI_x86_64_v2_rust-gix+excludes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+excludes-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+excludes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+excludes-devel}"
SRC_URI[x86_64_v2_rust-gix+excludes-devel.sha256sum] = "1d0341253f984d3ce9148a34d14f684de1bbe1122cdeba231fcf51f408280779"

URI_x86_64_v2_rust-gix+extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+extras-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+extras-devel}"
SRC_URI[x86_64_v2_rust-gix+extras-devel.sha256sum] = "c87b399b53d56ebb42076562690e55fafe95e52b5c884840da1b13ef4414d616"

URI_x86_64_v2_rust-gix+gix-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-archive-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-archive-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-archive-devel.sha256sum] = "7bc9a598ffb1b51b29b845c81611384d410c65bacb97ed1575c4bee1348be8da"

URI_x86_64_v2_rust-gix+gix-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-status-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-status-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-status-devel.sha256sum] = "95bc92eb0ba60219742e55b2da9c633144bad76dfe9a65bff967e97b13f33c73"

URI_x86_64_v2_rust-gix+gix-worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-worktree-stream-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-worktree-stream-devel.sha256sum] = "88432677c54b61d15546b8634601979473741d9daea648c47037a0c83117fd4a"

URI_x86_64_v2_rust-gix+hp-tempfile-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+hp-tempfile-registry-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+hp-tempfile-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+hp-tempfile-registry-devel}"
SRC_URI[x86_64_v2_rust-gix+hp-tempfile-registry-devel.sha256sum] = "42c278a2ea2ab46d4094aeadadb5b7fda17cbf6989619ef155548f4e76e409aa"

URI_x86_64_v2_rust-gix+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+index-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+index-devel}"
SRC_URI[x86_64_v2_rust-gix+index-devel.sha256sum] = "05283265b56790d09937ff2e2969d84339e2ccbde911a6e11cc638dd070d1f9a"

URI_x86_64_v2_rust-gix+interrupt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+interrupt-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+interrupt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+interrupt-devel}"
SRC_URI[x86_64_v2_rust-gix+interrupt-devel.sha256sum] = "35effe6ff8ed36b2c20174b78b7b8abbbd5c15c7f043a618c5dfd74ade4b364b"

URI_x86_64_v2_rust-gix+mailmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+mailmap-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+mailmap-devel}"
SRC_URI[x86_64_v2_rust-gix+mailmap-devel.sha256sum] = "d4cbb1aa736758238d1091d83483e12658da37847f496004faa5c32a6ae11f19"

URI_x86_64_v2_rust-gix+max-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-control-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-control-devel}"
SRC_URI[x86_64_v2_rust-gix+max-control-devel.sha256sum] = "9b85548adabb9dd1026a141331fb5b4f28fa9e73f605a20974247d805fa47e17"

URI_x86_64_v2_rust-gix+max-performance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-performance-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-performance-devel}"
SRC_URI[x86_64_v2_rust-gix+max-performance-devel.sha256sum] = "9fc287022e1f90315ea11fb8b11926add9b69d8dad56cad208e8e33df496bea3"

URI_x86_64_v2_rust-gix+max-performance-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-performance-safe-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-performance-safe-devel}"
SRC_URI[x86_64_v2_rust-gix+max-performance-safe-devel.sha256sum] = "a8e8f7175db5aa4732e5bfb7262e17531d163a5560748a3df5b00da2d13a2c72"

URI_x86_64_v2_rust-gix+merge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+merge-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+merge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+merge-devel}"
SRC_URI[x86_64_v2_rust-gix+merge-devel.sha256sum] = "17125ea5c72d7c8ac3b2d3df74c1979d3eb0c06a43f42c83419bdcac2ff61d69"

URI_x86_64_v2_rust-gix+need-more-recent-msrv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+need-more-recent-msrv-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+need-more-recent-msrv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+need-more-recent-msrv-devel}"
SRC_URI[x86_64_v2_rust-gix+need-more-recent-msrv-devel.sha256sum] = "c84f570e90de8db4ac7a42b988c801b5b5d9ac3f23c9f19c583e5a1c44164750"

URI_x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+pack-cache-lru-dynamic-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel.sha256sum] = "e57eb2d48b44819d6075b3c6cfa9d9e2391b4d102aa29c77189114cb067c97fa"

URI_x86_64_v2_rust-gix+pack-cache-lru-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+pack-cache-lru-static-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+pack-cache-lru-static-devel}"
SRC_URI[x86_64_v2_rust-gix+pack-cache-lru-static-devel.sha256sum] = "245ef0999061c72e3e30e1ad3ad9d32ebe074f3cdc7b4f1fd8d40efe5736dd5f"

URI_x86_64_v2_rust-gix+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+parallel-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix+parallel-devel.sha256sum] = "581418a190c8175b91a9538323e1734864c3550b27479ec147acf960234f861d"

URI_x86_64_v2_rust-gix+prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+prodash-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+prodash-devel}"
SRC_URI[x86_64_v2_rust-gix+prodash-devel.sha256sum] = "98331274e6b1f5f484ae445e87850ab3feaaef708757921c025b5b5387265ad1"

URI_x86_64_v2_rust-gix+progress-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+progress-tree-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+progress-tree-devel}"
SRC_URI[x86_64_v2_rust-gix+progress-tree-devel.sha256sum] = "c927cd07605e2f28c7b4c79c7dde8ef1acfdabe30008a1d50f17ade00e387d16"

URI_x86_64_v2_rust-gix+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+regex-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+regex-devel}"
SRC_URI[x86_64_v2_rust-gix+regex-devel.sha256sum] = "8345909529ea7f820f4173f8ded0595faf48977027cbc998833f471e8f6bbd89"

URI_x86_64_v2_rust-gix+revision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+revision-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+revision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+revision-devel}"
SRC_URI[x86_64_v2_rust-gix+revision-devel.sha256sum] = "4c7bf99774f619b7970f6663174f92b0e1e745cc2e80eb053ce5d8f9fa8da33d"

URI_x86_64_v2_rust-gix+revparse-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+revparse-regex-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+revparse-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+revparse-regex-devel}"
SRC_URI[x86_64_v2_rust-gix+revparse-regex-devel.sha256sum] = "0b964b05d3837817a8aba2da166131a0c0858a6a42de6d602448a5a70687bbc4"

URI_x86_64_v2_rust-gix+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+serde-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+serde-devel}"
SRC_URI[x86_64_v2_rust-gix+serde-devel.sha256sum] = "f1c720f72f75ad96d0d6f59a86977d878fa21439ff62e8407f41daadfb0b8d7e"

URI_x86_64_v2_rust-gix+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+sha1-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix+sha1-devel.sha256sum] = "26230a9b751cef3d19738933a90c0f99b0532f3975901b6a6ecc771f7538b1c9"

URI_x86_64_v2_rust-gix+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+sha256-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix+sha256-devel.sha256sum] = "53f1baa6112cd60d38479659c491efac64de74199d9490021b92b84a29ea6506"

URI_x86_64_v2_rust-gix+status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+status-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+status-devel}"
SRC_URI[x86_64_v2_rust-gix+status-devel.sha256sum] = "aeb804746d19b8e6c3ad082f0d5986b6151eaeda7b8626aac5a50d55329969ac"

URI_x86_64_v2_rust-gix+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tracing-detail-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix+tracing-detail-devel.sha256sum] = "00f6dce1c4b9903d7521427615a6ffd99147cd14e3fe1e71e776b2ecf3450992"

URI_x86_64_v2_rust-gix+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tracing-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix+tracing-devel.sha256sum] = "18cde9f4bf66822a7dd11dd035c3e1529d601676459ca19d0861eb192c02d409"

URI_x86_64_v2_rust-gix+tree-editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tree-editor-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tree-editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tree-editor-devel}"
SRC_URI[x86_64_v2_rust-gix+tree-editor-devel.sha256sum] = "497bee6036f06664e0d979e9914165caf988afc8fbd5d84fa7faf95e3c6a7608"

URI_x86_64_v2_rust-gix+tree-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tree-error-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tree-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tree-error-devel}"
SRC_URI[x86_64_v2_rust-gix+tree-error-devel.sha256sum] = "6935c670a0ff2daf88efa37bb4c83395e7d87846b1994433efda90516680a4b1"

URI_x86_64_v2_rust-gix+worktree-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-archive-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-archive-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-archive-devel.sha256sum] = "08ce2202aa52c601a54cf8dd417ffc1cb44cf5d27e7ccbb21a12d052f86f750b"

URI_x86_64_v2_rust-gix+worktree-mutation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-mutation-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-mutation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-mutation-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-mutation-devel.sha256sum] = "4fc429c126d7b14c1a6fab532ea1c9cb57e301efd6533b6dc678abe7465f37ed"

URI_x86_64_v2_rust-gix+worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-stream-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-stream-devel.sha256sum] = "3012b19eee803f06291246f52b31b88eb263e22a2fc63cdcdc2fd1f5018ae624"

URI_x86_64_v2_rust-gix+zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-ng-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-ng-devel.sha256sum] = "f4a35255bbeb184722ab7d69a979ad67496700547f925e1ec21211b05a26dff8"

URI_x86_64_v2_rust-gix+zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-rs-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-rs-devel.sha256sum] = "c2c082ead3704d0f4dd7abbcd9e58646642dcf2e300ebeef2640165550ec704f"

URI_x86_64_v2_rust-gix+zlib-stock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-stock-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-stock-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-stock-devel.sha256sum] = "62529773f4d47079c1b64ae0b1fe5db8a7390497f54ecb0f4a31e9052501b02f"

URI_x86_64_v2_rust-gix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-devel-0.85.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-devel}"
SRC_URI[x86_64_v2_rust-gix-devel.sha256sum] = "7525bbb1c9d6c7937e8e1458ca9e339ce85432b46ab394c8b611c6be43550e5c"

URI_aarch64_rust-gix+async-network-client-async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-network-client-async-std-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+async-network-client-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-network-client-async-std-devel}"
SRC_URI[aarch64_rust-gix+async-network-client-async-std-devel.sha256sum] = "bf09d0aaffc69a5e2635685598d58c7d02950213dc0f6fd4485f92038a71060e"

URI_aarch64_rust-gix+async-network-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-network-client-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+async-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-network-client-devel}"
SRC_URI[aarch64_rust-gix+async-network-client-devel.sha256sum] = "ca76e393de5f65d7538118a2378a65525f36c95f1f673f0a76eb298ce73542d5"

URI_aarch64_rust-gix+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-std-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-std-devel}"
SRC_URI[aarch64_rust-gix+async-std-devel.sha256sum] = "ab7e20f3d83d4cf131f287839d5fe0206a4749603a50cddd6a88b1350c6bad5d"

URI_aarch64_rust-gix+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+attributes-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+attributes-devel}"
SRC_URI[aarch64_rust-gix+attributes-devel.sha256sum] = "847a0122e84c826b5592f461503bf5020d869aae58a0750313a0dbedc5c3b781"

URI_aarch64_rust-gix+auto-chain-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+auto-chain-error-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+auto-chain-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+auto-chain-error-devel}"
SRC_URI[aarch64_rust-gix+auto-chain-error-devel.sha256sum] = "65293a83f0acb34954fc1062fe2061bc9517ae59c765c0f77e8d5702d76de226"

URI_aarch64_rust-gix+basic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+basic-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+basic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+basic-devel}"
SRC_URI[aarch64_rust-gix+basic-devel.sha256sum] = "da017722de5aadc5ae73561f81928d5b08892f7076da4ad11c7c8abf1f4f17a9"

URI_aarch64_rust-gix+blame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blame-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+blame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blame-devel}"
SRC_URI[aarch64_rust-gix+blame-devel.sha256sum] = "286c30a17517e80d3f7c8e590c8a1b1b53fe209733df5084a16c8e17cf730339"

URI_aarch64_rust-gix+blob-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blob-diff-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+blob-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blob-diff-devel}"
SRC_URI[aarch64_rust-gix+blob-diff-devel.sha256sum] = "7c0666c8b5d562ce0a643b12df95332b96be9313f3eb7a0ca2de4a953e1e58de"

URI_aarch64_rust-gix+blocking-http-transport-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-curl-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-curl-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-curl-devel.sha256sum] = "9817484a9347357d67a92ca38e614cf702d09e5316d65768f858e7ed0f94cc00"

URI_aarch64_rust-gix+blocking-http-transport-curl-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-curl-openssl-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-curl-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-curl-openssl-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-curl-openssl-devel.sha256sum] = "23ee751b08c683b02b7e9acb26cda795ee149ac6206c636061498baa1794e0be"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-devel.sha256sum] = "121f2297581135aa4e3f404b42a4814c684d60634d96c4b969055d3a0fdc1ce4"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-native-tls-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel.sha256sum] = "44bb2a4711538f5e14d2feda4a8990b77ae8dfce2ad59ddc19477f47c8b36e85"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-rust-tls-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel.sha256sum] = "aa2a86747e5d08f585bc6545225514b3a4da0b775fd74e55aa881b04cfd9af10"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel.sha256sum] = "7d172ca731f802a70d4ce5e3fc4812113e554d4ccfab383a5f5d1d87b3fa3637"

URI_aarch64_rust-gix+blocking-network-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-network-client-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+blocking-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-network-client-devel}"
SRC_URI[aarch64_rust-gix+blocking-network-client-devel.sha256sum] = "b211eba45232b32ad6a17ee67ecc53c2094c8754f69b976ecaf135655bc7764c"

URI_aarch64_rust-gix+cache-efficiency-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+cache-efficiency-debug-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+cache-efficiency-debug-devel}"
SRC_URI[aarch64_rust-gix+cache-efficiency-debug-devel.sha256sum] = "181ea6c0b30a124125a0492a9b8d09fbb97da6ac7a783d19affe3ad5c993c327"

URI_aarch64_rust-gix+comfort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+comfort-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+comfort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+comfort-devel}"
SRC_URI[aarch64_rust-gix+comfort-devel.sha256sum] = "597ee110c7192996a59ecc453be085b16e426c04076fe0540229df66d729bfb5"

URI_aarch64_rust-gix+command-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+command-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+command-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+command-devel}"
SRC_URI[aarch64_rust-gix+command-devel.sha256sum] = "495c5400ac64a32c2f3de6e7bcdcdb99d9ae2906b3ec4fa23ecb8e428262723b"

URI_aarch64_rust-gix+credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+credentials-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+credentials-devel}"
SRC_URI[aarch64_rust-gix+credentials-devel.sha256sum] = "3b00631bd6ff5d52a4142d75efd43457a5c6fbfa661734cd63892c45837c02af"

URI_aarch64_rust-gix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+default-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+default-devel}"
SRC_URI[aarch64_rust-gix+default-devel.sha256sum] = "ff2c42d5f3283fa69a031f89dfbce6bf7ef4bfd83ae1dc547d99a32e2e2c9e58"

URI_aarch64_rust-gix+dirwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+dirwalk-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+dirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+dirwalk-devel}"
SRC_URI[aarch64_rust-gix+dirwalk-devel.sha256sum] = "cd3f3ca95de88133007cf495d9dda3b4487c92e5a8d9bd0ff1a1e83f6250257f"

URI_aarch64_rust-gix+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+document-features-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+document-features-devel}"
SRC_URI[aarch64_rust-gix+document-features-devel.sha256sum] = "ad6c027b012313b07cc5efdf4042445e0600def727ff52d5d1bd5ba98d4cb55a"

URI_aarch64_rust-gix+excludes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+excludes-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+excludes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+excludes-devel}"
SRC_URI[aarch64_rust-gix+excludes-devel.sha256sum] = "8ab295eda5aa348cfc9c6d3153705f05e521312217e76982cfb53442ef2e730f"

URI_aarch64_rust-gix+extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+extras-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+extras-devel}"
SRC_URI[aarch64_rust-gix+extras-devel.sha256sum] = "8f390271750cda9e1ac86d6656639ff187ec0200e64736950cd0dd6bd4e46447"

URI_aarch64_rust-gix+gix-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-archive-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-archive-devel}"
SRC_URI[aarch64_rust-gix+gix-archive-devel.sha256sum] = "17469af27a106cc6316800db11b31c336a0734a3a2db6adec9484dd1517f9edd"

URI_aarch64_rust-gix+gix-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-status-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-status-devel}"
SRC_URI[aarch64_rust-gix+gix-status-devel.sha256sum] = "0ecb6c09eb09548b1ca37b324fb093f68001fd1469d3a7055180b61acfd75f58"

URI_aarch64_rust-gix+gix-worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-worktree-stream-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-worktree-stream-devel}"
SRC_URI[aarch64_rust-gix+gix-worktree-stream-devel.sha256sum] = "f367d68eb825c0d23f87597e3a7d8c81ccf9559d526b2573b81b0beeafe5ce79"

URI_aarch64_rust-gix+hp-tempfile-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+hp-tempfile-registry-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+hp-tempfile-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+hp-tempfile-registry-devel}"
SRC_URI[aarch64_rust-gix+hp-tempfile-registry-devel.sha256sum] = "105af647ad8e226bee27e04e7f5ce61c98b08de608247a627ab0995456b95300"

URI_aarch64_rust-gix+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+index-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+index-devel}"
SRC_URI[aarch64_rust-gix+index-devel.sha256sum] = "cb86ed6955a145015d543cf4df6af3480d2842187412c17689f66676401e8afc"

URI_aarch64_rust-gix+interrupt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+interrupt-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+interrupt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+interrupt-devel}"
SRC_URI[aarch64_rust-gix+interrupt-devel.sha256sum] = "e8d0d721be02722707b3a9834723600b3d3ba62f0f9b696cf5c464ea2b81e2c4"

URI_aarch64_rust-gix+mailmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+mailmap-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+mailmap-devel}"
SRC_URI[aarch64_rust-gix+mailmap-devel.sha256sum] = "8648b0269525abf16d1dc22491b772a40d518b3ce3a71d1d6f9340b8b1abd22f"

URI_aarch64_rust-gix+max-control-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-control-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+max-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-control-devel}"
SRC_URI[aarch64_rust-gix+max-control-devel.sha256sum] = "ffd690638f3f0b11f436dac88d151fd1d24f78aea69a8f488e091a4d8d3e549b"

URI_aarch64_rust-gix+max-performance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-performance-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-performance-devel}"
SRC_URI[aarch64_rust-gix+max-performance-devel.sha256sum] = "25c765d027ca520314427286e1494283727cd9689cdaa661346697997ede58c2"

URI_aarch64_rust-gix+max-performance-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-performance-safe-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-performance-safe-devel}"
SRC_URI[aarch64_rust-gix+max-performance-safe-devel.sha256sum] = "5ec71bd612de57b7846bc557473961cb0126b7e3031755ff75fb55e60287b39d"

URI_aarch64_rust-gix+merge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+merge-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+merge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+merge-devel}"
SRC_URI[aarch64_rust-gix+merge-devel.sha256sum] = "d888a180d5e446a0711dce2251c58d25b67283f9f71ca90cc91d12f6451b7880"

URI_aarch64_rust-gix+need-more-recent-msrv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+need-more-recent-msrv-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+need-more-recent-msrv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+need-more-recent-msrv-devel}"
SRC_URI[aarch64_rust-gix+need-more-recent-msrv-devel.sha256sum] = "003c58dd606b4c2b2feb487da9d5dd71c4e83a23db64063d0871aeea40190461"

URI_aarch64_rust-gix+pack-cache-lru-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+pack-cache-lru-dynamic-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+pack-cache-lru-dynamic-devel}"
SRC_URI[aarch64_rust-gix+pack-cache-lru-dynamic-devel.sha256sum] = "095c934e43ae617808561543ae39634bd9026d4224feabae5614bf4ede6f585e"

URI_aarch64_rust-gix+pack-cache-lru-static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+pack-cache-lru-static-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+pack-cache-lru-static-devel}"
SRC_URI[aarch64_rust-gix+pack-cache-lru-static-devel.sha256sum] = "8151353035800d87a175afb9c2d6c14df702bd56a16d729fa6a5dfc5d5cc7106"

URI_aarch64_rust-gix+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+parallel-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+parallel-devel}"
SRC_URI[aarch64_rust-gix+parallel-devel.sha256sum] = "05832fd979ce9691ad113590cacacc0fd83e5076d4cd4043d4881b07324b76eb"

URI_aarch64_rust-gix+prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+prodash-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+prodash-devel}"
SRC_URI[aarch64_rust-gix+prodash-devel.sha256sum] = "176881913d935228dfeb0450757e27ffe9448054bf70d4119da6ddbd11831c35"

URI_aarch64_rust-gix+progress-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+progress-tree-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+progress-tree-devel}"
SRC_URI[aarch64_rust-gix+progress-tree-devel.sha256sum] = "d7ab4be7313dfe1ac6b93bc4fa102a6b58f7ed3e49a2b9f52c95c149882a4668"

URI_aarch64_rust-gix+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+regex-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+regex-devel}"
SRC_URI[aarch64_rust-gix+regex-devel.sha256sum] = "7a9e6e6e4e69832d56f59e6a4b35cd8dfe2e23f788ea82bc1a36f2f38028d324"

URI_aarch64_rust-gix+revision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+revision-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+revision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+revision-devel}"
SRC_URI[aarch64_rust-gix+revision-devel.sha256sum] = "52a1417d5eab4d98a8834de0cbbe1f0d86e744489d7302b8eeb583412f7a4cf3"

URI_aarch64_rust-gix+revparse-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+revparse-regex-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+revparse-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+revparse-regex-devel}"
SRC_URI[aarch64_rust-gix+revparse-regex-devel.sha256sum] = "c07da4485b6a72d1a6ac48e9f6eab3c81566eb37fef706f66a4453c7fb3ac482"

URI_aarch64_rust-gix+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+serde-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+serde-devel}"
SRC_URI[aarch64_rust-gix+serde-devel.sha256sum] = "7d94411d60627a6bb524b56179330a45f641f88cf0106bc2e9d81cff1fc1308c"

URI_aarch64_rust-gix+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+sha1-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+sha1-devel}"
SRC_URI[aarch64_rust-gix+sha1-devel.sha256sum] = "41c88b69378277972d597ddd2100817c2e7e31ed8ce8535921816110d546214c"

URI_aarch64_rust-gix+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+sha256-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+sha256-devel}"
SRC_URI[aarch64_rust-gix+sha256-devel.sha256sum] = "1dbab3e54172686d1710aa8a021918782c172f8f2876dab50d0fcef54613e4ff"

URI_aarch64_rust-gix+status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+status-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+status-devel}"
SRC_URI[aarch64_rust-gix+status-devel.sha256sum] = "9a2943f5376b99b34ba8eb8e5778d27be4ae8d3ec6d14dab4fdb6dfd48f8c300"

URI_aarch64_rust-gix+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tracing-detail-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix+tracing-detail-devel.sha256sum] = "af7f2e598e3f0a5adc2924f2938e6fc05c2c1d29ca11cc898d535e7249151caf"

URI_aarch64_rust-gix+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tracing-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tracing-devel}"
SRC_URI[aarch64_rust-gix+tracing-devel.sha256sum] = "0ae68b2af8e736d8ab39182e5f30b9632152190af22eabd0aa091b9e5a2c4fc6"

URI_aarch64_rust-gix+tree-editor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tree-editor-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+tree-editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tree-editor-devel}"
SRC_URI[aarch64_rust-gix+tree-editor-devel.sha256sum] = "a4cd77cb1e7ad06a82409101f5e59c2476d2930470ed684c5e46421576587d11"

URI_aarch64_rust-gix+tree-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tree-error-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+tree-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tree-error-devel}"
SRC_URI[aarch64_rust-gix+tree-error-devel.sha256sum] = "81c80b1791629ade45b4eee254636217a52c2c70dcd1918abfb35c1072899c52"

URI_aarch64_rust-gix+worktree-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-archive-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+worktree-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-archive-devel}"
SRC_URI[aarch64_rust-gix+worktree-archive-devel.sha256sum] = "66fb9ef4f5ae460748878a25af4cb36af598337c3a5073c51ef3015cd05b458f"

URI_aarch64_rust-gix+worktree-mutation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-mutation-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+worktree-mutation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-mutation-devel}"
SRC_URI[aarch64_rust-gix+worktree-mutation-devel.sha256sum] = "e4f1f6e99691d3cdc8c7971a7f1e9dd182dc1ce0d9eeab513cf50a63e984ca85"

URI_aarch64_rust-gix+worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-stream-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-stream-devel}"
SRC_URI[aarch64_rust-gix+worktree-stream-devel.sha256sum] = "8d488aaf29fc030c1f277a3f9064aabd8d43a72c851ca37173ca712a29577722"

URI_aarch64_rust-gix+zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-ng-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-ng-devel}"
SRC_URI[aarch64_rust-gix+zlib-ng-devel.sha256sum] = "5c62ea1c98e67b7e3c88c7fee1bad24946c983680a9fe03ad0ce3370da1fde6b"

URI_aarch64_rust-gix+zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-rs-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-rs-devel}"
SRC_URI[aarch64_rust-gix+zlib-rs-devel.sha256sum] = "b126222c760ded00965d7ad42e0ec29787a727720d03458542e7c4fa96eda978"

URI_aarch64_rust-gix+zlib-stock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-stock-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-stock-devel}"
SRC_URI[aarch64_rust-gix+zlib-stock-devel.sha256sum] = "3212a0375729c1c7c368774ffb5224ceda29d866daded3a7f5770ce470eef5a8"

URI_aarch64_rust-gix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-devel-0.85.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-devel}"
SRC_URI[aarch64_rust-gix-devel.sha256sum] = "66adcba170a874659858844ce0776192c1cbb0e8d620f07cc6ba575825fea265"

RDEPENDS:rust-gix+async-network-client-async-std-devel = " \
 cargo \
 rust-gix+async-network-client-devel \
 rust-gix+async-std-devel \
 rust-gix-devel \
 rust-gix-transport+async-std-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+async-network-client-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-protocol+async-client-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+attributes-devel = " \
 cargo \
 rust-gix+command-devel \
 rust-gix+excludes-devel \
 rust-gix-attributes+default-devel \
 rust-gix-devel \
 rust-gix-filter+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-submodule+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix+auto-chain-error-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-error+auto-chain-error-devel \
 "
RDEPENDS:rust-gix+basic-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix+index-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+blame-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix-blame+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+blob-diff-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix-devel \
 rust-gix-diff+blob-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-curl-devel = " \
 cargo \
 rust-gix+blocking-network-client-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-curl-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-curl-openssl-devel = " \
 cargo \
 rust-gix+blocking-http-transport-curl-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-curl-openssl-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-devel = " \
 cargo \
 rust-gix+blocking-network-client-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-native-tls-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-native-tls-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-rust-tls-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel \
 "
RDEPENDS:rust-gix+blocking-network-client-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-protocol+blocking-client-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+cache-efficiency-debug-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+cache-efficiency-debug-devel \
 "
RDEPENDS:rust-gix+comfort-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+progress-unit-bytes-devel \
 rust-gix-features+progress-unit-human-numbers-devel \
 "
RDEPENDS:rust-gix+command-devel = " \
 cargo \
 rust-gix-command+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+credentials-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-devel \
 rust-gix-negotiate+default-devel \
 rust-gix-prompt+default-devel \
 "
RDEPENDS:rust-gix+default-devel = " \
 cargo \
 rust-gix+auto-chain-error-devel \
 rust-gix+basic-devel \
 rust-gix+comfort-devel \
 rust-gix+extras-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix+sha1-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+dirwalk-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+excludes-devel \
 rust-gix-devel \
 rust-gix-dir+default-devel \
 "
RDEPENDS:rust-gix+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+excludes-devel = " \
 cargo \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-ignore+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix+extras-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+blame-devel \
 rust-gix+credentials-devel \
 rust-gix+dirwalk-devel \
 rust-gix+excludes-devel \
 rust-gix+interrupt-devel \
 rust-gix+mailmap-devel \
 rust-gix+revparse-regex-devel \
 rust-gix+status-devel \
 rust-gix+worktree-archive-devel \
 rust-gix+worktree-mutation-devel \
 rust-gix+worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+gix-archive-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+gix-status-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-status+default-devel \
 rust-gix-status+worktree-rewrites-devel \
 "
RDEPENDS:rust-gix+gix-worktree-stream-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-worktree-stream+default-devel \
 "
RDEPENDS:rust-gix+hp-tempfile-registry-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-tempfile+hp-hashmap-devel \
 "
RDEPENDS:rust-gix+index-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-index+default-devel \
 "
RDEPENDS:rust-gix+interrupt-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-tempfile+signals-devel \
 rust-parking_lot+default-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-gix+mailmap-devel = " \
 cargo \
 rust-gix+revision-devel \
 rust-gix-devel \
 rust-gix-mailmap+default-devel \
 "
RDEPENDS:rust-gix+max-control-devel = " \
 cargo \
 rust-gix+pack-cache-lru-dynamic-devel \
 rust-gix+pack-cache-lru-static-devel \
 rust-gix+parallel-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+max-performance-devel = " \
 cargo \
 rust-gix+max-performance-safe-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+max-performance-safe-devel = " \
 cargo \
 rust-gix+max-control-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+merge-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+blob-diff-devel \
 rust-gix+tree-editor-devel \
 rust-gix-devel \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix+need-more-recent-msrv-devel = " \
 cargo \
 rust-gix+merge-devel \
 rust-gix+tree-editor-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+pack-cache-lru-dynamic-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-pack+pack-cache-lru-dynamic-devel \
 "
RDEPENDS:rust-gix+pack-cache-lru-static-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-pack+pack-cache-lru-static-devel \
 "
RDEPENDS:rust-gix+parallel-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+parallel-devel \
 "
RDEPENDS:rust-gix+prodash-devel = " \
 cargo \
 rust-gix-devel \
 rust-prodash+default-devel \
 rust-prodash+progress-tree-devel \
 "
RDEPENDS:rust-gix+progress-tree-devel = " \
 cargo \
 rust-gix-devel \
 rust-prodash+default-devel \
 rust-prodash+progress-tree-devel \
 "
RDEPENDS:rust-gix+regex-devel = " \
 cargo \
 rust-gix-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-gix+revision-devel = " \
 cargo \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-revision+describe-devel \
 rust-gix-revision+merge_base-devel \
 "
RDEPENDS:rust-gix+revparse-regex-devel = " \
 cargo \
 rust-gix+regex-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+serde-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-commitgraph+serde-devel \
 rust-gix-credentials+default-devel \
 rust-gix-credentials+serde-devel \
 rust-gix-devel \
 rust-gix-ignore+default-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-index+default-devel \
 rust-gix-index+serde-devel \
 rust-gix-mailmap+default-devel \
 rust-gix-mailmap+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-odb+serde-devel \
 rust-gix-pack+serde-devel \
 rust-gix-protocol+serde-devel \
 rust-gix-ref+serde-devel \
 rust-gix-revision+serde-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+serde-devel \
 rust-gix-url+serde-devel \
 rust-gix-worktree+serde-devel \
 rust-gix-worktree-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix+sha1-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-hash+sha1-devel \
 rust-gix-pack+sha1-devel \
 rust-gix-worktree-stream+default-devel \
 rust-gix-worktree-stream+sha1-devel \
 "
RDEPENDS:rust-gix+sha256-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-hash+sha256-devel \
 rust-gix-pack+sha256-devel \
 rust-gix-worktree-stream+default-devel \
 rust-gix-worktree-stream+sha256-devel \
 "
RDEPENDS:rust-gix+status-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix+dirwalk-devel \
 rust-gix+gix-status-devel \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-diff+index-devel \
 "
RDEPENDS:rust-gix+tracing-detail-devel = " \
 cargo \
 rust-gix+tracing-devel \
 rust-gix-devel \
 rust-gix-features+tracing-detail-devel \
 "
RDEPENDS:rust-gix+tracing-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+tracing-devel \
 "
RDEPENDS:rust-gix+tree-editor-devel = " \
 cargo \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+tree-error-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-error+tree-error-devel \
 "
RDEPENDS:rust-gix+worktree-archive-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+gix-archive-devel \
 rust-gix+worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+worktree-mutation-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix-devel \
 rust-gix-worktree-state+default-devel \
 "
RDEPENDS:rust-gix+worktree-stream-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+gix-worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+zlib-ng-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-devel \
 "
RDEPENDS:rust-gix+zlib-rs-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-devel \
 "
RDEPENDS:rust-gix+zlib-stock-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-devel \
 "
RDEPENDS:rust-gix-devel = " \
 bash \
 cargo \
 rust \
 rust-gix-actor+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-config+default-devel \
 rust-gix-date+default-devel \
 rust-gix-diff-devel \
 rust-gix-discover+default-devel \
 rust-gix-error+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+once_cell-devel \
 rust-gix-features+progress-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-odb+default-devel \
 rust-gix-pack+object-cache-dynamic-devel \
 rust-gix-pack-devel \
 rust-gix-path+default-devel \
 rust-gix-protocol+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-refspec+default-devel \
 rust-gix-revision-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-shallow+default-devel \
 rust-gix-tempfile-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-url+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-nonempty+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
