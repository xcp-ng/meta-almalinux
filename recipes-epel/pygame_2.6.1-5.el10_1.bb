# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pygame"
PV = "2.6.1"
PR = "5.el10_1"
PACKAGES = " \
 pygame-devel \
 python3-pygame \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pygame-2.6.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e996f8c1e184618eb3c8dba4216f890e7d8e7160285e78904024fc8d304986d0"

URI_x86_64_v2_pygame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pygame-devel-2.6.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pygame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pygame-devel}"
SRC_URI[x86_64_v2_pygame-devel.sha256sum] = "b0d7ff8348c79c681f433d85f12a35fb2803bc11af44883d3b5df9e3870ea29e"

URI_x86_64_v2_python3-pygame = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pygame-2.6.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pygame;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pygame}"
SRC_URI[x86_64_v2_python3-pygame.sha256sum] = "92639b18dcf10f3255b076104d3df3bbc76f6f2ae4410b29e51f3229b1488d1c"

URI_aarch64_pygame-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pygame-devel-2.6.1-5.el10_1.aarch64.rpm;name=aarch64_pygame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pygame-devel}"
SRC_URI[aarch64_pygame-devel.sha256sum] = "15171dff20fcb70eea6e7d8ea9fe068e1f9821e5bbaf9566c4b2ee277c896db5"

URI_aarch64_python3-pygame = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pygame-2.6.1-5.el10_1.aarch64.rpm;name=aarch64_python3-pygame;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pygame}"
SRC_URI[aarch64_python3-pygame.sha256sum] = "91d17174d6510670dccaed2b0df92e44a3b00e4ff3448d411627d2f4ff2fd143"

RDEPENDS:pygame-devel = " \
 SDL2_mixer-devel \
 SDL2_ttf-devel \
 python3-devel \
 python3-pygame \
 "
RDEPENDS:python3-pygame = " \
 SDL2_image \
 SDL2_mixer \
 SDL2_ttf \
 freetype \
 glibc \
 gnu-free-sans-fonts \
 libpng \
 portmidi \
 python3 \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
