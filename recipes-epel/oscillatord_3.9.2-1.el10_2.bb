# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oscillatord"
PV = "3.9.2"
PR = "1.el10_2"
PACKAGES = " \
 oscillatord \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oscillatord-3.9.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "702c30871ed43ca7a736eba5b2ed1083daa3422861ec8e7a5e4bf7510d6f0df4"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - oscillatord: libff.so.0.0.0()(64bit)
# - oscillatord: libubloxcfg.so.0.0.0()(64bit)
# - oscillatord: ubloxcfg >= 1.16-1.20260223git499048b

URI_x86_64_v2_oscillatord = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oscillatord-3.9.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oscillatord;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oscillatord}"
SRC_URI[x86_64_v2_oscillatord.sha256sum] = "1384f4d2898d6b1ebb3b278e99830b298a594f1fe7d482753043505c5099139d"

URI_aarch64_oscillatord = "${EPEL_MIRROR}/aarch64/Packages/o/oscillatord-3.9.2-1.el10_2.aarch64.rpm;name=aarch64_oscillatord;unpack=0"
SRC_URI:append = " ${URI_aarch64_oscillatord}"
SRC_URI[aarch64_oscillatord.sha256sum] = "82df720751afba5755a58035ee4f539d494d1a166d77bfddc1451556ab1039ac"

RDEPENDS:oscillatord:x86_64_v2 = " \
 bash \
 glibc \
 json-c \
 libgcc \
 liboscillator-disciplining \
"
RDEPENDS:oscillatord:aarch64 = " \
 bash \
 glibc \
 json-c \
 libgcc \
 liboscillator-disciplining \
 ubloxcfg \
"
