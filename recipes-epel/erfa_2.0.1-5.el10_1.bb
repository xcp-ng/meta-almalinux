# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "erfa"
PV = "2.0.1"
PR = "5.el10_1"
PACKAGES = " \
 erfa \
 erfa-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/erfa-2.0.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11ba7dcdd159b84c36752cb5ae12db6416355b1ac8a07b312c094ad335312f59"

URI_x86_64_v2_erfa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/erfa-2.0.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_erfa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_erfa}"
SRC_URI[x86_64_v2_erfa.sha256sum] = "780626ff6174b01b3b66a105a66cb7d55b527ebce401691cdef1f9cf330e6367"

URI_x86_64_v2_erfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/erfa-devel-2.0.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_erfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_erfa-devel}"
SRC_URI[x86_64_v2_erfa-devel.sha256sum] = "6e261f302ac70dddd5d2bfa18b27a73e0f78efaeb6e426268e6b5fa9201c50d0"

URI_aarch64_erfa = "${EPEL_MIRROR}/aarch64/Packages/e/erfa-2.0.1-5.el10_1.aarch64.rpm;name=aarch64_erfa;unpack=0"
SRC_URI:append = " ${URI_aarch64_erfa}"
SRC_URI[aarch64_erfa.sha256sum] = "600993b20052a7b71bc46707f3f01eab8e453bd6de98514409d787640583a2cb"

URI_aarch64_erfa-devel = "${EPEL_MIRROR}/aarch64/Packages/e/erfa-devel-2.0.1-5.el10_1.aarch64.rpm;name=aarch64_erfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_erfa-devel}"
SRC_URI[aarch64_erfa-devel.sha256sum] = "0bf156d37615187b06b1e66167345285fcdd00e2d9d4cb02bc2bbb879f95091a"

RDEPENDS:erfa = " \
 glibc \
 "
RDEPENDS:erfa-devel = " \
 erfa \
 pkgconf-pkg-config \
 "
