# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-shirou-gopsutil"
PV = "3.24.5"
PR = "3.el10_0"
PACKAGES = " \
 golang-github-shirou-gopsutil-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-shirou-gopsutil-3.24.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b49979753a342249a6d958e7badb97550cd0fc40b9b270941838cc94b654a541"

URI_x86_64_v2_golang-github-shirou-gopsutil-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-shirou-gopsutil-devel-3.24.5-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-shirou-gopsutil-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-shirou-gopsutil-devel}"
SRC_URI[x86_64_v2_golang-github-shirou-gopsutil-devel.sha256sum] = "a9fff6ac783e99f8e8d6c72a9f19d7ff596921e8856a3224751c378ab432ee2b"

URI_aarch64_golang-github-shirou-gopsutil-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-shirou-gopsutil-devel-3.24.5-3.el10_0.noarch.rpm;name=aarch64_golang-github-shirou-gopsutil-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-shirou-gopsutil-devel}"
SRC_URI[aarch64_golang-github-shirou-gopsutil-devel.sha256sum] = "916fff308442a760248636ebcbacf5754443c083959fbf095d60d7b79d0f1185"

RDEPENDS:golang-github-shirou-gopsutil-devel = " \
 go-filesystem \
 golang-github-tklauser-sysconf-devel \
 golang-x-sys-devel \
 "
