# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-negotiate"
PV = "0.23.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-negotiate+default-devel \
 rust-gix-negotiate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-negotiate-0.23.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dceead986241677003113f625a9b90f5869587a88d30c1ba862d37118a2396e2"

URI_x86_64_v2_rust-gix-negotiate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate+default-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate+default-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate+default-devel.sha256sum] = "0de5f82248b8e4870c996e1015f3bb284226cb4fd366727cdc3c12e7a67f974d"

URI_x86_64_v2_rust-gix-negotiate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate-devel-0.23.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate-devel.sha256sum] = "2affa34e342dace550dfa419a9dc6a395b8cd2890c9fb28287d56775705a0159"

URI_aarch64_rust-gix-negotiate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate+default-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-negotiate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate+default-devel}"
SRC_URI[aarch64_rust-gix-negotiate+default-devel.sha256sum] = "053bdea93d77ae318132ec364f5c34b1bf5b64f8c90a7e158cd33f516870f607"

URI_aarch64_rust-gix-negotiate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate-devel-0.23.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-negotiate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate-devel}"
SRC_URI[aarch64_rust-gix-negotiate-devel.sha256sum] = "3b3fb7b09f082e46bacd9ae1a027cd5e544bba57cf789eac708869c1d891da0b"

RDEPENDS:rust-gix-negotiate+default-devel = " \
 cargo \
 rust-gix-negotiate-devel \
 "
RDEPENDS:rust-gix-negotiate-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
