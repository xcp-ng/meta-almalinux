# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslotest"
PV = "6.0.0"
PR = "4.el10_2"
PACKAGES = " \
 python-oslotest-doc \
 python3-oslotest \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslotest-6.0.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce7227975fded54d2cc840740d290cf0cffc6c04cc3ad728ee3dd0363b8cd877"

URI_x86_64_v2_python-oslotest-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslotest-doc-6.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslotest-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslotest-doc}"
SRC_URI[x86_64_v2_python-oslotest-doc.sha256sum] = "3892148f3db3c010eca6c706721c7ce710edbd5e610a8a9ef36065c473df0c0d"

URI_x86_64_v2_python3-oslotest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslotest-6.0.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslotest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslotest}"
SRC_URI[x86_64_v2_python3-oslotest.sha256sum] = "e18d8f69424bacb4a9c021da4c7d99065d7da850c2a3544048c6307ba50bb0b1"

URI_aarch64_python-oslotest-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslotest-doc-6.0.0-4.el10_2.noarch.rpm;name=aarch64_python-oslotest-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslotest-doc}"
SRC_URI[aarch64_python-oslotest-doc.sha256sum] = "8ea668a66721a421a16c56ae8d3e77f6bb0109ea50b13733e60a2fce670c8c00"

URI_aarch64_python3-oslotest = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslotest-6.0.0-4.el10_2.noarch.rpm;name=aarch64_python3-oslotest;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslotest}"
SRC_URI[aarch64_python3-oslotest.sha256sum] = "0e1b2bf9901143d5111649764cb31c907d04172ce6f1c94346efad14d8cb6874"

RDEPENDS:python-oslotest-doc = " \
 "
RDEPENDS:python3-oslotest = " \
 bash \
 python3 \
 python3-fixtures \
 python3-subunit \
 python3-testtools \
 "
