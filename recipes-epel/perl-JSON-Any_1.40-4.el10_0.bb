# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-JSON-Any"
PV = "1.40"
PR = "4.el10_0"
PACKAGES = " \
 perl-JSON-Any \
 perl-JSON-Any-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-JSON-Any-1.40-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bd8bdf057be34a5439af714bafcb16746a84506df71cf66195f511566745a81"

URI_x86_64_v2_perl-JSON-Any = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-JSON-Any-1.40-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-JSON-Any;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-JSON-Any}"
SRC_URI[x86_64_v2_perl-JSON-Any.sha256sum] = "7372e413ee97f575a269ca212d0f715ea7fcb0e0e137fe355ae0f0b5fd86e543"

URI_x86_64_v2_perl-JSON-Any-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-JSON-Any-tests-1.40-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-JSON-Any-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-JSON-Any-tests}"
SRC_URI[x86_64_v2_perl-JSON-Any-tests.sha256sum] = "de284d25ab174af099668437f5e3a692d42d87d016b3f8b631664797e3ff4e48"

URI_aarch64_perl-JSON-Any = "${EPEL_MIRROR}/aarch64/Packages/p/perl-JSON-Any-1.40-4.el10_0.noarch.rpm;name=aarch64_perl-JSON-Any;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-JSON-Any}"
SRC_URI[aarch64_perl-JSON-Any.sha256sum] = "c7fe175c4819f70f93f43b7f191ef24c47fa710361c988492fb0fffad5b048c4"

URI_aarch64_perl-JSON-Any-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-JSON-Any-tests-1.40-4.el10_0.noarch.rpm;name=aarch64_perl-JSON-Any-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-JSON-Any-tests}"
SRC_URI[aarch64_perl-JSON-Any-tests.sha256sum] = "dc2eba156026493e8e1e8612861baf951dfb57daab3d84e87ccccce327c17d41"

RDEPENDS:perl-JSON-Any = " \
 perl-Carp \
 perl-JSON-XS \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-JSON-Any-tests = " \
 perl-JSON-Any \
 perl-Test-Harness \
 "
