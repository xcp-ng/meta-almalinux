# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-b4"
PV = "0.14.3"
PR = "2.el10_2"
PACKAGES = " \
 b4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-b4-0.14.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5d6a647e5da8fd4bf73d743eb49a8d0cf88caa0b99fe630af28d1be71b690c4"

URI_x86_64_v2_b4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/b4-0.14.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_b4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_b4}"
SRC_URI[x86_64_v2_b4.sha256sum] = "386ae91acbabf02d6d62f4cf570e2ce88861dade7599bb8fe438dba27d867ccd"

URI_aarch64_b4 = "${EPEL_MIRROR}/aarch64/Packages/b/b4-0.14.3-2.el10_2.noarch.rpm;name=aarch64_b4;unpack=0"
SRC_URI:append = " ${URI_aarch64_b4}"
SRC_URI[aarch64_b4.sha256sum] = "1645da03d8515567da0751512dada8d54e88ff0fc67ceb89317d0fb78494e3eb"

RDEPENDS:b4 = " \
 git-filter-repo \
 patatt \
 python3 \
 python3-dkimpy \
 python3-requests \
 "
