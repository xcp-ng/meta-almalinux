# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pinfo"
PV = "0.6.13"
PR = "9.el10_1"
PACKAGES = " \
 pinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pinfo-0.6.13-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a5b266347275842549a48576af711c6766a43ed7b9340e66567402fa184f6df"

URI_x86_64_v2_pinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pinfo-0.6.13-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pinfo}"
SRC_URI[x86_64_v2_pinfo.sha256sum] = "b47b8633b131f1944846126b80abb544719cafb43dfdf68571e403015d23a9f1"

URI_aarch64_pinfo = "${EPEL_MIRROR}/aarch64/Packages/p/pinfo-0.6.13-9.el10_1.aarch64.rpm;name=aarch64_pinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_pinfo}"
SRC_URI[aarch64_pinfo.sha256sum] = "2c2e846802fbafd14775aade91dc43fdc3b1b8d26705f58b6f0aa9af5bee1c49"

RDEPENDS:pinfo = " \
 glibc \
 ncurses-libs \
 xdg-utils \
 "
