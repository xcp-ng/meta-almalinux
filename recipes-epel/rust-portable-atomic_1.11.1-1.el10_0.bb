# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portable-atomic"
PV = "1.11.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-portable-atomic+critical-section-devel \
 rust-portable-atomic+default-devel \
 rust-portable-atomic+disable-fiq-devel \
 rust-portable-atomic+fallback-devel \
 rust-portable-atomic+float-devel \
 rust-portable-atomic+force-amo-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic+s-mode-devel \
 rust-portable-atomic+serde-devel \
 rust-portable-atomic+std-devel \
 rust-portable-atomic+unsafe-assume-single-core-devel \
 rust-portable-atomic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-portable-atomic-1.11.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68ad69207d715774fc88f13088a6c46661c046dc5adf855fa7677fa45c7c96c4"

URI_x86_64_v2_rust-portable-atomic+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+critical-section-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+critical-section-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+critical-section-devel.sha256sum] = "826728e50a77d272f98784249123c8d2c371e788fa57870932a97f2a7b81cae1"

URI_x86_64_v2_rust-portable-atomic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+default-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+default-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+default-devel.sha256sum] = "a7746f592cc7b0ac4d4d8e59844e6606d1dd9d21be30ec674468b5080022b707"

URI_x86_64_v2_rust-portable-atomic+disable-fiq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+disable-fiq-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+disable-fiq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+disable-fiq-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+disable-fiq-devel.sha256sum] = "277744d4262cca73b62e8cb53dbd8c1ef38a0971157f40c055ad07ce527534dd"

URI_x86_64_v2_rust-portable-atomic+fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+fallback-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+fallback-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+fallback-devel.sha256sum] = "be78a98a71839d085b3e888c9b8833ae07fd24fde46f38f3936bd2d2be1affd0"

URI_x86_64_v2_rust-portable-atomic+float-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+float-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+float-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+float-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+float-devel.sha256sum] = "6673bf64c146f4415d92fefb3ba8cc22ecb71b3e6cb246de41bdbb0ab5c675e0"

URI_x86_64_v2_rust-portable-atomic+force-amo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+force-amo-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+force-amo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+force-amo-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+force-amo-devel.sha256sum] = "0e727fe69e2df9ad56c218074f0b4dc4a7b9848458df48c41d5095dbf27d9a52"

URI_x86_64_v2_rust-portable-atomic+require-cas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+require-cas-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+require-cas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+require-cas-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+require-cas-devel.sha256sum] = "279f8dd850645fa4d3c61a869b1d1ba844a4bdb58c752650450524348f96c117"

URI_x86_64_v2_rust-portable-atomic+s-mode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+s-mode-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+s-mode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+s-mode-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+s-mode-devel.sha256sum] = "d6892d43c66d98853f316f123f9df15e6fbbbbb058888b364e99fc4ceb0d0f44"

URI_x86_64_v2_rust-portable-atomic+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+serde-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+serde-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+serde-devel.sha256sum] = "20a6366b30f5aad1eab1a5875bf7c82f89953e4c1602fa7463121de3385ec7c1"

URI_x86_64_v2_rust-portable-atomic+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+std-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+std-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+std-devel.sha256sum] = "b673c6689ef54615deb87bb484211b6b27c72bbe8db07d99c8e10a6b0f95f07b"

URI_x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic+unsafe-assume-single-core-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic+unsafe-assume-single-core-devel.sha256sum] = "2e424a5ac134f810687882ff2eb080d33ccfe1a7bd1bb05bb9d113059de39945"

URI_x86_64_v2_rust-portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-devel-1.11.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-portable-atomic-devel.sha256sum] = "627a26a9c57445d471dbe2e0fc331663bea4bf7646a99c825694f3d9c465f75c"

URI_aarch64_rust-portable-atomic+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+critical-section-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+critical-section-devel}"
SRC_URI[aarch64_rust-portable-atomic+critical-section-devel.sha256sum] = "8ceb7112413ff5b19dd62c6c9085277bba9f0210fc6a24568973cd50a6c920c8"

URI_aarch64_rust-portable-atomic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+default-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+default-devel}"
SRC_URI[aarch64_rust-portable-atomic+default-devel.sha256sum] = "b6a0aaf9b18d19929b176ecec2e93092c7d73d1549787ea149f55969250459d9"

URI_aarch64_rust-portable-atomic+disable-fiq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+disable-fiq-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+disable-fiq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+disable-fiq-devel}"
SRC_URI[aarch64_rust-portable-atomic+disable-fiq-devel.sha256sum] = "d958f31680f9e6725126d5f171ae53f05103f487c255e0a2b0d06ef0088c2cd5"

URI_aarch64_rust-portable-atomic+fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+fallback-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+fallback-devel}"
SRC_URI[aarch64_rust-portable-atomic+fallback-devel.sha256sum] = "dcd7105610ff3f97af7240d7662d9b265ee783e0368cc7103e1200ee087221da"

URI_aarch64_rust-portable-atomic+float-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+float-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+float-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+float-devel}"
SRC_URI[aarch64_rust-portable-atomic+float-devel.sha256sum] = "b834cd5b55de434cb75725b22ac814e59933efd889727ddd0f74180486aa3d62"

URI_aarch64_rust-portable-atomic+force-amo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+force-amo-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+force-amo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+force-amo-devel}"
SRC_URI[aarch64_rust-portable-atomic+force-amo-devel.sha256sum] = "bd0e14c3956aa79e40bb1e559f827b30b1e73dfca137c61775a1d4b1ff8745e7"

URI_aarch64_rust-portable-atomic+require-cas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+require-cas-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+require-cas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+require-cas-devel}"
SRC_URI[aarch64_rust-portable-atomic+require-cas-devel.sha256sum] = "026bee593e410c771957174c72b2ffd8a1a160e19cf7d7cbc1bb24b904ffa79f"

URI_aarch64_rust-portable-atomic+s-mode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+s-mode-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+s-mode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+s-mode-devel}"
SRC_URI[aarch64_rust-portable-atomic+s-mode-devel.sha256sum] = "ebc6f942827f23956dd351cf316a2ae6687fbd8925a074232d2d59b0446f9135"

URI_aarch64_rust-portable-atomic+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+serde-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+serde-devel}"
SRC_URI[aarch64_rust-portable-atomic+serde-devel.sha256sum] = "6442d92f29ce9515faaf5ee3dda22eccac283e70c34bb45e45b40636d1f6d202"

URI_aarch64_rust-portable-atomic+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+std-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+std-devel}"
SRC_URI[aarch64_rust-portable-atomic+std-devel.sha256sum] = "74f7c8d3e2b90b264303b9abde569cd25a1d8ff9fe8e3f83e4836f0f0361b8d1"

URI_aarch64_rust-portable-atomic+unsafe-assume-single-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic+unsafe-assume-single-core-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic+unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic+unsafe-assume-single-core-devel}"
SRC_URI[aarch64_rust-portable-atomic+unsafe-assume-single-core-devel.sha256sum] = "993d9eca0b4812d2e79827eaa926ab80586e4599b2139a4f35bc728923e842a3"

URI_aarch64_rust-portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-devel-1.11.1-1.el10_0.noarch.rpm;name=aarch64_rust-portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-portable-atomic-devel}"
SRC_URI[aarch64_rust-portable-atomic-devel.sha256sum] = "cc3db49da9613a16ed0375064ccb6b8c27d3f2ce51a853bb9e76f6682f3f9710"

RDEPENDS:rust-portable-atomic+critical-section-devel = " \
 cargo \
 rust-critical-section+default-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+default-devel = " \
 cargo \
 rust-portable-atomic+fallback-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+disable-fiq-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+fallback-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+float-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+force-amo-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+require-cas-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+s-mode-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+serde-devel = " \
 cargo \
 rust-portable-atomic-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-portable-atomic+std-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic+unsafe-assume-single-core-devel = " \
 cargo \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-portable-atomic-devel = " \
 cargo \
 rust \
 "
