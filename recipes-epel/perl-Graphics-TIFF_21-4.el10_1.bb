# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Graphics-TIFF"
PV = "21"
PR = "4.el10_1"
PACKAGES = " \
 perl-Graphics-TIFF \
 perl-Graphics-TIFF-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Graphics-TIFF-21-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a7e80499bdf9a2950c8d8807b9ca30edfa9b2eab4e52150365d5db5e4dccf48"

URI_x86_64_v2_perl-Graphics-TIFF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Graphics-TIFF-21-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Graphics-TIFF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Graphics-TIFF}"
SRC_URI[x86_64_v2_perl-Graphics-TIFF.sha256sum] = "008cde86ca24b9fcf2667e76c55621e9c9abdd19b22a15adfee4c8da50909bf1"

URI_x86_64_v2_perl-Graphics-TIFF-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Graphics-TIFF-tests-21-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Graphics-TIFF-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Graphics-TIFF-tests}"
SRC_URI[x86_64_v2_perl-Graphics-TIFF-tests.sha256sum] = "ca9409a719db867d8fa32e6349cc34a5796962cfd2daf52f86670bbebe98c6ff"

URI_aarch64_perl-Graphics-TIFF = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Graphics-TIFF-21-4.el10_1.aarch64.rpm;name=aarch64_perl-Graphics-TIFF;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Graphics-TIFF}"
SRC_URI[aarch64_perl-Graphics-TIFF.sha256sum] = "0afeabc9f3b2033b2fc5de56a4612df62f5f2e906c0911add217fe82cf968117"

URI_aarch64_perl-Graphics-TIFF-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Graphics-TIFF-tests-21-4.el10_1.noarch.rpm;name=aarch64_perl-Graphics-TIFF-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Graphics-TIFF-tests}"
SRC_URI[aarch64_perl-Graphics-TIFF-tests.sha256sum] = "cdccf0c6b38d07ef1e819d6eafa6df5eb1a91ce2930ad589bc0faa0d3dbf0856"

RDEPENDS:perl-Graphics-TIFF = " \
 glibc \
 libtiff \
 perl-Exporter \
 perl-Readonly \
 perl-base \
 perl-libs \
 "
RDEPENDS:perl-Graphics-TIFF-tests = " \
 ImageMagick \
 ImageMagick-perl \
 bash \
 perl-English \
 perl-File-Temp \
 perl-Graphics-TIFF \
 perl-IPC-Cmd \
 perl-PathTools \
 perl-Readonly \
 perl-Test-Deep \
 perl-Test-Harness \
 perl-Test-Requires \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
