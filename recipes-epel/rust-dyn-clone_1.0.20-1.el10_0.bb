# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dyn-clone"
PV = "1.0.20"
PR = "1.el10_0"
PACKAGES = " \
 rust-dyn-clone+default-devel \
 rust-dyn-clone-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dyn-clone-1.0.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e1fafcca929baeaab3ebc36864fb541c8944706d54146754ef18078476fc20e"

URI_x86_64_v2_rust-dyn-clone+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dyn-clone+default-devel-1.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dyn-clone+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dyn-clone+default-devel}"
SRC_URI[x86_64_v2_rust-dyn-clone+default-devel.sha256sum] = "b4b96b140e6a6816436c49a97e097156ee3b762b9aba99ba4f4291c2d2132331"

URI_x86_64_v2_rust-dyn-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dyn-clone-devel-1.0.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dyn-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dyn-clone-devel}"
SRC_URI[x86_64_v2_rust-dyn-clone-devel.sha256sum] = "89bb5f5734051a6781341f4015467d9a1720b0f8763c7a05afa211ffaae4926d"

URI_aarch64_rust-dyn-clone+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dyn-clone+default-devel-1.0.20-1.el10_0.noarch.rpm;name=aarch64_rust-dyn-clone+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dyn-clone+default-devel}"
SRC_URI[aarch64_rust-dyn-clone+default-devel.sha256sum] = "2206a2f9e5c6d86cb847631f0a84fd9ccd78872643b2dcbd2faa33848c4a083d"

URI_aarch64_rust-dyn-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dyn-clone-devel-1.0.20-1.el10_0.noarch.rpm;name=aarch64_rust-dyn-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dyn-clone-devel}"
SRC_URI[aarch64_rust-dyn-clone-devel.sha256sum] = "f39b246d7d5aede5d4c9c772b053ccebbeb3681a9a06d8e6e7da50bed369cc82"

RDEPENDS:rust-dyn-clone+default-devel = " \
 cargo \
 rust-dyn-clone-devel \
 "
RDEPENDS:rust-dyn-clone-devel = " \
 cargo \
 rust \
 "
