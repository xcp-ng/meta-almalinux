# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qthttpserver"
PV = "6.9.1"
PR = "1.el10_1"
PACKAGES = " \
 qt6-qthttpserver \
 qt6-qthttpserver-devel \
 qt6-qthttpserver-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qthttpserver-6.9.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bddc2734bf2f29e0d8add75d2b4e2c43b46005b4d6f94c4fabeb433e3307731d"

URI_x86_64_v2_qt6-qthttpserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qthttpserver-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qthttpserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qthttpserver}"
SRC_URI[x86_64_v2_qt6-qthttpserver.sha256sum] = "7e3968c690cb0b9bf27b42fe1d2513e34c98e8b278f1ecce0bdfa8547fcae6cf"

URI_x86_64_v2_qt6-qthttpserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qthttpserver-devel-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qthttpserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qthttpserver-devel}"
SRC_URI[x86_64_v2_qt6-qthttpserver-devel.sha256sum] = "16ee19aed0d5126c9df0c6bc8ec869baf5ea5bdff99a080359942ad67b322d45"

URI_x86_64_v2_qt6-qthttpserver-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qthttpserver-examples-6.9.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qthttpserver-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qthttpserver-examples}"
SRC_URI[x86_64_v2_qt6-qthttpserver-examples.sha256sum] = "7416aeed37ae6d997b8a384ed77c87c69ceb1017b9d71369536086c4fb8084cb"

URI_aarch64_qt6-qthttpserver = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qthttpserver-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qthttpserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qthttpserver}"
SRC_URI[aarch64_qt6-qthttpserver.sha256sum] = "416b052d6c0ea7f2d3131016e5f792be794e7bc3e1e00dae6f85aea55b2d6880"

URI_aarch64_qt6-qthttpserver-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qthttpserver-devel-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qthttpserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qthttpserver-devel}"
SRC_URI[aarch64_qt6-qthttpserver-devel.sha256sum] = "40039402c86e51576bbc7a092c5a18dd690111044ff56973603a5bb5b975b8b9"

URI_aarch64_qt6-qthttpserver-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qthttpserver-examples-6.9.1-1.el10_1.aarch64.rpm;name=aarch64_qt6-qthttpserver-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qthttpserver-examples}"
SRC_URI[aarch64_qt6-qthttpserver-examples.sha256sum] = "42c64ef844369cc773b1001d0ae1d81440c65bd43a116dce10c4ebcadbf71fd2"

RDEPENDS:qt6-qthttpserver = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtwebsockets \
 "
RDEPENDS:qt6-qthttpserver-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qthttpserver \
 qt6-qtwebsockets-devel \
 "
RDEPENDS:qt6-qthttpserver-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qthttpserver \
 qt6-qthttpserver-devel \
 "
