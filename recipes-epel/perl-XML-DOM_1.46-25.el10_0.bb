# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-DOM"
PV = "1.46"
PR = "25.el10_0"
PACKAGES = " \
 perl-XML-DOM \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-DOM-1.46-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3deaca79863926ea2be4c127a3b5dc3cab38ec4f5efd4386780411091d05cb2e"

URI_x86_64_v2_perl-XML-DOM = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-DOM-1.46-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-DOM;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-DOM}"
SRC_URI[x86_64_v2_perl-XML-DOM.sha256sum] = "3d99865f5858d4503c01f2da9b36132ae93c59958a7be2c180632182b4a2bfb6"

URI_aarch64_perl-XML-DOM = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-DOM-1.46-25.el10_0.noarch.rpm;name=aarch64_perl-XML-DOM;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-DOM}"
SRC_URI[aarch64_perl-XML-DOM.sha256sum] = "f862258753dd0a72d5b10e5e64f2f2b0e97a3142099fb051590f63a0a6356094"

RDEPENDS:perl-XML-DOM = " \
 perl-Carp \
 perl-Exporter \
 perl-XML-DOM \
 perl-XML-Parser \
 perl-XML-RegExp \
 perl-libs \
 perl-libwww-perl \
 perl-overload \
 perl-vars \
 "
