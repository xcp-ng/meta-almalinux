# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "amdsmi"
PV = "7.1.1"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 amdsmi \
 amdsmi-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/a/amdsmi-7.1.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e93f5a2ab10d89eac8fedda903d8c99b4aaa9f83cb860207d555efbc0f01dfd"

URI_x86_64_v2_amdsmi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amdsmi-7.1.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amdsmi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amdsmi}"
SRC_URI[x86_64_v2_amdsmi.sha256sum] = "b2169f3fc45b8abd6416e71fe1ede0dbc494c08e8703621e0e44ef7d3469215d"

URI_x86_64_v2_amdsmi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/amdsmi-devel-7.1.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_amdsmi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_amdsmi-devel}"
SRC_URI[x86_64_v2_amdsmi-devel.sha256sum] = "49e885a3a0b98406d9c90b8db98f4d52a7914888ff7c0bc02ffa2305ecfb1101"

RDEPENDS:amdsmi = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-pyyaml \
 "
RDEPENDS:amdsmi-devel = " \
 amdsmi \
 cmake-filesystem \
 "
