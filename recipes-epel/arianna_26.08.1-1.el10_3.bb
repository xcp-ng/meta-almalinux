# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "arianna"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 arianna \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/arianna-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "09363bbd86fa1755dde1ca1176f3d3a0f5a5514c68dd6b250ba3b631e00abca3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/arianna-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_arianna;unpack=0"
SRC_URI[x86_64_v2_arianna.sha256sum] = "6c21a0d6b5e4583119bc8067e3ebd3aa647ad40212fe51f58ae159deb6947727"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/arianna-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_arianna;unpack=0"
SRC_URI[aarch64_arianna.sha256sum] = "1d0502a7586d17c917bfc2b7fe15c43c5faeb6d1e8737c5de8688a2228e5d774"

RDEPENDS:arianna = " \
 glibc \
 kf6-baloo-libs \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kquickcharts \
 kf6-kwindowsystem \
 kf6-qqc2-desktop-style \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qthttpserver \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 "
