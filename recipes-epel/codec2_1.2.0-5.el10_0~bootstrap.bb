# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "codec2"
PV = "1.2.0"
PR = "5.el10_0~bootstrap"
PACKAGES = " \
 codec2 \
 codec2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/codec2-1.2.0-5.el10_0~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2dc35265119d6b9b67725f77bab1f6909d4f539aab7db51924c6a1de80c2722"

URI_x86_64_v2_codec2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codec2-1.2.0-5.el10_0~bootstrap.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codec2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codec2}"
SRC_URI[x86_64_v2_codec2.sha256sum] = "f4596a83af0514e8495f69ac402d0013a82ebb57ab6787865e8479d8afba1f98"

URI_x86_64_v2_codec2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/codec2-devel-1.2.0-5.el10_0~bootstrap.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_codec2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_codec2-devel}"
SRC_URI[x86_64_v2_codec2-devel.sha256sum] = "ae8d16d8e7789a4a0850d26abe23632d95739b1baf36ae68853cb72fa17192b5"

URI_aarch64_codec2 = "${EPEL_MIRROR}/aarch64/Packages/c/codec2-1.2.0-5.el10_0~bootstrap.aarch64.rpm;name=aarch64_codec2;unpack=0"
SRC_URI:append = " ${URI_aarch64_codec2}"
SRC_URI[aarch64_codec2.sha256sum] = "60b42659649e2415dc069a0ebf170ce541da167c185518b547f4d7214de84d1a"

URI_aarch64_codec2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/codec2-devel-1.2.0-5.el10_0~bootstrap.aarch64.rpm;name=aarch64_codec2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_codec2-devel}"
SRC_URI[aarch64_codec2-devel.sha256sum] = "8b214ae8201b1487ddbc84ddec6adefaa5a8d065abdc59924806b814ca29d4ff"

RDEPENDS:codec2 = " \
 glibc \
 "
RDEPENDS:codec2-devel = " \
 cmake-filesystem \
 codec2 \
 pkgconf-pkg-config \
 "
