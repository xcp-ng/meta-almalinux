# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Declare-Constraints-Simple"
PV = "0.03"
PR = "51.el10_0"
PACKAGES = " \
 perl-Declare-Constraints-Simple \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Declare-Constraints-Simple-0.03-51.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f52cbe8044004674868d35b66d1a3432f6d10aa42ab4e26b8f88bc15c7b94e57"

URI_x86_64_v2_perl-Declare-Constraints-Simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Declare-Constraints-Simple-0.03-51.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Declare-Constraints-Simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Declare-Constraints-Simple}"
SRC_URI[x86_64_v2_perl-Declare-Constraints-Simple.sha256sum] = "8bec6094cc84a5b109fc3b7b27515a5457b43263b03ac1809c559a882687dec6"

URI_aarch64_perl-Declare-Constraints-Simple = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Declare-Constraints-Simple-0.03-51.el10_0.noarch.rpm;name=aarch64_perl-Declare-Constraints-Simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Declare-Constraints-Simple}"
SRC_URI[aarch64_perl-Declare-Constraints-Simple.sha256sum] = "2ec1d2addcb32f705fc4de2dc90d1a7fcbbc5d4eb591cb288016e10f40837010"

RDEPENDS:perl-Declare-Constraints-Simple = " \
 perl-Carp-Clan \
 perl-Class-Inspector \
 perl-Scalar-List-Utils \
 perl-aliased \
 perl-base \
 perl-libs \
 perl-overload \
 "
