# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql16-postgis"
PV = "3.5.3"
PR = "4.el10_2.1"
PACKAGES = " \
 postgis \
 postgis-client \
 postgis-docs \
 postgis-upgrade \
 postgis-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql16-postgis-3.5.3-4.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ff6edf6f7c4a5937e4bbfc09145e6065011b1ec91a6f40a8e7142b12522fa5ce"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - postgis-client: libgeos_c.so.1()(64bit)
# - postgis-upgrade: libgeos_c.so.1()(64bit)
# - postgis: libgeos_c.so.1()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-3.5.3-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgis;unpack=0"
SRC_URI[x86_64_v2_postgis.sha256sum] = "8d027cf981846635f2d259dc382db8ec64373e81ba6012bcafaf4362566784cf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-client-3.5.3-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgis-client;unpack=0"
SRC_URI[x86_64_v2_postgis-client.sha256sum] = "31a1c0615a09ba7acd6f2608b283a6ac76938ef2b03fbee3d58d3c34f844a081"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-docs-3.5.3-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgis-docs;unpack=0"
SRC_URI[x86_64_v2_postgis-docs.sha256sum] = "b2be65b456b4fe7eefd553e95df0c116cba85f73c64d96f61fd37fb72ffcb4cc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-upgrade-3.5.3-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgis-upgrade;unpack=0"
SRC_URI[x86_64_v2_postgis-upgrade.sha256sum] = "378c4260ed1c22e9d54e0a76d2cee58c55ba80eb2b7e5a2b49964101daf87037"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgis-utils-3.5.3-4.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_postgis-utils;unpack=0"
SRC_URI[x86_64_v2_postgis-utils.sha256sum] = "1d0ed039406ed2d8d181f1b7e3455ba0b6098a38e5eba9c6300d71e94a46226c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-3.5.3-4.el10_2.1.aarch64.rpm;name=aarch64_postgis;unpack=0"
SRC_URI[aarch64_postgis.sha256sum] = "00ed673f8451a70f58bfa7bba5343cca4bf202f4ef0adf5b858e18391b2a255b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-client-3.5.3-4.el10_2.1.aarch64.rpm;name=aarch64_postgis-client;unpack=0"
SRC_URI[aarch64_postgis-client.sha256sum] = "60cc4ef898a17e0c9e7e7d0de652ef6b493dd83fb2458177dc5e58c40e596d78"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-docs-3.5.3-4.el10_2.1.aarch64.rpm;name=aarch64_postgis-docs;unpack=0"
SRC_URI[aarch64_postgis-docs.sha256sum] = "4a68d903a9a308726a3b00e851f92cf6b70092c89dabd0afb844d45c798a68b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-upgrade-3.5.3-4.el10_2.1.aarch64.rpm;name=aarch64_postgis-upgrade;unpack=0"
SRC_URI[aarch64_postgis-upgrade.sha256sum] = "5a5fac3cc43ece602260686e9f8d2300d44c8d9363271f6d61bb03db23e2c2ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgis-utils-3.5.3-4.el10_2.1.aarch64.rpm;name=aarch64_postgis-utils;unpack=0"
SRC_URI[aarch64_postgis-utils.sha256sum] = "802698eb177cda1aa1ca9198933234833b8b592a2118c8256fe91a8910ae9220"

RDEPENDS:postgis:x86_64_v2 = " \
 gdal-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 proj \
 protobuf-c \
"
RDEPENDS:postgis:aarch64 = " \
 gdal-libs \
 geos \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 proj \
 protobuf-c \
"
RDEPENDS:postgis-client:x86_64_v2 = " \
 bash \
 gdal-libs \
 glibc \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 postgis \
 postgresql-private-libs \
 proj \
"
RDEPENDS:postgis-client:aarch64 = " \
 bash \
 gdal-libs \
 geos \
 glibc \
 perl-File-Basename \
 perl-interpreter \
 perl-libs \
 postgis \
 postgresql-private-libs \
 proj \
"
RDEPENDS:postgis-docs = " \
 "
RDEPENDS:postgis-upgrade:x86_64_v2 = " \
 gdal-libs \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 postgis \
 postgresql-upgrade \
 proj \
 protobuf-c \
"
RDEPENDS:postgis-upgrade:aarch64 = " \
 gdal-libs \
 geos \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 libxml2 \
 pcre2 \
 postgis \
 postgresql-upgrade \
 proj \
 protobuf-c \
"
RDEPENDS:postgis-utils = " \
 perl-DBD-Pg \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 postgis \
 "
