# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-gl"
PV = "0.20080515"
PR = "32.el10"
PACKAGES = " \
 hunspell-gl \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-gl-0.20080515-32.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3fbd172b9db7a3826b2d9a4369166c9b2c4471434aa322f9af942addb216562d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-gl-0.20080515-32.el10.noarch.rpm;name=x86_64_v2_hunspell-gl;unpack=0"
SRC_URI[x86_64_v2_hunspell-gl.sha256sum] = "3172cb3a8b547a3a2d8a70f472f95d76eabdde817782cf82b26af52f049dee9f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-gl-0.20080515-32.el10.noarch.rpm;name=aarch64_hunspell-gl;unpack=0"
SRC_URI[aarch64_hunspell-gl.sha256sum] = "3172cb3a8b547a3a2d8a70f472f95d76eabdde817782cf82b26af52f049dee9f"

RDEPENDS:hunspell-gl = " \
 hunspell-filesystem \
 "
