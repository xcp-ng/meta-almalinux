# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-calendrical_calculations"
PV = "0.2.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-calendrical_calculations+default-devel \
 rust-calendrical_calculations+logging-devel \
 rust-calendrical_calculations-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-calendrical_calculations-0.2.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "535a9cbdfd79eb40384451e2aab1d659770994e341b1533d9f971e5e04047eb1"

URI_x86_64_v2_rust-calendrical_calculations+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-calendrical_calculations+default-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-calendrical_calculations+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-calendrical_calculations+default-devel}"
SRC_URI[x86_64_v2_rust-calendrical_calculations+default-devel.sha256sum] = "c750e3e9c534db8a8f7a219c118264aaa904c164bfecc6bdb2deb7fd874388cb"

URI_x86_64_v2_rust-calendrical_calculations+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-calendrical_calculations+logging-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-calendrical_calculations+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-calendrical_calculations+logging-devel}"
SRC_URI[x86_64_v2_rust-calendrical_calculations+logging-devel.sha256sum] = "a2d4c1f44ddcf8c924f0fcf62aacb86f43dd9280741d617c80cff7d03dfa7c98"

URI_x86_64_v2_rust-calendrical_calculations-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-calendrical_calculations-devel-0.2.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-calendrical_calculations-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-calendrical_calculations-devel}"
SRC_URI[x86_64_v2_rust-calendrical_calculations-devel.sha256sum] = "ea04b39eea3d1c856350f892ef0068cf5f548730b3f7f46e23052cbcb941f72f"

URI_aarch64_rust-calendrical_calculations+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-calendrical_calculations+default-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-calendrical_calculations+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-calendrical_calculations+default-devel}"
SRC_URI[aarch64_rust-calendrical_calculations+default-devel.sha256sum] = "cf461b547f39816d727afb1381a35e12d5a25873d34190cbd0fc13151f113549"

URI_aarch64_rust-calendrical_calculations+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-calendrical_calculations+logging-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-calendrical_calculations+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-calendrical_calculations+logging-devel}"
SRC_URI[aarch64_rust-calendrical_calculations+logging-devel.sha256sum] = "99dc87b9d5944d0cb54c8cf3dd30f1046e263d6860d8a547da5c7e28e49a4cf3"

URI_aarch64_rust-calendrical_calculations-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-calendrical_calculations-devel-0.2.4-1.el10_3.noarch.rpm;name=aarch64_rust-calendrical_calculations-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-calendrical_calculations-devel}"
SRC_URI[aarch64_rust-calendrical_calculations-devel.sha256sum] = "3143d9ac6dc82d25e3fbfaf994e96ad0d747c788f0d46635f75ff3317c610ee3"

RDEPENDS:rust-calendrical_calculations+default-devel = " \
 cargo \
 rust-calendrical_calculations-devel \
 "
RDEPENDS:rust-calendrical_calculations+logging-devel = " \
 cargo \
 rust-calendrical_calculations-devel \
 rust-log-devel \
 "
RDEPENDS:rust-calendrical_calculations-devel = " \
 cargo \
 rust \
 rust-core_maths-devel \
 rust-displaydoc-devel \
 "
