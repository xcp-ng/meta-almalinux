# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma5support"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma5support \
 plasma5support-devel \
 plasma5support-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma5support-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "13f3d81ea10c71b2725f74308a9653b0441af09e176fb798e0791899f32fc783"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support;unpack=0"
SRC_URI[x86_64_v2_plasma5support.sha256sum] = "055e0dbf6bcbfb8f1907b1f9073951befa3cf64258ed8a646576daaca1f7083a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma5support-devel;unpack=0"
SRC_URI[x86_64_v2_plasma5support-devel.sha256sum] = "cb04aa4487d5d3df6b82df15b0b89537a2f4f5c99555e8443d10f8afb83f188b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma5support-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma5support-doc;unpack=0"
SRC_URI[x86_64_v2_plasma5support-doc.sha256sum] = "e50f92886cb6c97e9bc0d4855898737219b8089b82bd2b74f769119dc1dc136c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma5support;unpack=0"
SRC_URI[aarch64_plasma5support.sha256sum] = "c58f3b6e2412fc93ddf9ebd32403b558fedf02c819a70c0d2c76c4c896e20d79"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma5support-devel;unpack=0"
SRC_URI[aarch64_plasma5support-devel.sha256sum] = "e2de45e6a04cd40571e7fbbfc68d4a2ce6c5dc708b5426df827d344df442ca46"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma5support-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma5support-doc;unpack=0"
SRC_URI[aarch64_plasma5support-doc.sha256sum] = "66b48fa55ec9b2bf8394c4995d02d70b55cfa54cb3acb07ca99098774cf7237f"

RDEPENDS:plasma5support = " \
 glibc \
 gpsd-libs \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kunitconversion \
 kf6-networkmanager-qt \
 kf6-solid \
 libX11 \
 libXfixes \
 libksysguard \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma5support-devel = " \
 cmake-filesystem \
 plasma5support \
 qt6-qtbase-devel \
 "
RDEPENDS:plasma5support-doc = " \
 "
