# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pie"
PV = "1.4.10"
PR = "1.el10_2"
PACKAGES = " \
 pie \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pie-1.4.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bf426e9597845aa40d3f5e42e905031b07fa5a4a2824971b561c0cf5df7b9590"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pie-1.4.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pie;unpack=0"
SRC_URI[x86_64_v2_pie.sha256sum] = "4141cb4c565b3f2afe8ca3ea286609dc381cf48fc10938342801670d9e26d75f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pie-1.4.10-1.el10_2.noarch.rpm;name=aarch64_pie;unpack=0"
SRC_URI[aarch64_pie.sha256sum] = "396d555c533fe4a4b0ec3add0e09d61095f383b63081a404a1008fe7254e80e0"

RDEPENDS:pie = " \
 bash \
 ca-certificates \
 virtual//usr/bin/php \
 virtual/php-cli \
 virtual/php-ctype \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-mbstring \
 virtual/php-phar \
 virtual/php-posix \
 virtual/php-zip \
 virtual/php_language__ge_8.1 \
 "
