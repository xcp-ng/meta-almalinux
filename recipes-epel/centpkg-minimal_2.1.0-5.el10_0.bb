# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "centpkg-minimal"
PV = "2.1.0"
PR = "5.el10_0"
PACKAGES = " \
 centpkg-minimal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/centpkg-minimal-2.1.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e2f8bae82b9b4ecba525b42a53ff731113627322c472bb5798ab74d3f70542d9"

URI_x86_64_v2_centpkg-minimal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centpkg-minimal-2.1.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_centpkg-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_centpkg-minimal}"
SRC_URI[x86_64_v2_centpkg-minimal.sha256sum] = "4c4097ca4e231dea7934369604aeec5f3870456f8d94a2aef111a6762a402da0"

URI_aarch64_centpkg-minimal = "${EPEL_MIRROR}/aarch64/Packages/c/centpkg-minimal-2.1.0-5.el10_0.noarch.rpm;name=aarch64_centpkg-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_centpkg-minimal}"
SRC_URI[aarch64_centpkg-minimal.sha256sum] = "815dc2933c23a955e2c58b189b03f8ca69910f8aadf105cb8640b9bdddec51f1"

RDEPENDS:centpkg-minimal = " \
 bash \
 curl \
 git-core \
 util-linux \
 "
