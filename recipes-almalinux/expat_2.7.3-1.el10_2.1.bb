# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "expat"
PV = "2.7.3"
PR = "1.el10_2.1"
PACKAGES = " \
 expat \
 expat-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/expat-2.7.3-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25a557160b2956a035b16dee63b4bc659cf951ba9448cd240bcc338272b16801"

URI_x86_64_v2_expat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/expat-2.7.3-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_expat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_expat}"
SRC_URI[x86_64_v2_expat.sha256sum] = "c6ae02d6a0433d3ccc3c893e38763abab104ef2ebb227fe0becab5fea242a19b"

URI_x86_64_v2_expat-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/expat-devel-2.7.3-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_expat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_expat-devel}"
SRC_URI[x86_64_v2_expat-devel.sha256sum] = "7c8cf73a61ca7c18212476bb5c096cff2c35a0c5e0761fbf0bd970eae7eb428f"

URI_aarch64_expat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/expat-2.7.3-1.el10_2.1.aarch64.rpm;name=aarch64_expat;unpack=0"
SRC_URI:append = " ${URI_aarch64_expat}"
SRC_URI[aarch64_expat.sha256sum] = "30d112bbb30a0f0672230701f9da3eda2e254ae74e6b319f986ee1aa7d6fb0f0"

URI_aarch64_expat-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/expat-devel-2.7.3-1.el10_2.1.aarch64.rpm;name=aarch64_expat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_expat-devel}"
SRC_URI[aarch64_expat-devel.sha256sum] = "80f1733d10419f3a01342b4ee8a29d198004fff14d488d3f0996566401ceed26"

RDEPENDS:expat = " \
 glibc \
 "
RDEPENDS:expat-devel = " \
 expat \
 pkgconf-pkg-config \
 "
