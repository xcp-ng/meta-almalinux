# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-mailmap"
PV = "0.33.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-mailmap+default-devel \
 rust-gix-mailmap+document-features-devel \
 rust-gix-mailmap+serde-devel \
 rust-gix-mailmap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-mailmap-0.33.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "389b2ce2c2c5d4d68fdb2aa3b086fc4b59954d93021cb82e6a3771a17ef6077c"

URI_x86_64_v2_rust-gix-mailmap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+default-devel-0.33.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+default-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+default-devel.sha256sum] = "8a150fdf49f00756b444afc9aedbf8314a708f3cd0c9ca0175b929bd8866ac4c"

URI_x86_64_v2_rust-gix-mailmap+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+document-features-devel-0.33.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+document-features-devel.sha256sum] = "f51c132224ea5bc42a10d77c4e3b313530c9f03a673579091bafecb64aa9309a"

URI_x86_64_v2_rust-gix-mailmap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap+serde-devel-0.33.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap+serde-devel.sha256sum] = "b952537e74f7c4f8b10dcb9094c8c0620a0edf074a1215fc04c3b046aca25b4a"

URI_x86_64_v2_rust-gix-mailmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-mailmap-devel-0.33.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-mailmap-devel}"
SRC_URI[x86_64_v2_rust-gix-mailmap-devel.sha256sum] = "620191c31ff9da3eae96fa4ba4079db0ca1359c80f3cc237f5617f3ea5958b8d"

URI_aarch64_rust-gix-mailmap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+default-devel-0.33.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-mailmap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+default-devel}"
SRC_URI[aarch64_rust-gix-mailmap+default-devel.sha256sum] = "d026b914e2c407189d73881a6756c7934eb50abe2daf3468a7e0c4faacb98bc5"

URI_aarch64_rust-gix-mailmap+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+document-features-devel-0.33.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-mailmap+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+document-features-devel}"
SRC_URI[aarch64_rust-gix-mailmap+document-features-devel.sha256sum] = "3d27532cb8922e890791cb9eb8e63f7725681e49cde2748530234243df797c9e"

URI_aarch64_rust-gix-mailmap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap+serde-devel-0.33.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-mailmap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap+serde-devel}"
SRC_URI[aarch64_rust-gix-mailmap+serde-devel.sha256sum] = "488bd4fb99b8a216e5d8105ac7fd71f5abb965bf130c33796d42219ecf1011f6"

URI_aarch64_rust-gix-mailmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-mailmap-devel-0.33.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-mailmap-devel}"
SRC_URI[aarch64_rust-gix-mailmap-devel.sha256sum] = "21042d74d786fafbc24120389c9c4c80b36e2cab9015a7db3053c52d1b19ce9d"

RDEPENDS:rust-gix-mailmap+default-devel = " \
 cargo \
 rust-gix-mailmap-devel \
 "
RDEPENDS:rust-gix-mailmap+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-mailmap-devel \
 "
RDEPENDS:rust-gix-mailmap+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-actor+serde-devel \
 rust-gix-mailmap-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-mailmap-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-actor+default-devel \
 rust-gix-date+default-devel \
 rust-gix-error+default-devel \
 "
