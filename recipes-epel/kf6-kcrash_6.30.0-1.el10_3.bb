# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcrash"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcrash \
 kf6-kcrash-devel \
 kf6-kcrash-doc \
 kf6-kcrash-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kcrash-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cb9b68cb3de6aeb62fe85f7d93875a60d89cab276f0e156d59b1df7a5cffcf3b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash;unpack=0"
SRC_URI[x86_64_v2_kf6-kcrash.sha256sum] = "d6aed1b726ee098405aebff3e5a14c64ede2d2741c1d97768f089d4bfc2ab402"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kcrash-devel.sha256sum] = "6d083c0aff9faeb67a0c4b575794f8fa1fc528e3b2be64dfa7165145cee47878"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcrash-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kcrash-doc.sha256sum] = "a9a5fed7f7f0d3fa5c477f8642f20118d650074b4a4fca81d3745613d70ac634"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcrash-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kcrash-html.sha256sum] = "c3f1bf18256db77929fd9886854343dd40f303d77283b5df16a9758f56906aef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcrash;unpack=0"
SRC_URI[aarch64_kf6-kcrash.sha256sum] = "528b3dd407da18519916a1759874717993285044f5cd03216dfe58c9efc00d44"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcrash-devel;unpack=0"
SRC_URI[aarch64_kf6-kcrash-devel.sha256sum] = "c535535b75823d81a91d722f50732c298af6359dbea3c5f2669127909aebea02"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcrash-doc;unpack=0"
SRC_URI[aarch64_kf6-kcrash-doc.sha256sum] = "9bf678e80a29780ee18f2fa75cd589207a93db5f669d95e2e3087ec148ad25cd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcrash-html;unpack=0"
SRC_URI[aarch64_kf6-kcrash-html.sha256sum] = "c90a6c5d4f99b397f6476d1da04c9036a53a03fe899c564c5be65934b471853b"

RDEPENDS:kf6-kcrash = " \
 glibc \
 kf6-kcoreaddons \
 libX11 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcrash-devel = " \
 cmake-filesystem \
 kf6-kcrash \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcrash-doc = " \
 "
RDEPENDS:kf6-kcrash-html = " \
 "
