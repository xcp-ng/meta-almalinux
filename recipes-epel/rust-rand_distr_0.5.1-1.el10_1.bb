# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_distr"
PV = "0.5.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-rand_distr+alloc-devel \
 rust-rand_distr+default-devel \
 rust-rand_distr+serde-devel \
 rust-rand_distr+std-devel \
 rust-rand_distr+std_math-devel \
 rust-rand_distr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_distr-0.5.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40049beef10db3ec29564b18a0987c4bee541685c39d7d71c79ddc2adac62f82"

URI_x86_64_v2_rust-rand_distr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+alloc-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+alloc-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+alloc-devel.sha256sum] = "7dadb673d0254635e0b121798c22a59792cd37a9cd754048e43cb1c58e88151b"

URI_x86_64_v2_rust-rand_distr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+default-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+default-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+default-devel.sha256sum] = "f2bc44c593ccd10e0bbfd1605f1147c453138892eed76757c58cb4526d57d4d2"

URI_x86_64_v2_rust-rand_distr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+serde-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+serde-devel.sha256sum] = "2c38ca344a158371baab5878135157ac9b8907384fc0a3ba28403b4346bc66be"

URI_x86_64_v2_rust-rand_distr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+std-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+std-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+std-devel.sha256sum] = "d9fde490cbbb4417e08847be615ae4b46a16a5825859db5e8db496314d5b0eef"

URI_x86_64_v2_rust-rand_distr+std_math-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr+std_math-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr+std_math-devel}"
SRC_URI[x86_64_v2_rust-rand_distr+std_math-devel.sha256sum] = "e97f70694e5883af26dc5a7a2679af64e9cedf79448ea101e1681e7f0368cbd1"

URI_x86_64_v2_rust-rand_distr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_distr-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_distr-devel}"
SRC_URI[x86_64_v2_rust-rand_distr-devel.sha256sum] = "fe1dbaa3f419fb3f118bb387928068409aca05c06da87896eda918e5a94f59e6"

URI_aarch64_rust-rand_distr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+alloc-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-rand_distr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+alloc-devel}"
SRC_URI[aarch64_rust-rand_distr+alloc-devel.sha256sum] = "edc3f5e0bfb21b44097f6e69baf3938c4834f7964c3b1d0f1815d4b815cdd038"

URI_aarch64_rust-rand_distr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+default-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-rand_distr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+default-devel}"
SRC_URI[aarch64_rust-rand_distr+default-devel.sha256sum] = "11274b6d4034a3ab909d082a02b8dd1df26d772b2c959cbd43b018144db864f9"

URI_aarch64_rust-rand_distr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+serde-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-rand_distr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+serde-devel}"
SRC_URI[aarch64_rust-rand_distr+serde-devel.sha256sum] = "258f0b3f988fb99034928516cc7e2874bb4b1b4dba5adee50f6059da012aef87"

URI_aarch64_rust-rand_distr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+std-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-rand_distr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+std-devel}"
SRC_URI[aarch64_rust-rand_distr+std-devel.sha256sum] = "2f123397ab6f9f75fa9d72b7e5538bb8baebda5c1e9ebae4258c136df04e2669"

URI_aarch64_rust-rand_distr+std_math-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr+std_math-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-rand_distr+std_math-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr+std_math-devel}"
SRC_URI[aarch64_rust-rand_distr+std_math-devel.sha256sum] = "0d28105c315133c2b2f8bc0f67f380a2f6447e3712ff09f92ea3b09e4cd0ed6c"

URI_aarch64_rust-rand_distr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_distr-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-rand_distr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_distr-devel}"
SRC_URI[aarch64_rust-rand_distr-devel.sha256sum] = "5f6daa4996c9c328ab7ba5e22f54daf295ae48503cf874ca57277b5dc10db850"

RDEPENDS:rust-rand_distr+alloc-devel = " \
 cargo \
 rust-rand+alloc-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr+default-devel = " \
 cargo \
 rust-rand_distr+std-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr+serde-devel = " \
 cargo \
 rust-rand+serde-devel \
 rust-rand_distr-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_with+default-devel \
 "
RDEPENDS:rust-rand_distr+std-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand_distr+alloc-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr+std_math-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-rand_distr-devel \
 "
RDEPENDS:rust-rand_distr-devel = " \
 cargo \
 rust \
 rust-num-traits+libm-devel \
 rust-num-traits-devel \
 rust-rand-devel \
 "
