# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 libkworkspace6 \
 plasma-lookandfeel-fedora \
 plasma-workspace \
 plasma-workspace-common \
 plasma-workspace-devel \
 plasma-workspace-doc \
 plasma-workspace-libs \
 sddm-wayland-plasma \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5dde09d9a00c0a31803b95f95aa945b4bee23cb76b3876e1df81e31ffc97c53"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - plasma-workspace: kde-settings-plasma

URI_x86_64_v2_libkworkspace6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkworkspace6-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkworkspace6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkworkspace6}"
SRC_URI[x86_64_v2_libkworkspace6.sha256sum] = "eea43522877e01ba4e8acfbde1bed56345a9d35a114cae96b8daca5ba972cbed"

URI_x86_64_v2_plasma-lookandfeel-fedora = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-lookandfeel-fedora-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-lookandfeel-fedora;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-lookandfeel-fedora}"
SRC_URI[x86_64_v2_plasma-lookandfeel-fedora.sha256sum] = "b037e3b37ec59b9a5c6e00249b83014b67decb6e0ea9153d24bd3f6ae2370519"

URI_x86_64_v2_plasma-workspace = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace}"
SRC_URI[x86_64_v2_plasma-workspace.sha256sum] = "8fccf61c9fac4ebfb552186d293da6a59bf64bd916e51582ef3b0179cdf74561"

URI_x86_64_v2_plasma-workspace-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-common-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-common}"
SRC_URI[x86_64_v2_plasma-workspace-common.sha256sum] = "2b13e4e3f0df91c5aaec5caea937783ce926aadbecb330293b990d752fff8ed9"

URI_x86_64_v2_plasma-workspace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-devel-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-devel}"
SRC_URI[x86_64_v2_plasma-workspace-devel.sha256sum] = "4ede6f9aac20d30328b05539f0654d249b1bedf8a38e4949344c1dbc8224f924"

URI_x86_64_v2_plasma-workspace-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-doc-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-doc}"
SRC_URI[x86_64_v2_plasma-workspace-doc.sha256sum] = "8464ba0b11c4faaba56db4ce4c0d01dba7b665fd5df03288392cf6cd549b6004"

URI_x86_64_v2_plasma-workspace-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-libs-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-workspace-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-libs}"
SRC_URI[x86_64_v2_plasma-workspace-libs.sha256sum] = "3937cda1bc0badde5cd0c4df390c30fa620c99553df3ce96b276d1fec861aef0"

URI_x86_64_v2_sddm-wayland-plasma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-wayland-plasma-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-wayland-plasma}"
SRC_URI[x86_64_v2_sddm-wayland-plasma.sha256sum] = "ec6056df0a19bac638a7b4da704256900381ee03664bd04c684a043f9936a22e"
RPROVIDES:sddm-wayland-plasma:x86_64_v2 = "virtual/sddm-greeter-displayserver"

URI_aarch64_libkworkspace6 = "${EPEL_MIRROR}/aarch64/Packages/l/libkworkspace6-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_libkworkspace6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkworkspace6}"
SRC_URI[aarch64_libkworkspace6.sha256sum] = "456ff29a9674f34ff4034edc57096dffb15e06b6e9d8803fd0b5fe66ab2d9ba2"

URI_aarch64_plasma-lookandfeel-fedora = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-lookandfeel-fedora-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma-lookandfeel-fedora;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-lookandfeel-fedora}"
SRC_URI[aarch64_plasma-lookandfeel-fedora.sha256sum] = "0fddfa83bd486142207e981f3fc3524ee47f9fd3317d41b89ca4408f32fdc50f"

URI_aarch64_plasma-workspace = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-workspace;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace}"
SRC_URI[aarch64_plasma-workspace.sha256sum] = "73576fe534bae8244a2accefee558dba09eb3852d8c289dd54c7c59a8766ba8a"

URI_aarch64_plasma-workspace-common = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-common-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-workspace-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-common}"
SRC_URI[aarch64_plasma-workspace-common.sha256sum] = "949bb253ab379a8ed5499ce45d2b93eea9f461a87cd1bcc646cc4d797e9551c6"

URI_aarch64_plasma-workspace-devel = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-devel-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-workspace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-devel}"
SRC_URI[aarch64_plasma-workspace-devel.sha256sum] = "614d1fd4f043c25b7df5ca1c90dc8144eb5aead5934ea18c4dc71437a94cd215"

URI_aarch64_plasma-workspace-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-doc-6.7.3-1.el10_3.noarch.rpm;name=aarch64_plasma-workspace-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-doc}"
SRC_URI[aarch64_plasma-workspace-doc.sha256sum] = "60db6e163882a3c2457fdfdb5e37af3b02ae0609e4799e4d41074b4e2cd9c53e"

URI_aarch64_plasma-workspace-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-libs-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-workspace-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-libs}"
SRC_URI[aarch64_plasma-workspace-libs.sha256sum] = "47ac46dfec3bdf8eed6083c58a6e17a6b118185ca883f9945088b64236be0a51"

URI_aarch64_sddm-wayland-plasma = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-wayland-plasma-6.7.3-1.el10_3.noarch.rpm;name=aarch64_sddm-wayland-plasma;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-wayland-plasma}"
SRC_URI[aarch64_sddm-wayland-plasma.sha256sum] = "65e4dd28634cba7f9de84f5753d315e30b7082eca5b6d7ba79dc691e4a163047"
RPROVIDES:sddm-wayland-plasma:aarch64 = "virtual/sddm-greeter-displayserver"

RDEPENDS:libkworkspace6 = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 libXau \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-workspace-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-lookandfeel-fedora = " \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 "
RDEPENDS:plasma-workspace:x86_64_v2 = " \
 PackageKit-Qt6 \
 appstream-qt \
 bash \
 dbus \
 dbus-libs \
 dbus-tools \
 fontconfig \
 glibc \
 gnome-menus \
 iso-codes \
 kactivitymanagerd \
 kf6-baloo \
 kf6-baloo-libs \
 kf6-frameworkintegration \
 kf6-karchive \
 kf6-kauth \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kded \
 kf6-kdoctools \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-kquickcharts \
 kf6-krunner \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 kio-extras \
 kio-fuse \
 knighttime \
 kscreenlocker \
 ksystemstats \
 kwayland \
 kwin \
 layer-shell-qt \
 libICE \
 libSM \
 libX11 \
 libXcursor \
 libXfixes \
 libXtst \
 libcanberra \
 libicu \
 libkexiv2-qt6 \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 ocean-sound-theme \
 plasma-activities \
 plasma-activities-stats \
 plasma-desktop \
 plasma-keyboard \
 plasma-lookandfeel-fedora \
 plasma-workspace-common \
 plasma-workspace-libs \
 policycoreutils \
 polkit-kde \
 powerdevil \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 qt6-qttools \
 qt6-qtvirtualkeyboard \
 qt6-qtwayland \
 socat \
 systemd \
 unity-gtk3-module \
 uresourced \
 virtual/coreutils \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 xcb-util-wm \
 xdg-desktop-portal-kde \
 xmessage \
 xorg-x11-server-Xwayland \
 xprop \
 xrdb \
 zlib-ng-compat \
"
RDEPENDS:plasma-workspace:aarch64 = " \
 PackageKit-Qt6 \
 appstream-qt \
 bash \
 dbus \
 dbus-libs \
 dbus-tools \
 fontconfig \
 glibc \
 gnome-menus \
 iso-codes \
 kactivitymanagerd \
 kde-settings-plasma \
 kf6-baloo \
 kf6-baloo-libs \
 kf6-frameworkintegration \
 kf6-karchive \
 kf6-kauth \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kded \
 kf6-kdoctools \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-kquickcharts \
 kf6-krunner \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-solid \
 kio-extras \
 kio-fuse \
 knighttime \
 kscreenlocker \
 ksystemstats \
 kwayland \
 kwin \
 layer-shell-qt \
 libICE \
 libSM \
 libX11 \
 libXcursor \
 libXfixes \
 libXtst \
 libcanberra \
 libicu \
 libkexiv2-qt6 \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwayland-client \
 libxcb \
 ocean-sound-theme \
 plasma-activities \
 plasma-activities-stats \
 plasma-desktop \
 plasma-keyboard \
 plasma-lookandfeel-fedora \
 plasma-workspace-common \
 plasma-workspace-libs \
 policycoreutils \
 polkit-kde \
 powerdevil \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtsvg \
 qt6-qttools \
 qt6-qtvirtualkeyboard \
 qt6-qtwayland \
 socat \
 systemd \
 unity-gtk3-module \
 uresourced \
 virtual/coreutils \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 xcb-util-wm \
 xdg-desktop-portal-kde \
 xmessage \
 xorg-x11-server-Xwayland \
 xprop \
 xrdb \
 zlib-ng-compat \
"
RDEPENDS:plasma-workspace-common = " \
 "
RDEPENDS:plasma-workspace-devel = " \
 cmake-filesystem \
 libkworkspace6 \
 plasma-workspace-libs \
 "
RDEPENDS:plasma-workspace-doc = " \
 plasma-workspace-common \
 "
RDEPENDS:plasma-workspace-libs = " \
 appstream-qt \
 fontconfig \
 freetype \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdeclarative \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-kpackage \
 kf6-kparts \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kuserfeedback \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-networkmanager-qt \
 kf6-solid \
 knighttime \
 kwayland \
 libX11 \
 libXcursor \
 libXfixes \
 libXft \
 libcanberra \
 libgcc \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libqalculate \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxcrypt \
 plasma-activities \
 plasma-activities-stats \
 plasma-workspace-common \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 qt6-qtsvg \
 systemd-libs \
 xcb-util \
 xcb-util-cursor \
 "
RDEPENDS:sddm-wayland-plasma = " \
 kwin \
 layer-shell-qt \
 plasma-keyboard \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/sddm-greeter-displayserver"

PROVIDES:append:aarch64 = " rpm/virtual/sddm-greeter-displayserver"
