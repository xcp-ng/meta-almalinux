# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tryfn"
PV = "1.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tryfn+color-auto-devel \
 rust-tryfn+color-devel \
 rust-tryfn+default-devel \
 rust-tryfn+diff-devel \
 rust-tryfn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tryfn-1.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ed68dbfe86092db71a662132f2fdb1897ae02a1dcb4fee37655ae029ee228b9e"

URI_x86_64_v2_rust-tryfn+color-auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+color-auto-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+color-auto-devel}"
SRC_URI[x86_64_v2_rust-tryfn+color-auto-devel.sha256sum] = "c5bdea872afcc18b53b73f2c4bbd290110d2e25e20b37243abc572e61ad5bdde"

URI_x86_64_v2_rust-tryfn+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+color-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+color-devel}"
SRC_URI[x86_64_v2_rust-tryfn+color-devel.sha256sum] = "8b0d58b1006ae2b28da212b6d925aaa23626b7bc178fa14e1e1c7f5beb487c4c"

URI_x86_64_v2_rust-tryfn+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+default-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+default-devel}"
SRC_URI[x86_64_v2_rust-tryfn+default-devel.sha256sum] = "126791655c4a7f88fd6e979b136ddf05bc3f9f9b72788de9faa316204e2bf332"

URI_x86_64_v2_rust-tryfn+diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn+diff-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn+diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn+diff-devel}"
SRC_URI[x86_64_v2_rust-tryfn+diff-devel.sha256sum] = "0be5ac5d0e883ae3e637d9a1e698ecb38ea9b4db143dbcd2302b5bcdf7f466c6"

URI_x86_64_v2_rust-tryfn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tryfn-devel-1.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tryfn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tryfn-devel}"
SRC_URI[x86_64_v2_rust-tryfn-devel.sha256sum] = "56e6b5a4f035423fd1646374e95d7b2ba8a7886cf128982b689703f5e5e32cbd"

URI_aarch64_rust-tryfn+color-auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+color-auto-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-tryfn+color-auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+color-auto-devel}"
SRC_URI[aarch64_rust-tryfn+color-auto-devel.sha256sum] = "68e8eb6c9ecd5c7143c8018c84e0b74766b09a8a32639c8be95e8ac54be078aa"

URI_aarch64_rust-tryfn+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+color-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-tryfn+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+color-devel}"
SRC_URI[aarch64_rust-tryfn+color-devel.sha256sum] = "175de06d28e3d8faf026a95408ceb8dd2f89ba70a1ad2146feb0f3408b23f256"

URI_aarch64_rust-tryfn+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+default-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-tryfn+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+default-devel}"
SRC_URI[aarch64_rust-tryfn+default-devel.sha256sum] = "697b48315d4b249c64b71e6ccfc9a02b4ec1741e350b3d35fc72b5d0dbdebe96"

URI_aarch64_rust-tryfn+diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn+diff-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-tryfn+diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn+diff-devel}"
SRC_URI[aarch64_rust-tryfn+diff-devel.sha256sum] = "fed2a4d3947e1bffda88f65aac646a725c54a6cb1e239b968b3c933e4495378e"

URI_aarch64_rust-tryfn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tryfn-devel-1.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-tryfn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tryfn-devel}"
SRC_URI[aarch64_rust-tryfn-devel.sha256sum] = "8b74a7f7329205d8725b7eb4edff188f58b2a576c4f5f6b8691e68179fd6f752"

RDEPENDS:rust-tryfn+color-auto-devel = " \
 cargo \
 rust-snapbox+color-auto-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn+color-devel = " \
 cargo \
 rust-snapbox+color-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn+default-devel = " \
 cargo \
 rust-tryfn+color-auto-devel \
 rust-tryfn+diff-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn+diff-devel = " \
 cargo \
 rust-snapbox+diff-devel \
 rust-tryfn-devel \
 "
RDEPENDS:rust-tryfn-devel = " \
 cargo \
 rust \
 rust-ignore+default-devel \
 rust-libtest-mimic+default-devel \
 rust-snapbox-devel \
 "
