# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below_derive"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-below_derive+default-devel \
 rust-below_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below_derive-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1198f53c630a69511d3c8d7d044746c178c690ed9f2bd4aeed4f28f0eb7f603"

URI_x86_64_v2_rust-below_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below_derive+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below_derive+default-devel}"
SRC_URI[x86_64_v2_rust-below_derive+default-devel.sha256sum] = "1c49c15bdd3eca3e10cabf75460ebf8ca6e19a64304a303f89618011367cb30f"

URI_x86_64_v2_rust-below_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below_derive-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below_derive-devel}"
SRC_URI[x86_64_v2_rust-below_derive-devel.sha256sum] = "59f046a8e04fc9796aba22f66bff4e641515965e424cd123663216b0ebf6a4d0"

URI_aarch64_rust-below_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below_derive+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below_derive+default-devel}"
SRC_URI[aarch64_rust-below_derive+default-devel.sha256sum] = "c095a7e482a74b4fab1ab7f14898710b6b7117886df824edc1ca3e93fa82a7a1"

URI_aarch64_rust-below_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below_derive-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-below_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below_derive-devel}"
SRC_URI[aarch64_rust-below_derive-devel.sha256sum] = "2095b0559ea6a9e5d6a6d85496fb3b1453b14e915ff49c489fe02e3d1487be4f"

RDEPENDS:rust-below_derive+default-devel = " \
 cargo \
 rust-below_derive-devel \
 "
RDEPENDS:rust-below_derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 rust-syn1+extra-traits-devel \
 rust-syn1+fold-devel \
 rust-syn1+full-devel \
 rust-syn1+visit-devel \
 rust-syn1+visit-mut-devel \
 "
