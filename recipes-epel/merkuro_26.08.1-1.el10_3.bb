# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "merkuro"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 merkuro \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/merkuro-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "252c9664258bc8b646e216a8bce1317b5728604828253b42584d6437b0e1fa83"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/merkuro-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_merkuro;unpack=0"
SRC_URI[x86_64_v2_merkuro.sha256sum] = "0bcfcf8a51f38b0f40441c39f1cd9fcb513ecb35ed5ac89d01947fa0249a85d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/merkuro-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_merkuro;unpack=0"
SRC_URI[aarch64_merkuro.sha256sum] = "2fd5ffce6bffd53ada472da5c0c6d76f2c69fb000e907413a83155724bdc83b5"

RDEPENDS:merkuro = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgme2pp \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kmime \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kidentitymanagement \
 kmailtransport \
 kmbox \
 libgcc \
 libkdepim \
 libkleo \
 libplasma \
 libstdc++ \
 mailcommon \
 messagelib \
 mimetreeparser \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
