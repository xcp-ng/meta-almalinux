# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell"
PV = "49.5"
PR = "16.el10.alma.1"
PACKAGES = " \
 gnome-shell \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-49.5-16.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0573de7cb4d1a776462a5f505c5ed141bf52e8715dd07779fb8157a35bb77bc9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-49.5-16.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_gnome-shell;unpack=0"
SRC_URI[x86_64_v2_gnome-shell.sha256sum] = "10774e911336e97413522919a240e24f067ee99e8f2785c78b2c60b18807ed22"
RPROVIDES:gnome-shell:append:x86_64_v2 = " virtual/PolicyKit-authentication-agent"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-49.5-16.el10.alma.1.aarch64.rpm;name=aarch64_gnome-shell;unpack=0"
SRC_URI[aarch64_gnome-shell.sha256sum] = "68caf8b179113d1e23bef0e27a22e315bc446b63cb59956a3d23e32e14fd9f78"
RPROVIDES:gnome-shell:append:aarch64 = " virtual/PolicyKit-authentication-agent"

RDEPENDS:gnome-shell = " \
 NetworkManager-libnm \
 accountsservice-libs \
 at-spi2-atk \
 atk \
 cairo \
 evolution-data-server \
 gcr \
 gcr-libs \
 gdk-pixbuf2 \
 gdm \
 geoclue2-libs \
 gettext \
 gjs \
 glib2 \
 glibc \
 gnome-autoar \
 gnome-control-center \
 gnome-desktop4 \
 gnome-settings-daemon \
 gobject-introspection \
 graphene \
 gsettings-desktop-schemas \
 gstreamer1 \
 gstreamer1-plugins-good \
 gtk4 \
 ibus-libs \
 json-glib \
 libX11 \
 libXext \
 libXfixes \
 libadwaita \
 libgcc \
 libglvnd-gles \
 libgweather \
 libical-glib \
 libnma-gtk4 \
 librsvg2 \
 libsecret \
 libsoup3 \
 mutter \
 pango \
 pipewire-gstreamer \
 pipewire-libs \
 polkit \
 polkit-libs \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 python3 \
 python3-argcomplete \
 switcheroo-control \
 systemd-libs \
 tecla \
 upower \
 xdg-desktop-portal-gnome \
 xdg-desktop-portal-gtk \
 xdg-user-dirs-gtk \
 "
