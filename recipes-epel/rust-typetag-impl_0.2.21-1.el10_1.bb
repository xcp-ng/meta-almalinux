# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typetag-impl"
PV = "0.2.21"
PR = "1.el10_1"
PACKAGES = " \
 rust-typetag-impl+default-devel \
 rust-typetag-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typetag-impl-0.2.21-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e73cc622fe6c7837037a955cf9dd305281b9361e07f5172c969b2c1cdfe34ee"

URI_x86_64_v2_rust-typetag-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-impl+default-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag-impl+default-devel}"
SRC_URI[x86_64_v2_rust-typetag-impl+default-devel.sha256sum] = "9ac2314abb7bbfef0be099ea55301b05c385bc947f807c5a0d95c85f8f57ca0e"

URI_x86_64_v2_rust-typetag-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-impl-devel-0.2.21-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag-impl-devel}"
SRC_URI[x86_64_v2_rust-typetag-impl-devel.sha256sum] = "b93dfdec318bd583a4d9c881dc53d3df5e6333965fef732f9941763990182436"

URI_aarch64_rust-typetag-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-impl+default-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-typetag-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag-impl+default-devel}"
SRC_URI[aarch64_rust-typetag-impl+default-devel.sha256sum] = "521890251c63ef7fc6beeb31a620d8a04b61800ac8b10060ff663b1810147e1f"

URI_aarch64_rust-typetag-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-impl-devel-0.2.21-1.el10_1.noarch.rpm;name=aarch64_rust-typetag-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag-impl-devel}"
SRC_URI[aarch64_rust-typetag-impl-devel.sha256sum] = "db718632efc3150c29b4787de30b96abcd886a173aaaf31b7f488cb3a1ff5f02"

RDEPENDS:rust-typetag-impl+default-devel = " \
 cargo \
 rust-typetag-impl-devel \
 "
RDEPENDS:rust-typetag-impl-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
