# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gcsfs"
PV = "2024.12.0"
PR = "1.el10_1"
PACKAGES = " \
 python-gcsfs-doc \
 python3-gcsfs \
 python3-gcsfs+crc \
 python3-gcsfs+gcsfuse \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-gcsfs-2024.12.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7f7cf2e08a3e14abff2e9c0c9d9951b4e07c256d9428e16ea009bf56f16d1f6c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-gcsfs-doc-2024.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-gcsfs-doc;unpack=0"
SRC_URI[x86_64_v2_python-gcsfs-doc.sha256sum] = "6a3bd661287f4584b9050c3c7b200892e872d97a49533ed6deaf2bca7498bc2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gcsfs-2024.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gcsfs;unpack=0"
SRC_URI[x86_64_v2_python3-gcsfs.sha256sum] = "32d3536286af4d362bc69e8ba2b38e9270c85c48152162a392b35df6e0213753"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gcsfs+crc-2024.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gcsfs+crc;unpack=0"
SRC_URI[x86_64_v2_python3-gcsfs+crc.sha256sum] = "742f89ec86fdfa542462d5a814d7eccd010f17b6648ea531e6173968b80ac02b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gcsfs+gcsfuse-2024.12.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gcsfs+gcsfuse;unpack=0"
SRC_URI[x86_64_v2_python3-gcsfs+gcsfuse.sha256sum] = "577d005eee60b5db67b69d722b5315a28060671a8f49c620c3c92d718900d8bd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-gcsfs-doc-2024.12.0-1.el10_1.noarch.rpm;name=aarch64_python-gcsfs-doc;unpack=0"
SRC_URI[aarch64_python-gcsfs-doc.sha256sum] = "35035ea3c042e9664e7a2b2831846562aae15b357421e44b83efde080c98eec9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-gcsfs-2024.12.0-1.el10_1.noarch.rpm;name=aarch64_python3-gcsfs;unpack=0"
SRC_URI[aarch64_python3-gcsfs.sha256sum] = "c4143c779b27ef18053ddba27e0290a717788aba61b7cf88411b1b3623f476c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-gcsfs+crc-2024.12.0-1.el10_1.noarch.rpm;name=aarch64_python3-gcsfs+crc;unpack=0"
SRC_URI[aarch64_python3-gcsfs+crc.sha256sum] = "d1937a858acd1d95a957138678eed6c197ad930175dc986b6dc4d304a90306bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-gcsfs+gcsfuse-2024.12.0-1.el10_1.noarch.rpm;name=aarch64_python3-gcsfs+gcsfuse;unpack=0"
SRC_URI[aarch64_python3-gcsfs+gcsfuse.sha256sum] = "f79a84d939d6615c47d39bf59ca068668c2a3f940c4ce2ada3768a8c45316560"

RDEPENDS:python-gcsfs-doc = " \
 "
RDEPENDS:python3-gcsfs = " \
 python3 \
 python3-aiohttp \
 python3-decorator \
 python3-fsspec \
 python3-google-auth \
 python3-google-auth-oauthlib \
 python3-google-cloud-storage \
 python3-requests \
 "
RDEPENDS:python3-gcsfs+crc = " \
 python3 \
 python3-crcmod \
 python3-gcsfs \
 "
RDEPENDS:python3-gcsfs+gcsfuse = " \
 python3 \
 python3-fusepy \
 python3-gcsfs \
 "
