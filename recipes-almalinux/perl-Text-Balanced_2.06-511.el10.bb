# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Balanced"
PV = "2.06"
PR = "511.el10"
PACKAGES = " \
 perl-Text-Balanced \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Text-Balanced-2.06-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8f95c2535909ead6ffd5ead732395eb8aaf9d97f88473a1df937f4d4b1995e7"

URI_x86_64_v2_perl-Text-Balanced = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Balanced-2.06-511.el10.noarch.rpm;name=x86_64_v2_perl-Text-Balanced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Balanced}"
SRC_URI[x86_64_v2_perl-Text-Balanced.sha256sum] = "e71870819c5c42fd438d7d953882ad7590f485fa203f6ffd126fa80ce23d5ad1"

URI_aarch64_perl-Text-Balanced = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Balanced-2.06-511.el10.noarch.rpm;name=aarch64_perl-Text-Balanced;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Balanced}"
SRC_URI[aarch64_perl-Text-Balanced.sha256sum] = "e71870819c5c42fd438d7d953882ad7590f485fa203f6ffd126fa80ce23d5ad1"

RDEPENDS:perl-Text-Balanced = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
