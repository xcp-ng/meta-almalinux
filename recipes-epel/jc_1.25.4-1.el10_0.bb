# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jc"
PV = "1.25.4"
PR = "1.el10_0"
PACKAGES = " \
 jc \
 python3-jc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jc-1.25.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "131a31223253facf99d9f48001e3363f11ecfa34015473192a7d090b596d52f6"

URI_x86_64_v2_jc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jc-1.25.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_jc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jc}"
SRC_URI[x86_64_v2_jc.sha256sum] = "a3d04d0fbc5fcbfe99fc8750c12d9b3bf1df1f9533e506243346108036f3565a"

URI_x86_64_v2_python3-jc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jc-1.25.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-jc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jc}"
SRC_URI[x86_64_v2_python3-jc.sha256sum] = "b39aa83adf8261abdf0bf5e2fec41563a7a03d2df5e5ce4b01ccdc5af537e761"

URI_aarch64_jc = "${EPEL_MIRROR}/aarch64/Packages/j/jc-1.25.4-1.el10_0.noarch.rpm;name=aarch64_jc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jc}"
SRC_URI[aarch64_jc.sha256sum] = "bc14b4d8e477681d36bee0a88a5461e278ed18317f168f0b1dfbdc43d9fb20da"

URI_aarch64_python3-jc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jc-1.25.4-1.el10_0.noarch.rpm;name=aarch64_python3-jc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jc}"
SRC_URI[aarch64_python3-jc.sha256sum] = "a5400a708d7b0f5a1d977251e75af5bd6e2a6c8311eef8f37ccf17621954914f"

RDEPENDS:jc = " \
 python3 \
 python3-jc \
 "
RDEPENDS:python3-jc = " \
 python3 \
 python3-pygments \
 python3-ruamel-yaml \
 python3-xmltodict \
 "
