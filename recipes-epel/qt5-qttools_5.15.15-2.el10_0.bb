# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qttools"
PV = "5.15.15"
PR = "2.el10_0"
PACKAGES = " \
 qt5-assistant \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qdbusviewer \
 qt5-qttools \
 qt5-qttools-common \
 qt5-qttools-devel \
 qt5-qttools-examples \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 qt5-qttools-libs-help \
 qt5-qttools-static \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qt5-qttools-5.15.15-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "80dc08613136eef84cc5287febb06d7f20b6ac57be8ecfdaf410a78e0d220ee9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-assistant-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-assistant;unpack=0"
SRC_URI[x86_64_v2_qt5-assistant.sha256sum] = "29803524dbd5f1c2a0deb2da915e122e1aba2b691f639cbf97981f78e44ca7f3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-designer-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-designer;unpack=0"
SRC_URI[x86_64_v2_qt5-designer.sha256sum] = "768a3ada2eee25360adf38f0b5a431db8393554c68867f4bf225caaff10830e8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-doctools-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-doctools;unpack=0"
SRC_URI[x86_64_v2_qt5-doctools.sha256sum] = "16b0a658d2a0b41c8e6be0ec96caf2248706e2c3201b8c45e004f0f772872eb3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-linguist-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-linguist;unpack=0"
SRC_URI[x86_64_v2_qt5-linguist.sha256sum] = "dc5d06aa41570fdec25243069c2e80ebbd2423183965a0897bdade9d1bcb5381"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qdbusviewer-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qdbusviewer;unpack=0"
SRC_URI[x86_64_v2_qt5-qdbusviewer.sha256sum] = "d2a33cd80eb2c213ec8d203761c0586c85676399b676a08dc44abdecb36f3cc2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools.sha256sum] = "d4021f56922435e703add0c1975c7fd78e01a14d70bf29923ed29272b1014dfe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-common-5.15.15-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qttools-common;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-common.sha256sum] = "8b5afb4a61fa5d17a4fc950de71420748cc2d47df4ea11e7f0d68aff7756a808"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-devel-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-devel;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-devel.sha256sum] = "ceaa11c7d541a50d24e3cb74e8e6936ea33d032c7d74cecceb0bcee2e5e1ab2d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-examples-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-examples;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-examples.sha256sum] = "3afa020c92685220ac0e70543615aa60aa49a8d4335fd2dbeb1fbad286f35356"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-designer-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-designer;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-libs-designer.sha256sum] = "04980cdb7b7fbeb47cd75a0956f29e5a49e7a2ff37ac7ac81c81208971677656"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-designercomponents-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-designercomponents;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-libs-designercomponents.sha256sum] = "2dbf05602e126d13b8a58456f383d5bd96ac3a481f2d1fc935e88744e3a247fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-libs-help-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-libs-help;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-libs-help.sha256sum] = "d57ee3792acc5d3c0fb40a07b9cc8ba67895073c2cbe3bc085f21256d6dcf583"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qttools-static-5.15.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qttools-static;unpack=0"
SRC_URI[x86_64_v2_qt5-qttools-static.sha256sum] = "f3805baff247908b154526bb532deb1b0c909130ab3dd6f75747389fa2ba6702"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-assistant-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-assistant;unpack=0"
SRC_URI[aarch64_qt5-assistant.sha256sum] = "799a526b3cceecd6a4791eae26a424a7f7893811b29856c83938549010fbd92e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-designer-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-designer;unpack=0"
SRC_URI[aarch64_qt5-designer.sha256sum] = "5e346de00fa157a85813109aff5c06b45c7208f47342b6b1fe5267aae62accb0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-doctools-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-doctools;unpack=0"
SRC_URI[aarch64_qt5-doctools.sha256sum] = "0996224fd067ef179677796e5029ac132e900614a0692fbeb470c0a8a65eaba0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-linguist-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-linguist;unpack=0"
SRC_URI[aarch64_qt5-linguist.sha256sum] = "37573c9766152c83e9e91b41b410cf8528d9a952dfdedea8bff397a31a9535f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qdbusviewer-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-qdbusviewer;unpack=0"
SRC_URI[aarch64_qt5-qdbusviewer.sha256sum] = "ebad0509097b20039a7cc0df9855e5eb44c40c3285a9da4519b4069e6cd0b585"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-qttools;unpack=0"
SRC_URI[aarch64_qt5-qttools.sha256sum] = "5b3c3753382c9efa54fef9405113192a1738fc45e4bcf8f48decf09a3ea1ab69"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-common-5.15.15-2.el10_0.noarch.rpm;name=aarch64_qt5-qttools-common;unpack=0"
SRC_URI[aarch64_qt5-qttools-common.sha256sum] = "520d6427fe1691614dd50fe851c22ced7b62d27639d35596275c61e9aa722e5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-devel-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-qttools-devel;unpack=0"
SRC_URI[aarch64_qt5-qttools-devel.sha256sum] = "47a1874466c1fbde022075afbec4e3871078dbc4a3439ab3bec925d1e6b1e79a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-examples-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-qttools-examples;unpack=0"
SRC_URI[aarch64_qt5-qttools-examples.sha256sum] = "9c5b5f604d518ac1dd0ec3248f6505f654d0c191a35fad49f88cf1250650c6a2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-designer-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-qttools-libs-designer;unpack=0"
SRC_URI[aarch64_qt5-qttools-libs-designer.sha256sum] = "167be8cc0fa1a9f6c957de83c791f0b848e4f790b36b14b667d54232701dd75e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-designercomponents-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-qttools-libs-designercomponents;unpack=0"
SRC_URI[aarch64_qt5-qttools-libs-designercomponents.sha256sum] = "40f3c38b9f710eda331b4773ab54fd322035547e70d170ab107680847b81ec3e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-libs-help-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-qttools-libs-help;unpack=0"
SRC_URI[aarch64_qt5-qttools-libs-help.sha256sum] = "a7cb6482f9b7776ba81387eca7995772e6f95bbb60b1c476fa5d955b689a0b99"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qttools-static-5.15.15-2.el10_0.aarch64.rpm;name=aarch64_qt5-qttools-static;unpack=0"
SRC_URI[aarch64_qt5-qttools-static.sha256sum] = "83aa21e3595ecfef22449ab4b85a5c59bf86053d762a9778900f97d8aea69e9d"

RDEPENDS:qt5-assistant = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-designer = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 "
RDEPENDS:qt5-doctools = " \
 clang-libs \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-linguist = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qdbusviewer = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-common = " \
 "
RDEPENDS:qt5-qttools-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-designer \
 qt5-doctools \
 qt5-linguist \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-qttools \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-designercomponents \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-qttools-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qttools-common \
 qt5-qttools-libs-designer \
 qt5-qttools-libs-help \
 "
RDEPENDS:qt5-qttools-libs-designer = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-libs-designercomponents = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 qt5-qttools-libs-designer \
 "
RDEPENDS:qt5-qttools-libs-help = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qttools-common \
 "
RDEPENDS:qt5-qttools-static = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qttools-devel \
 "
