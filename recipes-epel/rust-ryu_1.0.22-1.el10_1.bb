# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ryu"
PV = "1.0.22"
PR = "1.el10_1"
PACKAGES = " \
 rust-ryu+default-devel \
 rust-ryu+no-panic-devel \
 rust-ryu+small-devel \
 rust-ryu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ryu-1.0.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b785d06a3ccd4d6ef1e870fcd3e719517ac4f45f8e61890580c9528baa679ae4"

URI_x86_64_v2_rust-ryu+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+default-devel-1.0.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+default-devel}"
SRC_URI[x86_64_v2_rust-ryu+default-devel.sha256sum] = "dea949ff4b2aa8ae1c81cddb243a44b9dd3ac6f8df58ee1e64ac1270737e163d"

URI_x86_64_v2_rust-ryu+no-panic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+no-panic-devel-1.0.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+no-panic-devel}"
SRC_URI[x86_64_v2_rust-ryu+no-panic-devel.sha256sum] = "4af301744e3e4a28f37fd553d370943b8d08e3ffca4e31bf516eee927ac8aa2f"

URI_x86_64_v2_rust-ryu+small-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu+small-devel-1.0.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu+small-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu+small-devel}"
SRC_URI[x86_64_v2_rust-ryu+small-devel.sha256sum] = "859f788a02bec338dd89b818a339e7df5e1fa1f72ea1108bd8a92d533d317692"

URI_x86_64_v2_rust-ryu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ryu-devel-1.0.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ryu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ryu-devel}"
SRC_URI[x86_64_v2_rust-ryu-devel.sha256sum] = "962bc0fec76d0a9ee538daa67ff6c25afbb2d88948796c61326969f26596a76e"

URI_aarch64_rust-ryu+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+default-devel-1.0.22-1.el10_1.noarch.rpm;name=aarch64_rust-ryu+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+default-devel}"
SRC_URI[aarch64_rust-ryu+default-devel.sha256sum] = "348e0687e966287fac546e360eac82078f07a267b373c77540056cf66d682207"

URI_aarch64_rust-ryu+no-panic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+no-panic-devel-1.0.22-1.el10_1.noarch.rpm;name=aarch64_rust-ryu+no-panic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+no-panic-devel}"
SRC_URI[aarch64_rust-ryu+no-panic-devel.sha256sum] = "eb21d5c023bc83021d649e13832e9ceb4c6a97aa105ffcef4f74f6df240b1be9"

URI_aarch64_rust-ryu+small-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu+small-devel-1.0.22-1.el10_1.noarch.rpm;name=aarch64_rust-ryu+small-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu+small-devel}"
SRC_URI[aarch64_rust-ryu+small-devel.sha256sum] = "c37340841f56006b6bfcf004b7f66bc2771940fca5f91b3eb119f4fe69a3977c"

URI_aarch64_rust-ryu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ryu-devel-1.0.22-1.el10_1.noarch.rpm;name=aarch64_rust-ryu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ryu-devel}"
SRC_URI[aarch64_rust-ryu-devel.sha256sum] = "b4c748aeba4e4dee6dce9d2ea3e7f6af9244c513bc48dcc119942da08e52101d"

RDEPENDS:rust-ryu+default-devel = " \
 cargo \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu+no-panic-devel = " \
 cargo \
 rust-no-panic+default-devel \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu+small-devel = " \
 cargo \
 rust-ryu-devel \
 "
RDEPENDS:rust-ryu-devel = " \
 cargo \
 rust \
 "
