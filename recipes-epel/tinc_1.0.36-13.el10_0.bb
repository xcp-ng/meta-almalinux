# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinc"
PV = "1.0.36"
PR = "13.el10_0"
PACKAGES = " \
 tinc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinc-1.0.36-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "276244035aef8cf51507f182d96b98e5c087a6bf97cccb95ad6f685dbb6e3717"

URI_x86_64_v2_tinc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinc-1.0.36-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinc}"
SRC_URI[x86_64_v2_tinc.sha256sum] = "fe35298eda495d1dd726a94f8ef15424915d2e735b2d8db5b22ea7a3b7f7c917"

URI_aarch64_tinc = "${EPEL_MIRROR}/aarch64/Packages/t/tinc-1.0.36-13.el10_0.aarch64.rpm;name=aarch64_tinc;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinc}"
SRC_URI[aarch64_tinc.sha256sum] = "c5c5011a1d025be4f088700b5f3e4cd5c29513561c0e3df1a179214dd749ca21"

RDEPENDS:tinc = " \
 bash \
 glibc \
 lzo \
 openssl-libs \
 systemd \
 zlib-ng-compat \
 "
