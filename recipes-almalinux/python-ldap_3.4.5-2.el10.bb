# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ldap"
PV = "3.4.5"
PR = "2.el10"
PACKAGES = " \
 python3-ldap \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-ldap-3.4.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7ca5d1c4d06dad2d4e64102b931b2d80066dd99ad5489980712d994d9872ad6e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ldap-3.4.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-ldap;unpack=0"
SRC_URI[x86_64_v2_python3-ldap.sha256sum] = "272d60fcf895488023b2e2701f5e9bc8bdecb92b49607234470fa3fa556fc5eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ldap-3.4.5-2.el10.aarch64.rpm;name=aarch64_python3-ldap;unpack=0"
SRC_URI[aarch64_python3-ldap.sha256sum] = "79b5e8e08ab09d080852af28846aa223cab7b532adc3cfdd4b9bc54ad8496ec9"

RDEPENDS:python3-ldap = " \
 bash \
 glibc \
 openldap \
 python3 \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-setuptools \
 "
