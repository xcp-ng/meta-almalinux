# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-string_cache"
PV = "0.9.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-string_cache+default-devel \
 rust-string_cache+serde-devel \
 rust-string_cache+serde_support-devel \
 rust-string_cache-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-string_cache-0.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5b744c330399deb4b1b7944efd3ab859a2f563925d9f9aabd5cba4f584cc2622"

URI_x86_64_v2_rust-string_cache+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache+default-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache+default-devel}"
SRC_URI[x86_64_v2_rust-string_cache+default-devel.sha256sum] = "d39a5db1f32af276656383f79445198feb563eab261645c0b0e47dfc5fd2e1a6"

URI_x86_64_v2_rust-string_cache+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache+serde-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache+serde-devel}"
SRC_URI[x86_64_v2_rust-string_cache+serde-devel.sha256sum] = "9fe13875ef1d1b855969d849826599922e1eb9a71dc57cb9976b6fd0080be3e7"

URI_x86_64_v2_rust-string_cache+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache+serde_support-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache+serde_support-devel}"
SRC_URI[x86_64_v2_rust-string_cache+serde_support-devel.sha256sum] = "44f8278475834eae6123b68c47c8d27e9f75a798cd359fcb3dcdf921b8d9966c"

URI_x86_64_v2_rust-string_cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-string_cache-devel-0.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-string_cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-string_cache-devel}"
SRC_URI[x86_64_v2_rust-string_cache-devel.sha256sum] = "621e82a5db1a382dbab2dd05fa53b5f3a0a35bd4d1b1238ebbe7a02a49d54d1a"

URI_aarch64_rust-string_cache+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache+default-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache+default-devel}"
SRC_URI[aarch64_rust-string_cache+default-devel.sha256sum] = "81edaed7f620874b0846594c25fa99c20822d99a849344d1164a32525044abc5"

URI_aarch64_rust-string_cache+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache+serde-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache+serde-devel}"
SRC_URI[aarch64_rust-string_cache+serde-devel.sha256sum] = "9f03e1bf56de5bc24585af3a6607a5abfedc996bfc2418d8140243e66e557a61"

URI_aarch64_rust-string_cache+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache+serde_support-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache+serde_support-devel}"
SRC_URI[aarch64_rust-string_cache+serde_support-devel.sha256sum] = "c0ceb8244bbe7cd0dec00612d127ff952a289980330cce3b55a0e7fe3dd4e0bf"

URI_aarch64_rust-string_cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-string_cache-devel-0.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-string_cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-string_cache-devel}"
SRC_URI[aarch64_rust-string_cache-devel.sha256sum] = "2bbbd84a9d7d586d49ac2ac080f9712562e2ab4d05ab63e8eaf31310b6d756dc"

RDEPENDS:rust-string_cache+default-devel = " \
 cargo \
 rust-string_cache+serde_support-devel \
 rust-string_cache-devel \
 "
RDEPENDS:rust-string_cache+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-string_cache-devel \
 "
RDEPENDS:rust-string_cache+serde_support-devel = " \
 cargo \
 rust-string_cache+serde-devel \
 rust-string_cache-devel \
 "
RDEPENDS:rust-string_cache-devel = " \
 cargo \
 rust \
 rust-new_debug_unreachable+default-devel \
 rust-parking_lot+default-devel \
 rust-phf_shared+default-devel \
 rust-precomputed-hash+default-devel \
 "
