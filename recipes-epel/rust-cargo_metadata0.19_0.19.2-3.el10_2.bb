# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata0.19"
PV = "0.19.2"
PR = "3.el10_2"
PACKAGES = " \
 rust-cargo_metadata0.19+builder-devel \
 rust-cargo_metadata0.19+default-devel \
 rust-cargo_metadata0.19+derive_builder-devel \
 rust-cargo_metadata0.19-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata0.19-0.19.2-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a09414c69c41ddfd97253aa15b9e9beef88bd91bbcde7f9c140243b02574e10d"

URI_x86_64_v2_rust-cargo_metadata0.19+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.19+builder-devel-0.19.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.19+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.19+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.19+builder-devel.sha256sum] = "d85b2311bb58f37d981fc6148596e0e19d2ce5e9cdb1ae912de04af850db8f8d"

URI_x86_64_v2_rust-cargo_metadata0.19+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.19+default-devel-0.19.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.19+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.19+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.19+default-devel.sha256sum] = "8df966f19ab6a3c7f503148cce5db1b84c39eac72707c67116d495d614278078"

URI_x86_64_v2_rust-cargo_metadata0.19+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.19+derive_builder-devel-0.19.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.19+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.19+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.19+derive_builder-devel.sha256sum] = "87a3b5bc628b01c16169a8edf519ac2c11adb70f1151f378768b2b873367d5d7"

URI_x86_64_v2_rust-cargo_metadata0.19-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.19-devel-0.19.2-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.19-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.19-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.19-devel.sha256sum] = "265bcd0f008b3e02e94000aae0bc739b5195b2d1ae41397e669b8169ad69dff4"

URI_aarch64_rust-cargo_metadata0.19+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.19+builder-devel-0.19.2-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.19+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.19+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.19+builder-devel.sha256sum] = "a6643a546e824f8ebc434570592ace3c7b28d7854e6e39cbd63e35c51db97998"

URI_aarch64_rust-cargo_metadata0.19+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.19+default-devel-0.19.2-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.19+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.19+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.19+default-devel.sha256sum] = "d814853b3a7781c2118663a1b9063fe796fb8b902e74b42a2fbe12e6fe065944"

URI_aarch64_rust-cargo_metadata0.19+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.19+derive_builder-devel-0.19.2-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.19+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.19+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.19+derive_builder-devel.sha256sum] = "13ee7ccd20a7761d15772cd0aaf0f1c2dbd1714d77825c74f80589325c75a73e"

URI_aarch64_rust-cargo_metadata0.19-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.19-devel-0.19.2-3.el10_2.noarch.rpm;name=aarch64_rust-cargo_metadata0.19-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.19-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.19-devel.sha256sum] = "4dc1ef3c60ce399b864309c7600a71e481ca1d5f39cb86420c9d06ae5c5847c2"

RDEPENDS:rust-cargo_metadata0.19+builder-devel = " \
 cargo \
 rust-cargo_metadata0.19+derive_builder-devel \
 rust-cargo_metadata0.19-devel \
 "
RDEPENDS:rust-cargo_metadata0.19+default-devel = " \
 cargo \
 rust-cargo_metadata0.19-devel \
 "
RDEPENDS:rust-cargo_metadata0.19+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata0.19-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata0.19-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform0.1+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror+default-devel \
 "
