# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zbus"
PV = "5.18.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-zbus+async-executor-devel \
 rust-zbus+async-fs-devel \
 rust-zbus+async-io-devel \
 rust-zbus+async-lock-devel \
 rust-zbus+async-process-devel \
 rust-zbus+async-task-devel \
 rust-zbus+blocking-api-devel \
 rust-zbus+blocking-devel \
 rust-zbus+bus-impl-devel \
 rust-zbus+camino-devel \
 rust-zbus+chrono-devel \
 rust-zbus+default-devel \
 rust-zbus+option-as-array-devel \
 rust-zbus+p2p-devel \
 rust-zbus+serde_bytes-devel \
 rust-zbus+time-devel \
 rust-zbus+tokio-devel \
 rust-zbus+url-devel \
 rust-zbus+uuid-devel \
 rust-zbus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zbus-5.18.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4946b0612d9e90cba0dac7ec2c48ffbef9a82843567692302de434da068dbed"

URI_x86_64_v2_rust-zbus+async-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-executor-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-executor-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-executor-devel.sha256sum] = "e4bfa70e62ab6c182783cb61f41e8fa734caf671b4982cd0b373559c57fc59f6"

URI_x86_64_v2_rust-zbus+async-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-fs-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-fs-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-fs-devel.sha256sum] = "6309deb9f68e92a12180a3c9d62f5c6f5da0661f195ca9badc42d752e46eb05f"

URI_x86_64_v2_rust-zbus+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-io-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-io-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-io-devel.sha256sum] = "96bac6a0af744b17066d51c23496e5fd7fe32455cfa3442ea033808200b92833"

URI_x86_64_v2_rust-zbus+async-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-lock-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-lock-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-lock-devel.sha256sum] = "8ca31905643579ada2384563fd6a20edac82a400b24dec62f733483ccddb4567"

URI_x86_64_v2_rust-zbus+async-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-process-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-process-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-process-devel.sha256sum] = "5aac09c5141b62e7061b811599fd48da5ca29c074ed59a1f84c289f86cd3ec9c"

URI_x86_64_v2_rust-zbus+async-task-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+async-task-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+async-task-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+async-task-devel}"
SRC_URI[x86_64_v2_rust-zbus+async-task-devel.sha256sum] = "01330aeaca1a4f613ab1c534bd2762054f9bf991fa9280b05b16ab4b8ccc210c"

URI_x86_64_v2_rust-zbus+blocking-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+blocking-api-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+blocking-api-devel}"
SRC_URI[x86_64_v2_rust-zbus+blocking-api-devel.sha256sum] = "b63d67ca803bdb9134507ada1f9db1c586b654f24bd8d257887ffa63ce3cff4b"

URI_x86_64_v2_rust-zbus+blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+blocking-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+blocking-devel}"
SRC_URI[x86_64_v2_rust-zbus+blocking-devel.sha256sum] = "6b0a7e23ed1037419e9a8d60a38166e91bef404b085ca99b1b2b860759ac8456"

URI_x86_64_v2_rust-zbus+bus-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+bus-impl-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+bus-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+bus-impl-devel}"
SRC_URI[x86_64_v2_rust-zbus+bus-impl-devel.sha256sum] = "e0f1810d02a5e34eda0ad794eebf139b225041f3f5fa9dbce399030d6e92bca9"

URI_x86_64_v2_rust-zbus+camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+camino-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+camino-devel}"
SRC_URI[x86_64_v2_rust-zbus+camino-devel.sha256sum] = "fdcb6ed5e6ece66a533d1dc49225ec8c6d547099ac08f180da1d552c00c61923"

URI_x86_64_v2_rust-zbus+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+chrono-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+chrono-devel}"
SRC_URI[x86_64_v2_rust-zbus+chrono-devel.sha256sum] = "1862296e574726ff49aee705951f3c9fbf16469a3ccc14f3c26a367b69144f22"

URI_x86_64_v2_rust-zbus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+default-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+default-devel}"
SRC_URI[x86_64_v2_rust-zbus+default-devel.sha256sum] = "79eca38fc2cc2b337be058b75eaf622bdbd2a60bcb7513837e436ff7d18f5a2e"

URI_x86_64_v2_rust-zbus+option-as-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+option-as-array-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+option-as-array-devel}"
SRC_URI[x86_64_v2_rust-zbus+option-as-array-devel.sha256sum] = "74efe64eaf5c5f7d858e2adb313c9c881f388e04c34d92662b75c23aee83bc5f"

URI_x86_64_v2_rust-zbus+p2p-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+p2p-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+p2p-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+p2p-devel}"
SRC_URI[x86_64_v2_rust-zbus+p2p-devel.sha256sum] = "1e6eb863b568467deb280efd69c7c47f958263689cbf8c3dd4a1a98501e6c7b3"

URI_x86_64_v2_rust-zbus+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+serde_bytes-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-zbus+serde_bytes-devel.sha256sum] = "2f713612489bc07ac605848c91e7bb06eaa372af6d877959b987d4f72ce10f4f"

URI_x86_64_v2_rust-zbus+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+time-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+time-devel}"
SRC_URI[x86_64_v2_rust-zbus+time-devel.sha256sum] = "d655002b81df8a3cefc6f66913c4f359063944fcd70f2a35f5c26471736ba199"

URI_x86_64_v2_rust-zbus+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+tokio-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+tokio-devel}"
SRC_URI[x86_64_v2_rust-zbus+tokio-devel.sha256sum] = "7f361e8ee0b563295a2caeb99289e8bad408a5b5c506a4e160e1670c98f79c8c"

URI_x86_64_v2_rust-zbus+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+url-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+url-devel}"
SRC_URI[x86_64_v2_rust-zbus+url-devel.sha256sum] = "6cd9305537ffb97b6cec29a8ec53b845586d590b6b30f5d104e7de6864938a06"

URI_x86_64_v2_rust-zbus+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus+uuid-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus+uuid-devel}"
SRC_URI[x86_64_v2_rust-zbus+uuid-devel.sha256sum] = "52fc0642a84f50dbb11e435311174370c7bccc5ca869c7df839d7421feb3489b"

URI_x86_64_v2_rust-zbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zbus-devel-5.18.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zbus-devel}"
SRC_URI[x86_64_v2_rust-zbus-devel.sha256sum] = "5ee226019b0d8071f267ba8a43f0b71af28b201a4200905e6b6b310c53b213cc"

URI_aarch64_rust-zbus+async-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-executor-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-executor-devel}"
SRC_URI[aarch64_rust-zbus+async-executor-devel.sha256sum] = "722a47a6f531d97721215a093368a4edaba3e82e98cdb612b33cc9122b52202a"

URI_aarch64_rust-zbus+async-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-fs-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+async-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-fs-devel}"
SRC_URI[aarch64_rust-zbus+async-fs-devel.sha256sum] = "f4aee76da18972156e231882788eb3ef543aeff8e79ed1e098e06969316b6fd6"

URI_aarch64_rust-zbus+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-io-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-io-devel}"
SRC_URI[aarch64_rust-zbus+async-io-devel.sha256sum] = "969fbc5c513b7cbf6ef9ac0784e78cbd07bc1b52aca4d180e40d1592b3e7552f"

URI_aarch64_rust-zbus+async-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-lock-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-lock-devel}"
SRC_URI[aarch64_rust-zbus+async-lock-devel.sha256sum] = "8497124041091250675a3286673d3268f7234c4dcd653e8e0c6430a8a45a0f66"

URI_aarch64_rust-zbus+async-process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-process-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+async-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-process-devel}"
SRC_URI[aarch64_rust-zbus+async-process-devel.sha256sum] = "e04c23e26c1ba28ded46c40751764cf6207e1c6db70bc9dc842283ce5930f825"

URI_aarch64_rust-zbus+async-task-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+async-task-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+async-task-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+async-task-devel}"
SRC_URI[aarch64_rust-zbus+async-task-devel.sha256sum] = "a1b975a4075fca18681b2b9aca5554484a6c09f2af4b2a3d15b4a32240ed206b"

URI_aarch64_rust-zbus+blocking-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+blocking-api-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+blocking-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+blocking-api-devel}"
SRC_URI[aarch64_rust-zbus+blocking-api-devel.sha256sum] = "01093117e0b7ed64f93b28a09ac629e692d7c8d6799fc24d5afea234a94ed12d"

URI_aarch64_rust-zbus+blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+blocking-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+blocking-devel}"
SRC_URI[aarch64_rust-zbus+blocking-devel.sha256sum] = "099879596f833f3f1fe84a736d580d3e4db6c6ce270a1981a5a5f4bc6494624b"

URI_aarch64_rust-zbus+bus-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+bus-impl-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+bus-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+bus-impl-devel}"
SRC_URI[aarch64_rust-zbus+bus-impl-devel.sha256sum] = "0159f8fb3bc2c230cd2cb534b63ab944e77bc7b5ed68cb8964c56a77ac8da00b"

URI_aarch64_rust-zbus+camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+camino-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+camino-devel}"
SRC_URI[aarch64_rust-zbus+camino-devel.sha256sum] = "6f77caa438a77dd6c3b7c407154e16ea85d83fdde7b56fbec263047c51b05646"

URI_aarch64_rust-zbus+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+chrono-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+chrono-devel}"
SRC_URI[aarch64_rust-zbus+chrono-devel.sha256sum] = "4aa219cc720bba8aff7944075dae6d0d4ebc1b60c165d755fa8c818d6d28ebc5"

URI_aarch64_rust-zbus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+default-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+default-devel}"
SRC_URI[aarch64_rust-zbus+default-devel.sha256sum] = "50129bdb423a505a877b51507e46d8c85d493e78688e917eccc21e4ed453938c"

URI_aarch64_rust-zbus+option-as-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+option-as-array-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+option-as-array-devel}"
SRC_URI[aarch64_rust-zbus+option-as-array-devel.sha256sum] = "ca3757c28c167c0088ac0fd978c9d217e5cb0b596acb41530be6ff7370603e69"

URI_aarch64_rust-zbus+p2p-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+p2p-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+p2p-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+p2p-devel}"
SRC_URI[aarch64_rust-zbus+p2p-devel.sha256sum] = "bbc769a032ec53749112684a4199b19bc58dd42b340722cbf16979fcd833f60b"

URI_aarch64_rust-zbus+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+serde_bytes-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+serde_bytes-devel}"
SRC_URI[aarch64_rust-zbus+serde_bytes-devel.sha256sum] = "092a126b56782bcc9f63762c17a9eccc82758b5754cebdf83c954f4a7125ec15"

URI_aarch64_rust-zbus+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+time-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+time-devel}"
SRC_URI[aarch64_rust-zbus+time-devel.sha256sum] = "775e5a9365bc720508ac2fc0fee9272b25207fffe6bd4d5d1c0b8f94065b9ff3"

URI_aarch64_rust-zbus+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+tokio-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+tokio-devel}"
SRC_URI[aarch64_rust-zbus+tokio-devel.sha256sum] = "6e5fe73515238211ad6d56886c7770bd293d5709cd6676e20a6ecdc21ba9ef17"

URI_aarch64_rust-zbus+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+url-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+url-devel}"
SRC_URI[aarch64_rust-zbus+url-devel.sha256sum] = "ce9d74c669d7ef46328e0151b3d2d9b197a2e918e1a616df514cf5888100435f"

URI_aarch64_rust-zbus+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus+uuid-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus+uuid-devel}"
SRC_URI[aarch64_rust-zbus+uuid-devel.sha256sum] = "56080b50711873f45c946c48b791c180c2a764e81acad52f654dc4c0c26519b3"

URI_aarch64_rust-zbus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zbus-devel-5.18.0-1.el10_3.noarch.rpm;name=aarch64_rust-zbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zbus-devel}"
SRC_URI[aarch64_rust-zbus-devel.sha256sum] = "a0353c947513422a8e7ad8e68b46a407bca309e81254a1a5a8f71fd5a0e1b6a1"

RDEPENDS:rust-zbus+async-executor-devel = " \
 cargo \
 rust-async-executor+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-fs-devel = " \
 cargo \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-io-devel = " \
 cargo \
 rust-async-io+default-devel \
 rust-zbus+async-executor-devel \
 rust-zbus+async-fs-devel \
 rust-zbus+async-lock-devel \
 rust-zbus+async-process-devel \
 rust-zbus+async-task-devel \
 rust-zbus+blocking-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-lock-devel = " \
 cargo \
 rust-async-lock+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-process-devel = " \
 cargo \
 rust-async-process+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+async-task-devel = " \
 cargo \
 rust-async-task+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+blocking-api-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zbus_macros+blocking-api-devel \
 "
RDEPENDS:rust-zbus+blocking-devel = " \
 cargo \
 rust-blocking+default-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+bus-impl-devel = " \
 cargo \
 rust-zbus+p2p-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+camino-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+camino-devel \
 "
RDEPENDS:rust-zbus+chrono-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+chrono-devel \
 "
RDEPENDS:rust-zbus+default-devel = " \
 cargo \
 rust-zbus+async-io-devel \
 rust-zbus+blocking-api-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+option-as-array-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+option-as-array-devel \
 "
RDEPENDS:rust-zbus+p2p-devel = " \
 cargo \
 rust-uuid+v4-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+serde_bytes-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+serde_bytes-devel \
 "
RDEPENDS:rust-zbus+time-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+time-devel \
 "
RDEPENDS:rust-zbus+tokio-devel = " \
 cargo \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-zbus-devel \
 "
RDEPENDS:rust-zbus+url-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+url-devel \
 "
RDEPENDS:rust-zbus+uuid-devel = " \
 cargo \
 rust-zbus-devel \
 rust-zvariant+uuid-devel \
 "
RDEPENDS:rust-zbus-devel = " \
 cargo \
 rust \
 rust-async-broadcast+default-devel \
 rust-async-recursion+default-devel \
 rust-async-trait+default-devel \
 rust-enumflags2+default-devel \
 rust-enumflags2+serde-devel \
 rust-event-listener+default-devel \
 rust-futures-core+default-devel \
 rust-futures-lite+std-devel \
 rust-futures-lite-devel \
 rust-hex+default-devel \
 rust-libc-devel \
 rust-ordered-stream+default-devel \
 rust-rustix+net-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_repr+default-devel \
 rust-tracing+default-devel \
 rust-uuid+default-devel \
 rust-uuid+serde-devel \
 rust-winnow+default-devel \
 rust-zbus_macros+default-devel \
 rust-zbus_names+default-devel \
 rust-zvariant+default-devel \
 rust-zvariant+enumflags2-devel \
 "
