# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-object0.36"
PV = "0.36.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-object0.36+all-devel \
 rust-object0.36+archive-devel \
 rust-object0.36+build-devel \
 rust-object0.36+build_core-devel \
 rust-object0.36+cargo-all-devel \
 rust-object0.36+coff-devel \
 rust-object0.36+compression-devel \
 rust-object0.36+default-devel \
 rust-object0.36+doc-devel \
 rust-object0.36+elf-devel \
 rust-object0.36+macho-devel \
 rust-object0.36+pe-devel \
 rust-object0.36+read-devel \
 rust-object0.36+read_core-devel \
 rust-object0.36+std-devel \
 rust-object0.36+unaligned-devel \
 rust-object0.36+unstable-all-devel \
 rust-object0.36+unstable-devel \
 rust-object0.36+write-devel \
 rust-object0.36+write_core-devel \
 rust-object0.36+write_std-devel \
 rust-object0.36+xcoff-devel \
 rust-object0.36-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-object0.36-0.36.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4291420144f6d25f2b6a9e346c308bd9a60d4570db7a536aa598fd454e0559d4"

URI_x86_64_v2_rust-object0.36+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+all-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+all-devel}"
SRC_URI[x86_64_v2_rust-object0.36+all-devel.sha256sum] = "74fc6bb9160cc078d10405b8efcd821847a9c76d61302b8ec0267852720ebc3e"

URI_x86_64_v2_rust-object0.36+archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+archive-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+archive-devel}"
SRC_URI[x86_64_v2_rust-object0.36+archive-devel.sha256sum] = "6063362bdc430679aca4365a25655e6ca70bc52833384193bf33522c5f489131"

URI_x86_64_v2_rust-object0.36+build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+build-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+build-devel}"
SRC_URI[x86_64_v2_rust-object0.36+build-devel.sha256sum] = "ab01c66ca5284c0781d694e5d59bdf9b537dceb355fc3eadd55750c3352403dd"
RPROVIDES:rust-object0.36+build-devel:x86_64_v2 = "virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~"

URI_x86_64_v2_rust-object0.36+build_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+build_core-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+build_core-devel}"
SRC_URI[x86_64_v2_rust-object0.36+build_core-devel.sha256sum] = "c31494b480047617b489d0655d51f04f33d75a5f7e9e8e0e23b5dbe1d7de8e1b"

URI_x86_64_v2_rust-object0.36+cargo-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+cargo-all-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+cargo-all-devel}"
SRC_URI[x86_64_v2_rust-object0.36+cargo-all-devel.sha256sum] = "1e93c4ce8fe55315d16881f2320be163148df9af6ef9b88cc52772cff5f6bd0a"

URI_x86_64_v2_rust-object0.36+coff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+coff-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+coff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+coff-devel}"
SRC_URI[x86_64_v2_rust-object0.36+coff-devel.sha256sum] = "617fe98460dff874f9f3444a57a90d312c14aeb84d397160446103c8ee30ae04"

URI_x86_64_v2_rust-object0.36+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+compression-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+compression-devel}"
SRC_URI[x86_64_v2_rust-object0.36+compression-devel.sha256sum] = "18609d65df7c12321a13a0bf2fe3c37df7407f94aa5ea890a0b9bc337ba3b85b"

URI_x86_64_v2_rust-object0.36+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+default-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+default-devel}"
SRC_URI[x86_64_v2_rust-object0.36+default-devel.sha256sum] = "97e58193f86b96c79d63f2448c4ccbb3ece30794a8b477f22284f308240a24f4"

URI_x86_64_v2_rust-object0.36+doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+doc-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+doc-devel}"
SRC_URI[x86_64_v2_rust-object0.36+doc-devel.sha256sum] = "3a7b453e6bdb0ddd8bfc092f32dadd84855b10bd7d8c15335ebdebb6a8f17ba6"

URI_x86_64_v2_rust-object0.36+elf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+elf-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+elf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+elf-devel}"
SRC_URI[x86_64_v2_rust-object0.36+elf-devel.sha256sum] = "35f3cc5c32a97341a2ec2173a00a69f2ff3e832924b57808c91d595c8a6cce96"
RPROVIDES:rust-object0.36+elf-devel:x86_64_v2 = "virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~"

URI_x86_64_v2_rust-object0.36+macho-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+macho-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+macho-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+macho-devel}"
SRC_URI[x86_64_v2_rust-object0.36+macho-devel.sha256sum] = "3b88579943a8588e5e4c2fdb1ff6cd94c0eda3375c9ecea25756cd570229c2d6"

URI_x86_64_v2_rust-object0.36+pe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+pe-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+pe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+pe-devel}"
SRC_URI[x86_64_v2_rust-object0.36+pe-devel.sha256sum] = "60e7c9a0262ba249575368f2655a801f1637dd6e0783148e0e9dff8961f21336"

URI_x86_64_v2_rust-object0.36+read-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+read-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+read-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+read-devel}"
SRC_URI[x86_64_v2_rust-object0.36+read-devel.sha256sum] = "2ec86756a7906ea4f8254edfa7b09a406cc62fdbf2ee041ba27ea51a7e9a86a9"

URI_x86_64_v2_rust-object0.36+read_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+read_core-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+read_core-devel}"
SRC_URI[x86_64_v2_rust-object0.36+read_core-devel.sha256sum] = "40d9e4625c0d843477e818035192d52c22f499dac1dec943971a86e5c97c8856"

URI_x86_64_v2_rust-object0.36+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+std-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+std-devel}"
SRC_URI[x86_64_v2_rust-object0.36+std-devel.sha256sum] = "adabbbd1bca18f098d27e66a6bb59ecb9452da275e6ae6555a197bf8159d65bd"

URI_x86_64_v2_rust-object0.36+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+unaligned-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+unaligned-devel}"
SRC_URI[x86_64_v2_rust-object0.36+unaligned-devel.sha256sum] = "c9123dee941909b50d7c8cb38a84f795d69cd45b6ec878d6bae8e125929273f6"

URI_x86_64_v2_rust-object0.36+unstable-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+unstable-all-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+unstable-all-devel}"
SRC_URI[x86_64_v2_rust-object0.36+unstable-all-devel.sha256sum] = "7114023327cc3f151b82eb9b6dbaad925d0b7810c316958a7fac865b34974841"

URI_x86_64_v2_rust-object0.36+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+unstable-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+unstable-devel}"
SRC_URI[x86_64_v2_rust-object0.36+unstable-devel.sha256sum] = "bd70ff8b16d0aa0208a1f8c5a2246aa99dce4459aa5c719e8470d2722cf9c7e7"

URI_x86_64_v2_rust-object0.36+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+write-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+write-devel}"
SRC_URI[x86_64_v2_rust-object0.36+write-devel.sha256sum] = "e4a8870f841296d6d579482170f0e7273236cbcac733972a3a0002b7457373d5"

URI_x86_64_v2_rust-object0.36+write_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+write_core-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+write_core-devel}"
SRC_URI[x86_64_v2_rust-object0.36+write_core-devel.sha256sum] = "790fc8c89b0f9c192253c6868063121a752328eab7e78404ab86cd3407d93f78"

URI_x86_64_v2_rust-object0.36+write_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+write_std-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+write_std-devel}"
SRC_URI[x86_64_v2_rust-object0.36+write_std-devel.sha256sum] = "4c20003e24d4f25e560b8edac564f0e197b0a57e57c956257ae5cad74735f018"

URI_x86_64_v2_rust-object0.36+xcoff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36+xcoff-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36+xcoff-devel}"
SRC_URI[x86_64_v2_rust-object0.36+xcoff-devel.sha256sum] = "0982323f722b37b4f805cec7818d1dd9a35b9fbfb04886f5c0cad1e2bbb11c21"

URI_x86_64_v2_rust-object0.36-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-object0.36-devel-0.36.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-object0.36-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-object0.36-devel}"
SRC_URI[x86_64_v2_rust-object0.36-devel.sha256sum] = "83e359e9c1de7b9f4572a1bb752a663510df7d2739926d2ad5584af8a9967b7a"
RPROVIDES:rust-object0.36-devel:x86_64_v2 = "virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

URI_aarch64_rust-object0.36+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+all-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+all-devel}"
SRC_URI[aarch64_rust-object0.36+all-devel.sha256sum] = "07aa21efea25ed560a2e51ddd9728f80ce04520d1a95591dcb6a7f365fa1ce1f"

URI_aarch64_rust-object0.36+archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+archive-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+archive-devel}"
SRC_URI[aarch64_rust-object0.36+archive-devel.sha256sum] = "699cbaeb8f152d00159d3ef36aac68fac79a7c9e7452f99beef1030cad3b1405"

URI_aarch64_rust-object0.36+build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+build-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+build-devel}"
SRC_URI[aarch64_rust-object0.36+build-devel.sha256sum] = "0c4c794f81c191a400612091da19a4c5537623100f1ea98e266be054a1f5ced5"
RPROVIDES:rust-object0.36+build-devel:aarch64 = "virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~"

URI_aarch64_rust-object0.36+build_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+build_core-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+build_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+build_core-devel}"
SRC_URI[aarch64_rust-object0.36+build_core-devel.sha256sum] = "7172fe1ac1d439f583415745deea5a295ea7e219e08f57d946ce0d666e3eb1bc"

URI_aarch64_rust-object0.36+cargo-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+cargo-all-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+cargo-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+cargo-all-devel}"
SRC_URI[aarch64_rust-object0.36+cargo-all-devel.sha256sum] = "48892f140c9a937d144a771c98bf5e15b75f2aa64634a82abef7496f6205122a"

URI_aarch64_rust-object0.36+coff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+coff-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+coff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+coff-devel}"
SRC_URI[aarch64_rust-object0.36+coff-devel.sha256sum] = "29efe9b15384afcab82e5f2bcd7f987a84a0fe85f3951cc51bbdac44d74f7a17"

URI_aarch64_rust-object0.36+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+compression-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+compression-devel}"
SRC_URI[aarch64_rust-object0.36+compression-devel.sha256sum] = "fd6cc53aab8ce4ce25415b1cad3f6257dd0224ee09d2c2e7b1ee24da4ac020d7"

URI_aarch64_rust-object0.36+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+default-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+default-devel}"
SRC_URI[aarch64_rust-object0.36+default-devel.sha256sum] = "039b29f71bc97ea8c0e3ae6a13e29ae883647da2db1ebcb74b493bb1aa624dc8"

URI_aarch64_rust-object0.36+doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+doc-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+doc-devel}"
SRC_URI[aarch64_rust-object0.36+doc-devel.sha256sum] = "34d6fb33e53fd883885304d54192d9270075309769514afef4b17c376f4acca9"

URI_aarch64_rust-object0.36+elf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+elf-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+elf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+elf-devel}"
SRC_URI[aarch64_rust-object0.36+elf-devel.sha256sum] = "3c068b8472c7e6bf1b91e642480ebbd0aaafa354433416228c4e6b7a89156c8f"
RPROVIDES:rust-object0.36+elf-devel:aarch64 = "virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~"

URI_aarch64_rust-object0.36+macho-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+macho-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+macho-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+macho-devel}"
SRC_URI[aarch64_rust-object0.36+macho-devel.sha256sum] = "4867c34d896c3ba08b78fd4869ff1a7a93532c624809370b30914709d82bdae9"

URI_aarch64_rust-object0.36+pe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+pe-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+pe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+pe-devel}"
SRC_URI[aarch64_rust-object0.36+pe-devel.sha256sum] = "7a166d8bdba57c47e73b62a4709040018996344317fcc236f3e17a89995da83f"

URI_aarch64_rust-object0.36+read-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+read-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+read-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+read-devel}"
SRC_URI[aarch64_rust-object0.36+read-devel.sha256sum] = "68818fa26ef2c31b641507f2da4e83f4b2323fdba0e09ce23e3be3219d8284ff"

URI_aarch64_rust-object0.36+read_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+read_core-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+read_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+read_core-devel}"
SRC_URI[aarch64_rust-object0.36+read_core-devel.sha256sum] = "8649898ed7ef50a12f4fac32794a980270815e14dbd96caa0fd183616fa31011"

URI_aarch64_rust-object0.36+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+std-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+std-devel}"
SRC_URI[aarch64_rust-object0.36+std-devel.sha256sum] = "9648e0018bfea636eb2110989c6268273ebe1a77a96719459403cc28895fa4e9"

URI_aarch64_rust-object0.36+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+unaligned-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+unaligned-devel}"
SRC_URI[aarch64_rust-object0.36+unaligned-devel.sha256sum] = "3e2b3856d6b26d753a41295471a41627522e4656b92000c0f3c1077e9099c46a"

URI_aarch64_rust-object0.36+unstable-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+unstable-all-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+unstable-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+unstable-all-devel}"
SRC_URI[aarch64_rust-object0.36+unstable-all-devel.sha256sum] = "50bc342499d3b6904a0c6f2272f484287438958ff321ebbec060a38c3fa87d18"

URI_aarch64_rust-object0.36+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+unstable-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+unstable-devel}"
SRC_URI[aarch64_rust-object0.36+unstable-devel.sha256sum] = "be16c5d29ec2592887815a27274fd6f32cc6d1ef8b32df050a39b3e7889de08e"

URI_aarch64_rust-object0.36+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+write-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+write-devel}"
SRC_URI[aarch64_rust-object0.36+write-devel.sha256sum] = "0eea0d7724bdb4ea657b65ac670fa3a5d7bbb477bac16815a5e0f43464e690ee"

URI_aarch64_rust-object0.36+write_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+write_core-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+write_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+write_core-devel}"
SRC_URI[aarch64_rust-object0.36+write_core-devel.sha256sum] = "811dd43268539dacf66bdb2bf07656ae4a63c193e68e6abb9e54cf6859cf5690"

URI_aarch64_rust-object0.36+write_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+write_std-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+write_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+write_std-devel}"
SRC_URI[aarch64_rust-object0.36+write_std-devel.sha256sum] = "0b009ef95e9f08df452f00a80ca8a39d09c20394d3d7a25e55f86c28dd2af1a9"

URI_aarch64_rust-object0.36+xcoff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36+xcoff-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36+xcoff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36+xcoff-devel}"
SRC_URI[aarch64_rust-object0.36+xcoff-devel.sha256sum] = "31643d70d31b452b1d7e4e2c04a18a9567d6636bfe7743cbd2915d8cd40fb8e1"

URI_aarch64_rust-object0.36-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-object0.36-devel-0.36.7-1.el10_1.noarch.rpm;name=aarch64_rust-object0.36-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-object0.36-devel}"
SRC_URI[aarch64_rust-object0.36-devel.sha256sum] = "8ac181f2388c80de19b10550dab1e06bed40175af744a8063f2c848fcb4ddbde"
RPROVIDES:rust-object0.36-devel:aarch64 = "virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

RDEPENDS:rust-object0.36+all-devel = " \
 cargo \
 rust-object0.36+build-devel \
 rust-object0.36+compression-devel \
 rust-object0.36+read-devel \
 rust-object0.36+std-devel \
 rust-object0.36+write-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+archive-devel = " \
 cargo \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+build-devel = " \
 cargo \
 rust-object0.36+build_core-devel \
 rust-object0.36+elf-devel \
 rust-object0.36+write_std-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+build_core-devel = " \
 cargo \
 rust-object0.36+read_core-devel \
 rust-object0.36+write_core-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+cargo-all-devel = " \
 cargo \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+coff-devel = " \
 cargo \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+compression-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-object0.36+std-devel \
 rust-object0.36-devel \
 rust-ruzstd0.7+default-devel \
 "
RDEPENDS:rust-object0.36+default-devel = " \
 cargo \
 rust-object0.36+compression-devel \
 rust-object0.36+read-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+doc-devel = " \
 cargo \
 rust-object0.36+archive-devel \
 rust-object0.36+build_core-devel \
 rust-object0.36+coff-devel \
 rust-object0.36+compression-devel \
 rust-object0.36+elf-devel \
 rust-object0.36+macho-devel \
 rust-object0.36+pe-devel \
 rust-object0.36+read_core-devel \
 rust-object0.36+std-devel \
 rust-object0.36+write_std-devel \
 rust-object0.36+xcoff-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+elf-devel = " \
 cargo \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+macho-devel = " \
 cargo \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+pe-devel = " \
 cargo \
 rust-object0.36+coff-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+read-devel = " \
 cargo \
 rust-object0.36+archive-devel \
 rust-object0.36+coff-devel \
 rust-object0.36+elf-devel \
 rust-object0.36+macho-devel \
 rust-object0.36+pe-devel \
 rust-object0.36+read_core-devel \
 rust-object0.36+unaligned-devel \
 rust-object0.36+xcoff-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+read_core-devel = " \
 cargo \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+unaligned-devel = " \
 cargo \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+unstable-all-devel = " \
 cargo \
 rust-object0.36+all-devel \
 rust-object0.36+unstable-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+unstable-devel = " \
 cargo \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+write-devel = " \
 cargo \
 rust-object0.36+coff-devel \
 rust-object0.36+elf-devel \
 rust-object0.36+macho-devel \
 rust-object0.36+pe-devel \
 rust-object0.36+write_std-devel \
 rust-object0.36+xcoff-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+write_core-devel = " \
 cargo \
 rust-crc32fast-devel \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15-devel \
 rust-indexmap-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+write_std-devel = " \
 cargo \
 rust-crc32fast+std-devel \
 rust-crc32fast-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-object0.36+std-devel \
 rust-object0.36+write_core-devel \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36+xcoff-devel = " \
 cargo \
 rust-object0.36-devel \
 "
RDEPENDS:rust-object0.36-devel = " \
 cargo \
 rust \
 rust-memchr-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~ rpm/virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~ rpm/virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_object/build__ge_0.35.0_with_crate_object/build__lt_0.39.0~ rpm/virtual/crate_object/elf__ge_0.35.0_with_crate_object/elf__lt_0.39.0~ rpm/virtual/crate_object__ge_0.35.0_with_crate_object__lt_0.39.0~"
