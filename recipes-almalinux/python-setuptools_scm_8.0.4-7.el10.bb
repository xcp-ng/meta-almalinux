# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-setuptools_scm"
PV = "8.0.4"
PR = "7.el10"
PACKAGES = " \
 python3-setuptools_scm \
 python3-setuptools_scm+toml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-setuptools_scm-8.0.4-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b8668b7ae55ae86839814b7d3b4ecbd057b842559230ab056b8d8a49b5281b1"

URI_x86_64_v2_python3-setuptools_scm = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-setuptools_scm-8.0.4-7.el10.noarch.rpm;name=x86_64_v2_python3-setuptools_scm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setuptools_scm}"
SRC_URI[x86_64_v2_python3-setuptools_scm.sha256sum] = "b2c13bd3d32dc4d49228a756b6f39279bdb4236da5c2fcdd5d8de5bdffb21e50"

URI_x86_64_v2_python3-setuptools_scm+toml = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-setuptools_scm+toml-8.0.4-7.el10.noarch.rpm;name=x86_64_v2_python3-setuptools_scm+toml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setuptools_scm+toml}"
SRC_URI[x86_64_v2_python3-setuptools_scm+toml.sha256sum] = "beba46bacd6bc9bb40ac56406d5403e92859fbb52f6623fec984b90277c20d2a"

URI_aarch64_python3-setuptools_scm = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-setuptools_scm-8.0.4-7.el10.noarch.rpm;name=aarch64_python3-setuptools_scm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setuptools_scm}"
SRC_URI[aarch64_python3-setuptools_scm.sha256sum] = "b2c13bd3d32dc4d49228a756b6f39279bdb4236da5c2fcdd5d8de5bdffb21e50"

URI_aarch64_python3-setuptools_scm+toml = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-setuptools_scm+toml-8.0.4-7.el10.noarch.rpm;name=aarch64_python3-setuptools_scm+toml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setuptools_scm+toml}"
SRC_URI[aarch64_python3-setuptools_scm+toml.sha256sum] = "beba46bacd6bc9bb40ac56406d5403e92859fbb52f6623fec984b90277c20d2a"

RDEPENDS:python3-setuptools_scm = " \
 python3 \
 python3-packaging \
 python3-setuptools \
 python3-typing-extensions \
 "
RDEPENDS:python3-setuptools_scm+toml = " \
 python3 \
 python3-setuptools_scm \
 "
