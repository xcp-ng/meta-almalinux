# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-call-stack"
PV = "0.4.0"
PR = "7.el10_0"
PACKAGES = " \
 ghc-call-stack \
 ghc-call-stack-devel \
 ghc-call-stack-doc \
 ghc-call-stack-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-call-stack-0.4.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b453cebdf53263143651cd479d7b8c18b3fda8ea0df8ac12520527c724ee24ca"

URI_x86_64_v2_ghc-call-stack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-call-stack-0.4.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-call-stack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-call-stack}"
SRC_URI[x86_64_v2_ghc-call-stack.sha256sum] = "36f4bb2a3e0dc340af1ddddb77637427c7a6f00193a322d7459ab1ec6a1b3014"

URI_x86_64_v2_ghc-call-stack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-call-stack-devel-0.4.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-call-stack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-call-stack-devel}"
SRC_URI[x86_64_v2_ghc-call-stack-devel.sha256sum] = "8bdb3047b124ae87322ebab8a3e43d8ea58fe1b51ab81a78542fbe27b243df43"

URI_x86_64_v2_ghc-call-stack-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-call-stack-doc-0.4.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-call-stack-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-call-stack-doc}"
SRC_URI[x86_64_v2_ghc-call-stack-doc.sha256sum] = "9866fafccf515f7cc3903b575d1f81757f03d29edc97603d9b9cad721cbff0bd"

URI_x86_64_v2_ghc-call-stack-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-call-stack-prof-0.4.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-call-stack-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-call-stack-prof}"
SRC_URI[x86_64_v2_ghc-call-stack-prof.sha256sum] = "14b708b6ba1fb851b4e7bf370907c4e91e6cc1c9aa04f56df810fcab0be989f2"

URI_aarch64_ghc-call-stack = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-call-stack-0.4.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-call-stack;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-call-stack}"
SRC_URI[aarch64_ghc-call-stack.sha256sum] = "7e0d7d3cb2db0818b41acd50234bf71fbd3515e34547689b83fd8fd1e6942c0b"

URI_aarch64_ghc-call-stack-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-call-stack-devel-0.4.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-call-stack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-call-stack-devel}"
SRC_URI[aarch64_ghc-call-stack-devel.sha256sum] = "f63907c86ac5f02675cc92cb3b17bb8f20997f2f14130873e95e3735bbb7516d"

URI_aarch64_ghc-call-stack-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-call-stack-doc-0.4.0-7.el10_0.noarch.rpm;name=aarch64_ghc-call-stack-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-call-stack-doc}"
SRC_URI[aarch64_ghc-call-stack-doc.sha256sum] = "358adbbc3ac833dd982e45b321fc62e700c37772a1f97a21bd5dd38b12bb9b92"

URI_aarch64_ghc-call-stack-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-call-stack-prof-0.4.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-call-stack-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-call-stack-prof}"
SRC_URI[aarch64_ghc-call-stack-prof.sha256sum] = "8b0a3c3cc24260169fd6c49c63940e20ebaaa24d6ed2c09382ea02298fa7536d"

RDEPENDS:ghc-call-stack = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-call-stack-devel = " \
 ghc-base-devel \
 ghc-call-stack \
 ghc-compiler \
 "
RDEPENDS:ghc-call-stack-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-call-stack-prof = " \
 ghc-base-prof \
 ghc-call-stack-devel \
 "
