# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolourpaint"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kolourpaint \
 kolourpaint-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kolourpaint-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb932689901f9dc4877ff2e30f7c3db19d1c6d71994d7b5cc0c895b9c3132815"

URI_x86_64_v2_kolourpaint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolourpaint}"
SRC_URI[x86_64_v2_kolourpaint.sha256sum] = "485dad0fb7ed7fced5a50fc22a02729c971dd512dd8c57e3be3d9d228b6d8ed8"

URI_x86_64_v2_kolourpaint-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolourpaint-libs}"
SRC_URI[x86_64_v2_kolourpaint-libs.sha256sum] = "bbc8ae1802657a0bed784636cf29cc904629c4c7a0ba52cd7fb5f41b8b7cbd31"

URI_aarch64_kolourpaint = "${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kolourpaint;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolourpaint}"
SRC_URI[aarch64_kolourpaint.sha256sum] = "4364b58b3c7226048d6f41ad9cb8a7408993769d963d57a7391947ef1358f2fc"

URI_aarch64_kolourpaint-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kolourpaint-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolourpaint-libs}"
SRC_URI[aarch64_kolourpaint-libs.sha256sum] = "8f3d2ffe045c9595c299c64e43dd4eb4b6638616ee05c29fe74040fe076ff109"

RDEPENDS:kolourpaint = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kolourpaint-libs \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kolourpaint-libs = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kolourpaint \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
