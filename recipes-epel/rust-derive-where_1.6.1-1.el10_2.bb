# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive-where"
PV = "1.6.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-derive-where+default-devel \
 rust-derive-where+nightly-devel \
 rust-derive-where+safe-devel \
 rust-derive-where+serde-devel \
 rust-derive-where+zeroize-devel \
 rust-derive-where+zeroize-on-drop-devel \
 rust-derive-where-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive-where-1.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "046ec07226f1d7e228af54ea0e87da608be5413c12661955a79f1a2e9d67ba98"

URI_x86_64_v2_rust-derive-where+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+default-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+default-devel}"
SRC_URI[x86_64_v2_rust-derive-where+default-devel.sha256sum] = "a2a66e09a4e769725e0e78d7df4b5b98c6d639bb2042d8c0f7553411b7b21a98"

URI_x86_64_v2_rust-derive-where+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+nightly-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+nightly-devel}"
SRC_URI[x86_64_v2_rust-derive-where+nightly-devel.sha256sum] = "3c6b1a9bc3326c4e31a9c59d7e6d42cc0e86eba986248fc05e5b84af2639fc38"

URI_x86_64_v2_rust-derive-where+safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+safe-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+safe-devel}"
SRC_URI[x86_64_v2_rust-derive-where+safe-devel.sha256sum] = "887bf363d98b9fec75d4689117c2337c0e6b8c8999351ae618d35cff6181fe80"

URI_x86_64_v2_rust-derive-where+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+serde-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+serde-devel}"
SRC_URI[x86_64_v2_rust-derive-where+serde-devel.sha256sum] = "5392b9b289db415f3f565471e5a2f5883937265db72ce9e05671ab6177967837"

URI_x86_64_v2_rust-derive-where+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+zeroize-devel}"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-devel.sha256sum] = "d7a191a8e4ace1f7e256d8ca3a368380f731041d1167729541109382ff44ba56"

URI_x86_64_v2_rust-derive-where+zeroize-on-drop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where+zeroize-on-drop-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where+zeroize-on-drop-devel}"
SRC_URI[x86_64_v2_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "5292288a893ddf3e71192eecdb8c03c4a58c943fda1a369e3fc462e7d51835c9"

URI_x86_64_v2_rust-derive-where-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive-where-devel-1.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive-where-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive-where-devel}"
SRC_URI[x86_64_v2_rust-derive-where-devel.sha256sum] = "1cda53051eb1d78410bd7f4e7e64a093249869896323dff6d3f74eb7ca0b6672"

URI_aarch64_rust-derive-where+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+default-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-derive-where+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+default-devel}"
SRC_URI[aarch64_rust-derive-where+default-devel.sha256sum] = "b25c0848d6270be249b208bed197a27b7df492f8cb717c3488df23f25dadbae1"

URI_aarch64_rust-derive-where+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+nightly-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-derive-where+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+nightly-devel}"
SRC_URI[aarch64_rust-derive-where+nightly-devel.sha256sum] = "4693d808a4d4bfb14382ae4b5b81f4b8a99cf64945b8d041606f439e1823e031"

URI_aarch64_rust-derive-where+safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+safe-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-derive-where+safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+safe-devel}"
SRC_URI[aarch64_rust-derive-where+safe-devel.sha256sum] = "048d3b5867c69e0e3baa8182df2e95794447e50c0d2d3ea85626e4b5ccc71a98"

URI_aarch64_rust-derive-where+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+serde-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-derive-where+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+serde-devel}"
SRC_URI[aarch64_rust-derive-where+serde-devel.sha256sum] = "d93746ae7b306f99aaa33bfc7102509cd21dd8f130a523d8b1c4125ba3257e30"

URI_aarch64_rust-derive-where+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-derive-where+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+zeroize-devel}"
SRC_URI[aarch64_rust-derive-where+zeroize-devel.sha256sum] = "4f18f5b2f0d07a419a083e45f461e8fc101c4d5855bf2b7c125e192f3a043eb9"

URI_aarch64_rust-derive-where+zeroize-on-drop-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where+zeroize-on-drop-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-derive-where+zeroize-on-drop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where+zeroize-on-drop-devel}"
SRC_URI[aarch64_rust-derive-where+zeroize-on-drop-devel.sha256sum] = "1ccae4cced97c002ea22c56e02d61ed096732aa782d004f04f8139f87d2ad2a7"

URI_aarch64_rust-derive-where-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive-where-devel-1.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-derive-where-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive-where-devel}"
SRC_URI[aarch64_rust-derive-where-devel.sha256sum] = "4d9ab58bce01ba5289eabe9e19a31531575d543e600f0fcfe7778c0ab208cc17"

RDEPENDS:rust-derive-where+default-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+nightly-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+safe-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+serde-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-devel = " \
 cargo \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where+zeroize-on-drop-devel = " \
 cargo \
 rust-derive-where+zeroize-devel \
 rust-derive-where-devel \
 "
RDEPENDS:rust-derive-where-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
