# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opkssh"
PV = "0.14.0"
PR = "1.el10_1"
PACKAGES = " \
 opkssh \
 opkssh-doc \
 opkssh-server \
 opkssh-server-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opkssh-0.14.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0506d2645388a3ace62d203a38eb85beb2fa7b5ead2fcdbc23e4c5e4102776b"

URI_x86_64_v2_opkssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-0.14.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opkssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh}"
SRC_URI[x86_64_v2_opkssh.sha256sum] = "a5f90a3be99ced43e82385685160a23dd7c339184e9c40468c3bb64b5f0cf01b"

URI_x86_64_v2_opkssh-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-doc-0.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh-doc}"
SRC_URI[x86_64_v2_opkssh-doc.sha256sum] = "4d62556dd75b92d029e70b7e8fef79502f5440e5eaacefbdf0252ec908988ebe"

URI_x86_64_v2_opkssh-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-0.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh-server}"
SRC_URI[x86_64_v2_opkssh-server.sha256sum] = "5bd1b474f1b1cfa403fe9a9b813be2f13f9db413a638e06d1bf7197bbc089422"

URI_x86_64_v2_opkssh-server-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opkssh-server-selinux-0.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_opkssh-server-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opkssh-server-selinux}"
SRC_URI[x86_64_v2_opkssh-server-selinux.sha256sum] = "8189741004336b5f2ea73cab86d2cf11f621b9a70f64d13dff11a06f5e2823f9"

URI_aarch64_opkssh = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-0.14.0-1.el10_1.aarch64.rpm;name=aarch64_opkssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh}"
SRC_URI[aarch64_opkssh.sha256sum] = "b83afcaf12bd83d9ffc43df2deb8182e4cd31909d4d1e507f918fa215f6eac31"

URI_aarch64_opkssh-doc = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-doc-0.14.0-1.el10_1.noarch.rpm;name=aarch64_opkssh-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh-doc}"
SRC_URI[aarch64_opkssh-doc.sha256sum] = "a0e3e5e27645f1b4f92254af903ba0c33b26829fbe045c779fac264c2234de46"

URI_aarch64_opkssh-server = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-0.14.0-1.el10_1.noarch.rpm;name=aarch64_opkssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh-server}"
SRC_URI[aarch64_opkssh-server.sha256sum] = "ea041728f26398525f9742a80474b74e216e47f5861cf71a101ffd965385c47f"

URI_aarch64_opkssh-server-selinux = "${EPEL_MIRROR}/aarch64/Packages/o/opkssh-server-selinux-0.14.0-1.el10_1.noarch.rpm;name=aarch64_opkssh-server-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_opkssh-server-selinux}"
SRC_URI[aarch64_opkssh-server-selinux.sha256sum] = "110f2e00899545a0a7548ee4f4bd9f0cdc83f4d7967bca4f2ff300ea2fc04f3d"

RDEPENDS:opkssh = " \
 glibc \
 shadow-utils \
 "
RDEPENDS:opkssh-doc = " \
 "
RDEPENDS:opkssh-server = " \
 bash \
 opkssh \
 opkssh-server-selinux \
 "
RDEPENDS:opkssh-server-selinux = " \
 bash \
 selinux-policy-targeted \
 "
