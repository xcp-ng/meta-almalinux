# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-snappy"
PV = "0.0.4"
PR = "6.el10_0"
PACKAGES = " \
 compat-golang-github-syndtr-gosnappy-devel \
 golang-github-snappy \
 golang-github-snappy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-snappy-0.0.4-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7a4d7acbd7806243229145c12352bf500f73bb0cc1002707442463057ce6af3"

URI_x86_64_v2_compat-golang-github-syndtr-gosnappy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-syndtr-gosnappy-devel-0.0.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-syndtr-gosnappy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-syndtr-gosnappy-devel}"
SRC_URI[x86_64_v2_compat-golang-github-syndtr-gosnappy-devel.sha256sum] = "d35d4bee03706d4a3eaf4a2b86ecfb69d6aa080aea100e6e0034643ec0125f80"

URI_x86_64_v2_golang-github-snappy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-snappy-0.0.4-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-snappy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-snappy}"
SRC_URI[x86_64_v2_golang-github-snappy.sha256sum] = "578b4171ebaabcb51ee0d9fca5fe73a00e3e63513d332ed4ab526739d0d9a7f9"

URI_x86_64_v2_golang-github-snappy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-snappy-devel-0.0.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-snappy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-snappy-devel}"
SRC_URI[x86_64_v2_golang-github-snappy-devel.sha256sum] = "e6487b97ca13b65759bd8bb14512d091517ac682074fad9a257c1e3428ab413f"

URI_aarch64_compat-golang-github-syndtr-gosnappy-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-syndtr-gosnappy-devel-0.0.4-6.el10_0.noarch.rpm;name=aarch64_compat-golang-github-syndtr-gosnappy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-syndtr-gosnappy-devel}"
SRC_URI[aarch64_compat-golang-github-syndtr-gosnappy-devel.sha256sum] = "e154c03a75784eb446def6eafea2a8a4979387bf0da9750da657fd0e281faafb"

URI_aarch64_golang-github-snappy = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-snappy-0.0.4-6.el10_0.aarch64.rpm;name=aarch64_golang-github-snappy;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-snappy}"
SRC_URI[aarch64_golang-github-snappy.sha256sum] = "75b1cd1aa58e6a99693017edb24d2fc6d200755f8ace7d48ec2e9ab9a60f82d7"

URI_aarch64_golang-github-snappy-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-snappy-devel-0.0.4-6.el10_0.noarch.rpm;name=aarch64_golang-github-snappy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-snappy-devel}"
SRC_URI[aarch64_golang-github-snappy-devel.sha256sum] = "d53145af038e4b5877ed25d29e9de04f7b30fe2d3001c056ba2fcf2391013eec"

RDEPENDS:compat-golang-github-syndtr-gosnappy-devel = " \
 go-filesystem \
 golang-github-snappy-devel \
 "
RDEPENDS:golang-github-snappy = " \
 glibc \
 "
RDEPENDS:golang-github-snappy-devel = " \
 go-filesystem \
 "
