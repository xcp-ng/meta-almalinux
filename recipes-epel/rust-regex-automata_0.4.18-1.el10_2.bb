# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex-automata"
PV = "0.4.18"
PR = "1.el10_2"
PACKAGES = " \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+default-devel \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+internal-instrument-devel \
 rust-regex-automata+internal-instrument-pikevm-devel \
 rust-regex-automata+logging-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-automata+perf-literal-multisubstring-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata+unicode-age-devel \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-automata+unicode-case-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-script-devel \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-automata-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-automata-0.4.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d9706aca7ed2d727f157185418312d3fcf12459ef543c17f0efba9d9dc0e64b"

URI_x86_64_v2_rust-regex-automata+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+alloc-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+alloc-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+alloc-devel.sha256sum] = "247dee346973a6ebd1045eb39774de45c6607e86af5546f304a0d2d7d8666d68"

URI_x86_64_v2_rust-regex-automata+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+default-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+default-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+default-devel.sha256sum] = "19acf3c73f5c25c9c31c2d8b42e2e444156a689906e23039d5c7415db702f34c"

URI_x86_64_v2_rust-regex-automata+dfa-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-build-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-build-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-build-devel.sha256sum] = "ee7faf9e22623de90788e6d9cee9a452ab234e7a2b061806f896d70e70d09085"

URI_x86_64_v2_rust-regex-automata+dfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-devel.sha256sum] = "0c6beb28981a110c161529eb4fdb2c0e7160445757f1af1d1523121bed43b6df"

URI_x86_64_v2_rust-regex-automata+dfa-onepass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-onepass-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-onepass-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-onepass-devel.sha256sum] = "6bfccc8b8161e129e2a55a63a5a46e658c249af92813baf95d3c3f85afd7a5eb"

URI_x86_64_v2_rust-regex-automata+dfa-search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+dfa-search-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+dfa-search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+dfa-search-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+dfa-search-devel.sha256sum] = "57019537c643d25854ef4e0848af32b4d94321e5a9d6554f042bafdd298ac604"

URI_x86_64_v2_rust-regex-automata+hybrid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+hybrid-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+hybrid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+hybrid-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+hybrid-devel.sha256sum] = "81deef2a3eb3cdd99695fd6db5717eb4f9af5ba8d51c2b98ff17ffa863e225e4"

URI_x86_64_v2_rust-regex-automata+internal-instrument-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+internal-instrument-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+internal-instrument-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+internal-instrument-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+internal-instrument-devel.sha256sum] = "605ba43604845103116885254a120f532cb967f55070031dd585126407851c39"

URI_x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+internal-instrument-pikevm-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+internal-instrument-pikevm-devel.sha256sum] = "f6cb97c8de9b06ce9d0c51bb9e8b66fd0920f2458e5e7f1730fdc0d15da9a03a"

URI_x86_64_v2_rust-regex-automata+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+logging-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+logging-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+logging-devel.sha256sum] = "39e8e4b598f77b5beaf63d3960a7b4c05bb3367d20e8e1e35f48120ed26d49fd"

URI_x86_64_v2_rust-regex-automata+meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+meta-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+meta-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+meta-devel.sha256sum] = "b09d0505e991f357cda5de4ff4b48011829b07bdd354b296bd68606252195a56"

URI_x86_64_v2_rust-regex-automata+nfa-backtrack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-backtrack-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-backtrack-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-backtrack-devel.sha256sum] = "b082bbfc36044935c0df2d483d79abc5105ac3978921f0e9b50bb2e4488fd346"

URI_x86_64_v2_rust-regex-automata+nfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-devel.sha256sum] = "57068d9138bd15404156b838c9fe9499e55e18b4ae98d934ba1c7436e7e00026"

URI_x86_64_v2_rust-regex-automata+nfa-pikevm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-pikevm-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-pikevm-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-pikevm-devel.sha256sum] = "65b08b82d68939f0d29aed3bdddfbcd74b08ad3d0614b7efe4c1aae9a447e78c"

URI_x86_64_v2_rust-regex-automata+nfa-thompson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+nfa-thompson-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+nfa-thompson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+nfa-thompson-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+nfa-thompson-devel.sha256sum] = "bc810de943a4d3a927c48e79a4787d9ebb44fff18a9f9143380e5e34e161b841"

URI_x86_64_v2_rust-regex-automata+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-devel.sha256sum] = "30fdebf92108bb9b0c5f84bec2ad39d66b7603f2d3871bd5275d88a06c3066f7"

URI_x86_64_v2_rust-regex-automata+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-inline-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-inline-devel.sha256sum] = "106037e29ed4b8e9d242c52e26b90570b0ba998723e2a35d7db1e19feebdf7d7"

URI_x86_64_v2_rust-regex-automata+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-devel.sha256sum] = "d9b3026682cd4058f5cd2255db3611546de0aefc3861e56a860721744d6ed2c0"

URI_x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-multisubstring-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-multisubstring-devel.sha256sum] = "a6d99a80811b73ea9fe62dc20cf9995c7d6465e7f950f64ab41ddd34b76fd5ea"

URI_x86_64_v2_rust-regex-automata+perf-literal-substring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+perf-literal-substring-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+perf-literal-substring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+perf-literal-substring-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+perf-literal-substring-devel.sha256sum] = "584dfcf90d06706cca66c992dbb1eed944240af33997dc3a320b037cc02ab94b"

URI_x86_64_v2_rust-regex-automata+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+std-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+std-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+std-devel.sha256sum] = "edab825a8998113b8a2b26e4e3ecc0b74f84bbbc17892c1fe259a9732241b51a"

URI_x86_64_v2_rust-regex-automata+syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+syntax-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+syntax-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+syntax-devel.sha256sum] = "3a0f7a5ae3590954ebba398e6678f0b03c39efcf98d73ad071417e426fdd5b25"

URI_x86_64_v2_rust-regex-automata+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-age-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-age-devel.sha256sum] = "7b178cdb5bef6d9f1c0034cafa741fa2f8398c9998a9c5b7c1d0c8db39edf1cc"

URI_x86_64_v2_rust-regex-automata+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-bool-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-bool-devel.sha256sum] = "9ee6e3181502491e02d85245c540938b79d1a817591d361ac1027b39fe3359a5"

URI_x86_64_v2_rust-regex-automata+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-case-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-case-devel.sha256sum] = "e22b39aceceaa4f53ee4c30869798b8f2d86b3758e120ffbb286c55306ff30a8"

URI_x86_64_v2_rust-regex-automata+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-devel.sha256sum] = "b4cad562e6c1ddef0e0d1be992ac99ce601377e901964fb0394476ea748ef014"

URI_x86_64_v2_rust-regex-automata+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-gencat-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-gencat-devel.sha256sum] = "17d638902ec4f9b232b6e15ffe415ee5ea931d2bdd9c023e86caf669bbe0f439"

URI_x86_64_v2_rust-regex-automata+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-perl-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-perl-devel.sha256sum] = "0d4cefdd16d6d6ab63ceeda6772a9cff640d1868fbba2b7d14f2caf25a37c012"

URI_x86_64_v2_rust-regex-automata+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-script-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-script-devel.sha256sum] = "5a242c3d68ab6111b18e26e4d0f40535ede4a5774c2d3267cc2534899dd57b2f"

URI_x86_64_v2_rust-regex-automata+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-segment-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-segment-devel.sha256sum] = "66faf859000b2b48dced01bc4976354aace5794d56add5e7203ee441ee420296"

URI_x86_64_v2_rust-regex-automata+unicode-word-boundary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata+unicode-word-boundary-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata+unicode-word-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata+unicode-word-boundary-devel}"
SRC_URI[x86_64_v2_rust-regex-automata+unicode-word-boundary-devel.sha256sum] = "34e07564985df12fb4c52b6086a03cabe9bf3279b6762e521146b32e204e6abb"

URI_x86_64_v2_rust-regex-automata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-automata-devel-0.4.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-automata-devel}"
SRC_URI[x86_64_v2_rust-regex-automata-devel.sha256sum] = "7c3e4f1fa2b9a6dbfc3a56ede5011de80385593d5bc27c90757a2205d22012b3"

URI_aarch64_rust-regex-automata+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+alloc-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+alloc-devel}"
SRC_URI[aarch64_rust-regex-automata+alloc-devel.sha256sum] = "a6cea4627c908e894c42c638174680334ce0523f4d2ee6eb0e4f5d2a076826de"

URI_aarch64_rust-regex-automata+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+default-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+default-devel}"
SRC_URI[aarch64_rust-regex-automata+default-devel.sha256sum] = "a24250f1e3622df1cb651a78321dcb10f6c900053dc9419726403b4a7637c4af"

URI_aarch64_rust-regex-automata+dfa-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-build-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+dfa-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-build-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-build-devel.sha256sum] = "569647907049fbf68feed8e89ad94c36b82bbe3343bddef9567c9e8ae806db87"

URI_aarch64_rust-regex-automata+dfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+dfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-devel.sha256sum] = "4a20270843cfc9c1aa98cc4fc70e032097e5baec3d0ce56eccddc0989b51ae1b"

URI_aarch64_rust-regex-automata+dfa-onepass-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-onepass-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+dfa-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-onepass-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-onepass-devel.sha256sum] = "eba3ff99d8680df64260f175b31161b87af8b94e7c6529ebc87a1302e5c64e1e"

URI_aarch64_rust-regex-automata+dfa-search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+dfa-search-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+dfa-search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+dfa-search-devel}"
SRC_URI[aarch64_rust-regex-automata+dfa-search-devel.sha256sum] = "30dc1d639303d62bdacfc733af63ae800d35894661c62475d846a64983e5d030"

URI_aarch64_rust-regex-automata+hybrid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+hybrid-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+hybrid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+hybrid-devel}"
SRC_URI[aarch64_rust-regex-automata+hybrid-devel.sha256sum] = "090493f5fc0a386e8e7f32dcf8651bbe41d2a64696afabe472ea457fa31f60c4"

URI_aarch64_rust-regex-automata+internal-instrument-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+internal-instrument-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+internal-instrument-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+internal-instrument-devel}"
SRC_URI[aarch64_rust-regex-automata+internal-instrument-devel.sha256sum] = "32bac184e473803933eabc7c287b5a5f96bf2ba4188912e9a99dbfe5fb05657b"

URI_aarch64_rust-regex-automata+internal-instrument-pikevm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+internal-instrument-pikevm-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+internal-instrument-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+internal-instrument-pikevm-devel}"
SRC_URI[aarch64_rust-regex-automata+internal-instrument-pikevm-devel.sha256sum] = "48fd6341cc0cc60a2fd8256a234d95f9396dd515e84a54cac4a35ea9868e1715"

URI_aarch64_rust-regex-automata+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+logging-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+logging-devel}"
SRC_URI[aarch64_rust-regex-automata+logging-devel.sha256sum] = "df50d5fad809151dcbc1e3efef75b911279367fe4dd6fb07feb5f459501a48f4"

URI_aarch64_rust-regex-automata+meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+meta-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+meta-devel}"
SRC_URI[aarch64_rust-regex-automata+meta-devel.sha256sum] = "53c6cc3ed2c22e2bcd92ac32ddffee2163ce9d8d33b89793a6cb896ec3df5678"

URI_aarch64_rust-regex-automata+nfa-backtrack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-backtrack-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+nfa-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-backtrack-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-backtrack-devel.sha256sum] = "035997fadf57bdbb33e2673f2ea97a5ce4ec9b2060aa76af69daddc61bf50747"

URI_aarch64_rust-regex-automata+nfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+nfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-devel.sha256sum] = "b18e4b4b8b88161f3dbfc72e1b212cf96a2ed040a535d226294f24c8f8c423de"

URI_aarch64_rust-regex-automata+nfa-pikevm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-pikevm-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+nfa-pikevm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-pikevm-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-pikevm-devel.sha256sum] = "c90de601dfa3097dedaf9bb10140ae895307ca453eee429f94403ca4e3b14fb8"

URI_aarch64_rust-regex-automata+nfa-thompson-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+nfa-thompson-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+nfa-thompson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+nfa-thompson-devel}"
SRC_URI[aarch64_rust-regex-automata+nfa-thompson-devel.sha256sum] = "a8f4047f902c22cb5ea991a5d6372d0f721707ceb5f2f66bf3966585e6845c22"

URI_aarch64_rust-regex-automata+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-devel.sha256sum] = "21700d936f1230127d9a104b0a7036f3512857020b9993955553fc4d4a4b1f34"

URI_aarch64_rust-regex-automata+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-inline-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-inline-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-inline-devel.sha256sum] = "e9f175098866705b973d675c38351ebb307a54f341e03132eb605f6814cc4b63"

URI_aarch64_rust-regex-automata+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-devel.sha256sum] = "cd0e75b45c57ef1da42abcab2f752854caadbb62e0d11e13472f194f184cd4a4"

URI_aarch64_rust-regex-automata+perf-literal-multisubstring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-multisubstring-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-multisubstring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-multisubstring-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-multisubstring-devel.sha256sum] = "e7ec82931e44e180c9838fc76229a281422f92da99dcc0b7917467dee9a9894e"

URI_aarch64_rust-regex-automata+perf-literal-substring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+perf-literal-substring-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+perf-literal-substring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+perf-literal-substring-devel}"
SRC_URI[aarch64_rust-regex-automata+perf-literal-substring-devel.sha256sum] = "d31760e23ba691bd129ae54072c59ac09c99688d5cdc5dddec8d17fc72caf52b"

URI_aarch64_rust-regex-automata+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+std-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+std-devel}"
SRC_URI[aarch64_rust-regex-automata+std-devel.sha256sum] = "1763d1d00ad9adba50cf612d3c6ce5ab6f9fb0dad958a829104b19e44ec61a71"

URI_aarch64_rust-regex-automata+syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+syntax-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+syntax-devel}"
SRC_URI[aarch64_rust-regex-automata+syntax-devel.sha256sum] = "d9423163460663d224cda67c5047ca11479d2d6b25e4aca0a3e3680cefcea3b1"

URI_aarch64_rust-regex-automata+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-age-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-age-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-age-devel.sha256sum] = "44a14e5f6beb01028c726efc42078f751d7070b3e4787060d2da4fca0f3f22f2"

URI_aarch64_rust-regex-automata+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-bool-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-bool-devel.sha256sum] = "4b0dd355a73aa236e53a853d7135571f02847461decc57797cdc11325da6b015"

URI_aarch64_rust-regex-automata+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-case-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-case-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-case-devel.sha256sum] = "ddf7401921e800518c754e985c5d3b04b11cfb364882268a943765528d3c9acd"

URI_aarch64_rust-regex-automata+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-devel.sha256sum] = "021c39a6439bd66e03e694114414111e654155e9d28ea3a16e75a63425c0c3c7"

URI_aarch64_rust-regex-automata+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-gencat-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-gencat-devel.sha256sum] = "9022d9150cf03d5727dbd66fdcdcf72bda84111bcd3fefd0f63570daf0e2755d"

URI_aarch64_rust-regex-automata+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-perl-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-perl-devel.sha256sum] = "ecd9be629ec098bfcc9ea1b214f55c62cf912ec78891ea948de625fc7fec069b"

URI_aarch64_rust-regex-automata+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-script-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-script-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-script-devel.sha256sum] = "1a0bcfb721cc84921443c4627a65fe25bd6b0d04a1d090d45334ea2e69d0b43d"

URI_aarch64_rust-regex-automata+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-segment-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-segment-devel.sha256sum] = "d3eca041cccfb5a46a041476ec43c1acf2abc6e2f0f2b335d144c1d6a14fb646"

URI_aarch64_rust-regex-automata+unicode-word-boundary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata+unicode-word-boundary-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata+unicode-word-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata+unicode-word-boundary-devel}"
SRC_URI[aarch64_rust-regex-automata+unicode-word-boundary-devel.sha256sum] = "2d82b5257ae345e97141c07752a7a356ccb325faf0837c686db0d2525b247b03"

URI_aarch64_rust-regex-automata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-automata-devel-0.4.18-1.el10_2.noarch.rpm;name=aarch64_rust-regex-automata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-automata-devel}"
SRC_URI[aarch64_rust-regex-automata-devel.sha256sum] = "f8f5c80953a568ce7aa36d8d63329f8c2029057309885391a319e2c9730fbe00"

RDEPENDS:rust-regex-automata+alloc-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+default-devel = " \
 cargo \
 rust-regex-automata+dfa-devel \
 rust-regex-automata+hybrid-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-devel \
 rust-regex-automata+perf-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-build-devel = " \
 cargo \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-devel = " \
 cargo \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-onepass-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+dfa-search-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+hybrid-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+internal-instrument-devel = " \
 cargo \
 rust-regex-automata+internal-instrument-pikevm-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+internal-instrument-pikevm-devel = " \
 cargo \
 rust-regex-automata+logging-devel \
 rust-regex-automata+std-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+logging-devel = " \
 cargo \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick-devel \
 rust-log+default-devel \
 rust-memchr+logging-devel \
 rust-memchr-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+meta-devel = " \
 cargo \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-backtrack-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-devel = " \
 cargo \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-pikevm-devel = " \
 cargo \
 rust-regex-automata+nfa-thompson-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+nfa-thompson-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-devel = " \
 cargo \
 rust-regex-automata+perf-inline-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-inline-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-devel = " \
 cargo \
 rust-regex-automata+perf-literal-multisubstring-devel \
 rust-regex-automata+perf-literal-substring-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-multisubstring-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+perf-literal-substring-devel = " \
 cargo \
 rust-aho-corasick+perf-literal-devel \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata+std-devel = " \
 cargo \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+std-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+syntax-devel = " \
 cargo \
 rust-regex-automata+alloc-devel \
 rust-regex-automata-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-age-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-age-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-bool-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-bool-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-case-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-case-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-devel = " \
 cargo \
 rust-regex-automata+unicode-age-devel \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-automata+unicode-case-devel \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-script-devel \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-gencat-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-gencat-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-perl-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-perl-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-script-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-script-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-segment-devel = " \
 cargo \
 rust-regex-automata-devel \
 rust-regex-syntax+unicode-segment-devel \
 rust-regex-syntax-devel \
 "
RDEPENDS:rust-regex-automata+unicode-word-boundary-devel = " \
 cargo \
 rust-regex-automata-devel \
 "
RDEPENDS:rust-regex-automata-devel = " \
 cargo \
 rust \
 "
