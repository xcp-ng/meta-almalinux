# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cpuguy83-md2man-epel"
PV = "2.0.3"
PR = "1.el10_0"
PACKAGES = " \
 compat-golang-github-cpuguy83-md2man2-devel \
 golang-github-cpuguy83-md2man-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-cpuguy83-md2man-epel-2.0.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25035f3bf95f4e693eeb48ab2768451ff61d35763b80bc249fa26443cc5ef38d"

URI_x86_64_v2_compat-golang-github-cpuguy83-md2man2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-cpuguy83-md2man2-devel-2.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-cpuguy83-md2man2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-cpuguy83-md2man2-devel}"
SRC_URI[x86_64_v2_compat-golang-github-cpuguy83-md2man2-devel.sha256sum] = "5cc0acfd15853ef8a9bc1f773d8fec6ea40d32a9a15374a753f72f5a1a8c5fdd"

URI_x86_64_v2_golang-github-cpuguy83-md2man-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-cpuguy83-md2man-devel-2.0.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-cpuguy83-md2man-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cpuguy83-md2man-devel}"
SRC_URI[x86_64_v2_golang-github-cpuguy83-md2man-devel.sha256sum] = "831545308a43c252a27902eb23d5deafb9a35c456e9d6a93b65782b14b681f11"

URI_aarch64_compat-golang-github-cpuguy83-md2man2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-cpuguy83-md2man2-devel-2.0.3-1.el10_0.noarch.rpm;name=aarch64_compat-golang-github-cpuguy83-md2man2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-cpuguy83-md2man2-devel}"
SRC_URI[aarch64_compat-golang-github-cpuguy83-md2man2-devel.sha256sum] = "fe86a32482b5e3268787631b07edc51511c8504a4d3c9e73c0797096d56a39fb"

URI_aarch64_golang-github-cpuguy83-md2man-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cpuguy83-md2man-devel-2.0.3-1.el10_0.noarch.rpm;name=aarch64_golang-github-cpuguy83-md2man-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cpuguy83-md2man-devel}"
SRC_URI[aarch64_golang-github-cpuguy83-md2man-devel.sha256sum] = "caab52064cc63abd3d5ea249a974c9fa76ab6e24acf64710219c6c1d1e88634f"

RDEPENDS:compat-golang-github-cpuguy83-md2man2-devel = " \
 go-filesystem \
 golang-github-cpuguy83-md2man-devel \
 "
RDEPENDS:golang-github-cpuguy83-md2man-devel = " \
 compat-golang-github-russross-blackfriday-2-devel \
 go-filesystem \
 "
