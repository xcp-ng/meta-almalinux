# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-data-encoding"
PV = "2.10.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-data-encoding+alloc-devel \
 rust-data-encoding+default-devel \
 rust-data-encoding+std-devel \
 rust-data-encoding-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-data-encoding-2.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8496fba1ed964408802156e2122b02375b19c18df5d970bc844f993c37963636"

URI_x86_64_v2_rust-data-encoding+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+alloc-devel-2.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding+alloc-devel}"
SRC_URI[x86_64_v2_rust-data-encoding+alloc-devel.sha256sum] = "894821466f39266b85ec98f03819c0e39bd931792a36cefe661145a1a927eb18"

URI_x86_64_v2_rust-data-encoding+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+default-devel-2.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding+default-devel}"
SRC_URI[x86_64_v2_rust-data-encoding+default-devel.sha256sum] = "421fa3d7c0728d9051d4e3fa6cc315f403196245207c36f12a6f1b01f13a8c1b"

URI_x86_64_v2_rust-data-encoding+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding+std-devel-2.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding+std-devel}"
SRC_URI[x86_64_v2_rust-data-encoding+std-devel.sha256sum] = "c87ec6a22a5cbf36df88166b15951e36b9016f580176a9eea0595b989501052a"

URI_x86_64_v2_rust-data-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-data-encoding-devel-2.10.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-data-encoding-devel}"
SRC_URI[x86_64_v2_rust-data-encoding-devel.sha256sum] = "690df223139d67b451b27916fed58d5c536aa4eb7ee18a5deec4cebb114081c9"

URI_aarch64_rust-data-encoding+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+alloc-devel-2.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding+alloc-devel}"
SRC_URI[aarch64_rust-data-encoding+alloc-devel.sha256sum] = "dccdf81d4c1bcb0f26ad04838c9a11c32d65be0210a6d3a8346a74d817e053e2"

URI_aarch64_rust-data-encoding+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+default-devel-2.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding+default-devel}"
SRC_URI[aarch64_rust-data-encoding+default-devel.sha256sum] = "be683a5f8950c841cba1cc8aa0ec4d008eab5472436c873856cad1e8f7c97e99"

URI_aarch64_rust-data-encoding+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding+std-devel-2.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding+std-devel}"
SRC_URI[aarch64_rust-data-encoding+std-devel.sha256sum] = "9ae22992681d4acd11ef53ef7e74f239682357a71c96e1ae69adf772857d3135"

URI_aarch64_rust-data-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-data-encoding-devel-2.10.0-1.el10_3.noarch.rpm;name=aarch64_rust-data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-data-encoding-devel}"
SRC_URI[aarch64_rust-data-encoding-devel.sha256sum] = "d3fad795fb05923a23d342d62098ff094211edef192b858010ed7c7aaacfe1b5"

RDEPENDS:rust-data-encoding+alloc-devel = " \
 cargo \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding+default-devel = " \
 cargo \
 rust-data-encoding+std-devel \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding+std-devel = " \
 cargo \
 rust-data-encoding+alloc-devel \
 rust-data-encoding-devel \
 "
RDEPENDS:rust-data-encoding-devel = " \
 cargo \
 rust \
 "
