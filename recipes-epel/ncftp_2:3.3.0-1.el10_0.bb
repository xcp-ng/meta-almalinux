# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ncftp"
PE = "2"
PV = "3.3.0"
PR = "1.el10_0"
PACKAGES = " \
 ncftp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ncftp-3.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcae9a64fa20e905e94229bcdd2e54516832a641905a400901da5048e01e9f9e"

URI_x86_64_v2_ncftp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ncftp-3.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ncftp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ncftp}"
SRC_URI[x86_64_v2_ncftp.sha256sum] = "b962d463c3e32028ec2082625800f3978c5f82f7c432ce358fad0bf14e0016ea"

URI_aarch64_ncftp = "${EPEL_MIRROR}/aarch64/Packages/n/ncftp-3.3.0-1.el10_0.aarch64.rpm;name=aarch64_ncftp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ncftp}"
SRC_URI[aarch64_ncftp.sha256sum] = "87e86e47856fa0245a55854c32e6ea5ef7d4f937e46bf30d8f48b6bdcf8b5e97"

RDEPENDS:ncftp = " \
 glibc \
 ncurses-libs \
 "
