# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gethostname"
PV = "0.4.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-gethostname+default-devel \
 rust-gethostname-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gethostname-0.4.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f22bd5a1907b4ba2a247d57a7a87fdb98fdb5091eabeaae57a2b82e48c2a8bd2"

URI_x86_64_v2_rust-gethostname+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gethostname+default-devel-0.4.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gethostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gethostname+default-devel}"
SRC_URI[x86_64_v2_rust-gethostname+default-devel.sha256sum] = "4294bef23df6f1d8e3d6d2c23f03272702888b72e87e31480790c9996fdffda0"

URI_x86_64_v2_rust-gethostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gethostname-devel-0.4.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gethostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gethostname-devel}"
SRC_URI[x86_64_v2_rust-gethostname-devel.sha256sum] = "6a1bc508f0b370ad2d72faf18806256e783c89f2d2a5374b6ae346ed414e66e8"

URI_aarch64_rust-gethostname+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gethostname+default-devel-0.4.3-4.el10_0.noarch.rpm;name=aarch64_rust-gethostname+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gethostname+default-devel}"
SRC_URI[aarch64_rust-gethostname+default-devel.sha256sum] = "2ab63622137eef3a708d1eb15db23ecee9a647f7c05bc8e62b8f227bfef25a52"

URI_aarch64_rust-gethostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gethostname-devel-0.4.3-4.el10_0.noarch.rpm;name=aarch64_rust-gethostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gethostname-devel}"
SRC_URI[aarch64_rust-gethostname-devel.sha256sum] = "9ce7ca46e60b36bc01dd9f0a850b9f11c5b5ef90790534495f8a8a6e53d20130"

RDEPENDS:rust-gethostname+default-devel = " \
 cargo \
 rust-gethostname-devel \
 "
RDEPENDS:rust-gethostname-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
