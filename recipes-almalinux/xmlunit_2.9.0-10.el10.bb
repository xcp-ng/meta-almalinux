# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xmlunit"
PV = "2.9.0"
PR = "10.el10"
PACKAGES = " \
 xmlunit \
 xmlunit-assertj \
 xmlunit-core \
 xmlunit-javadoc \
 xmlunit-legacy \
 xmlunit-matchers \
 xmlunit-placeholders \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/xmlunit-2.9.0-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "498894b294288840ca3f5de8aaf6adf79d3cf31b426de86bbeade2a2aa747ab0"

URI_x86_64_v2_xmlunit = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmlunit-2.9.0-10.el10.noarch.rpm;name=x86_64_v2_xmlunit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlunit}"
SRC_URI[x86_64_v2_xmlunit.sha256sum] = "1b2373a36dcc77a3454ba8de6d4c11eb7968bfdec4c1dca1cfa75e760567aa3a"

URI_x86_64_v2_xmlunit-assertj = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmlunit-assertj-2.9.0-10.el10.noarch.rpm;name=x86_64_v2_xmlunit-assertj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlunit-assertj}"
SRC_URI[x86_64_v2_xmlunit-assertj.sha256sum] = "e0d4270c06c102c7ebc8a95ab2fca59d1990b061be0ea5f7b1ab772d41482c3f"

URI_x86_64_v2_xmlunit-core = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmlunit-core-2.9.0-10.el10.noarch.rpm;name=x86_64_v2_xmlunit-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlunit-core}"
SRC_URI[x86_64_v2_xmlunit-core.sha256sum] = "94decf6fe492560b76fc7422e5e323acc2e7e2d03cc9f265e5996dbfade553bd"

URI_x86_64_v2_xmlunit-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmlunit-javadoc-2.9.0-10.el10.noarch.rpm;name=x86_64_v2_xmlunit-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlunit-javadoc}"
SRC_URI[x86_64_v2_xmlunit-javadoc.sha256sum] = "e73d304aadec79b10a50824262da7067d14aa31123c2885cc6a86bf6516ede44"

URI_x86_64_v2_xmlunit-legacy = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmlunit-legacy-2.9.0-10.el10.noarch.rpm;name=x86_64_v2_xmlunit-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlunit-legacy}"
SRC_URI[x86_64_v2_xmlunit-legacy.sha256sum] = "bfa333c18b9b945ac0e78350f1d31c5f68e0b002cf1fd532f2f823a358f4b51f"

URI_x86_64_v2_xmlunit-matchers = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmlunit-matchers-2.9.0-10.el10.noarch.rpm;name=x86_64_v2_xmlunit-matchers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlunit-matchers}"
SRC_URI[x86_64_v2_xmlunit-matchers.sha256sum] = "ec03e0f14376ff838336c0589d39ceea2fe8336a540696d393152896f4015fa3"

URI_x86_64_v2_xmlunit-placeholders = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xmlunit-placeholders-2.9.0-10.el10.noarch.rpm;name=x86_64_v2_xmlunit-placeholders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xmlunit-placeholders}"
SRC_URI[x86_64_v2_xmlunit-placeholders.sha256sum] = "44cf76c6ca04ff079b98bfaab20e54cb9872e41e9cbf9247c84c504643a0bea1"

URI_aarch64_xmlunit = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmlunit-2.9.0-10.el10.noarch.rpm;name=aarch64_xmlunit;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlunit}"
SRC_URI[aarch64_xmlunit.sha256sum] = "1b2373a36dcc77a3454ba8de6d4c11eb7968bfdec4c1dca1cfa75e760567aa3a"

URI_aarch64_xmlunit-assertj = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmlunit-assertj-2.9.0-10.el10.noarch.rpm;name=aarch64_xmlunit-assertj;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlunit-assertj}"
SRC_URI[aarch64_xmlunit-assertj.sha256sum] = "e0d4270c06c102c7ebc8a95ab2fca59d1990b061be0ea5f7b1ab772d41482c3f"

URI_aarch64_xmlunit-core = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmlunit-core-2.9.0-10.el10.noarch.rpm;name=aarch64_xmlunit-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlunit-core}"
SRC_URI[aarch64_xmlunit-core.sha256sum] = "94decf6fe492560b76fc7422e5e323acc2e7e2d03cc9f265e5996dbfade553bd"

URI_aarch64_xmlunit-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmlunit-javadoc-2.9.0-10.el10.noarch.rpm;name=aarch64_xmlunit-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlunit-javadoc}"
SRC_URI[aarch64_xmlunit-javadoc.sha256sum] = "e73d304aadec79b10a50824262da7067d14aa31123c2885cc6a86bf6516ede44"

URI_aarch64_xmlunit-legacy = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmlunit-legacy-2.9.0-10.el10.noarch.rpm;name=aarch64_xmlunit-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlunit-legacy}"
SRC_URI[aarch64_xmlunit-legacy.sha256sum] = "bfa333c18b9b945ac0e78350f1d31c5f68e0b002cf1fd532f2f823a358f4b51f"

URI_aarch64_xmlunit-matchers = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmlunit-matchers-2.9.0-10.el10.noarch.rpm;name=aarch64_xmlunit-matchers;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlunit-matchers}"
SRC_URI[aarch64_xmlunit-matchers.sha256sum] = "ec03e0f14376ff838336c0589d39ceea2fe8336a540696d393152896f4015fa3"

URI_aarch64_xmlunit-placeholders = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xmlunit-placeholders-2.9.0-10.el10.noarch.rpm;name=aarch64_xmlunit-placeholders;unpack=0"
SRC_URI:append = " ${URI_aarch64_xmlunit-placeholders}"
SRC_URI[aarch64_xmlunit-placeholders.sha256sum] = "44cf76c6ca04ff079b98bfaab20e54cb9872e41e9cbf9247c84c504643a0bea1"

RDEPENDS:xmlunit = " \
 javapackages-filesystem \
 maven-bundle-plugin \
 "
RDEPENDS:xmlunit-assertj = " \
 assertj-core \
 javapackages-filesystem \
 xmlunit-core \
 "
RDEPENDS:xmlunit-core = " \
 javapackages-filesystem \
 "
RDEPENDS:xmlunit-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:xmlunit-legacy = " \
 javapackages-filesystem \
 junit \
 xmlunit-core \
 "
RDEPENDS:xmlunit-matchers = " \
 hamcrest \
 javapackages-filesystem \
 xmlunit-core \
 "
RDEPENDS:xmlunit-placeholders = " \
 javapackages-filesystem \
 xmlunit-core \
 "
