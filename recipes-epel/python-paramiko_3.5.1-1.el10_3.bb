# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-paramiko"
PV = "3.5.1"
PR = "1.el10_3"
PACKAGES = " \
 python-paramiko-doc \
 python3-paramiko \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-paramiko-3.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a96bc6fac30590db810c6cda71c06e6986d2653665f8b8cd4012ab6e0a241f59"

URI_x86_64_v2_python-paramiko-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-paramiko-doc-3.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-paramiko-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-paramiko-doc}"
SRC_URI[x86_64_v2_python-paramiko-doc.sha256sum] = "6ca5325e6abe7c9b382f57010aacfb36e0a5886b51841052d6b3cd9374f4dac8"

URI_x86_64_v2_python3-paramiko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-paramiko-3.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-paramiko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-paramiko}"
SRC_URI[x86_64_v2_python3-paramiko.sha256sum] = "485aa66eefe61031fb64b2cd9a24b20978d698e030787bcc8f851076b22e829c"

URI_aarch64_python-paramiko-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-paramiko-doc-3.5.1-1.el10_3.noarch.rpm;name=aarch64_python-paramiko-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-paramiko-doc}"
SRC_URI[aarch64_python-paramiko-doc.sha256sum] = "08166f1419ea054bb8da7aa2a1eb59b5f6d853deb77bc575bfe5a6bd10e2670f"

URI_aarch64_python3-paramiko = "${EPEL_MIRROR}/aarch64/Packages/p/python3-paramiko-3.5.1-1.el10_3.noarch.rpm;name=aarch64_python3-paramiko;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-paramiko}"
SRC_URI[aarch64_python3-paramiko.sha256sum] = "ee3e43ec5ad240b1ab2bb7b19285ebd99771d6d76e8c3ace398c3188a9891581"

RDEPENDS:python-paramiko-doc = " \
 python3-paramiko \
 "
RDEPENDS:python3-paramiko = " \
 python3 \
 python3-bcrypt \
 python3-cryptography \
 python3-pynacl \
 "
