# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert-impl"
PV = "0.1.3"
PR = "12.el10_1"
PACKAGES = " \
 rust-assert-impl+default-devel \
 rust-assert-impl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-assert-impl-0.1.3-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "22a28267d7b716479bc79818d592de1d4ca324a806cd1aaeb176be970c397789"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert-impl+default-devel-0.1.3-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert-impl+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-assert-impl+default-devel.sha256sum] = "59c281c4114bed2a2b4d7e8c3dbc937ffcc8f71f56dd11eefb6d7c98a32be885"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert-impl-devel-0.1.3-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert-impl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-assert-impl-devel.sha256sum] = "4efcf5655043d622e1b19d9682516d5ddee9a103e824ceb75b20cd6d64ca8c5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-assert-impl+default-devel-0.1.3-12.el10_1.noarch.rpm;name=aarch64_rust-assert-impl+default-devel;unpack=0"
SRC_URI[aarch64_rust-assert-impl+default-devel.sha256sum] = "92c3efe9c663de31f93d70e621fb8a5dce1fce19bc415b41909aecb9391327ba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-assert-impl-devel-0.1.3-12.el10_1.noarch.rpm;name=aarch64_rust-assert-impl-devel;unpack=0"
SRC_URI[aarch64_rust-assert-impl-devel.sha256sum] = "30bf2877b38e7b349bb5a9925b22b2f06b946258563507d2e701a6ea3cc1dee7"

RDEPENDS:rust-assert-impl+default-devel = " \
 cargo \
 rust-assert-impl-devel \
 "
RDEPENDS:rust-assert-impl-devel = " \
 cargo \
 "
