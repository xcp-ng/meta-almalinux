# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-containerd-console"
PV = "1.0.3"
PR = "8.el10_0"
PACKAGES = " \
 golang-github-containerd-console-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-containerd-console-1.0.3-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74e0b2e92e1590040fc46377a23bd99df545cf406edeea830d84c0abe4a075db"

URI_x86_64_v2_golang-github-containerd-console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-containerd-console-devel-1.0.3-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-containerd-console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-containerd-console-devel}"
SRC_URI[x86_64_v2_golang-github-containerd-console-devel.sha256sum] = "5796577839a6b56a514f397a63041560554326ce69da993c2cbaf8452a8db144"

URI_aarch64_golang-github-containerd-console-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-containerd-console-devel-1.0.3-8.el10_0.noarch.rpm;name=aarch64_golang-github-containerd-console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-containerd-console-devel}"
SRC_URI[aarch64_golang-github-containerd-console-devel.sha256sum] = "24feb8d404a7f8a5ddc533f69453a718b80f9029f4f8feacf522e9b045106b12"

RDEPENDS:golang-github-containerd-console-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
