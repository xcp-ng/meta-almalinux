# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mlmmj"
PV = "1.7.0"
PR = "1.el10_2"
PACKAGES = " \
 mlmmj \
 mlmmj-selinux \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/mlmmj-1.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "324f8c6a836eb79d847c47d2a69fcda717be0d6ec1a43da78ca3363e2bda0c8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlmmj-1.7.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mlmmj;unpack=0"
SRC_URI[x86_64_v2_mlmmj.sha256sum] = "bb2c8a983b8e163c6c4dbdc92177916488f43756e219e24e7005b64abe5d29db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mlmmj-selinux-1.7.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mlmmj-selinux;unpack=0"
SRC_URI[x86_64_v2_mlmmj-selinux.sha256sum] = "394628f68774bd2f822ada2f8fc72af867261bd2c87cda4b7e9d5f97b1b95b0c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mlmmj-1.7.0-1.el10_2.aarch64.rpm;name=aarch64_mlmmj;unpack=0"
SRC_URI[aarch64_mlmmj.sha256sum] = "5314e9135ce3b324f3de2f65da51f4fa3d9350ea46008b11f122a6f982f1c54e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mlmmj-selinux-1.7.0-1.el10_2.noarch.rpm;name=aarch64_mlmmj-selinux;unpack=0"
SRC_URI[aarch64_mlmmj-selinux.sha256sum] = "3e5d93c7408458589b651b2eda2f0863de5157b152034255c638d9e67a2a2294"

RDEPENDS:mlmmj = " \
 bash \
 glibc \
 "
RDEPENDS:mlmmj-selinux = " \
 bash \
 mlmmj \
 selinux-policy-targeted \
 "
