# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-secret-service"
PV = "5.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-secret-service+crypto-openssl-devel \
 rust-secret-service+crypto-rust-devel \
 rust-secret-service+default-devel \
 rust-secret-service+rt-async-io-crypto-openssl-devel \
 rust-secret-service+rt-async-io-crypto-rust-devel \
 rust-secret-service+rt-tokio-crypto-openssl-devel \
 rust-secret-service+rt-tokio-crypto-rust-devel \
 rust-secret-service-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-secret-service-5.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6f1c00c1e9ee348734fd2b6a7743e6ce451031e647d0f7454a5c9668bd01267"

URI_x86_64_v2_rust-secret-service+crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+crypto-openssl-devel-5.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-secret-service+crypto-openssl-devel.sha256sum] = "c27cc99ef3f95db6414d314c1ed2f6cda10e3e91aa538c1813e5b0aaaa66da60"

URI_x86_64_v2_rust-secret-service+crypto-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+crypto-rust-devel-5.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+crypto-rust-devel}"
SRC_URI[x86_64_v2_rust-secret-service+crypto-rust-devel.sha256sum] = "a6446b1aa543548f1ec6361a5f70c2c973c4fe2cbc14b0c783367dee3891bce5"

URI_x86_64_v2_rust-secret-service+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+default-devel-5.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+default-devel}"
SRC_URI[x86_64_v2_rust-secret-service+default-devel.sha256sum] = "6eda2101decd7b7878819badb508833a3aefd84fa5ef99f15af199a228f17a08"

URI_x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-async-io-crypto-openssl-devel-5.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-secret-service+rt-async-io-crypto-openssl-devel.sha256sum] = "6fe6ffeee900212ae02ef1af729d18f60ff354838bcd1797b4c85aca658c3084"

URI_x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-async-io-crypto-rust-devel-5.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel}"
SRC_URI[x86_64_v2_rust-secret-service+rt-async-io-crypto-rust-devel.sha256sum] = "81023a3a33e0b53735edc94e5588c19f1a14c106d6a7559b9da6d06b7da3d007"

URI_x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-tokio-crypto-openssl-devel-5.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-secret-service+rt-tokio-crypto-openssl-devel.sha256sum] = "aa9834fd60e9b20555c3db89b6cbee626414356b230c3e7807e3c077ef14441c"

URI_x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service+rt-tokio-crypto-rust-devel-5.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel}"
SRC_URI[x86_64_v2_rust-secret-service+rt-tokio-crypto-rust-devel.sha256sum] = "312d01829227407a9557c4c80ba1c42eaee47b762d7510c34c0514f8fa730581"

URI_x86_64_v2_rust-secret-service-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-secret-service-devel-5.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-secret-service-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-secret-service-devel}"
SRC_URI[x86_64_v2_rust-secret-service-devel.sha256sum] = "71725fcdb911b1e91616606921a1aed0314da0f618cbe21dec97c054447db787"

URI_aarch64_rust-secret-service+crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+crypto-openssl-devel-5.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-secret-service+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+crypto-openssl-devel}"
SRC_URI[aarch64_rust-secret-service+crypto-openssl-devel.sha256sum] = "96e34d5e35ca53ef426519c3f445290f19e291d85ad5b886691a4d499c4dac8d"

URI_aarch64_rust-secret-service+crypto-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+crypto-rust-devel-5.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-secret-service+crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+crypto-rust-devel}"
SRC_URI[aarch64_rust-secret-service+crypto-rust-devel.sha256sum] = "b6ce4f774254c8d92f60453cadddf613979d2b0acb7a7b047df269e6d5d6c894"

URI_aarch64_rust-secret-service+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+default-devel-5.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-secret-service+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+default-devel}"
SRC_URI[aarch64_rust-secret-service+default-devel.sha256sum] = "0178f5dbb5bac09d937520691f812e0c95ce3462beafc7788689248cb44bdfe7"

URI_aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-async-io-crypto-openssl-devel-5.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel}"
SRC_URI[aarch64_rust-secret-service+rt-async-io-crypto-openssl-devel.sha256sum] = "bab9c46d6c6d6540a9243a9e9d4b1915d83bf245b93330a5d25d96ab68167e54"

URI_aarch64_rust-secret-service+rt-async-io-crypto-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-async-io-crypto-rust-devel-5.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-secret-service+rt-async-io-crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+rt-async-io-crypto-rust-devel}"
SRC_URI[aarch64_rust-secret-service+rt-async-io-crypto-rust-devel.sha256sum] = "80e957b4bcf98ffbd78cc94ab050f020738556fe93a639d7244c01936c545f4c"

URI_aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-tokio-crypto-openssl-devel-5.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel}"
SRC_URI[aarch64_rust-secret-service+rt-tokio-crypto-openssl-devel.sha256sum] = "4ebc7f92db4d053449f17f6efd3383e69cf272600fe804e28e64528cf17fb3f8"

URI_aarch64_rust-secret-service+rt-tokio-crypto-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service+rt-tokio-crypto-rust-devel-5.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-secret-service+rt-tokio-crypto-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service+rt-tokio-crypto-rust-devel}"
SRC_URI[aarch64_rust-secret-service+rt-tokio-crypto-rust-devel.sha256sum] = "ebdd2388a281c294950b872ded8f0564ab77da904fca757d1cd5293cbbe33962"

URI_aarch64_rust-secret-service-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-secret-service-devel-5.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-secret-service-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-secret-service-devel}"
SRC_URI[aarch64_rust-secret-service-devel.sha256sum] = "2e4a86e771c7f0b6b042b398e16462994c163f1b6502c5fbd1a02683bd99454f"

RDEPENDS:rust-secret-service+crypto-openssl-devel = " \
 cargo \
 rust-openssl+default-devel \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+crypto-rust-devel = " \
 cargo \
 rust-aes+default-devel \
 rust-cbc+alloc-devel \
 rust-cbc+block-padding-devel \
 rust-cbc+default-devel \
 rust-hkdf+default-devel \
 rust-secret-service-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-secret-service+default-devel = " \
 cargo \
 rust-secret-service-devel \
 "
RDEPENDS:rust-secret-service+rt-async-io-crypto-openssl-devel = " \
 cargo \
 rust-secret-service+crypto-openssl-devel \
 rust-secret-service-devel \
 rust-zbus+async-io-devel \
 "
RDEPENDS:rust-secret-service+rt-async-io-crypto-rust-devel = " \
 cargo \
 rust-secret-service+crypto-rust-devel \
 rust-secret-service-devel \
 rust-zbus+async-io-devel \
 "
RDEPENDS:rust-secret-service+rt-tokio-crypto-openssl-devel = " \
 cargo \
 rust-secret-service+crypto-openssl-devel \
 rust-secret-service-devel \
 rust-zbus+tokio-devel \
 "
RDEPENDS:rust-secret-service+rt-tokio-crypto-rust-devel = " \
 cargo \
 rust-secret-service+crypto-rust-devel \
 rust-secret-service-devel \
 rust-zbus+tokio-devel \
 "
RDEPENDS:rust-secret-service-devel = " \
 cargo \
 rust \
 rust-futures-util+default-devel \
 rust-generic-array+default-devel \
 rust-getrandom0.2+default-devel \
 rust-num+default-devel \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-zbus+blocking-api-devel \
 rust-zbus-devel \
 "
