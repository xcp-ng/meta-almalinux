# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typed-arena"
PV = "2.0.2"
PR = "7.el10_1"
PACKAGES = " \
 rust-typed-arena+default-devel \
 rust-typed-arena+std-devel \
 rust-typed-arena-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typed-arena-2.0.2-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8aed0fe3b957bcca283eb09a9871e936f897da9ee0fac0a0452d4bdd2c732d7"

URI_x86_64_v2_rust-typed-arena+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-arena+default-devel-2.0.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-arena+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-arena+default-devel}"
SRC_URI[x86_64_v2_rust-typed-arena+default-devel.sha256sum] = "3fd076ce2acae64af8fe365e3917e186413f12eeaa7bb1e73367a7d2f053894c"

URI_x86_64_v2_rust-typed-arena+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-arena+std-devel-2.0.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-arena+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-arena+std-devel}"
SRC_URI[x86_64_v2_rust-typed-arena+std-devel.sha256sum] = "df17617ad78caa4e8671c9ee86209e8d17d2595a4fbb340f4492e07563cb7b22"

URI_x86_64_v2_rust-typed-arena-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typed-arena-devel-2.0.2-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typed-arena-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typed-arena-devel}"
SRC_URI[x86_64_v2_rust-typed-arena-devel.sha256sum] = "156d537f9a5501a551153701a32f066c2e9aff905e38925435e7d16894a5ae2c"

URI_aarch64_rust-typed-arena+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-arena+default-devel-2.0.2-7.el10_1.noarch.rpm;name=aarch64_rust-typed-arena+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-arena+default-devel}"
SRC_URI[aarch64_rust-typed-arena+default-devel.sha256sum] = "31ed9a9190c85be9ba8338f7d4cc6afddf9edbe099d5a7016fa02a4bb9d533f0"

URI_aarch64_rust-typed-arena+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-arena+std-devel-2.0.2-7.el10_1.noarch.rpm;name=aarch64_rust-typed-arena+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-arena+std-devel}"
SRC_URI[aarch64_rust-typed-arena+std-devel.sha256sum] = "cc7e8231ff66f0a900fb99d56255ade95d85b9fdc0b042110b540fe355c09e01"

URI_aarch64_rust-typed-arena-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typed-arena-devel-2.0.2-7.el10_1.noarch.rpm;name=aarch64_rust-typed-arena-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typed-arena-devel}"
SRC_URI[aarch64_rust-typed-arena-devel.sha256sum] = "ac13466914a69201df2b529a3abed569f4a23566861c30bd40ef6bccdbba9fcc"

RDEPENDS:rust-typed-arena+default-devel = " \
 cargo \
 rust-typed-arena+std-devel \
 rust-typed-arena-devel \
 "
RDEPENDS:rust-typed-arena+std-devel = " \
 cargo \
 rust-typed-arena-devel \
 "
RDEPENDS:rust-typed-arena-devel = " \
 cargo \
 "
