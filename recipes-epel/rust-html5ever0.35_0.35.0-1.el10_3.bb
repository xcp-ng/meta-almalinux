# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html5ever0.35"
PV = "0.35.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-html5ever0.35+default-devel \
 rust-html5ever0.35+trace_tokenizer-devel \
 rust-html5ever0.35-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html5ever0.35-0.35.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a93c3c659e3129a6314494da45f41a3f52be1341fe66b356bbbde3f6df3756fd"

URI_x86_64_v2_rust-html5ever0.35+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever0.35+default-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever0.35+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever0.35+default-devel}"
SRC_URI[x86_64_v2_rust-html5ever0.35+default-devel.sha256sum] = "79151b3da38b48a598ac19d36b6d88efd4c6de753c15223ca752a4d36cb1d6e8"

URI_x86_64_v2_rust-html5ever0.35+trace_tokenizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever0.35+trace_tokenizer-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever0.35+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever0.35+trace_tokenizer-devel}"
SRC_URI[x86_64_v2_rust-html5ever0.35+trace_tokenizer-devel.sha256sum] = "364c9e7f0fb4dec9652d40f27faf1f26da194ea3198512bed7303ae5ef2cd9f2"

URI_x86_64_v2_rust-html5ever0.35-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever0.35-devel-0.35.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever0.35-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever0.35-devel}"
SRC_URI[x86_64_v2_rust-html5ever0.35-devel.sha256sum] = "f121c123d58369204a6299f0f7c499dcd384b057437fab1ab6e6f51f4c1fb751"

URI_aarch64_rust-html5ever0.35+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever0.35+default-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-html5ever0.35+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever0.35+default-devel}"
SRC_URI[aarch64_rust-html5ever0.35+default-devel.sha256sum] = "6f5479eea8962c12fdf99eab0d304235d13681e5da9e90ef15e324cc57bf59f0"

URI_aarch64_rust-html5ever0.35+trace_tokenizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever0.35+trace_tokenizer-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-html5ever0.35+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever0.35+trace_tokenizer-devel}"
SRC_URI[aarch64_rust-html5ever0.35+trace_tokenizer-devel.sha256sum] = "a2adfb0b0c4bde2e0e70c2f79e92a87b9f05d7cc1270583a3c018782ed254b93"

URI_aarch64_rust-html5ever0.35-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever0.35-devel-0.35.0-1.el10_3.noarch.rpm;name=aarch64_rust-html5ever0.35-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever0.35-devel}"
SRC_URI[aarch64_rust-html5ever0.35-devel.sha256sum] = "9d0ecab2fe1f9ac707d8782ebd45ac083c6e016f4e47e4494b99f6966837662d"

RDEPENDS:rust-html5ever0.35+default-devel = " \
 cargo \
 rust-html5ever0.35-devel \
 "
RDEPENDS:rust-html5ever0.35+trace_tokenizer-devel = " \
 cargo \
 rust-html5ever0.35-devel \
 "
RDEPENDS:rust-html5ever0.35-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-markup5ever0.35+default-devel \
 rust-match_token+default-devel \
 "
