# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ldns"
PV = "1.8.3"
PR = "19.el10"
PACKAGES = " \
 ldns \
 ldns-devel \
 ldns-doc \
 ldns-utils \
 perl-ldns \
 python3-ldns \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ldns-1.8.3-19.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8627b8733791ac48276a49f90672cdb8e125efe4443b8d41207e48de27fd6e94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ldns-1.8.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_ldns;unpack=0"
SRC_URI[x86_64_v2_ldns.sha256sum] = "948654f5743396e6d044f6263e49f679d8310b7e72b969979cf4824e2f311d97"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ldns-devel-1.8.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_ldns-devel;unpack=0"
SRC_URI[x86_64_v2_ldns-devel.sha256sum] = "59bc637c26bf5ec14b025fda0c1cdc7d4d759af30ae76144bec64dcd8c9cd168"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ldns-doc-1.8.3-19.el10.noarch.rpm;name=x86_64_v2_ldns-doc;unpack=0"
SRC_URI[x86_64_v2_ldns-doc.sha256sum] = "3ed589cbb9bedc745f572a3b4c05f2b231ef056445f71289aa79101ffe5eb240"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ldns-utils-1.8.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_ldns-utils;unpack=0"
SRC_URI[x86_64_v2_ldns-utils.sha256sum] = "cd27a72e7438ebd83d1e1b1577cfeaf76b0963b6e2390600d70edd47baa9411f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-ldns-1.8.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_perl-ldns;unpack=0"
SRC_URI[x86_64_v2_perl-ldns.sha256sum] = "5436749dceaf57ba1684670b092cc853f3e157c17ccef85117886e1fab79a46f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-ldns-1.8.3-19.el10.x86_64_v2.rpm;name=x86_64_v2_python3-ldns;unpack=0"
SRC_URI[x86_64_v2_python3-ldns.sha256sum] = "9bf2eafcf62c900f42b03f9b9e13915fc5e358cc402f3009990564ec63319d5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ldns-1.8.3-19.el10.aarch64.rpm;name=aarch64_ldns;unpack=0"
SRC_URI[aarch64_ldns.sha256sum] = "99caf501e5ec8777b61b662c9f7c579faee0bb0979f79e74b63ceb44c9745c78"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ldns-devel-1.8.3-19.el10.aarch64.rpm;name=aarch64_ldns-devel;unpack=0"
SRC_URI[aarch64_ldns-devel.sha256sum] = "62f667497ee88f2b6bcd3c425bdb096a5f75dce0cf998d3d01a0d8759488346c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ldns-doc-1.8.3-19.el10.noarch.rpm;name=aarch64_ldns-doc;unpack=0"
SRC_URI[aarch64_ldns-doc.sha256sum] = "3ed589cbb9bedc745f572a3b4c05f2b231ef056445f71289aa79101ffe5eb240"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ldns-utils-1.8.3-19.el10.aarch64.rpm;name=aarch64_ldns-utils;unpack=0"
SRC_URI[aarch64_ldns-utils.sha256sum] = "bbd5e8a6c2d6c02168fc37108ef7b8d17350e325cc28e0338ef9bb31105a340f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-ldns-1.8.3-19.el10.aarch64.rpm;name=aarch64_perl-ldns;unpack=0"
SRC_URI[aarch64_perl-ldns.sha256sum] = "676b3456494a5992837e0f87f3add9bdff4b4161cac8974d4e3136260df6432f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-ldns-1.8.3-19.el10.aarch64.rpm;name=aarch64_python3-ldns;unpack=0"
SRC_URI[aarch64_python3-ldns.sha256sum] = "b95394ea6d0ed808258573dacde8536bd3cc9fe45279e941976bf4b0530f1771"

RDEPENDS:ldns = " \
 ca-certificates \
 glibc \
 openssl-libs \
 "
RDEPENDS:ldns-devel = " \
 bash \
 ldns \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:ldns-doc = " \
 "
RDEPENDS:ldns-utils = " \
 glibc \
 ldns \
 libpcap \
 openssl-libs \
 "
RDEPENDS:perl-ldns = " \
 glibc \
 ldns \
 perl-AutoLoader \
 perl-Carp \
 perl-Exporter \
 perl-ldns \
 perl-libs \
 "
RDEPENDS:python3-ldns = " \
 glibc \
 ldns \
 openssl-libs \
 python3 \
 python3-libs \
 "
