# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "converseen"
PV = "0.15.2.7"
PR = "2.el10_3"
PACKAGES = " \
 converseen \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/converseen-0.15.2.7-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab83e4dd2969087472fe225f98eac490c197a63211d6724ea4f809b509ee6002"

URI_x86_64_v2_converseen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/converseen-0.15.2.7-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_converseen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_converseen}"
SRC_URI[x86_64_v2_converseen.sha256sum] = "d3249fdfbf40b92a600d619d2635319cd0dbc96b7c62bd068b8fce79bd0d70da"

URI_aarch64_converseen = "${EPEL_MIRROR}/aarch64/Packages/c/converseen-0.15.2.7-2.el10_3.aarch64.rpm;name=aarch64_converseen;unpack=0"
SRC_URI:append = " ${URI_aarch64_converseen}"
SRC_URI[aarch64_converseen.sha256sum] = "619fa77b410b28c9bb74b8f2ca0d4169b5cdffb0afbe3386f4b9f7102d4cb9cf"

RDEPENDS:converseen = " \
 ImageMagick-c++ \
 ImageMagick-libs \
 glibc \
 hicolor-icon-theme \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
