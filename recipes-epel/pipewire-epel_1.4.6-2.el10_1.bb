# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pipewire-epel"
PV = "1.4.6"
PR = "2.el10_1"
PACKAGES = " \
 pipewire-module-filter-chain-lv2 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pipewire-epel-1.4.6-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c78dc1fff67c7ef1a09b5a80e5338339788bde15ea0e4e033de3f02f7e7a3282"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pipewire-module-filter-chain-lv2-1.4.6-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI[x86_64_v2_pipewire-module-filter-chain-lv2.sha256sum] = "e601de4ad511603b849654c43980749cdccde50a2b8ad5126f6c2ba4f0079fb1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pipewire-module-filter-chain-lv2-1.4.6-2.el10_1.aarch64.rpm;name=aarch64_pipewire-module-filter-chain-lv2;unpack=0"
SRC_URI[aarch64_pipewire-module-filter-chain-lv2.sha256sum] = "9d45136176eb1bd74f2c3a035bbaf332cd1b6b9d1074399cfefed2f3c50cb54c"

RDEPENDS:pipewire-module-filter-chain-lv2 = " \
 glibc \
 lilv-libs \
 pipewire-libs \
 "
