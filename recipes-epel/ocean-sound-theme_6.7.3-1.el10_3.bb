# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ocean-sound-theme"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 ocean-sound-theme \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/ocean-sound-theme-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5e8215711d280aabf226f975fd1483b05f2a7a2936348915d6a27a9d8f9c396"

URI_x86_64_v2_ocean-sound-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ocean-sound-theme-6.7.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_ocean-sound-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocean-sound-theme}"
SRC_URI[x86_64_v2_ocean-sound-theme.sha256sum] = "5eebf04c5250b95c63d8364fb74dd72c8456aea46fd8ddc9863a68b020e5dcd7"

URI_aarch64_ocean-sound-theme = "${EPEL_MIRROR}/aarch64/Packages/o/ocean-sound-theme-6.7.3-1.el10_3.noarch.rpm;name=aarch64_ocean-sound-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocean-sound-theme}"
SRC_URI[aarch64_ocean-sound-theme.sha256sum] = "10ac388785c408fd794bbe11dab3edc7160d27c168ce3918cd5f4bbbafafc08a"

RDEPENDS:ocean-sound-theme = " \
 kf6-filesystem \
 "
