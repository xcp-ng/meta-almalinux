# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rayon"
PV = "1.11.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rayon+default-devel \
 rust-rayon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rayon-1.11.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6cd8ef4b6fb798392e68e8cb7923744510a219411af0e853838ad185d83eb69c"

URI_x86_64_v2_rust-rayon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon+default-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon+default-devel}"
SRC_URI[x86_64_v2_rust-rayon+default-devel.sha256sum] = "96e46552988cc8ee0712233bca5bb8365691591a0a98873f9c5559c751c07c04"

URI_x86_64_v2_rust-rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon-devel-1.11.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon-devel}"
SRC_URI[x86_64_v2_rust-rayon-devel.sha256sum] = "e3c63ab5bd56a2f34046a5ecc20f862c3525d5455702966f91802436ac5038f5"

URI_aarch64_rust-rayon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon+default-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rayon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon+default-devel}"
SRC_URI[aarch64_rust-rayon+default-devel.sha256sum] = "22e61631bec979b20338918e1237257b1fb324bd55ccdbb86a37fbe12284afc6"

URI_aarch64_rust-rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon-devel-1.11.0-1.el10_1.noarch.rpm;name=aarch64_rust-rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon-devel}"
SRC_URI[aarch64_rust-rayon-devel.sha256sum] = "570724b323bd0ba9ddb5ca11c70a9b2e2cd3d8546df64e982fa947d19ecce03b"

RDEPENDS:rust-rayon+default-devel = " \
 cargo \
 rust-rayon-devel \
 "
RDEPENDS:rust-rayon-devel = " \
 cargo \
 rust \
 rust-either-devel \
 rust-rayon-core+default-devel \
 "
