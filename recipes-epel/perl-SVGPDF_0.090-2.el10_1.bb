# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SVGPDF"
PV = "0.090"
PR = "2.el10_1"
PACKAGES = " \
 perl-SVGPDF \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-SVGPDF-0.090-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bb1406dac72874c0b1731597bf2e1f213899bd1be4af253671452737985e615d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SVGPDF-0.090-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SVGPDF;unpack=0"
SRC_URI[x86_64_v2_perl-SVGPDF.sha256sum] = "969e49263bbed0866bfb3b7dcfa49561fe78ba5641e2d232d340f66ac59fc1df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-SVGPDF-0.090-2.el10_1.noarch.rpm;name=aarch64_perl-SVGPDF;unpack=0"
SRC_URI[aarch64_perl-SVGPDF.sha256sum] = "84b771dc65e844a154243ce6cd06eec0c5f3c893ab9a6a95dea5721f47b0b006"

RDEPENDS:perl-SVGPDF = " \
 perl-Carp \
 perl-Exporter \
 perl-File-LoadLines \
 perl-File-Temp \
 perl-MIME-Base64 \
 perl-Math-Complex \
 perl-Object-Pad \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Text-ParseWords \
 perl-libs \
 "
