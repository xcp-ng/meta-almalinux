# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm"
PV = "4.19.1.1"
PR = "12.el10.alma.1"
PACKAGES = " \
 python3-rpm \
 rpm \
 rpm-apidocs \
 rpm-build \
 rpm-build-libs \
 rpm-cron \
 rpm-devel \
 rpm-libs \
 rpm-plugin-audit \
 rpm-plugin-fapolicyd \
 rpm-plugin-ima \
 rpm-plugin-selinux \
 rpm-plugin-syslog \
 rpm-plugin-systemd-inhibit \
 rpm-sign \
 rpm-sign-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rpm-4.19.1.1-12.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b134c69223b95c73be8ecb5501fb13cf360e5599fb29011053f1bf6d71fadae8"

URI_x86_64_v2_python3-rpm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-rpm-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpm}"
SRC_URI[x86_64_v2_python3-rpm.sha256sum] = "d97cd39037ed805780be77a8891181357afd4021c4cc63c30dc3b5e2e04b134c"

URI_x86_64_v2_rpm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm}"
SRC_URI[x86_64_v2_rpm.sha256sum] = "aa29f473abc55deb4c0bb500dd4c5c2c8a85c12d52a8a56449da5f862d14514c"

URI_x86_64_v2_rpm-apidocs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-apidocs-4.19.1.1-12.el10.alma.1.noarch.rpm;name=x86_64_v2_rpm-apidocs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-apidocs}"
SRC_URI[x86_64_v2_rpm-apidocs.sha256sum] = "eb45c998d532ef6bddeb40760613f14b5d872858b1b4d125e676144af3f878a8"

URI_x86_64_v2_rpm-build = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-build-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-build;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-build}"
SRC_URI[x86_64_v2_rpm-build.sha256sum] = "2730b293a82441f5255f45b46e69c7632abba5bbdfb4205d8032e85da15bd5d7"

URI_x86_64_v2_rpm-build-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-build-libs-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-build-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-build-libs}"
SRC_URI[x86_64_v2_rpm-build-libs.sha256sum] = "8dfbe5174c3d31e380c1c17168f1b130a3d7b6238bf43d83c3a9dc1cc211ae0f"

URI_x86_64_v2_rpm-cron = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-cron-4.19.1.1-12.el10.alma.1.noarch.rpm;name=x86_64_v2_rpm-cron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-cron}"
SRC_URI[x86_64_v2_rpm-cron.sha256sum] = "a8754978a4eacb3c99574481f63fc318fbc61d84cfc64ee72dd7ac49e1951b6d"

URI_x86_64_v2_rpm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-devel-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-devel}"
SRC_URI[x86_64_v2_rpm-devel.sha256sum] = "a0aea9cc198fb629efbc6fa95167368f5f3b39e4a944498650a9cf8062e47716"

URI_x86_64_v2_rpm-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-libs-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-libs}"
SRC_URI[x86_64_v2_rpm-libs.sha256sum] = "47352996dd1ea501c695f855892ff23a7fa3e1dfcf9aa4258f916ba4e69cdb19"

URI_x86_64_v2_rpm-plugin-audit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-plugin-audit-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-audit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-audit}"
SRC_URI[x86_64_v2_rpm-plugin-audit.sha256sum] = "ac737963c3a06737cfac9f67e97e86f8c78d3ea1c844c204812ddf47af2bc802"

URI_x86_64_v2_rpm-plugin-fapolicyd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-fapolicyd-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-fapolicyd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-fapolicyd}"
SRC_URI[x86_64_v2_rpm-plugin-fapolicyd.sha256sum] = "93529ee66ac05e59d32230b41563773b33295208c3aea8de0b1eceef5df64edd"

URI_x86_64_v2_rpm-plugin-ima = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-ima-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-ima;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-ima}"
SRC_URI[x86_64_v2_rpm-plugin-ima.sha256sum] = "7066151abe94938b354d4285bbd256ed23dc11ecd96fa4b5f7746566090781db"

URI_x86_64_v2_rpm-plugin-selinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-plugin-selinux-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-selinux}"
SRC_URI[x86_64_v2_rpm-plugin-selinux.sha256sum] = "a9d59bb4fe5eeec649bc88b91e4e1d154fdfab69ce9867276e7a226f6e55b1e5"

URI_x86_64_v2_rpm-plugin-syslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-syslog-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-syslog}"
SRC_URI[x86_64_v2_rpm-plugin-syslog.sha256sum] = "e4f2cbe9961c29bb8fda9e804c2390c44f2568650f685a373706d984de13d6c9"

URI_x86_64_v2_rpm-plugin-systemd-inhibit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-plugin-systemd-inhibit-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-plugin-systemd-inhibit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-plugin-systemd-inhibit}"
SRC_URI[x86_64_v2_rpm-plugin-systemd-inhibit.sha256sum] = "9443641f6d556db92c0e99cba11470711e36eb0aa841e7f81035df93c349908b"

URI_x86_64_v2_rpm-sign = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sign-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-sign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sign}"
SRC_URI[x86_64_v2_rpm-sign.sha256sum] = "b4979ef95901d0737703badea48f15d60430a1210a7783d61b0d248cd19b6597"

URI_x86_64_v2_rpm-sign-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sign-libs-4.19.1.1-12.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_rpm-sign-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sign-libs}"
SRC_URI[x86_64_v2_rpm-sign-libs.sha256sum] = "7d1eabe7ae2d2118f952584b5b03163bbd2e693a411a49f8c83d1596b802be9f"

URI_aarch64_python3-rpm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-rpm-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_python3-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpm}"
SRC_URI[aarch64_python3-rpm.sha256sum] = "1e8de2ea29b87f2eb0af0e118873b2f9c919cfb754dac3fa9f3c8e1f35210d92"

URI_aarch64_rpm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm}"
SRC_URI[aarch64_rpm.sha256sum] = "2765499d8e54f70aff53c0b5617438df453110542379d65ca9e4aa05e5f278e8"

URI_aarch64_rpm-apidocs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-apidocs-4.19.1.1-12.el10.alma.1.noarch.rpm;name=aarch64_rpm-apidocs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-apidocs}"
SRC_URI[aarch64_rpm-apidocs.sha256sum] = "eb45c998d532ef6bddeb40760613f14b5d872858b1b4d125e676144af3f878a8"

URI_aarch64_rpm-build = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-build-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-build;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-build}"
SRC_URI[aarch64_rpm-build.sha256sum] = "4cfa7a9607334616d45b07e7319f00fcf209953b816abe583cdf55754ae602d0"

URI_aarch64_rpm-build-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-build-libs-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-build-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-build-libs}"
SRC_URI[aarch64_rpm-build-libs.sha256sum] = "332e7520d49b6fa8a78cd95d141851bfd6eba46ad9cd88552db9d4697e7465c2"

URI_aarch64_rpm-cron = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-cron-4.19.1.1-12.el10.alma.1.noarch.rpm;name=aarch64_rpm-cron;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-cron}"
SRC_URI[aarch64_rpm-cron.sha256sum] = "a8754978a4eacb3c99574481f63fc318fbc61d84cfc64ee72dd7ac49e1951b6d"

URI_aarch64_rpm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-devel-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-devel}"
SRC_URI[aarch64_rpm-devel.sha256sum] = "45c68fb98a9b84597eeaf8941d5346c3ccdc346f4d16192151ea889bbda1919e"

URI_aarch64_rpm-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-libs-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-libs}"
SRC_URI[aarch64_rpm-libs.sha256sum] = "205b4fdff4576f423cef44123586280ee64ef8c1c2667f19823078b5af2a4ed7"

URI_aarch64_rpm-plugin-audit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-plugin-audit-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-audit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-audit}"
SRC_URI[aarch64_rpm-plugin-audit.sha256sum] = "ea6615d5f138cf5ca681bc0c2ee914898d121d4fe8a967eace1523ff5ce6a079"

URI_aarch64_rpm-plugin-fapolicyd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-fapolicyd-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-fapolicyd;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-fapolicyd}"
SRC_URI[aarch64_rpm-plugin-fapolicyd.sha256sum] = "88f413ece77f2ff240f4e515c22d3595e4a73e78c29de5171d49175a4e99abc6"

URI_aarch64_rpm-plugin-ima = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-ima-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-ima;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-ima}"
SRC_URI[aarch64_rpm-plugin-ima.sha256sum] = "52e4bf18d8ba9a2d4c1f140b070fc24ee57a3c1f9793f00c40cfc268fdbe54ee"

URI_aarch64_rpm-plugin-selinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-plugin-selinux-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-selinux}"
SRC_URI[aarch64_rpm-plugin-selinux.sha256sum] = "7b9130a61a05e13ad1b7f9af68e386cb5627ed8d651a65390cfd3aad968e13ec"

URI_aarch64_rpm-plugin-syslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-syslog-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-syslog}"
SRC_URI[aarch64_rpm-plugin-syslog.sha256sum] = "3789e21d14cddaddcb37fae5717dfce372ca4dda5999dabd080de8b9af6c4abc"

URI_aarch64_rpm-plugin-systemd-inhibit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-plugin-systemd-inhibit-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-plugin-systemd-inhibit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-plugin-systemd-inhibit}"
SRC_URI[aarch64_rpm-plugin-systemd-inhibit.sha256sum] = "0c3f88cce3bbbbc163a8c9b4c1f61d369aaf30e761414f63c45d7fb7ed079cc7"

URI_aarch64_rpm-sign = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sign-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-sign;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sign}"
SRC_URI[aarch64_rpm-sign.sha256sum] = "b4a95b4a6810c0ac8b00e6f7147bcb9bf35c52c22634a89bca8c096b1ab7d404"

URI_aarch64_rpm-sign-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sign-libs-4.19.1.1-12.el10.alma.1.aarch64.rpm;name=aarch64_rpm-sign-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sign-libs}"
SRC_URI[aarch64_rpm-sign-libs.sha256sum] = "0ca21ef4e589ad3cd2bde719ec21ef2fbd19aa0bd3a34f4779abeed0d7269625"

RDEPENDS:python3-rpm = " \
 glibc \
 python3 \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm = " \
 bash \
 curl \
 findutils \
 glibc \
 libarchive \
 popt \
 rpm-libs \
 sed \
 virtual/coreutils \
 "
RDEPENDS:rpm-apidocs = " \
 "
RDEPENDS:rpm-build = " \
 bash \
 binutils \
 bzip2 \
 cpio \
 debugedit \
 diffutils \
 elfutils \
 elfutils-libelf \
 file \
 findutils \
 gawk \
 glibc \
 grep \
 gzip \
 patch \
 pkgconf-pkg-config \
 popt \
 readline \
 redhat-rpm-config \
 rpm \
 rpm-build-libs \
 rpm-libs \
 sed \
 tar \
 unzip \
 virtual//usr/bin/gdb-add-index \
 xz \
 zstd \
 "
RDEPENDS:rpm-build-libs = " \
 elfutils-libelf \
 elfutils-libs \
 file-libs \
 glibc \
 libcap \
 libgcc \
 libgomp \
 lua-libs \
 popt \
 rpm-libs \
 "
RDEPENDS:rpm-cron = " \
 bash \
 crontabs \
 logrotate \
 rpm \
 "
RDEPENDS:rpm-devel = " \
 cmake-filesystem \
 glibc \
 pkgconf-pkg-config \
 popt \
 popt-devel \
 rpm \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm-libs = " \
 bzip2-libs \
 glibc \
 libacl \
 libcap \
 libzstd \
 lua-libs \
 popt \
 rpm \
 rpm-sequoia \
 sqlite-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:rpm-plugin-audit = " \
 audit-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-fapolicyd = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-ima = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-selinux = " \
 glibc \
 libselinux \
 rpm-libs \
 selinux-policy \
 "
RDEPENDS:rpm-plugin-syslog = " \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-plugin-systemd-inhibit = " \
 dbus-libs \
 glibc \
 rpm-libs \
 "
RDEPENDS:rpm-sign = " \
 glibc \
 popt \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:rpm-sign-libs = " \
 glibc \
 ima-evm-utils \
 popt \
 rpm-libs \
 "
