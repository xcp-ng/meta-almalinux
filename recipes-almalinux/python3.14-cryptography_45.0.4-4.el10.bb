# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-cryptography"
PV = "45.0.4"
PR = "4.el10"
PACKAGES = " \
 python3.14-cryptography \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-cryptography-45.0.4-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e53a3c2294d52254d1fd305b0a86a5714a42b3ed189b48b5faf35afd506f39b"

URI_x86_64_v2_python3.14-cryptography = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-cryptography-45.0.4-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-cryptography;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-cryptography}"
SRC_URI[x86_64_v2_python3.14-cryptography.sha256sum] = "9d2bf17268a3e9726a1625aca8009cca3ba598296218f09885541952494c46bb"

URI_aarch64_python3.14-cryptography = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-cryptography-45.0.4-4.el10.aarch64.rpm;name=aarch64_python3.14-cryptography;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-cryptography}"
SRC_URI[aarch64_python3.14-cryptography.sha256sum] = "b263b400e9bc132c49f09a3a3c56105c16e5ec1ec9cb75e42d759a54c5876eeb"

RDEPENDS:python3.14-cryptography = " \
 glibc \
 libgcc \
 openssl-libs \
 python3.14 \
 python3.14-cffi \
 "
