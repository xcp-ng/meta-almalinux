# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-frameworkintegration"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-frameworkintegration \
 kf6-frameworkintegration-devel \
 kf6-frameworkintegration-doc \
 kf6-frameworkintegration-html \
 kf6-frameworkintegration-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-frameworkintegration-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5145a6884fd2b51c1b7b815ce3fab45bb82adee4801175ce97edde95acb60957"

URI_x86_64_v2_kf6-frameworkintegration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration}"
SRC_URI[x86_64_v2_kf6-frameworkintegration.sha256sum] = "a010061ba580723f7a36a28ba59e79ed3b73448ddad8a2261cb4ade62ff96c87"

URI_x86_64_v2_kf6-frameworkintegration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-devel}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-devel.sha256sum] = "2ab0acaa23e6d4abd222fd56e5c2e8aed93ce24ae76340e06d421ea33619d68f"

URI_x86_64_v2_kf6-frameworkintegration-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-frameworkintegration-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-doc}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-doc.sha256sum] = "6c7e9581404dd41e4e27f38c327b867e9f8dfc24c47e18aeaa6f65b8b22845f9"

URI_x86_64_v2_kf6-frameworkintegration-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-frameworkintegration-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-html}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-html.sha256sum] = "ec85d173cba8f72ccfe66e84a046c31f299a6ec553adbdf792839d2f468e15b8"

URI_x86_64_v2_kf6-frameworkintegration-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-frameworkintegration-libs-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-frameworkintegration-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-frameworkintegration-libs}"
SRC_URI[x86_64_v2_kf6-frameworkintegration-libs.sha256sum] = "8fd919f707dc10477277872777b7813efc712f447dd50e518c6f1a540bc7ccb7"

URI_aarch64_kf6-frameworkintegration = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-frameworkintegration;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration}"
SRC_URI[aarch64_kf6-frameworkintegration.sha256sum] = "f569b0c5b162095a30b7d098177f0287f340f8153d819b738cbbd0d4086a754a"

URI_aarch64_kf6-frameworkintegration-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-frameworkintegration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-devel}"
SRC_URI[aarch64_kf6-frameworkintegration-devel.sha256sum] = "93f7fe628d134c9da950a3447374506f1315c93d4a7cde736e2083f850a104c1"

URI_aarch64_kf6-frameworkintegration-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-frameworkintegration-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-doc}"
SRC_URI[aarch64_kf6-frameworkintegration-doc.sha256sum] = "fb06368097f5ac14925f301db4b0c1db006922671ed8b358c7cff480257211bd"

URI_aarch64_kf6-frameworkintegration-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-frameworkintegration-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-html}"
SRC_URI[aarch64_kf6-frameworkintegration-html.sha256sum] = "c12b81a1db9a192e93c57b4a34dbc99101f3ecf7fb7e770cf8e9c5ff27ef74b6"

URI_aarch64_kf6-frameworkintegration-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-frameworkintegration-libs-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-frameworkintegration-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-frameworkintegration-libs}"
SRC_URI[aarch64_kf6-frameworkintegration-libs.sha256sum] = "5742a93101db0e90854b9f8cb067bb7a0c4346c32d6850a305ee7826b5829fe8"

RDEPENDS:kf6-frameworkintegration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-knotifications \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-frameworkintegration-devel = " \
 cmake-filesystem \
 kf6-frameworkintegration-libs \
 kf6-kconfigwidgets-devel \
 kf6-kiconthemes-devel \
 "
RDEPENDS:kf6-frameworkintegration-doc = " \
 "
RDEPENDS:kf6-frameworkintegration-html = " \
 "
RDEPENDS:kf6-frameworkintegration-libs = " \
 PackageKit-Qt6 \
 appstream-qt \
 glibc \
 kf6-frameworkintegration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
