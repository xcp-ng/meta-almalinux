# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-seancfoley-bintree"
PV = "1.3.1"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-seancfoley-bintree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-seancfoley-bintree-1.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53e77496f3a7566ed188551174d5e2fc60d045428d47e2f9da8e6c510ea79299"

URI_x86_64_v2_golang-github-seancfoley-bintree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-seancfoley-bintree-devel-1.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-seancfoley-bintree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-seancfoley-bintree-devel}"
SRC_URI[x86_64_v2_golang-github-seancfoley-bintree-devel.sha256sum] = "85ea78eb910134a6b9031e4eda2c5b819faef92fb9645d7f7ec64fec707488c6"

URI_aarch64_golang-github-seancfoley-bintree-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-seancfoley-bintree-devel-1.3.1-2.el10_0.noarch.rpm;name=aarch64_golang-github-seancfoley-bintree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-seancfoley-bintree-devel}"
SRC_URI[aarch64_golang-github-seancfoley-bintree-devel.sha256sum] = "477d394c9b35181299c2a535803abfa195b1754d55538f0febcbcb6706e9617e"

RDEPENDS:golang-github-seancfoley-bintree-devel = " \
 go-filesystem \
 "
