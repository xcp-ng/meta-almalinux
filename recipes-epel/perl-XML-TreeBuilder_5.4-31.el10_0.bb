# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-TreeBuilder"
PV = "5.4"
PR = "31.el10_0"
PACKAGES = " \
 perl-XML-TreeBuilder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XML-TreeBuilder-5.4-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9b197468359f8f36b2d8253356b30a2c15af51744470f4902c90972761bcd62"

URI_x86_64_v2_perl-XML-TreeBuilder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XML-TreeBuilder-5.4-31.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-XML-TreeBuilder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-TreeBuilder}"
SRC_URI[x86_64_v2_perl-XML-TreeBuilder.sha256sum] = "0577a89610b3bc40e21b00072e6cddb02d2e8ea2a0eedef85a4b62d9dacc2f2c"

URI_aarch64_perl-XML-TreeBuilder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XML-TreeBuilder-5.4-31.el10_0.noarch.rpm;name=aarch64_perl-XML-TreeBuilder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-TreeBuilder}"
SRC_URI[aarch64_perl-XML-TreeBuilder.sha256sum] = "479f9120e842a770604a2712e7547d01f73581696e13c3d06cd052632086c6b2"

RDEPENDS:perl-XML-TreeBuilder = " \
 perl-Carp \
 perl-File-Basename \
 perl-HTML-Tagset \
 perl-HTML-Tree \
 perl-IO \
 perl-PathTools \
 perl-XML-Catalog \
 perl-XML-Parser \
 perl-XML-TreeBuilder \
 perl-libs \
 perl-vars \
 "
