# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fd-find"
PV = "10.3.0"
PR = "1.el10_1"
PACKAGES = " \
 fd-find \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fd-find-10.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcbc022070c0b6bfe28d91c90b7e98054a770fcf7996c760c66b65af7bc73dfe"

URI_x86_64_v2_fd-find = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fd-find-10.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fd-find;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fd-find}"
SRC_URI[x86_64_v2_fd-find.sha256sum] = "58a07bc95d6e1c9adda124d1cea5ab2888d0a74e69c5e10f3ee9e65789f4eb48"

URI_aarch64_fd-find = "${EPEL_MIRROR}/aarch64/Packages/f/fd-find-10.3.0-1.el10_1.aarch64.rpm;name=aarch64_fd-find;unpack=0"
SRC_URI:append = " ${URI_aarch64_fd-find}"
SRC_URI[aarch64_fd-find.sha256sum] = "8293211c1aa50acca808089b5a1463601526a541678ae9f61f65ddbe33ae8671"

RDEPENDS:fd-find = " \
 glibc \
 jemalloc \
 libgcc \
 "
