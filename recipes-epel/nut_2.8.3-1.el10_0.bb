# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nut"
PV = "2.8.3"
PR = "1.el10_0"
PACKAGES = " \
 nut \
 nut-cgi \
 nut-client \
 nut-devel \
 nut-xml \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nut-2.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e31b2428fc2f8fc37c4d79c9cd096e1c8b01def486b2aeff7fc9ccee3a50b7cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nut-2.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nut;unpack=0"
SRC_URI[x86_64_v2_nut.sha256sum] = "fc69a22e426f5d92458f5b9e73bd968393132648763550c95b8291402549492d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nut-cgi-2.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nut-cgi;unpack=0"
SRC_URI[x86_64_v2_nut-cgi.sha256sum] = "94e91a6b272c8114cca70fd94cafb6e514b0882ad73d02857142eb6ad1098d9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nut-client-2.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nut-client;unpack=0"
SRC_URI[x86_64_v2_nut-client.sha256sum] = "779510a5627b7782de3323591672f0da55df55481e951a4a110637c97f51837f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nut-devel-2.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nut-devel;unpack=0"
SRC_URI[x86_64_v2_nut-devel.sha256sum] = "a13c1104880b8670154d23f74ec17cee6e69f070eea9f76b5136fd63dbd64795"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nut-xml-2.8.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nut-xml;unpack=0"
SRC_URI[x86_64_v2_nut-xml.sha256sum] = "cf7aea8fbc843d14fc3ab13599c3520e853ca0a93651e32e64faa0cd751c2c6d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nut-2.8.3-1.el10_0.aarch64.rpm;name=aarch64_nut;unpack=0"
SRC_URI[aarch64_nut.sha256sum] = "4ea32537b8eed2077d3bd29643be421e459f1094e36b80d04b5fb8f915f59b7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nut-cgi-2.8.3-1.el10_0.aarch64.rpm;name=aarch64_nut-cgi;unpack=0"
SRC_URI[aarch64_nut-cgi.sha256sum] = "8769d42f7cdd89bc5ee4a18660582f9774cf286d6136580677d18f4f5fb37977"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nut-client-2.8.3-1.el10_0.aarch64.rpm;name=aarch64_nut-client;unpack=0"
SRC_URI[aarch64_nut-client.sha256sum] = "b6ace649112bcb7aa54a2da60538e2ab509f1e6f75795cdfdfd892f6336ec876"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nut-devel-2.8.3-1.el10_0.aarch64.rpm;name=aarch64_nut-devel;unpack=0"
SRC_URI[aarch64_nut-devel.sha256sum] = "e2638e156afc73f152b7f8c4a08798af13595bd037f96120caa6805d4e790fba"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nut-xml-2.8.3-1.el10_0.aarch64.rpm;name=aarch64_nut-xml;unpack=0"
SRC_URI[aarch64_nut-xml.sha256sum] = "048802ec659ef2bc6e98d21f49af0f094cc0c1f8c2f37321b8c947eef0e90435"

RDEPENDS:nut = " \
 bash \
 freeipmi \
 glibc \
 libgcc \
 libi2c \
 libstdc++ \
 libtool-ltdl \
 libusb1 \
 net-snmp-libs \
 nut-client \
 openssl-libs \
 setup \
 systemd \
 systemd-libs \
 virtual/coreutils \
 "
RDEPENDS:nut-cgi = " \
 gd \
 glibc \
 nut-client \
 virtual/webserver \
 "
RDEPENDS:nut-client = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 python3 \
 setup \
 systemd \
 systemd-libs \
 "
RDEPENDS:nut-devel = " \
 nut \
 nut-client \
 openssl-devel \
 pkgconf-pkg-config \
 virtual/webserver \
 "
RDEPENDS:nut-xml = " \
 glibc \
 neon \
 nut-client \
 systemd-libs \
 "
