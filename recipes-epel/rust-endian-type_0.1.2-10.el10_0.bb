# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-endian-type"
PV = "0.1.2"
PR = "10.el10_0"
PACKAGES = " \
 rust-endian-type+default-devel \
 rust-endian-type-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-endian-type-0.1.2-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "197cbf600978252747b9e492c9b651b0ac0a39a856390940631342c141bbbaa8"

URI_x86_64_v2_rust-endian-type+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-endian-type+default-devel-0.1.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-endian-type+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-endian-type+default-devel}"
SRC_URI[x86_64_v2_rust-endian-type+default-devel.sha256sum] = "44b1a3c22c83adaf876701e0b2557ead604268003779cae9f1082f3424d72ab5"

URI_x86_64_v2_rust-endian-type-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-endian-type-devel-0.1.2-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-endian-type-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-endian-type-devel}"
SRC_URI[x86_64_v2_rust-endian-type-devel.sha256sum] = "507dcd8ec35019b3203ca2b95d1ba69d9e5fd39221b2ce54508e8eab3c6ccd7f"

URI_aarch64_rust-endian-type+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-endian-type+default-devel-0.1.2-10.el10_0.noarch.rpm;name=aarch64_rust-endian-type+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-endian-type+default-devel}"
SRC_URI[aarch64_rust-endian-type+default-devel.sha256sum] = "11901db3f7d5ccebed1081f55503328ea7d03bda75dba292e6d30f4f39ac47b8"

URI_aarch64_rust-endian-type-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-endian-type-devel-0.1.2-10.el10_0.noarch.rpm;name=aarch64_rust-endian-type-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-endian-type-devel}"
SRC_URI[aarch64_rust-endian-type-devel.sha256sum] = "ea19b8046d1ebf304d6d492ba914178f1ede2c759c4eb340d674d12c3c9cfe8c"

RDEPENDS:rust-endian-type+default-devel = " \
 cargo \
 rust-endian-type-devel \
 "
RDEPENDS:rust-endian-type-devel = " \
 cargo \
 "
