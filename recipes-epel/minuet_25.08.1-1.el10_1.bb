# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "minuet"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 minuet \
 minuet-data \
 minuet-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/minuet-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c1631bdee7a59a202d9331c309769506b000eaed5d4686e6461f836f13c0a88e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minuet;unpack=0"
SRC_URI[x86_64_v2_minuet.sha256sum] = "f4e799d42b46c11116901202d2aca536ebae4bf76e8ef895ddb6950419237637"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-data-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_minuet-data;unpack=0"
SRC_URI[x86_64_v2_minuet-data.sha256sum] = "927b63f7d31ca8532fa509b1c3fba91e501109f3a93643065516436ac985781f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minuet-devel;unpack=0"
SRC_URI[x86_64_v2_minuet-devel.sha256sum] = "eefdf75c92c4a3f3f4cc48ade00334ffd7b327fbc22ced6aa428f9d7e6bd10c6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/minuet-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_minuet;unpack=0"
SRC_URI[aarch64_minuet.sha256sum] = "5d274344579a091a0374bd53ea40876a241829a65034985429ee1ce3f55d806f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/minuet-data-25.08.1-1.el10_1.noarch.rpm;name=aarch64_minuet-data;unpack=0"
SRC_URI[aarch64_minuet-data.sha256sum] = "0c3cce467f9b7b588f8b31df2b83e588d82ef0ac2b0e365b6812dc405b6ee2b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/minuet-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_minuet-devel;unpack=0"
SRC_URI[aarch64_minuet-devel.sha256sum] = "7170b092611a0c47b6ebdae8928efc46620bca14d3969e3fe55a3ce370d03f58"

RDEPENDS:minuet = " \
 fluidsynth-libs \
 glibc \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 minuet-data \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:minuet-data = " \
 minuet \
 "
RDEPENDS:minuet-devel = " \
 minuet \
 "
