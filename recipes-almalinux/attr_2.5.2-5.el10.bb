# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "attr"
PV = "2.5.2"
PR = "5.el10"
PACKAGES = " \
 attr \
 libattr \
 libattr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/attr-2.5.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ac48b43e6ab3eba36ca831de9ed6247d773fdb821970bade2ddb7a28a18ac2e"

URI_x86_64_v2_attr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/attr-2.5.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_attr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_attr}"
SRC_URI[x86_64_v2_attr.sha256sum] = "7b1c7a413f954e5e12ce8baa35a6953b7c166fbf356d7bd5527b0e1b80541132"

URI_x86_64_v2_libattr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libattr-2.5.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libattr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libattr}"
SRC_URI[x86_64_v2_libattr.sha256sum] = "aa11985585fdb587c541f93bf509de8329839aa5b20da1cb59faba00442ff1fe"

URI_x86_64_v2_libattr-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libattr-devel-2.5.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_libattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libattr-devel}"
SRC_URI[x86_64_v2_libattr-devel.sha256sum] = "6795e0e9fd34f3f5736d8d063e83bd9e90ead2602d15cb50fe6708c5f161bb98"

URI_aarch64_attr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/attr-2.5.2-5.el10.aarch64.rpm;name=aarch64_attr;unpack=0"
SRC_URI:append = " ${URI_aarch64_attr}"
SRC_URI[aarch64_attr.sha256sum] = "6183aeff9270b8293edd4a38cee6346257b05447551429bf30bdf97990ae982b"

URI_aarch64_libattr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libattr-2.5.2-5.el10.aarch64.rpm;name=aarch64_libattr;unpack=0"
SRC_URI:append = " ${URI_aarch64_libattr}"
SRC_URI[aarch64_libattr.sha256sum] = "74ecd65ef2acd6840730961fafdfe60e143dd2b114f425b500149d4c27137314"

URI_aarch64_libattr-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libattr-devel-2.5.2-5.el10.aarch64.rpm;name=aarch64_libattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libattr-devel}"
SRC_URI[aarch64_libattr-devel.sha256sum] = "ee3555af9b1453dbee3dddf50af4b1dc7ebbfa96fc12429f1b7c129dc67107da"

RDEPENDS:attr = " \
 glibc \
 libattr \
 "
RDEPENDS:libattr = " \
 glibc \
 "
RDEPENDS:libattr-devel = " \
 glibc-devel \
 libattr \
 pkgconf-pkg-config \
 "
