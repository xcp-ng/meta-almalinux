# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "human-theme-gtk"
PV = "3.2.0"
PR = "1.el10_3"
PACKAGES = " \
 human-theme-gtk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/human-theme-gtk-3.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "296be8dd7eaaf5f0d7e588a5eafab8b9c8807aec771d043f1d914888afbaeeae"

URI_x86_64_v2_human-theme-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/human-theme-gtk-3.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_human-theme-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_human-theme-gtk}"
SRC_URI[x86_64_v2_human-theme-gtk.sha256sum] = "9735b000140bc64eb1989539b38068acf3b78e4b0ec571d72b4bec6409876e3b"

URI_aarch64_human-theme-gtk = "${EPEL_MIRROR}/aarch64/Packages/h/human-theme-gtk-3.2.0-1.el10_3.noarch.rpm;name=aarch64_human-theme-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_human-theme-gtk}"
SRC_URI[aarch64_human-theme-gtk.sha256sum] = "be6760f31ebc0221823fc2dfc7427d191af44550b23db9bc69167f3b44108716"

RDEPENDS:human-theme-gtk = " \
 "
