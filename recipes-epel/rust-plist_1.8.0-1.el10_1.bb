# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-plist"
PV = "1.8.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-plist+default-devel \
 rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel \
 rust-plist+serde-devel \
 rust-plist-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-plist-1.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f7c9b16afa80a1cbdb80160ad4786126836300642c03dc5a96c0c58378bbe5b"

URI_x86_64_v2_rust-plist+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+default-devel-1.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+default-devel}"
SRC_URI[x86_64_v2_rust-plist+default-devel.sha256sum] = "0412538158147622baea36a972563e0b5665ce1780fbf1a586704fe2791111df"

URI_x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel-1.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel}"
SRC_URI[x86_64_v2_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel.sha256sum] = "c1e4e9ec61deb5550973a03c9405d6c82c30998159f8cb629a204202bfa7aa5f"

URI_x86_64_v2_rust-plist+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist+serde-devel-1.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist+serde-devel}"
SRC_URI[x86_64_v2_rust-plist+serde-devel.sha256sum] = "8201e98d5b441ee5ccf3eb2ad648e6a55d74b14965e4981354a9e31dda867856"

URI_x86_64_v2_rust-plist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-plist-devel-1.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-plist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-plist-devel}"
SRC_URI[x86_64_v2_rust-plist-devel.sha256sum] = "2002b2e336da0c1e9e3c7b94fad8438baaf9ee85d96970ad39921fbfec5001d5"

URI_aarch64_rust-plist+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+default-devel-1.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-plist+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+default-devel}"
SRC_URI[aarch64_rust-plist+default-devel.sha256sum] = "8701dad56fabba7876dfcd77b663edfc0cc43ef7861b75834eceb95bf18ac6a0"

URI_aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel-1.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel}"
SRC_URI[aarch64_rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel.sha256sum] = "92c47dd0f1aa5a377a170eb2ae9aa747a6b1b204482d625bba5b01097a596b18"

URI_aarch64_rust-plist+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist+serde-devel-1.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-plist+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist+serde-devel}"
SRC_URI[aarch64_rust-plist+serde-devel.sha256sum] = "d05a822e920d7e4bec1fcb727aee14bccb4bb38552f63ee9ad7a66b7d52aa50c"

URI_aarch64_rust-plist-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-plist-devel-1.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-plist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-plist-devel}"
SRC_URI[aarch64_rust-plist-devel.sha256sum] = "a14cb2d1fec0379a46ea87a1ff1d9bad8878e127a5f89594484cbd58cf5c5368"

RDEPENDS:rust-plist+default-devel = " \
 cargo \
 rust-plist+serde-devel \
 rust-plist-devel \
 "
RDEPENDS:rust-plist+enable_unstable_features_that_may_break_with_minor_version_bumps-devel = " \
 cargo \
 rust-plist-devel \
 "
RDEPENDS:rust-plist+serde-devel = " \
 cargo \
 rust-plist-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-plist-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-indexmap+default-devel \
 rust-quick-xml+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 "
