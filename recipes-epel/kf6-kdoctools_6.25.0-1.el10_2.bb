# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdoctools"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kdoctools \
 kf6-kdoctools-devel \
 kf6-kdoctools-doc \
 kf6-kdoctools-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdoctools-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9f34b0782fb67b4295925dd369ff068ef88ffd2bcf0a88f9fe0ed9c14f596b8"

URI_x86_64_v2_kf6-kdoctools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools}"
SRC_URI[x86_64_v2_kf6-kdoctools.sha256sum] = "ee9e3ec459c05695be6afde672e20508cecff2841095e129ba2915dd9a4873a7"

URI_x86_64_v2_kf6-kdoctools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdoctools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools-devel}"
SRC_URI[x86_64_v2_kf6-kdoctools-devel.sha256sum] = "37b768d9aaba83376d7b506067e41365057184a2bd9c5072452408df2128e442"

URI_x86_64_v2_kf6-kdoctools-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdoctools-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools-doc}"
SRC_URI[x86_64_v2_kf6-kdoctools-doc.sha256sum] = "6f29b7e24becf42a5e7af182a96587572a52bc2d96bf5440b465b4e90b4bbe6b"

URI_x86_64_v2_kf6-kdoctools-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdoctools-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdoctools-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdoctools-html}"
SRC_URI[x86_64_v2_kf6-kdoctools-html.sha256sum] = "15f9843f6d1d8d288b4338c762027aa6062c3399bd618fda3c4e5cc7267f797f"

URI_aarch64_kf6-kdoctools = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdoctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools}"
SRC_URI[aarch64_kf6-kdoctools.sha256sum] = "f06a28d6d74c3c38fe2c4fbb34c19602164bc0a4714c413c108d140f8e513b51"

URI_aarch64_kf6-kdoctools-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdoctools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools-devel}"
SRC_URI[aarch64_kf6-kdoctools-devel.sha256sum] = "1cde963d60a86617135a299e6d29025828eeb6855edad54f3a6cf56c76f34319"

URI_aarch64_kf6-kdoctools-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdoctools-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools-doc}"
SRC_URI[aarch64_kf6-kdoctools-doc.sha256sum] = "0bd35d5f6d3aff240520398294dccf16495f222bf19909b9b4057b230d3222cc"

URI_aarch64_kf6-kdoctools-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdoctools-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdoctools-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdoctools-html}"
SRC_URI[aarch64_kf6-kdoctools-html.sha256sum] = "b4f409a380f0845a1c4cf0a06a1de6536648f361903dfb95d600acce4e399e41"

RDEPENDS:kf6-kdoctools = " \
 docbook-dtds \
 docbook-style-xsl \
 glibc \
 kf6-karchive \
 libstdc++ \
 libxml2 \
 libxslt \
 qt6-qtbase \
 "
RDEPENDS:kf6-kdoctools-devel = " \
 cmake-filesystem \
 kf6-kdoctools \
 perl-Any-URI-Escape \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kdoctools-doc = " \
 "
RDEPENDS:kf6-kdoctools-html = " \
 "
