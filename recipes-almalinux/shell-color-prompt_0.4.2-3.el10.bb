# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shell-color-prompt"
PV = "0.4.2"
PR = "3.el10"
PACKAGES = " \
 bash-color-prompt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/shell-color-prompt-0.4.2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "243b2bb9bf4612a8ffee707e0d76c77edc16f1476ea0142463db490e2f3149a1"

URI_x86_64_v2_bash-color-prompt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bash-color-prompt-0.4.2-3.el10.noarch.rpm;name=x86_64_v2_bash-color-prompt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bash-color-prompt}"
SRC_URI[x86_64_v2_bash-color-prompt.sha256sum] = "bb249cbbd02bd14a34ceddaf825766c65152e314fca2188a4a12099c54e5fb6f"

URI_aarch64_bash-color-prompt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bash-color-prompt-0.4.2-3.el10.noarch.rpm;name=aarch64_bash-color-prompt;unpack=0"
SRC_URI:append = " ${URI_aarch64_bash-color-prompt}"
SRC_URI[aarch64_bash-color-prompt.sha256sum] = "bb249cbbd02bd14a34ceddaf825766c65152e314fca2188a4a12099c54e5fb6f"

RDEPENDS:bash-color-prompt = " \
 "
