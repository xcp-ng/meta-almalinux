# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-lesscpy"
PV = "0.14.0"
PR = "17.el10"
PACKAGES = " \
 python3-lesscpy \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-lesscpy-0.14.0-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f943749b460728e840f0df3899f1d7ef5eafef5a016f4d4d1be67bd03b6af950"

URI_x86_64_v2_python3-lesscpy = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-lesscpy-0.14.0-17.el10.noarch.rpm;name=x86_64_v2_python3-lesscpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lesscpy}"
SRC_URI[x86_64_v2_python3-lesscpy.sha256sum] = "c9bb11e36b6e39cab2845c4529d0227522bbc4aef4a3bb78658a01c051c84254"

URI_aarch64_python3-lesscpy = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-lesscpy-0.14.0-17.el10.noarch.rpm;name=aarch64_python3-lesscpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lesscpy}"
SRC_URI[aarch64_python3-lesscpy.sha256sum] = "c9bb11e36b6e39cab2845c4529d0227522bbc4aef4a3bb78658a01c051c84254"

RDEPENDS:python3-lesscpy = " \
 python3 \
 python3-ply \
 python3-six \
 "
