# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.10"
PV = "9.10.2"
PR = "8.el10_0"
PACKAGES = " \
 ghc9.10 \
 ghc9.10-Cabal \
 ghc9.10-Cabal-devel \
 ghc9.10-Cabal-doc \
 ghc9.10-Cabal-prof \
 ghc9.10-Cabal-syntax \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-Cabal-syntax-doc \
 ghc9.10-Cabal-syntax-prof \
 ghc9.10-array \
 ghc9.10-array-devel \
 ghc9.10-array-doc \
 ghc9.10-array-prof \
 ghc9.10-base \
 ghc9.10-base-devel \
 ghc9.10-base-doc \
 ghc9.10-base-prof \
 ghc9.10-binary \
 ghc9.10-binary-devel \
 ghc9.10-binary-doc \
 ghc9.10-binary-prof \
 ghc9.10-bytestring \
 ghc9.10-bytestring-devel \
 ghc9.10-bytestring-doc \
 ghc9.10-bytestring-prof \
 ghc9.10-compiler \
 ghc9.10-compiler-default \
 ghc9.10-containers \
 ghc9.10-containers-devel \
 ghc9.10-containers-doc \
 ghc9.10-containers-prof \
 ghc9.10-deepseq \
 ghc9.10-deepseq-devel \
 ghc9.10-deepseq-doc \
 ghc9.10-deepseq-prof \
 ghc9.10-devel \
 ghc9.10-directory \
 ghc9.10-directory-devel \
 ghc9.10-directory-doc \
 ghc9.10-directory-prof \
 ghc9.10-doc \
 ghc9.10-doc-index \
 ghc9.10-exceptions \
 ghc9.10-exceptions-devel \
 ghc9.10-exceptions-doc \
 ghc9.10-exceptions-prof \
 ghc9.10-filepath \
 ghc9.10-filepath-devel \
 ghc9.10-filepath-doc \
 ghc9.10-filepath-prof \
 ghc9.10-filesystem \
 ghc9.10-ghc \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-bignum-devel \
 ghc9.10-ghc-bignum-doc \
 ghc9.10-ghc-bignum-prof \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-boot-doc \
 ghc9.10-ghc-boot-prof \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-ghc-boot-th-doc \
 ghc9.10-ghc-boot-th-prof \
 ghc9.10-ghc-compact \
 ghc9.10-ghc-compact-devel \
 ghc9.10-ghc-compact-doc \
 ghc9.10-ghc-compact-prof \
 ghc9.10-ghc-devel \
 ghc9.10-ghc-doc \
 ghc9.10-ghc-experimental \
 ghc9.10-ghc-experimental-devel \
 ghc9.10-ghc-experimental-doc \
 ghc9.10-ghc-experimental-prof \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghc-heap-doc \
 ghc9.10-ghc-heap-prof \
 ghc9.10-ghc-platform \
 ghc9.10-ghc-platform-devel \
 ghc9.10-ghc-platform-doc \
 ghc9.10-ghc-platform-prof \
 ghc9.10-ghc-prof \
 ghc9.10-ghc-toolchain \
 ghc9.10-ghc-toolchain-devel \
 ghc9.10-ghc-toolchain-doc \
 ghc9.10-ghc-toolchain-prof \
 ghc9.10-ghci \
 ghc9.10-ghci-devel \
 ghc9.10-ghci-doc \
 ghc9.10-ghci-prof \
 ghc9.10-hadrian \
 ghc9.10-haskeline \
 ghc9.10-haskeline-devel \
 ghc9.10-haskeline-doc \
 ghc9.10-haskeline-prof \
 ghc9.10-hpc \
 ghc9.10-hpc-devel \
 ghc9.10-hpc-doc \
 ghc9.10-hpc-prof \
 ghc9.10-manual \
 ghc9.10-mtl \
 ghc9.10-mtl-devel \
 ghc9.10-mtl-doc \
 ghc9.10-mtl-prof \
 ghc9.10-os-string \
 ghc9.10-os-string-devel \
 ghc9.10-os-string-doc \
 ghc9.10-os-string-prof \
 ghc9.10-parsec \
 ghc9.10-parsec-devel \
 ghc9.10-parsec-doc \
 ghc9.10-parsec-prof \
 ghc9.10-pretty \
 ghc9.10-pretty-devel \
 ghc9.10-pretty-doc \
 ghc9.10-pretty-prof \
 ghc9.10-process \
 ghc9.10-process-devel \
 ghc9.10-process-doc \
 ghc9.10-process-prof \
 ghc9.10-prof \
 ghc9.10-semaphore-compat \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-semaphore-compat-doc \
 ghc9.10-semaphore-compat-prof \
 ghc9.10-stm \
 ghc9.10-stm-devel \
 ghc9.10-stm-doc \
 ghc9.10-stm-prof \
 ghc9.10-template-haskell \
 ghc9.10-template-haskell-devel \
 ghc9.10-template-haskell-doc \
 ghc9.10-template-haskell-prof \
 ghc9.10-terminfo \
 ghc9.10-terminfo-devel \
 ghc9.10-terminfo-doc \
 ghc9.10-terminfo-prof \
 ghc9.10-text \
 ghc9.10-text-devel \
 ghc9.10-text-doc \
 ghc9.10-text-prof \
 ghc9.10-time \
 ghc9.10-time-devel \
 ghc9.10-time-doc \
 ghc9.10-time-prof \
 ghc9.10-transformers \
 ghc9.10-transformers-devel \
 ghc9.10-transformers-doc \
 ghc9.10-transformers-prof \
 ghc9.10-unix \
 ghc9.10-unix-devel \
 ghc9.10-unix-doc \
 ghc9.10-unix-prof \
 ghc9.10-xhtml \
 ghc9.10-xhtml-devel \
 ghc9.10-xhtml-doc \
 ghc9.10-xhtml-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.10-9.10.2-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87c7d074e697bea3d9f15e7350f08a828497bb2fa93efb559439e6d569d82b29"

URI_x86_64_v2_ghc9.10 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10}"
SRC_URI[x86_64_v2_ghc9.10.sha256sum] = "c761f31868ebdc6d318ffc2b00becba5d77c13c2bb86d6191eedc4778b136ca9"

URI_x86_64_v2_ghc9.10-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-3.12.1.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal}"
SRC_URI[x86_64_v2_ghc9.10-Cabal.sha256sum] = "184f2c9fc26d2727b43ab571362666a1692ed0c4b4108b545ac151d014fa83ef"

URI_x86_64_v2_ghc9.10-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-devel-3.12.1.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-devel.sha256sum] = "694b8251ff1c7dc4b8d988d11950b89eb767f4625d1c76256e99590aec6403d5"

URI_x86_64_v2_ghc9.10-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-doc-3.12.1.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-doc.sha256sum] = "c19b546b8a2943a9cec552bb69f956884dff9204ff6824e83293823cf74ecd0d"

URI_x86_64_v2_ghc9.10-Cabal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-prof-3.12.1.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-prof}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-prof.sha256sum] = "ee4d7f5659551da33655d99b38d6af85c0d3b0c47d40832da20e048e4f694243"

URI_x86_64_v2_ghc9.10-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-3.12.1.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax.sha256sum] = "d80621afe2a643bd5b8ede175910bdc7d2ed761f3c3bb0bb23041e9703c047a9"

URI_x86_64_v2_ghc9.10-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-devel-3.12.1.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax-devel.sha256sum] = "cd8ecae4d70d007dce27980acfcc95c588f41e0d529ac5ba00c5315df6944c86"

URI_x86_64_v2_ghc9.10-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-doc-3.12.1.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax-doc.sha256sum] = "1e632d3052f083438bb7961095053f78861c9f1dc9d9ebeff401fa52a7f217b5"

URI_x86_64_v2_ghc9.10-Cabal-syntax-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-prof-3.12.1.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax-prof}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax-prof.sha256sum] = "305ec1b69da91b68024164a1e5a79941c6dadc9e351f9dfb2845f5209ca21da2"

URI_x86_64_v2_ghc9.10-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-0.5.8.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array}"
SRC_URI[x86_64_v2_ghc9.10-array.sha256sum] = "4701102a09b9b4c76678d0d32f3d176171f26e94b227914459e25ad26d2862da"

URI_x86_64_v2_ghc9.10-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-devel-0.5.8.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array-devel}"
SRC_URI[x86_64_v2_ghc9.10-array-devel.sha256sum] = "e7a749f6282971746d1f38d7dd3265095550b943f45b163476714aafb56e62cc"

URI_x86_64_v2_ghc9.10-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-doc-0.5.8.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array-doc}"
SRC_URI[x86_64_v2_ghc9.10-array-doc.sha256sum] = "ceaa8054162303e3a305750ff72ebcf6c3c4ca278b0b575988e03fb0618db20e"

URI_x86_64_v2_ghc9.10-array-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-prof-0.5.8.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-array-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array-prof}"
SRC_URI[x86_64_v2_ghc9.10-array-prof.sha256sum] = "c4025514c32ddb809c15b74bc57d9e47200ca9ec5b4a204e061615be2cd829be"

URI_x86_64_v2_ghc9.10-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-4.20.1.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base}"
SRC_URI[x86_64_v2_ghc9.10-base.sha256sum] = "6970c0349073520bbe1becf84c030e969d4b3935d762d270a61ff82d58b0976a"

URI_x86_64_v2_ghc9.10-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-devel-4.20.1.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base-devel}"
SRC_URI[x86_64_v2_ghc9.10-base-devel.sha256sum] = "08acd0b42b282ce50e7daae67e0acded13e90d37c942b212d8720228253a7357"

URI_x86_64_v2_ghc9.10-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-doc-4.20.1.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base-doc}"
SRC_URI[x86_64_v2_ghc9.10-base-doc.sha256sum] = "3b6ac60cf68a10e02550b98bc848b549e6e2cf2f0800bc76355ca64f22b7ccc6"

URI_x86_64_v2_ghc9.10-base-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-prof-4.20.1.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-base-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base-prof}"
SRC_URI[x86_64_v2_ghc9.10-base-prof.sha256sum] = "ba9e776c8c78212e1f6dac23d3b1e1e3e49b2705ab80dea7eb769b5f880ab81b"

URI_x86_64_v2_ghc9.10-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-0.8.9.3-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary}"
SRC_URI[x86_64_v2_ghc9.10-binary.sha256sum] = "c726e54d4c68657277fd53750cf525e3f72782bfeaac4dd6aa7342e4eb6361ba"

URI_x86_64_v2_ghc9.10-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-devel-0.8.9.3-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary-devel}"
SRC_URI[x86_64_v2_ghc9.10-binary-devel.sha256sum] = "8d5cf2de84874fd2b0a851742f7779a5106d7f53eb145840f46b5d597791633f"

URI_x86_64_v2_ghc9.10-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-doc-0.8.9.3-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary-doc}"
SRC_URI[x86_64_v2_ghc9.10-binary-doc.sha256sum] = "eb594ae8037676d8cd25143fe577225034cbe287c3bf3184c53a1f42355c6626"

URI_x86_64_v2_ghc9.10-binary-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-prof-0.8.9.3-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-binary-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary-prof}"
SRC_URI[x86_64_v2_ghc9.10-binary-prof.sha256sum] = "5788b1616968b3e542a1323118fb83e9b49be2b545dcfd02eb7d3fb053def06f"

URI_x86_64_v2_ghc9.10-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-0.12.2.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring}"
SRC_URI[x86_64_v2_ghc9.10-bytestring.sha256sum] = "7cf2d0a08d1b8dc20139fbf94e14c24ebbf2d9a2eacbfe5af5d8f544fd9662f8"

URI_x86_64_v2_ghc9.10-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-devel-0.12.2.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.10-bytestring-devel.sha256sum] = "79ac49cad7c30495c4df63bc2df234cbd134a4508185a1e2aef25b052eb0cc36"

URI_x86_64_v2_ghc9.10-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-doc-0.12.2.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.10-bytestring-doc.sha256sum] = "8dd00c458a831d6ad0f985a970077d09b4e86f410a83f0e903864f84da891a54"

URI_x86_64_v2_ghc9.10-bytestring-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-prof-0.12.2.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring-prof}"
SRC_URI[x86_64_v2_ghc9.10-bytestring-prof.sha256sum] = "5efefcf2a4ccad946238172b12678d4b1b1d3801075d2dee1d01aca1b948c1ae"

URI_x86_64_v2_ghc9.10-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-compiler-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-compiler}"
SRC_URI[x86_64_v2_ghc9.10-compiler.sha256sum] = "f518c0f78205d63dfae166307a5974d762c0428aeb41c72dc09b6ea516e8c8ca"

URI_x86_64_v2_ghc9.10-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-compiler-default-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-compiler-default}"
SRC_URI[x86_64_v2_ghc9.10-compiler-default.sha256sum] = "ff35fcd9acec3b0c3e0e2e3830419723ee03fce43106870a83eb63098836ba4d"

URI_x86_64_v2_ghc9.10-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-0.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers}"
SRC_URI[x86_64_v2_ghc9.10-containers.sha256sum] = "421022ef01e312d03e2d8e496bebabd82b79733dbb52a42158f553105fadd8d7"

URI_x86_64_v2_ghc9.10-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-devel-0.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers-devel}"
SRC_URI[x86_64_v2_ghc9.10-containers-devel.sha256sum] = "3f2a73d2778acdc01858e8f9ae1f1cbb11db639f7e0d67bf056604ab5de4c4cb"

URI_x86_64_v2_ghc9.10-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-doc-0.7-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers-doc}"
SRC_URI[x86_64_v2_ghc9.10-containers-doc.sha256sum] = "ad904dde7790e5b6fe2ecdfcbb6cea20b69d8b2be838b50a13424a4871f184fd"

URI_x86_64_v2_ghc9.10-containers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-prof-0.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-containers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers-prof}"
SRC_URI[x86_64_v2_ghc9.10-containers-prof.sha256sum] = "2b11d5b7659bc91b6452c414fe6cce7811ee457c23953bdaa834905297851000"

URI_x86_64_v2_ghc9.10-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-1.5.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq}"
SRC_URI[x86_64_v2_ghc9.10-deepseq.sha256sum] = "49c839d9d1f9a040e3918222a5b53883cafd89f79d0fd944b9280fda98c593ec"

URI_x86_64_v2_ghc9.10-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-devel-1.5.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.10-deepseq-devel.sha256sum] = "0f765042c7dee66b0c8b9d2e45898b631de3cdebda0467c3e5ac13f9200c352b"

URI_x86_64_v2_ghc9.10-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-doc-1.5.0.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.10-deepseq-doc.sha256sum] = "36c558be84e3ef14c8aff8277d4549c32f7b6bfb4d2fee73e62d4b132e71952a"

URI_x86_64_v2_ghc9.10-deepseq-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-prof-1.5.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq-prof}"
SRC_URI[x86_64_v2_ghc9.10-deepseq-prof.sha256sum] = "a1b135703d3dc8ae73867b0c2856f00d46f2a8633a600a74bad80debce4261de"

URI_x86_64_v2_ghc9.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-devel-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-devel}"
SRC_URI[x86_64_v2_ghc9.10-devel.sha256sum] = "c4a3afbd4348edc077c12a01bf2a173d8ff8464b6ab790db8323fbd9ff14ad25"

URI_x86_64_v2_ghc9.10-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-1.3.8.5-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory}"
SRC_URI[x86_64_v2_ghc9.10-directory.sha256sum] = "03fd2e8393720783df999fb8f4d5290beb56bbaab6c563443109ba57e6a7beb5"

URI_x86_64_v2_ghc9.10-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-devel-1.3.8.5-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory-devel}"
SRC_URI[x86_64_v2_ghc9.10-directory-devel.sha256sum] = "680744dc3fc0f55c4981149c23f774779c7e76a4fd0d9450960594813ce09827"

URI_x86_64_v2_ghc9.10-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-doc-1.3.8.5-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory-doc}"
SRC_URI[x86_64_v2_ghc9.10-directory-doc.sha256sum] = "d3f05601f974829aa9874e7b53e3de53b716e684e4814b1261fe995265b35109"

URI_x86_64_v2_ghc9.10-directory-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-prof-1.3.8.5-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-directory-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory-prof}"
SRC_URI[x86_64_v2_ghc9.10-directory-prof.sha256sum] = "7898f14ec312b4c5c382b9f17aef69fe7aa69a2ac02d00a3901067a8c71c5cdd"

URI_x86_64_v2_ghc9.10-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-doc-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-doc}"
SRC_URI[x86_64_v2_ghc9.10-doc.sha256sum] = "6b14fb8be4be4f8c44f907da5e893d1ff4ba735bd99a77e214111fb853519762"

URI_x86_64_v2_ghc9.10-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-doc-index-9.10.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-doc-index}"
SRC_URI[x86_64_v2_ghc9.10-doc-index.sha256sum] = "0aea309a9d9d1a3ab737a66c7be352566deff52d21b5e8c1d99e17325d551793"

URI_x86_64_v2_ghc9.10-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-0.10.9-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions}"
SRC_URI[x86_64_v2_ghc9.10-exceptions.sha256sum] = "884c2932828e83215d782275a7fd27b24a41189313071af73eb698a86f2e6424"

URI_x86_64_v2_ghc9.10-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-devel-0.10.9-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.10-exceptions-devel.sha256sum] = "fc37ce66911c41736398c5c0ee836cedd32e0bfc3f763d940eae9dd3aa4441b0"

URI_x86_64_v2_ghc9.10-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-doc-0.10.9-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.10-exceptions-doc.sha256sum] = "fa1681d90a119bb68b8f099b87993915eab037e6e9fe814b3e1b952c7c8d37ce"

URI_x86_64_v2_ghc9.10-exceptions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-prof-0.10.9-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions-prof}"
SRC_URI[x86_64_v2_ghc9.10-exceptions-prof.sha256sum] = "1367fddb7a4447ca1f36c114b629223ba2aff8f967f8ed6f56288ef64d6e03aa"

URI_x86_64_v2_ghc9.10-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-1.5.4.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath}"
SRC_URI[x86_64_v2_ghc9.10-filepath.sha256sum] = "2d1b619b657f0dd3a554f0d49d35b9151732d9fd22dfc9913b46b1ab6e2188b5"

URI_x86_64_v2_ghc9.10-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-devel-1.5.4.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.10-filepath-devel.sha256sum] = "0a22009d459d95098c6db913aeffc239655429a57a80d1ca00bca624806e3237"

URI_x86_64_v2_ghc9.10-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-doc-1.5.4.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.10-filepath-doc.sha256sum] = "c766ca0a99124a5e9c3d58061a0b5c9d61eefe8eb455f8cac3b7316697a67cd0"

URI_x86_64_v2_ghc9.10-filepath-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-prof-1.5.4.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath-prof}"
SRC_URI[x86_64_v2_ghc9.10-filepath-prof.sha256sum] = "027713e904e44c0ad219f079ab1117f335fd4bcda0ac52a4cd0cdd8e6e564f9e"

URI_x86_64_v2_ghc9.10-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filesystem-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filesystem}"
SRC_URI[x86_64_v2_ghc9.10-filesystem.sha256sum] = "7984daca135d20b76bf910f0e9d8d69e3be3912da65d6b06c08a452d20cb36d2"

URI_x86_64_v2_ghc9.10-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc}"
SRC_URI[x86_64_v2_ghc9.10-ghc.sha256sum] = "48abfb41c1358f08aec42942d746094b30f874419c72815012c5874cf35fc73c"

URI_x86_64_v2_ghc9.10-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-1.3-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum.sha256sum] = "957497276a26e68cff66fa1d1697a28d238c9354640d5223b9f7dad882c8d4b0"

URI_x86_64_v2_ghc9.10-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-devel-1.3-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum-devel.sha256sum] = "e8b9c74af9ef18a75dadd5dbbcd0aba399031b7b2f6f4804d42a91ba5928cc2e"

URI_x86_64_v2_ghc9.10-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-doc-1.3-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum-doc.sha256sum] = "ebeaa74ce31e6df0bf07271f74c6d48126ff004d61968f7c39f02264ee3199b8"

URI_x86_64_v2_ghc9.10-ghc-bignum-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-prof-1.3-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum-prof.sha256sum] = "633f3a28f0d3f328ba27c0df00bfc595730de29dc0af45f743f42131473894d7"

URI_x86_64_v2_ghc9.10-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot.sha256sum] = "c7b927961bba9ee3a4a4b8c6cc1861d363d42e6d9b6498a3a0d1c5814851c960"

URI_x86_64_v2_ghc9.10-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-devel-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-devel.sha256sum] = "78ece1f8261f69cf75f75dc25dd6682d5f661910dbd69be2e94fd15503786c96"

URI_x86_64_v2_ghc9.10-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-doc-9.10.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-doc.sha256sum] = "034bcfe5621f8c0ab09079dfc20fdd31982e1fab1e921a844e7f12b5de5bce2c"

URI_x86_64_v2_ghc9.10-ghc-boot-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-prof-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-prof.sha256sum] = "8e35acf76cc239825411b5523ea51eb50d4efb2e99d4be2e5878e5156543b408"

URI_x86_64_v2_ghc9.10-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th.sha256sum] = "88ca8e2f1a87f735f89f827ca544ec7075373ab36d4fbab69f0fbc55c56c4ac0"

URI_x86_64_v2_ghc9.10-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-devel-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th-devel.sha256sum] = "67fb6bed0429f5ddbf3abc442c41a3ed160652ab8142f420c576d84e7bc5095c"

URI_x86_64_v2_ghc9.10-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-doc-9.10.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th-doc.sha256sum] = "84df9ab57e6165514dce847e859c28d3b424206545d98811439c6770bf95d3fa"

URI_x86_64_v2_ghc9.10-ghc-boot-th-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-prof-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th-prof.sha256sum] = "0e67578a50fd02fb4c8f2463865545823a1e75dceed032e701d8ca3e410d2343"

URI_x86_64_v2_ghc9.10-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact.sha256sum] = "112059bd024383b7a0c9119164cddd23bdaad623b2965bbcc2863f30244a216a"

URI_x86_64_v2_ghc9.10-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-devel-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact-devel.sha256sum] = "603cd5dbd41508f2597dffe66e5a25362fc1d61e051127b48784a668c32361ba"

URI_x86_64_v2_ghc9.10-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-doc-0.1.0.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact-doc.sha256sum] = "04d2a31375cf95bf1161f94899515f6df4d3acbb34604a7872d51a548533462c"

URI_x86_64_v2_ghc9.10-ghc-compact-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-prof-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact-prof.sha256sum] = "0023e3ba810fad772b93926b32674f7c0290526f6e3e195574eb970a6fe1ba90"

URI_x86_64_v2_ghc9.10-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-devel-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-devel.sha256sum] = "d60f7cdf3c6152f8e24fa143c3e98b5b7714ed3bf35ed61e5cd1edda275c651e"

URI_x86_64_v2_ghc9.10-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-doc-9.10.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-doc.sha256sum] = "cf553be6518b060ac942faf58f5c4d25117c47199ac0ad9572d0622c2ea400cd"

URI_x86_64_v2_ghc9.10-ghc-experimental = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-9.1002.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental.sha256sum] = "cd1c7156b023e5d3357edda324c21efce71428e495fa9745c49ebd31bda512e6"

URI_x86_64_v2_ghc9.10-ghc-experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-devel-9.1002.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental-devel.sha256sum] = "04220af8a1344e7a5cc879585aaef80a6a795bf73c9dca8b37b14fd16d38fc5d"

URI_x86_64_v2_ghc9.10-ghc-experimental-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-doc-9.1002.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental-doc.sha256sum] = "aed1095eb652eb45eeac22fde0f7827a7bee0aef2110def7db9f67bebb72a306"

URI_x86_64_v2_ghc9.10-ghc-experimental-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-prof-9.1002.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-experimental-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental-prof.sha256sum] = "d07c01ead47e4cf119f553a918c233e9d48365cff38d6da793bcc0a4559ec8a6"

URI_x86_64_v2_ghc9.10-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap.sha256sum] = "42479f8517de7ac834a8d35452e3acfd8d65249cc5062fe77f69c35c1bb13fcb"

URI_x86_64_v2_ghc9.10-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-devel-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap-devel.sha256sum] = "12ebfd6ca623440d46efc0ca63a5c62f8ff0e9e815112235ead85e7d06790d6e"

URI_x86_64_v2_ghc9.10-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-doc-9.10.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap-doc.sha256sum] = "f1d3e93485192b21d6a1486dd1bf2a1d2e1f740ff1a89ab44f3aaa89fbde329f"

URI_x86_64_v2_ghc9.10-ghc-heap-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-prof-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap-prof.sha256sum] = "fcb87d794c48fc6eca8e7dae76cac24d395e08c111458f942a5bb9aeb6cce0a6"

URI_x86_64_v2_ghc9.10-ghc-platform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform.sha256sum] = "d2a82e1bd174c0ab3a28d8ff6e1ca5233bf88d588b2c5f31379cebeda7489b23"

URI_x86_64_v2_ghc9.10-ghc-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-devel-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform-devel.sha256sum] = "11f903a59b623b8d1c36afb8b57479311a50a9fa7b6630f8f22220af972628d4"

URI_x86_64_v2_ghc9.10-ghc-platform-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-doc-0.1.0.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform-doc.sha256sum] = "9f8c7ac078dd4a3f7539e3502daa12ff49f08098e592a95f10c17b3d6e0056bb"

URI_x86_64_v2_ghc9.10-ghc-platform-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-prof-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-platform-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform-prof.sha256sum] = "a66d2a97d439334be55e4b1107d736848d4af0695e2ec9e3ab76560653a78b46"

URI_x86_64_v2_ghc9.10-ghc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-prof-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghc-prof.sha256sum] = "0ad226d1494196c83445a46588c290ca6963414d3374bb5754f1ea3c68abe86a"

URI_x86_64_v2_ghc9.10-ghc-toolchain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain.sha256sum] = "127f805d0c952275669c41f80bbab9b9c74a1318274a24db1b88af0a820a9e68"

URI_x86_64_v2_ghc9.10-ghc-toolchain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-devel-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain-devel.sha256sum] = "741d84e3e15a0fd203e7030ddebf758b8f78e439bc56cb74ef083dcb8bc5f183"

URI_x86_64_v2_ghc9.10-ghc-toolchain-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-doc-0.1.0.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain-doc.sha256sum] = "df7efc728fce1ad7775244b0c57039ff725df492a284ca92b85623e2ba6034bc"

URI_x86_64_v2_ghc9.10-ghc-toolchain-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-prof-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain-prof.sha256sum] = "8ff0c9c6227cc2e07933421dd9d090fcb3b2f0dfe402e544bfc79d0d7bcd3268"

URI_x86_64_v2_ghc9.10-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci}"
SRC_URI[x86_64_v2_ghc9.10-ghci.sha256sum] = "07a28411cae8d58362d2d29634c64c0e9dd4d625ac38d04d67b3f5ebedc4bde0"

URI_x86_64_v2_ghc9.10-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-devel-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghci-devel.sha256sum] = "448959479a9ffd0a1f5edfaa0292824afb7804c3aa4b3a6d342be90fe6ea2ef0"

URI_x86_64_v2_ghc9.10-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-doc-9.10.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghci-doc.sha256sum] = "cff4642741e82114e14526954e2db3f52bbf4dde60d470153e8a2199fab9238a"

URI_x86_64_v2_ghc9.10-ghci-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-prof-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci-prof}"
SRC_URI[x86_64_v2_ghc9.10-ghci-prof.sha256sum] = "8e04ca73a76a4a903558243591f36f07d5be7891e9333674e56ab9a3e435c9ff"

URI_x86_64_v2_ghc9.10-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hadrian-0.1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hadrian}"
SRC_URI[x86_64_v2_ghc9.10-hadrian.sha256sum] = "7a425ae27e6a655ba50b19701a43d4b8eccce0ae8ec7841d185fb0b4dfa50e1d"

URI_x86_64_v2_ghc9.10-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-0.8.2.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline}"
SRC_URI[x86_64_v2_ghc9.10-haskeline.sha256sum] = "0d4b4be5e26be93a0ba1607c1745cdf87fed851f6ba1897aa6556ccc4de2c05c"

URI_x86_64_v2_ghc9.10-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-devel-0.8.2.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.10-haskeline-devel.sha256sum] = "f42c70c2ff0f182235656997a4a882baf2daa3785f4349153db2eab47e7fb78c"

URI_x86_64_v2_ghc9.10-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-doc-0.8.2.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.10-haskeline-doc.sha256sum] = "e7cc99af67b1b5d2807bb3a471f83e9d850e6889b63f3fff4e722e33b937212f"

URI_x86_64_v2_ghc9.10-haskeline-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-prof-0.8.2.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline-prof}"
SRC_URI[x86_64_v2_ghc9.10-haskeline-prof.sha256sum] = "85d1534ac26d38f4ab685bd6e25314a589c0d42e85b5b5ddce6fc4429a24b050"

URI_x86_64_v2_ghc9.10-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-0.7.0.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc}"
SRC_URI[x86_64_v2_ghc9.10-hpc.sha256sum] = "9ba19c592bb891fa30447cf1044046a0a45d758c769c5c19d1ce3a6567b5ef9e"

URI_x86_64_v2_ghc9.10-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-devel-0.7.0.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.10-hpc-devel.sha256sum] = "4bf36adb491b2acb0a85168eacbd2899656064354fbfcda945b9be30e69b31e1"

URI_x86_64_v2_ghc9.10-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-doc-0.7.0.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.10-hpc-doc.sha256sum] = "5dce37354cc43b87992526e501ad7b14f6451d92386378c31f70137b1fd794c3"

URI_x86_64_v2_ghc9.10-hpc-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-prof-0.7.0.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc-prof}"
SRC_URI[x86_64_v2_ghc9.10-hpc-prof.sha256sum] = "a08e873c7db319a16495c6be2af092fee3438f9a476c2b802922a60cc080bf62"

URI_x86_64_v2_ghc9.10-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-manual-9.10.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-manual}"
SRC_URI[x86_64_v2_ghc9.10-manual.sha256sum] = "50a4f78dc316fe1a2ceaac297179e2933df073980463dcb99274804e6abdc9a9"

URI_x86_64_v2_ghc9.10-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-2.3.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl}"
SRC_URI[x86_64_v2_ghc9.10-mtl.sha256sum] = "3f25a122b02f7a2b096654e49f18c8f7126f47225b92bbc1794e963cc5192ed8"

URI_x86_64_v2_ghc9.10-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-devel-2.3.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.10-mtl-devel.sha256sum] = "b633373cead73afc220bf995f12432c372fda729f42fd150f3e48c98fcc1dc52"

URI_x86_64_v2_ghc9.10-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-doc-2.3.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.10-mtl-doc.sha256sum] = "7247ab1197c1935f24eca8eff4a00a7fa7a4baedf2980f05a913758dbf6b9536"

URI_x86_64_v2_ghc9.10-mtl-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-prof-2.3.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl-prof}"
SRC_URI[x86_64_v2_ghc9.10-mtl-prof.sha256sum] = "411f71b14caf78040e2e62c56bbc20d030a11f0393d4e0727ecff012f92c6cb9"

URI_x86_64_v2_ghc9.10-os-string = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-2.0.4-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-os-string;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string}"
SRC_URI[x86_64_v2_ghc9.10-os-string.sha256sum] = "9433092c750d405f800143bf7a5f7c8cd88bb74fb895744c09fa0c8aafd38961"

URI_x86_64_v2_ghc9.10-os-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-devel-2.0.4-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string-devel}"
SRC_URI[x86_64_v2_ghc9.10-os-string-devel.sha256sum] = "fbb6d13dfe280a4e80b9d044b8d080329dff9a3dec7695a309bacbbaa1e26e1d"

URI_x86_64_v2_ghc9.10-os-string-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-doc-2.0.4-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string-doc}"
SRC_URI[x86_64_v2_ghc9.10-os-string-doc.sha256sum] = "1195d7334d64a078ca894560bf5dc01098b3fceb844461b225cfd0c0fdaae3bc"

URI_x86_64_v2_ghc9.10-os-string-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-prof-2.0.4-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string-prof}"
SRC_URI[x86_64_v2_ghc9.10-os-string-prof.sha256sum] = "943260111ca382722e259cff86702518fcd01f0fdfdce814240abbf097faee2d"

URI_x86_64_v2_ghc9.10-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-3.1.18.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec}"
SRC_URI[x86_64_v2_ghc9.10-parsec.sha256sum] = "ef88b44c223d018fa889d4ffbe7ac6ca8362857e518150d7bf87db6ab98907b7"

URI_x86_64_v2_ghc9.10-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-devel-3.1.18.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.10-parsec-devel.sha256sum] = "c2530187d3db2bc1b264a4ff39adc20ff57fd902a8d01dbc185df4673f4abc6f"

URI_x86_64_v2_ghc9.10-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-doc-3.1.18.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.10-parsec-doc.sha256sum] = "8f652fbed612fe057d212d97a4f40727e336fcd0ddcdc2a09c0815c67c61d101"

URI_x86_64_v2_ghc9.10-parsec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-prof-3.1.18.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec-prof}"
SRC_URI[x86_64_v2_ghc9.10-parsec-prof.sha256sum] = "8a9e5af0408525b3526c18e3ab72db9f70b2b592e22b711cf09f1100ca461372"

URI_x86_64_v2_ghc9.10-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-1.1.3.6-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty}"
SRC_URI[x86_64_v2_ghc9.10-pretty.sha256sum] = "1723f7430b4e50fe2bd351ca7c44524427ddfa36ee99e6754eb42a123055241d"

URI_x86_64_v2_ghc9.10-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-devel-1.1.3.6-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.10-pretty-devel.sha256sum] = "41a5d85b75dd0c40d483182df42b4b8b7077c0b1c04592f526a738da4e8b8fad"

URI_x86_64_v2_ghc9.10-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-doc-1.1.3.6-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.10-pretty-doc.sha256sum] = "4dd4232af227bb5bec92d43b743bf39624ac94d8c6f192a12790cab84fc1ec8c"

URI_x86_64_v2_ghc9.10-pretty-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-prof-1.1.3.6-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty-prof}"
SRC_URI[x86_64_v2_ghc9.10-pretty-prof.sha256sum] = "e97782183c8d8c332f7da76312cc9b5e876f6a3a14f657f63829942b8342918e"

URI_x86_64_v2_ghc9.10-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-1.6.25.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process}"
SRC_URI[x86_64_v2_ghc9.10-process.sha256sum] = "a527f97c1bedb4376eabc19c12ddc61e3d5ae74ec8bdfc6c9733504d9f50c5da"

URI_x86_64_v2_ghc9.10-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-devel-1.6.25.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process-devel}"
SRC_URI[x86_64_v2_ghc9.10-process-devel.sha256sum] = "67a63a94bbbb4ebb299d1d6117dabb08da0a1522c58defc11db71fb85e09d8c3"

URI_x86_64_v2_ghc9.10-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-doc-1.6.25.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process-doc}"
SRC_URI[x86_64_v2_ghc9.10-process-doc.sha256sum] = "084691fc6429ba08de9611aff4b6f0d0ffc9e2d54db601c9d8a9ea8c58fab738"

URI_x86_64_v2_ghc9.10-process-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-prof-1.6.25.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-process-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process-prof}"
SRC_URI[x86_64_v2_ghc9.10-process-prof.sha256sum] = "ff12b26ae760512c00ef75c91bba54d8923f5927c000a9994d59e465e638923b"

URI_x86_64_v2_ghc9.10-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-prof-9.10.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-prof}"
SRC_URI[x86_64_v2_ghc9.10-prof.sha256sum] = "bb8bf2e3d2b9a520b9366c8f0aba6d580c828eb5062767d5fa7fd571e1a17ec2"

URI_x86_64_v2_ghc9.10-semaphore-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat.sha256sum] = "88880a6022364a610e1819aa166a8afd22dd8dc1505fbed9af9dbbc1aa4fac67"

URI_x86_64_v2_ghc9.10-semaphore-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-devel-1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat-devel}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat-devel.sha256sum] = "10622c5ede0d18378fd25510d6af9e147b199298cb5d1d35de9a8beba26e9119"

URI_x86_64_v2_ghc9.10-semaphore-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-doc-1.0.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat-doc}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat-doc.sha256sum] = "92ea225b79aefd914109c9c634ed350654f1a34bc2d0ea0045c5455ebc733780"

URI_x86_64_v2_ghc9.10-semaphore-compat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-prof-1.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat-prof}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat-prof.sha256sum] = "e36380fa009461d4d51445b8f2840002812e2a6091d66f166d3ad4e7a6f5dff1"

URI_x86_64_v2_ghc9.10-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-2.5.3.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm}"
SRC_URI[x86_64_v2_ghc9.10-stm.sha256sum] = "0503a6091d91f3d7d10d56a45da30d62401acac1a781a6eb9f243c468b5a079d"

URI_x86_64_v2_ghc9.10-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-devel-2.5.3.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm-devel}"
SRC_URI[x86_64_v2_ghc9.10-stm-devel.sha256sum] = "46cadc08eac7d86dd0e37e867fc37c883acd1b56b1888c7a976f9e6121cc3aef"

URI_x86_64_v2_ghc9.10-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-doc-2.5.3.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm-doc}"
SRC_URI[x86_64_v2_ghc9.10-stm-doc.sha256sum] = "6597b82d2d624e430b87f7d57621704642fe7e4ead1e8339a3f5568567778f8f"

URI_x86_64_v2_ghc9.10-stm-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-prof-2.5.3.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-stm-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm-prof}"
SRC_URI[x86_64_v2_ghc9.10-stm-prof.sha256sum] = "788a42abbd03dfdf4ba876fb80b6739e3d16867076dc1c4c4a690ad746faefc5"

URI_x86_64_v2_ghc9.10-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-2.22.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell.sha256sum] = "0beb71667cd6cdf7ff6fcf92ffae99d9d6f21e836f00229754898209773f4f63"

URI_x86_64_v2_ghc9.10-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-devel-2.22.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell-devel.sha256sum] = "0700aa252054491a64676438653f56d8d5772917443130f54090e84e7b132f99"

URI_x86_64_v2_ghc9.10-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-doc-2.22.0.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell-doc.sha256sum] = "ff0b94a7bb46565aca51ebed4eae17c194bac0cc57e04fb118cdf3ad915f9700"

URI_x86_64_v2_ghc9.10-template-haskell-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-prof-2.22.0.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell-prof}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell-prof.sha256sum] = "fea7e5d7eb8289639018784b611d95733a0631e1f7fc5416235d04682c7d9c2f"

URI_x86_64_v2_ghc9.10-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-0.4.1.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo}"
SRC_URI[x86_64_v2_ghc9.10-terminfo.sha256sum] = "87416b9044cec9b6c06058e6f55256ebf85fd1a15632850d32d474c9595aa629"

URI_x86_64_v2_ghc9.10-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-devel-0.4.1.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.10-terminfo-devel.sha256sum] = "9568b4d8262150c74cb0dcd2d565ffc09c9382632448a6554bb1bf7c6fbc15f0"

URI_x86_64_v2_ghc9.10-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-doc-0.4.1.7-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.10-terminfo-doc.sha256sum] = "dbde5c4049e208ce33743346ea3c7a50b06c5a5dfb4d611d027c3e2bf2a1d482"

URI_x86_64_v2_ghc9.10-terminfo-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-prof-0.4.1.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo-prof}"
SRC_URI[x86_64_v2_ghc9.10-terminfo-prof.sha256sum] = "bd361c2301c6a6050d6dbf57964efda187fec747555080efe7e5a3f8a70b4143"

URI_x86_64_v2_ghc9.10-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-2.1.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text}"
SRC_URI[x86_64_v2_ghc9.10-text.sha256sum] = "a118568966c0040afe83e6c3b83d5a81187e97b68f6f101df070231a59963da8"

URI_x86_64_v2_ghc9.10-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-devel-2.1.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text-devel}"
SRC_URI[x86_64_v2_ghc9.10-text-devel.sha256sum] = "b75306ae19552f3dde67aeb09a1246ca12360a94cfa8a2d7831d66b4f90c6c95"

URI_x86_64_v2_ghc9.10-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-doc-2.1.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text-doc}"
SRC_URI[x86_64_v2_ghc9.10-text-doc.sha256sum] = "5aba5150d6c0164e69c8995d58059bb328b6a3c1d6b3f62d701cfb1c18504397"

URI_x86_64_v2_ghc9.10-text-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-prof-2.1.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-text-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text-prof}"
SRC_URI[x86_64_v2_ghc9.10-text-prof.sha256sum] = "2c93fd22fe5e40b9b213a1cfe37d34727acccfc6d1d469ed9e3405f352c424df"

URI_x86_64_v2_ghc9.10-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-1.12.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time}"
SRC_URI[x86_64_v2_ghc9.10-time.sha256sum] = "780d77dc3a5a12d3c7921f1665fd8b4e9bb140c9ac6831c922b105e9d20726a7"

URI_x86_64_v2_ghc9.10-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-devel-1.12.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time-devel}"
SRC_URI[x86_64_v2_ghc9.10-time-devel.sha256sum] = "51f1b455d337df82803452279e4fca3e23fc2ae4fcdba5a9ddd6a9f5fef0c9ec"

URI_x86_64_v2_ghc9.10-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-doc-1.12.2-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time-doc}"
SRC_URI[x86_64_v2_ghc9.10-time-doc.sha256sum] = "0e035f83f68a7fba5f1c2b78729890e3aa3f0a190b768b0d0c6052f311c0d57b"

URI_x86_64_v2_ghc9.10-time-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-prof-1.12.2-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-time-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time-prof}"
SRC_URI[x86_64_v2_ghc9.10-time-prof.sha256sum] = "2e3c86251129bb9399d6170822af0f74b917179de0628f8f37e39689befad984"

URI_x86_64_v2_ghc9.10-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-0.6.1.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers}"
SRC_URI[x86_64_v2_ghc9.10-transformers.sha256sum] = "989c9be7f9f829770ab32bce660b0eae4dd84bc2b41527ad1a5464e0fe63e29c"

URI_x86_64_v2_ghc9.10-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-devel-0.6.1.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.10-transformers-devel.sha256sum] = "3f143cf73264d7d6846281c8368dbdcd9ed419be30fdcd91528c4c53a5b9e450"

URI_x86_64_v2_ghc9.10-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-doc-0.6.1.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.10-transformers-doc.sha256sum] = "2058a253efa791bf189deb3767ebaf975e99b71faaf8ec63815beed353e42e2f"

URI_x86_64_v2_ghc9.10-transformers-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-prof-0.6.1.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers-prof}"
SRC_URI[x86_64_v2_ghc9.10-transformers-prof.sha256sum] = "046a10f69c7f4876ef6695da0b231fefff1c57b203782ea5700e6dcd5a3ffd76"

URI_x86_64_v2_ghc9.10-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-2.8.6.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix}"
SRC_URI[x86_64_v2_ghc9.10-unix.sha256sum] = "bb2ac41dd55f7ca8b8d7d9d77c60074e8d5e059ef05f69fc8b2c9ef76bfd9bbc"

URI_x86_64_v2_ghc9.10-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-devel-2.8.6.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix-devel}"
SRC_URI[x86_64_v2_ghc9.10-unix-devel.sha256sum] = "7d174e869455c5d6e6d61499e486a174f362f1b10d53e82b7c4a1afbc7a4b748"

URI_x86_64_v2_ghc9.10-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-doc-2.8.6.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix-doc}"
SRC_URI[x86_64_v2_ghc9.10-unix-doc.sha256sum] = "8b71fcbbc05ed0196a5c789c19b537318309080920f52683e8a9fd573c3a4ba9"

URI_x86_64_v2_ghc9.10-unix-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-prof-2.8.6.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-unix-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix-prof}"
SRC_URI[x86_64_v2_ghc9.10-unix-prof.sha256sum] = "12e5fa0ae032c2c61441ff94bcf41b51fb1d76084a9c006307b1d1d333ca41d5"

URI_x86_64_v2_ghc9.10-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-3000.2.2.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml}"
SRC_URI[x86_64_v2_ghc9.10-xhtml.sha256sum] = "5ef2143a06388139b4784732ddf86f6ba54b071d453ef03323b6abf2c667c20e"

URI_x86_64_v2_ghc9.10-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-devel-3000.2.2.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.10-xhtml-devel.sha256sum] = "794f2cdb19e553445e7ab2c7b33503fcf68cf7b325cf232081459574e427a4e3"

URI_x86_64_v2_ghc9.10-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-doc-3000.2.2.1-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.10-xhtml-doc.sha256sum] = "46d65d813516cd51bc7835291eb03397d999d0b2ae5058aad7be8d5a7a95ece1"

URI_x86_64_v2_ghc9.10-xhtml-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-prof-3000.2.2.1-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml-prof}"
SRC_URI[x86_64_v2_ghc9.10-xhtml-prof.sha256sum] = "525b1d592758efc060bb80020f0b71367287dfa67f80339d6192ebf7755db88b"

URI_aarch64_ghc9.10 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10}"
SRC_URI[aarch64_ghc9.10.sha256sum] = "81d95b15c89bb42f843d6e65125fdf75e6c5b7317b03ba7719460a240fe1d29c"

URI_aarch64_ghc9.10-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-3.12.1.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal}"
SRC_URI[aarch64_ghc9.10-Cabal.sha256sum] = "183d0084d8ee7b86deef6bb548e4480a08e337f880c0511d1d845c1fb4cffd3e"

URI_aarch64_ghc9.10-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-devel-3.12.1.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-devel}"
SRC_URI[aarch64_ghc9.10-Cabal-devel.sha256sum] = "a9684b24b10df4c0fdaab344f14d01a02274704ed033b90d89f51b8d7dda8862"

URI_aarch64_ghc9.10-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-doc-3.12.1.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-doc}"
SRC_URI[aarch64_ghc9.10-Cabal-doc.sha256sum] = "f0ac043ec8b2101da0e365b5fe9ad9cc06c5e14bbd9275029aecd8acb570ba10"

URI_aarch64_ghc9.10-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-prof-3.12.1.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-prof}"
SRC_URI[aarch64_ghc9.10-Cabal-prof.sha256sum] = "92f1b9dc376e079131a6da90e041e987d2bb2635ad643c6f787a0a349d9f61cf"

URI_aarch64_ghc9.10-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-3.12.1.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax.sha256sum] = "9b82a3f4051b41a2b11838fe443dd47b275ecbe6fb37c4607680025f802ce1db"

URI_aarch64_ghc9.10-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-devel-3.12.1.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax-devel.sha256sum] = "8d9d90f0e0c2b1d2ba9424f1036778eadefa3e31b80f22a001febe30597974f7"

URI_aarch64_ghc9.10-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-doc-3.12.1.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax-doc.sha256sum] = "fb0ebd7629eb5027434601dc58d6f3bc62cc991b87033c860f719e927f68a8bd"

URI_aarch64_ghc9.10-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-prof-3.12.1.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax-prof.sha256sum] = "cba7b4542788162eebeb61f25b7a532fbebd95c62985be726d2d200b7c9e6eb8"

URI_aarch64_ghc9.10-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-0.5.8.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array}"
SRC_URI[aarch64_ghc9.10-array.sha256sum] = "b04b43c3bb02aecbba5d43688ca6bbd15683508b3dfbda5b90748f6146ad49b5"

URI_aarch64_ghc9.10-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-devel-0.5.8.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array-devel}"
SRC_URI[aarch64_ghc9.10-array-devel.sha256sum] = "4e4cfde76093492821d0f42b2cd2deb5702a1bae817801fc3d47c9eb98dbe267"

URI_aarch64_ghc9.10-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-doc-0.5.8.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array-doc}"
SRC_URI[aarch64_ghc9.10-array-doc.sha256sum] = "d00ebf175c298d17dbacb21a0ad315111e49b22cf4534e447faa4f03020eab3b"

URI_aarch64_ghc9.10-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-prof-0.5.8.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array-prof}"
SRC_URI[aarch64_ghc9.10-array-prof.sha256sum] = "d773a657541592177f33b92a80b46c689aea6048429b1922b0cd18d2a46026b6"

URI_aarch64_ghc9.10-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-4.20.1.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base}"
SRC_URI[aarch64_ghc9.10-base.sha256sum] = "0bb6aef4ff05d866a69bac32b350b4992236f96b7a5aeef410914ae9545e96f9"

URI_aarch64_ghc9.10-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-devel-4.20.1.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base-devel}"
SRC_URI[aarch64_ghc9.10-base-devel.sha256sum] = "dbf89eb8ba57c6a0e6f9a26e06d3610b97bdef561777c2200df3055f447aa04c"

URI_aarch64_ghc9.10-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-doc-4.20.1.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base-doc}"
SRC_URI[aarch64_ghc9.10-base-doc.sha256sum] = "8a9337c1fbd26a96fbc0ae799ecc30ecbc90f483dac4a903e948b7508b16ed1f"

URI_aarch64_ghc9.10-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-prof-4.20.1.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base-prof}"
SRC_URI[aarch64_ghc9.10-base-prof.sha256sum] = "2304d028b30e7a45db87d13ece18087830e9631d360824e1e9c1de16d5649671"

URI_aarch64_ghc9.10-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-0.8.9.3-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary}"
SRC_URI[aarch64_ghc9.10-binary.sha256sum] = "394fcb4dd3cdcd903fc49f12b7c77ea114ac76996d9094d817d3579865fcae29"

URI_aarch64_ghc9.10-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-devel-0.8.9.3-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary-devel}"
SRC_URI[aarch64_ghc9.10-binary-devel.sha256sum] = "48ec395c7b5314b990b58dd362684a3af13825d95d0a3bbe9ce45cabedab44ee"

URI_aarch64_ghc9.10-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-doc-0.8.9.3-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary-doc}"
SRC_URI[aarch64_ghc9.10-binary-doc.sha256sum] = "b4517563875612b5d548b751fec740c1035b2e47470e1633a23f72419a3310ad"

URI_aarch64_ghc9.10-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-prof-0.8.9.3-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary-prof}"
SRC_URI[aarch64_ghc9.10-binary-prof.sha256sum] = "0c64854d738d352d1094f07ae9ee6316bcee39245b7ccdefccd59497e28c3bda"

URI_aarch64_ghc9.10-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-0.12.2.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring}"
SRC_URI[aarch64_ghc9.10-bytestring.sha256sum] = "c1bf5a157218631dd4e63cc0d0d95bf120b804cceba272c36d47be077ecbcbaf"

URI_aarch64_ghc9.10-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-devel-0.12.2.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring-devel}"
SRC_URI[aarch64_ghc9.10-bytestring-devel.sha256sum] = "6c3ff36867ba928c2cb1adc6574c433f47ff3c0fb3b95c3e21b957a0de356005"

URI_aarch64_ghc9.10-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-doc-0.12.2.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring-doc}"
SRC_URI[aarch64_ghc9.10-bytestring-doc.sha256sum] = "bfbb069da69d1c5f5d4beec50dfe6aad8e38e14fbd880433f780bca12f57e2cd"

URI_aarch64_ghc9.10-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-prof-0.12.2.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring-prof}"
SRC_URI[aarch64_ghc9.10-bytestring-prof.sha256sum] = "5b293af723b78149299a7a3a019eb66821957878234ec5fad5599697119404e7"

URI_aarch64_ghc9.10-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-compiler-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-compiler}"
SRC_URI[aarch64_ghc9.10-compiler.sha256sum] = "eb02b34ebcad2ba9798fd8a248e32680c4cfc213fcdc7089dfe1d15912c6f81a"

URI_aarch64_ghc9.10-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-compiler-default-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-compiler-default}"
SRC_URI[aarch64_ghc9.10-compiler-default.sha256sum] = "771d6e9c9cf962fb88b42493053cdf5f7fc31c57cdab672b0ece56237b55012a"

URI_aarch64_ghc9.10-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-0.7-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers}"
SRC_URI[aarch64_ghc9.10-containers.sha256sum] = "45cb09d79cb44845130f16be2d6c250e891545c98fcf625792f16d3e685be340"

URI_aarch64_ghc9.10-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-devel-0.7-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers-devel}"
SRC_URI[aarch64_ghc9.10-containers-devel.sha256sum] = "a90d4938902dcf813e29f0da148b95eed71d66edfd1150ad7e2f226a125f3ac9"

URI_aarch64_ghc9.10-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-doc-0.7-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers-doc}"
SRC_URI[aarch64_ghc9.10-containers-doc.sha256sum] = "8546a1cd577081ea4d414a8228f8ca725cb371033808e2a9dd8bdad28c1afcc2"

URI_aarch64_ghc9.10-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-prof-0.7-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers-prof}"
SRC_URI[aarch64_ghc9.10-containers-prof.sha256sum] = "4c3c586bf45fa680abfd7d7ca5440161861770b4f61c8909260cae75e77e3f18"

URI_aarch64_ghc9.10-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-1.5.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq}"
SRC_URI[aarch64_ghc9.10-deepseq.sha256sum] = "42429dbbacdc287c6144405e8226897824ca6a43bc34449a4dab55486fac20cb"

URI_aarch64_ghc9.10-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-devel-1.5.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq-devel}"
SRC_URI[aarch64_ghc9.10-deepseq-devel.sha256sum] = "60ec51eae84c0b8b37c87a233e47aee50e55c296d42f7af42ee35f41ab385470"

URI_aarch64_ghc9.10-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-doc-1.5.0.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq-doc}"
SRC_URI[aarch64_ghc9.10-deepseq-doc.sha256sum] = "66465294072eb03ef474f6118293dbef0423c39696a57036febe0780c9175292"

URI_aarch64_ghc9.10-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-prof-1.5.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq-prof}"
SRC_URI[aarch64_ghc9.10-deepseq-prof.sha256sum] = "f10d9cdcf786804b13d560ea3565b879104f6ca8a80236284154dcfa145d6dda"

URI_aarch64_ghc9.10-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-devel-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-devel}"
SRC_URI[aarch64_ghc9.10-devel.sha256sum] = "e29c77ffc5e43a529c45e1c2ed1d519e3bdfdc1ad4bd4399718acafb87af84a5"

URI_aarch64_ghc9.10-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-1.3.8.5-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory}"
SRC_URI[aarch64_ghc9.10-directory.sha256sum] = "f217464ce5a743abe09f6faf5c85ca134b5890345650b7eb296b390dbc867ac1"

URI_aarch64_ghc9.10-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-devel-1.3.8.5-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory-devel}"
SRC_URI[aarch64_ghc9.10-directory-devel.sha256sum] = "66bf240cfaf457189c4e08d7c94792fd6342043d59784887fd8831feed740ba3"

URI_aarch64_ghc9.10-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-doc-1.3.8.5-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory-doc}"
SRC_URI[aarch64_ghc9.10-directory-doc.sha256sum] = "d633c3f0f40a2b33f4770a967184b0aaa52c9788e7ebf4084addf7f201410e76"

URI_aarch64_ghc9.10-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-prof-1.3.8.5-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory-prof}"
SRC_URI[aarch64_ghc9.10-directory-prof.sha256sum] = "fd3181110e0ae3f035cd3fb2557dde72fcabf33c3f8240ec46f159618a544852"

URI_aarch64_ghc9.10-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-doc-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-doc}"
SRC_URI[aarch64_ghc9.10-doc.sha256sum] = "06e522f0c976787b9f49b0e8fca8b499fb29583e7a5c6dbb1720c6faa7cd75f1"

URI_aarch64_ghc9.10-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-doc-index-9.10.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-doc-index}"
SRC_URI[aarch64_ghc9.10-doc-index.sha256sum] = "4bd6c76891b477b64dfb55b888dd705443e4d5c76c52e96db77897e404bb667a"

URI_aarch64_ghc9.10-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-0.10.9-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions}"
SRC_URI[aarch64_ghc9.10-exceptions.sha256sum] = "708a6f62314fa47283f5fa442cc07e35e1968413c4ceb36b577943c5e3389628"

URI_aarch64_ghc9.10-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-devel-0.10.9-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions-devel}"
SRC_URI[aarch64_ghc9.10-exceptions-devel.sha256sum] = "e7d1e63bb3c7384e2f303eb0eab56f7beff859319efb74daefe1abd799924f24"

URI_aarch64_ghc9.10-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-doc-0.10.9-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions-doc}"
SRC_URI[aarch64_ghc9.10-exceptions-doc.sha256sum] = "dcfd62fd438958ef1a287a0419e1b620ab3e8ec44a6b011263ae933d9da7c20a"

URI_aarch64_ghc9.10-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-prof-0.10.9-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions-prof}"
SRC_URI[aarch64_ghc9.10-exceptions-prof.sha256sum] = "4515d2a4debfa2f7aa6bfa3b5a250a9fe2310330901d139de299a9881392e222"

URI_aarch64_ghc9.10-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-1.5.4.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath}"
SRC_URI[aarch64_ghc9.10-filepath.sha256sum] = "cc61e3eb7d9a0666db2b9df7bee4ae7e2309c1c601669146a7cb9987cfc642c0"

URI_aarch64_ghc9.10-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-devel-1.5.4.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath-devel}"
SRC_URI[aarch64_ghc9.10-filepath-devel.sha256sum] = "a49ab80a681c3a8b8f23f0d8aa36455911d36c997ffab1b7f9faa8d3fc18ddf9"

URI_aarch64_ghc9.10-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-doc-1.5.4.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath-doc}"
SRC_URI[aarch64_ghc9.10-filepath-doc.sha256sum] = "98e2fc0d844d524b129b3e5cd70bcb50b568873771ceeda76a56d8427a87a0f6"

URI_aarch64_ghc9.10-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-prof-1.5.4.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath-prof}"
SRC_URI[aarch64_ghc9.10-filepath-prof.sha256sum] = "26eb6ec20ed421be067771014923eb47600f2b44c3f099c1de267e5333255b9c"

URI_aarch64_ghc9.10-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filesystem-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filesystem}"
SRC_URI[aarch64_ghc9.10-filesystem.sha256sum] = "98211878bc306d5c0ace4173c23bc6755d3cba3f562304e83a1258a69ac44eec"

URI_aarch64_ghc9.10-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc}"
SRC_URI[aarch64_ghc9.10-ghc.sha256sum] = "c0e87b9ef1614762c007a584bf6f7a4e215bc78fe78205b0b0c05c7f1f5845f8"

URI_aarch64_ghc9.10-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-1.3-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum}"
SRC_URI[aarch64_ghc9.10-ghc-bignum.sha256sum] = "5f03f9e54e41c2e8a23d7fc5f050d9032a8c4c92e96a19b1ac0421a9233029c4"

URI_aarch64_ghc9.10-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-devel-1.3-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.10-ghc-bignum-devel.sha256sum] = "ae1a86f29e3433899296d6293d764712dceb62596da66f35eb92b7e57fe3f363"

URI_aarch64_ghc9.10-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-doc-1.3-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.10-ghc-bignum-doc.sha256sum] = "83073dee03cd22e9620c405447a43c5b6937653e18cffe620561683ee8ebb9bb"

URI_aarch64_ghc9.10-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-prof-1.3-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.10-ghc-bignum-prof.sha256sum] = "095c78ae207bd968856733cabdff6b5f4eecd2dfc2a76060a5eebe57cf991528"

URI_aarch64_ghc9.10-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot}"
SRC_URI[aarch64_ghc9.10-ghc-boot.sha256sum] = "f1551c792fd38e3ea7f8fefb56ef946343efd13cb404ad0f76746d51c076e4da"

URI_aarch64_ghc9.10-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-devel-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.10-ghc-boot-devel.sha256sum] = "c402ef7d5cc3c174b85cb71913852d82fdb0157fb934ba08e1caf617d76e60b2"

URI_aarch64_ghc9.10-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-doc-9.10.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.10-ghc-boot-doc.sha256sum] = "269b226c8884a63f3514e761688dac6169d7ad0212d75dc11bcb44fcb3c64f4c"

URI_aarch64_ghc9.10-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-prof-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.10-ghc-boot-prof.sha256sum] = "cf23979b1de209b2b920609ee9b007e9b406ca92073a1ddfb9522178c915f037"

URI_aarch64_ghc9.10-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th.sha256sum] = "7f39458438278913f210e072a949e101ae4d94f2a2e3e5b358fd4a32520d40d5"

URI_aarch64_ghc9.10-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-devel-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th-devel.sha256sum] = "cb19c552bcaa55eb6ea94d64b01aae7c755135121afbfe2ff52e49e3c5964d3c"

URI_aarch64_ghc9.10-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-doc-9.10.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th-doc.sha256sum] = "8cb82fe4e6bdd4d4e1146e24ac5547ad3e3acd7a04c603c1bd15eab83aac6e04"

URI_aarch64_ghc9.10-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-prof-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th-prof.sha256sum] = "4c51727ef10806c8bf9c42e1d58f0426c419310a3c2b98aea4a7e6475165f3b0"

URI_aarch64_ghc9.10-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact}"
SRC_URI[aarch64_ghc9.10-ghc-compact.sha256sum] = "2b4ea144845ea44141479a59415c0475977ef16c49b0fc3912b87ad6327faa7c"

URI_aarch64_ghc9.10-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-devel-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.10-ghc-compact-devel.sha256sum] = "3d2208576054f6734f7e9cd0b5ef0844a514490f50592297534921af90ac53e5"

URI_aarch64_ghc9.10-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-doc-0.1.0.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.10-ghc-compact-doc.sha256sum] = "a038152998cedde0f47ea52878780af2e9d8daa71fbb9b379512355aaefe00c6"

URI_aarch64_ghc9.10-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-prof-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.10-ghc-compact-prof.sha256sum] = "01a8ebc764f79fb0f695d21b32c5d59caeb16cbdf101bc12c250b60d6976cbea"

URI_aarch64_ghc9.10-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-devel-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-devel}"
SRC_URI[aarch64_ghc9.10-ghc-devel.sha256sum] = "8197d1809d78ddff2c20f299507991e80694c3c30d8344c2004f452ef02e7d50"

URI_aarch64_ghc9.10-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-doc-9.10.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-doc}"
SRC_URI[aarch64_ghc9.10-ghc-doc.sha256sum] = "445c06d0b239c868c69dd9e198de92b4bc70a0cdf0b652bffac384f918d08e01"

URI_aarch64_ghc9.10-ghc-experimental = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-9.1002.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental}"
SRC_URI[aarch64_ghc9.10-ghc-experimental.sha256sum] = "97694dc12ceff6a0fcd69c3aeb4c363e3d44fa6d98cabbd4df178cfeedfc444b"

URI_aarch64_ghc9.10-ghc-experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-devel-9.1002.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental-devel}"
SRC_URI[aarch64_ghc9.10-ghc-experimental-devel.sha256sum] = "cf09678f3304d32ac9a80ec44ba325c22731cee032ffe07893cf33646025a9ff"

URI_aarch64_ghc9.10-ghc-experimental-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-doc-9.1002.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental-doc}"
SRC_URI[aarch64_ghc9.10-ghc-experimental-doc.sha256sum] = "df5d4093cd7bc640ef25ca4d451d0697349aa96c9e27bf79bae00887881d5b32"

URI_aarch64_ghc9.10-ghc-experimental-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-prof-9.1002.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-experimental-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental-prof}"
SRC_URI[aarch64_ghc9.10-ghc-experimental-prof.sha256sum] = "c0f2d91cd902851805a9400d3a2ff6bb66a70cf0f083254638fd5d362e27a70e"

URI_aarch64_ghc9.10-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap}"
SRC_URI[aarch64_ghc9.10-ghc-heap.sha256sum] = "fa92ebdb751215e8a5a81ee9b6de3b14485c9ba8e0cd8344b868ea157ffcd89f"

URI_aarch64_ghc9.10-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-devel-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.10-ghc-heap-devel.sha256sum] = "de8ae3618e8edb4d15f043f986d7c1adb6333da6a13a4891a3b3715f75716fcf"

URI_aarch64_ghc9.10-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-doc-9.10.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.10-ghc-heap-doc.sha256sum] = "3e8e23208e301893865c1d139b60cdc99dc87a537a465e74574a6c8a5753bf56"

URI_aarch64_ghc9.10-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-prof-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.10-ghc-heap-prof.sha256sum] = "5033bc28e4ecf29ec4b9ed9f51010623089fb6501ae38d9f8a29604cd5de21d9"

URI_aarch64_ghc9.10-ghc-platform = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform}"
SRC_URI[aarch64_ghc9.10-ghc-platform.sha256sum] = "cf1c48ea2c979bed5a18a4938e11163b0bf889ed82cf772443885cbd9dbdbcc9"

URI_aarch64_ghc9.10-ghc-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-devel-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform-devel}"
SRC_URI[aarch64_ghc9.10-ghc-platform-devel.sha256sum] = "36f942bff28b2aaeb747baf48fcac4104d32f4a99bd37594db3c6cfd6e7a3ca5"

URI_aarch64_ghc9.10-ghc-platform-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-doc-0.1.0.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform-doc}"
SRC_URI[aarch64_ghc9.10-ghc-platform-doc.sha256sum] = "4c963915a5a9ff77679e18920a22971403bdd0e7e22e5052f7a9c5b6051ec91a"

URI_aarch64_ghc9.10-ghc-platform-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-prof-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-platform-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform-prof}"
SRC_URI[aarch64_ghc9.10-ghc-platform-prof.sha256sum] = "417d987807e9dc6030082374364dd14de5e95fbd30ae30cd16e62152e20dbc80"

URI_aarch64_ghc9.10-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-prof-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-prof}"
SRC_URI[aarch64_ghc9.10-ghc-prof.sha256sum] = "0eb9ebe0e96b09f7b81b8174c5d2ad44283921e18a76081d0d6d723011bee1d1"

URI_aarch64_ghc9.10-ghc-toolchain = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain.sha256sum] = "a0e3597ccf1e7471bc8fa84428356b95cfb80ea85c74026415bfbabd37c2beb4"

URI_aarch64_ghc9.10-ghc-toolchain-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-devel-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain-devel}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain-devel.sha256sum] = "adb63030a6f7636ccc3d22a6c49e71972372389098a521022945d1280d7cec1b"

URI_aarch64_ghc9.10-ghc-toolchain-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-doc-0.1.0.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain-doc}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain-doc.sha256sum] = "f8c48ea46a404d727f7e3caddf635ebd49c7bb0f7a35dcf818b8b0b81bfcb4a7"

URI_aarch64_ghc9.10-ghc-toolchain-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-prof-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghc-toolchain-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain-prof}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain-prof.sha256sum] = "f5d8fc9d7e9cb5412414ee2c74fb62086c0023e0f5b766b35f12ec81c96cb1ff"

URI_aarch64_ghc9.10-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci}"
SRC_URI[aarch64_ghc9.10-ghci.sha256sum] = "1e21821b3501f96edf5f78b65d2a49080d8b21f784275ae20ef41a976a8a2476"

URI_aarch64_ghc9.10-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-devel-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci-devel}"
SRC_URI[aarch64_ghc9.10-ghci-devel.sha256sum] = "60d5b517673fa5b114a1c45216948e1ce03aabb5e36278043e4e1349e4672df9"

URI_aarch64_ghc9.10-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-doc-9.10.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci-doc}"
SRC_URI[aarch64_ghc9.10-ghci-doc.sha256sum] = "75256eea8a82b3cf99db64f3d45fa08eb005b75c16e38078152b17d8aa0b6bdb"

URI_aarch64_ghc9.10-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-prof-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci-prof}"
SRC_URI[aarch64_ghc9.10-ghci-prof.sha256sum] = "4dd35a5df317708e2517fb25a6dd139341916190b22d95139863bfaef0a26bc2"

URI_aarch64_ghc9.10-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hadrian-0.1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hadrian}"
SRC_URI[aarch64_ghc9.10-hadrian.sha256sum] = "0c4f226230a0a0000848f5473aae7f46a163e5bf46a626597d68ca8cd2b5869b"

URI_aarch64_ghc9.10-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-0.8.2.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline}"
SRC_URI[aarch64_ghc9.10-haskeline.sha256sum] = "9de2fecdabd46e6915d292e99760c7fc6b466a76da8d60f249c344346d00880f"

URI_aarch64_ghc9.10-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-devel-0.8.2.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline-devel}"
SRC_URI[aarch64_ghc9.10-haskeline-devel.sha256sum] = "d1100af6a1da8a1b0afe238cb3fdfe4607199e804fdfddac5ee5ae80c010ca36"

URI_aarch64_ghc9.10-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-doc-0.8.2.1-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline-doc}"
SRC_URI[aarch64_ghc9.10-haskeline-doc.sha256sum] = "d774cb5a2931551778a7aa5213f932f7597c31f22b3a7b42a1b9559896d95ef5"

URI_aarch64_ghc9.10-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-prof-0.8.2.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline-prof}"
SRC_URI[aarch64_ghc9.10-haskeline-prof.sha256sum] = "6b97845d1a6b501de60acaa1b083a8653b9380d8a42f2b98060de35f51062a2a"

URI_aarch64_ghc9.10-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-0.7.0.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc}"
SRC_URI[aarch64_ghc9.10-hpc.sha256sum] = "7b8055afa46e875e1b83ef88291da708b9d4f2288cea04c4ca78dd9ef6ccf33c"

URI_aarch64_ghc9.10-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-devel-0.7.0.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc-devel}"
SRC_URI[aarch64_ghc9.10-hpc-devel.sha256sum] = "b5e2d55d1d8d68e2b95934bf570e27ec051863f9e9e6ecb8421527ef6e162365"

URI_aarch64_ghc9.10-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-doc-0.7.0.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc-doc}"
SRC_URI[aarch64_ghc9.10-hpc-doc.sha256sum] = "9957c3f057781e96fc94e355bab45f04e60bbd9a774ea6a960a2346abb941c28"

URI_aarch64_ghc9.10-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-prof-0.7.0.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc-prof}"
SRC_URI[aarch64_ghc9.10-hpc-prof.sha256sum] = "e3726e3ae3f6c4adad2177b5cb6e219b520f263f8ffb2902f667beb7a307fdf1"

URI_aarch64_ghc9.10-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-manual-9.10.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-manual}"
SRC_URI[aarch64_ghc9.10-manual.sha256sum] = "30cd6cbb66725842c700336b42d77822cb2074111166c4137cca8eac52a694c2"

URI_aarch64_ghc9.10-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-2.3.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl}"
SRC_URI[aarch64_ghc9.10-mtl.sha256sum] = "975b7ccb480184f2edc9b74becc388a89b75ecced6e2aae45dfb51bda41d00b0"

URI_aarch64_ghc9.10-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-devel-2.3.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl-devel}"
SRC_URI[aarch64_ghc9.10-mtl-devel.sha256sum] = "2945491fe3a7dfbe3a764ff24271ce5e324d2ecab2f8c8e28cbd855d9cd62be1"

URI_aarch64_ghc9.10-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-doc-2.3.1-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl-doc}"
SRC_URI[aarch64_ghc9.10-mtl-doc.sha256sum] = "8d53cd7853f4d1a029ac69b0e9241ca306e2da548d94c8085441a1b3aaf87083"

URI_aarch64_ghc9.10-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-prof-2.3.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl-prof}"
SRC_URI[aarch64_ghc9.10-mtl-prof.sha256sum] = "dc071f6cb11b8e23f1358dee59bd31b90e157261574ab6cba17ca42719b7f8cf"

URI_aarch64_ghc9.10-os-string = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-2.0.4-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-os-string;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string}"
SRC_URI[aarch64_ghc9.10-os-string.sha256sum] = "f99dcd18b7df3bd1ebdf9a0497ad5462d9be032420d6a216cc94d164663316c8"

URI_aarch64_ghc9.10-os-string-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-devel-2.0.4-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string-devel}"
SRC_URI[aarch64_ghc9.10-os-string-devel.sha256sum] = "afaa498657cafd4f621723ee3172a8784fa3b5542fcbb70e1ab683b2217386f4"

URI_aarch64_ghc9.10-os-string-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-doc-2.0.4-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string-doc}"
SRC_URI[aarch64_ghc9.10-os-string-doc.sha256sum] = "5357c0094e43c1cb36f70349afec2e8d1eb7f17ad67e4008ef244ececffa16da"

URI_aarch64_ghc9.10-os-string-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-prof-2.0.4-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string-prof}"
SRC_URI[aarch64_ghc9.10-os-string-prof.sha256sum] = "db2824d0045ac957f120d9b42cd44e19bcae83540d0b2def57fa4228ccd79e0e"

URI_aarch64_ghc9.10-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-3.1.18.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec}"
SRC_URI[aarch64_ghc9.10-parsec.sha256sum] = "5b4b8eaf705c177ddda8487a0b97bb38fa651b1f2dc7ceb7d8b988e0b94f77ab"

URI_aarch64_ghc9.10-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-devel-3.1.18.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec-devel}"
SRC_URI[aarch64_ghc9.10-parsec-devel.sha256sum] = "c2a6708dc41a23b540a5d153f9b62f1e0545bed4a86b5ed928471f3af5497f15"

URI_aarch64_ghc9.10-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-doc-3.1.18.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec-doc}"
SRC_URI[aarch64_ghc9.10-parsec-doc.sha256sum] = "3e9d810be719c3ea5e4fb4bb9668f70c0973261a0a19c5e0db60fd3f4ac3b972"

URI_aarch64_ghc9.10-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-prof-3.1.18.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec-prof}"
SRC_URI[aarch64_ghc9.10-parsec-prof.sha256sum] = "a75a13833b64e1be169e78b8ff7c8311d8d5a75718cb12785fe202b413890fbf"

URI_aarch64_ghc9.10-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-1.1.3.6-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty}"
SRC_URI[aarch64_ghc9.10-pretty.sha256sum] = "94f2832bbc784cd2d2da0cef8baba4a148b2504e6a56a695fb898104d07ae84e"

URI_aarch64_ghc9.10-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-devel-1.1.3.6-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty-devel}"
SRC_URI[aarch64_ghc9.10-pretty-devel.sha256sum] = "8a644eb095bd36fd5502517a02d39495439bc5427a94ddd4f7d90fd88c4e9ef3"

URI_aarch64_ghc9.10-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-doc-1.1.3.6-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty-doc}"
SRC_URI[aarch64_ghc9.10-pretty-doc.sha256sum] = "a4c50cabc5705b59739ea6d1e356c26d61d28d704154b9f0bc443a37df6ac706"

URI_aarch64_ghc9.10-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-prof-1.1.3.6-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty-prof}"
SRC_URI[aarch64_ghc9.10-pretty-prof.sha256sum] = "2f734f04d9c539153ad5e7667b90418f75fbf37637a76560b63200d14a617b3e"

URI_aarch64_ghc9.10-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-1.6.25.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process}"
SRC_URI[aarch64_ghc9.10-process.sha256sum] = "7e5d402baaf4860465cfe73fb94e47128dc5d62a21356161bba0f79de1873e7b"

URI_aarch64_ghc9.10-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-devel-1.6.25.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process-devel}"
SRC_URI[aarch64_ghc9.10-process-devel.sha256sum] = "8e2f92f2795b26b907b62b454b4dfcbaa1ee4ec13550c003450235d89c8c7bac"

URI_aarch64_ghc9.10-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-doc-1.6.25.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process-doc}"
SRC_URI[aarch64_ghc9.10-process-doc.sha256sum] = "656fa0843a886086997dc483738db72d2a672bf023b8da2f6a3b522b627ffead"

URI_aarch64_ghc9.10-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-prof-1.6.25.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process-prof}"
SRC_URI[aarch64_ghc9.10-process-prof.sha256sum] = "743a89e39d7984894b1b17600756dbc553a6796a4c1cd679d7cae0bd75325653"

URI_aarch64_ghc9.10-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-prof-9.10.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-prof}"
SRC_URI[aarch64_ghc9.10-prof.sha256sum] = "b8f431d37d0397473ed4c915cfc5ddbdfc11285f5ab24eb4de13517e9531754d"

URI_aarch64_ghc9.10-semaphore-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat}"
SRC_URI[aarch64_ghc9.10-semaphore-compat.sha256sum] = "661f489c45ecc9025edc0c53a35186d855d0175ba0cf44940a736da5132b6020"

URI_aarch64_ghc9.10-semaphore-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-devel-1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat-devel}"
SRC_URI[aarch64_ghc9.10-semaphore-compat-devel.sha256sum] = "ee3747d79235c076db6e3b85e0a0d1b5e54e1415d4708738c4aaa75a4c9fee0e"

URI_aarch64_ghc9.10-semaphore-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-doc-1.0.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat-doc}"
SRC_URI[aarch64_ghc9.10-semaphore-compat-doc.sha256sum] = "2afa918f13e3e71176fd8519eee002f1e862b8b0837aab80a4147ec861cece88"

URI_aarch64_ghc9.10-semaphore-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-prof-1.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat-prof}"
SRC_URI[aarch64_ghc9.10-semaphore-compat-prof.sha256sum] = "9f2866b5273ebbd3766ec068f783c82090da230039cdea18c3daf1e0adf52d93"

URI_aarch64_ghc9.10-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-2.5.3.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm}"
SRC_URI[aarch64_ghc9.10-stm.sha256sum] = "94270be595a2d6a2a345e10d0c45273432114c6602069bdb73da8e71ac257913"

URI_aarch64_ghc9.10-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-devel-2.5.3.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm-devel}"
SRC_URI[aarch64_ghc9.10-stm-devel.sha256sum] = "9c756d016a7b9078121eeb5837d7e53adca635517d1135d1b5863037207ecc7a"

URI_aarch64_ghc9.10-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-doc-2.5.3.1-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm-doc}"
SRC_URI[aarch64_ghc9.10-stm-doc.sha256sum] = "8b6243bc2ec17f110c1f739137eed7de5035bb60759e16f02743fa0d0c8823cf"

URI_aarch64_ghc9.10-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-prof-2.5.3.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm-prof}"
SRC_URI[aarch64_ghc9.10-stm-prof.sha256sum] = "e3ebcaa4752c06b0730657ccd1c3c84e7d55a37a026065e794a9306cffa19953"

URI_aarch64_ghc9.10-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-2.22.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell}"
SRC_URI[aarch64_ghc9.10-template-haskell.sha256sum] = "bcd6fb7773c030fa2716a76557cbce72c24b119ee672094f665774de12ea0368"

URI_aarch64_ghc9.10-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-devel-2.22.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell-devel}"
SRC_URI[aarch64_ghc9.10-template-haskell-devel.sha256sum] = "b390d0e37278ff28d4ebe72548ae83b8074ce73e1998a750121db6b5778077c6"

URI_aarch64_ghc9.10-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-doc-2.22.0.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell-doc}"
SRC_URI[aarch64_ghc9.10-template-haskell-doc.sha256sum] = "bb07982b8b45feaeeb104e381e25b1b0d3f01d367c440d2384e57bd64a5577f0"

URI_aarch64_ghc9.10-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-prof-2.22.0.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell-prof}"
SRC_URI[aarch64_ghc9.10-template-haskell-prof.sha256sum] = "4125e9a1fcaa9be01da581daaeddd31779a89a3afcf3fbe8c5c5daa9f65073f2"

URI_aarch64_ghc9.10-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-0.4.1.7-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo}"
SRC_URI[aarch64_ghc9.10-terminfo.sha256sum] = "0b3a01057d4537de6b0dcc472c7f4439cc5f1ef642e7085b0fc5ccf5023e050e"

URI_aarch64_ghc9.10-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-devel-0.4.1.7-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo-devel}"
SRC_URI[aarch64_ghc9.10-terminfo-devel.sha256sum] = "ca3101be4092573704e7c39977c6bc4c982a602b14b5e7d85e98bd50daf4f8d7"

URI_aarch64_ghc9.10-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-doc-0.4.1.7-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo-doc}"
SRC_URI[aarch64_ghc9.10-terminfo-doc.sha256sum] = "054d545044e9ca77ce11a24712b98548c257cd3dae5c4ba1e0a6d837f9646bb6"

URI_aarch64_ghc9.10-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-prof-0.4.1.7-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo-prof}"
SRC_URI[aarch64_ghc9.10-terminfo-prof.sha256sum] = "e325d1c6ed1db10fb7816c855349229a7284698da480135f355eb85dfde05e53"

URI_aarch64_ghc9.10-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-2.1.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text}"
SRC_URI[aarch64_ghc9.10-text.sha256sum] = "40d9b3a5a3c1c32d894f80463c205ed0c2beb557607fa48c314f0a1265400eb8"

URI_aarch64_ghc9.10-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-devel-2.1.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text-devel}"
SRC_URI[aarch64_ghc9.10-text-devel.sha256sum] = "dc1b6379ba869aafd12e5988431df66569b966bc98f93e52e9e9576a64f40d38"

URI_aarch64_ghc9.10-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-doc-2.1.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text-doc}"
SRC_URI[aarch64_ghc9.10-text-doc.sha256sum] = "66c7e5a981e3b1ee93199afcdf584e6a5690f535b19b33de0b0cc14328289e9f"

URI_aarch64_ghc9.10-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-prof-2.1.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text-prof}"
SRC_URI[aarch64_ghc9.10-text-prof.sha256sum] = "3bcbbc34c99b1d0113fdbc304936000e9dc0f250842f9786853286e19780ca94"

URI_aarch64_ghc9.10-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-1.12.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time}"
SRC_URI[aarch64_ghc9.10-time.sha256sum] = "0899a5c3024a2a723bc2e3d24281c4cc953892e508ac60b70cf95718fd8164f7"

URI_aarch64_ghc9.10-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-devel-1.12.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time-devel}"
SRC_URI[aarch64_ghc9.10-time-devel.sha256sum] = "55ff2db0ae87e120e73df1b1d4add5908ed3a9aea6a1b0976d21cdef8f6b18aa"

URI_aarch64_ghc9.10-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-doc-1.12.2-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time-doc}"
SRC_URI[aarch64_ghc9.10-time-doc.sha256sum] = "e915f37581f08ddb089a05a21ae254ddf7d5a122b625939cd050a3613d02e7c7"

URI_aarch64_ghc9.10-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-prof-1.12.2-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time-prof}"
SRC_URI[aarch64_ghc9.10-time-prof.sha256sum] = "337cef1bfd0b6e46736f3f1a12f15953d9f0ceaf5e6b5e974ab49b9bc34f97f5"

URI_aarch64_ghc9.10-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-0.6.1.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers}"
SRC_URI[aarch64_ghc9.10-transformers.sha256sum] = "eb34e2313b5204b70eeab124398c8f2bdd8b51c01dfedb2bb5585f7943b5b1d6"

URI_aarch64_ghc9.10-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-devel-0.6.1.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers-devel}"
SRC_URI[aarch64_ghc9.10-transformers-devel.sha256sum] = "54d53366d8279cf605ade4ec38015fb37dc52cdd64e3009b2e0f025b16a64111"

URI_aarch64_ghc9.10-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-doc-0.6.1.1-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers-doc}"
SRC_URI[aarch64_ghc9.10-transformers-doc.sha256sum] = "45fc640c5d4d4f206e6223a3eb4f269091e0edc8b2b46972c9f590402a7e2898"

URI_aarch64_ghc9.10-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-prof-0.6.1.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers-prof}"
SRC_URI[aarch64_ghc9.10-transformers-prof.sha256sum] = "dc6680a278ed5666ba3077c5fb92111c490e75519fd642c2af6c85cbc7bbf6fe"

URI_aarch64_ghc9.10-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-2.8.6.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix}"
SRC_URI[aarch64_ghc9.10-unix.sha256sum] = "7b82e26f7fc289b68f39e95878dac1b527c19e18737ad31eb0728e4c25c65c5e"

URI_aarch64_ghc9.10-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-devel-2.8.6.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix-devel}"
SRC_URI[aarch64_ghc9.10-unix-devel.sha256sum] = "84c31785034d235a29fe110e3457f57f74851f4370c5ca88626922e8d03abf2c"

URI_aarch64_ghc9.10-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-doc-2.8.6.0-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix-doc}"
SRC_URI[aarch64_ghc9.10-unix-doc.sha256sum] = "59655ed926c811310d073265f459f50378f91cf203cb86aaba73a173633c418f"

URI_aarch64_ghc9.10-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-prof-2.8.6.0-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix-prof}"
SRC_URI[aarch64_ghc9.10-unix-prof.sha256sum] = "7140bf30112896e9f4532eea56636087299ea40f841efb78443c3a939c22c6de"

URI_aarch64_ghc9.10-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-3000.2.2.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml}"
SRC_URI[aarch64_ghc9.10-xhtml.sha256sum] = "07d172ac0c55214757f5e41bdc07b53c8c59ff122b1968e65808d64ba3c1feb5"

URI_aarch64_ghc9.10-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-devel-3000.2.2.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml-devel}"
SRC_URI[aarch64_ghc9.10-xhtml-devel.sha256sum] = "7f8dad6b048d04ff69dd5200a935ec8332b06936eccf321e67c9885eed73a7c2"

URI_aarch64_ghc9.10-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-doc-3000.2.2.1-8.el10_0.noarch.rpm;name=aarch64_ghc9.10-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml-doc}"
SRC_URI[aarch64_ghc9.10-xhtml-doc.sha256sum] = "7e61948598df435062b8220188673aa3547685909ea2924dfe4240748b0298a6"

URI_aarch64_ghc9.10-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-prof-3000.2.2.1-8.el10_0.aarch64.rpm;name=aarch64_ghc9.10-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml-prof}"
SRC_URI[aarch64_ghc9.10-xhtml-prof.sha256sum] = "4bee449d3a6e2cb10d48b770f3907f3ae18562e5bfc1e951e6e4619660c4d518"

RDEPENDS:ghc9.10 = " \
 ghc9.10-compiler \
 ghc9.10-devel \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-compact-devel \
 ghc9.10-ghc-devel \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghci-devel \
 ghc9.10-hpc-devel \
 "
RDEPENDS:ghc9.10-Cabal = " \
 ghc9.10-Cabal-syntax \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-parsec \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-Cabal-devel = " \
 ghc9.10-Cabal \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-mtl-devel \
 ghc9.10-parsec-devel \
 ghc9.10-pretty-devel \
 ghc9.10-process-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-Cabal-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-Cabal-prof = " \
 ghc9.10-Cabal-devel \
 "
RDEPENDS:ghc9.10-Cabal-syntax = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-parsec \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-Cabal-syntax-devel = " \
 ghc9.10-Cabal-syntax \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-mtl-devel \
 ghc9.10-parsec-devel \
 ghc9.10-pretty-devel \
 ghc9.10-text-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-Cabal-syntax-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-Cabal-syntax-prof = " \
 ghc9.10-Cabal-syntax-devel \
 "
RDEPENDS:ghc9.10-array = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-array-devel = " \
 ghc9.10-array \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-array-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-array-prof = " \
 ghc9.10-array-devel \
 "
RDEPENDS:ghc9.10-base = " \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.10-base-devel = " \
 ghc9.10-base \
 ghc9.10-compiler \
 ghc9.10-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 numactl-devel \
 "
RDEPENDS:ghc9.10-base-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-base-prof = " \
 ghc9.10-base-devel \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.10-binary = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-binary-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 "
RDEPENDS:ghc9.10-binary-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-binary-prof = " \
 ghc9.10-binary-devel \
 "
RDEPENDS:ghc9.10-bytestring = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-bytestring-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-bytestring-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-bytestring-prof = " \
 ghc9.10-bytestring-devel \
 "
RDEPENDS:ghc9.10-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.10-Cabal \
 ghc9.10-Cabal-syntax \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-base-devel \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-filesystem \
 ghc9.10-ghc \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-platform \
 ghc9.10-ghc-toolchain \
 ghc9.10-ghci \
 ghc9.10-haskeline \
 ghc9.10-hpc \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-parsec \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-semaphore-compat \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-terminfo \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 ghc9.10-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 numactl-libs \
 "
RDEPENDS:ghc9.10-compiler-default = " \
 bash \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-containers = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-containers-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-containers \
 ghc9.10-deepseq-devel \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-containers-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-containers-prof = " \
 ghc9.10-containers-devel \
 "
RDEPENDS:ghc9.10-deepseq = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-deepseq-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq \
 "
RDEPENDS:ghc9.10-deepseq-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-deepseq-prof = " \
 ghc9.10-deepseq-devel \
 "
RDEPENDS:ghc9.10-devel = " \
 ghc9.10-Cabal-devel \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-haskeline-devel \
 ghc9.10-mtl-devel \
 ghc9.10-os-string-devel \
 ghc9.10-parsec-devel \
 ghc9.10-pretty-devel \
 ghc9.10-process-devel \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-stm-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-terminfo-devel \
 ghc9.10-text-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 ghc9.10-xhtml-devel \
 "
RDEPENDS:ghc9.10-directory = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-directory-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-directory \
 ghc9.10-filepath-devel \
 ghc9.10-os-string-devel \
 ghc9.10-time-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-directory-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-directory-prof = " \
 ghc9.10-directory-devel \
 "
RDEPENDS:ghc9.10-doc = " \
 "
RDEPENDS:ghc9.10-doc-index = " \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-exceptions = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-exceptions-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-exceptions \
 ghc9.10-mtl-devel \
 ghc9.10-stm-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-exceptions-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-exceptions-prof = " \
 ghc9.10-exceptions-devel \
 "
RDEPENDS:ghc9.10-filepath = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-filepath-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath \
 ghc9.10-os-string-devel \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-filepath-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-filepath-prof = " \
 ghc9.10-filepath-devel \
 "
RDEPENDS:ghc9.10-filesystem = " \
 "
RDEPENDS:ghc9.10-ghc = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-platform \
 ghc9.10-ghci \
 ghc9.10-hpc \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-semaphore-compat \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-bignum = " \
 ghc9.10-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-bignum-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-bignum \
 "
RDEPENDS:ghc9.10-ghc-bignum-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-bignum-prof = " \
 ghc9.10-ghc-bignum-devel \
 "
RDEPENDS:ghc9.10-ghc-boot = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-platform \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-boot-devel = " \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-ghc-platform-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-ghc-boot-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-boot-prof = " \
 ghc9.10-ghc-boot-devel \
 "
RDEPENDS:ghc9.10-ghc-boot-th = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-boot-th-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-boot-th \
 "
RDEPENDS:ghc9.10-ghc-boot-th-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-boot-th-prof = " \
 ghc9.10-ghc-boot-th-devel \
 "
RDEPENDS:ghc9.10-ghc-compact = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-compact-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-compact \
 "
RDEPENDS:ghc9.10-ghc-compact-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-compact-prof = " \
 ghc9.10-ghc-compact-devel \
 "
RDEPENDS:ghc9.10-ghc-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghci-devel \
 ghc9.10-hpc-devel \
 ghc9.10-process-devel \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-stm-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-ghc-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-experimental = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-experimental-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-experimental \
 "
RDEPENDS:ghc9.10-ghc-experimental-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-experimental-prof = " \
 ghc9.10-ghc-experimental-devel \
 "
RDEPENDS:ghc9.10-ghc-heap = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-heap-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-ghc-heap \
 "
RDEPENDS:ghc9.10-ghc-heap-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-heap-prof = " \
 ghc9.10-ghc-heap-devel \
 "
RDEPENDS:ghc9.10-ghc-platform = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-platform-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-platform \
 "
RDEPENDS:ghc9.10-ghc-platform-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-platform-prof = " \
 ghc9.10-ghc-platform-devel \
 "
RDEPENDS:ghc9.10-ghc-prof = " \
 ghc9.10-ghc-devel \
 "
RDEPENDS:ghc9.10-ghc-toolchain = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-platform \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-toolchain-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-platform-devel \
 ghc9.10-ghc-toolchain \
 ghc9.10-process-devel \
 ghc9.10-text-devel \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-ghc-toolchain-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-toolchain-prof = " \
 ghc9.10-ghc-toolchain-devel \
 "
RDEPENDS:ghc9.10-ghci = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-platform \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghci-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghci \
 ghc9.10-template-haskell-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-ghci-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghci-prof = " \
 ghc9.10-ghci-devel \
 "
RDEPENDS:ghc9.10-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.10-haskeline = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-terminfo \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.10-haskeline-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-directory-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath-devel \
 ghc9.10-haskeline \
 ghc9.10-process-devel \
 ghc9.10-stm-devel \
 ghc9.10-terminfo-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-haskeline-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-haskeline-prof = " \
 ghc9.10-haskeline-devel \
 "
RDEPENDS:ghc9.10-hpc = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-hpc-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-hpc \
 ghc9.10-time-devel \
 "
RDEPENDS:ghc9.10-hpc-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-hpc-prof = " \
 ghc9.10-hpc-devel \
 "
RDEPENDS:ghc9.10-manual = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-mtl = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-mtl-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-mtl \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-mtl-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-mtl-prof = " \
 ghc9.10-mtl-devel \
 "
RDEPENDS:ghc9.10-os-string = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-os-string-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-os-string \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-os-string-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-os-string-prof = " \
 ghc9.10-os-string-devel \
 "
RDEPENDS:ghc9.10-parsec = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-parsec-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-mtl-devel \
 ghc9.10-parsec \
 ghc9.10-text-devel \
 "
RDEPENDS:ghc9.10-parsec-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-parsec-prof = " \
 ghc9.10-parsec-devel \
 "
RDEPENDS:ghc9.10-pretty = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-pretty-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-pretty \
 "
RDEPENDS:ghc9.10-pretty-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-pretty-prof = " \
 ghc9.10-pretty-devel \
 "
RDEPENDS:ghc9.10-process = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-process-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-process \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-process-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-process-prof = " \
 ghc9.10-process-devel \
 "
RDEPENDS:ghc9.10-prof = " \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-semaphore-compat = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-semaphore-compat-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-exceptions-devel \
 ghc9.10-semaphore-compat \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-semaphore-compat-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-semaphore-compat-prof = " \
 ghc9.10-semaphore-compat-devel \
 "
RDEPENDS:ghc9.10-stm = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-stm-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-stm \
 "
RDEPENDS:ghc9.10-stm-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-stm-prof = " \
 ghc9.10-stm-devel \
 "
RDEPENDS:ghc9.10-template-haskell = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-template-haskell-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-pretty-devel \
 ghc9.10-template-haskell \
 "
RDEPENDS:ghc9.10-template-haskell-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-template-haskell-prof = " \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-terminfo = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.10-terminfo-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.10-terminfo-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-terminfo-prof = " \
 ghc9.10-terminfo-devel \
 "
RDEPENDS:ghc9.10-text = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-text-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-text \
 "
RDEPENDS:ghc9.10-text-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-text-prof = " \
 ghc9.10-text-devel \
 "
RDEPENDS:ghc9.10-time = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-time-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-time \
 "
RDEPENDS:ghc9.10-time-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-time-prof = " \
 ghc9.10-time-devel \
 "
RDEPENDS:ghc9.10-transformers = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-transformers-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-transformers \
 "
RDEPENDS:ghc9.10-transformers-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-transformers-prof = " \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-unix = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-unix-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-filepath-devel \
 ghc9.10-os-string-devel \
 ghc9.10-time-devel \
 ghc9.10-unix \
 "
RDEPENDS:ghc9.10-unix-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-unix-prof = " \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-xhtml = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-xhtml-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-xhtml \
 "
RDEPENDS:ghc9.10-xhtml-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-xhtml-prof = " \
 ghc9.10-xhtml-devel \
 "
