# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-netmap_sys"
PV = "0.1.4"
PR = "17.el10_1"
PACKAGES = " \
 rust-netmap_sys+default-devel \
 rust-netmap_sys+netmap_with_libs-devel \
 rust-netmap_sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-netmap_sys-0.1.4-17.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "507b788f923c7619210412d4e08cc43815c70a566a2494ba86c8e42a9bd0e1a6"

URI_x86_64_v2_rust-netmap_sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netmap_sys+default-devel-0.1.4-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netmap_sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netmap_sys+default-devel}"
SRC_URI[x86_64_v2_rust-netmap_sys+default-devel.sha256sum] = "6364de449af9900bae72a3af9e402ec0371110f92dd46e21b288958fceda4e9b"

URI_x86_64_v2_rust-netmap_sys+netmap_with_libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netmap_sys+netmap_with_libs-devel-0.1.4-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netmap_sys+netmap_with_libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netmap_sys+netmap_with_libs-devel}"
SRC_URI[x86_64_v2_rust-netmap_sys+netmap_with_libs-devel.sha256sum] = "55c46dec64b4b6b6d08a59d49ef0432a61eeac156b134803f3595048468820ac"

URI_x86_64_v2_rust-netmap_sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-netmap_sys-devel-0.1.4-17.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-netmap_sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-netmap_sys-devel}"
SRC_URI[x86_64_v2_rust-netmap_sys-devel.sha256sum] = "1e3450c0eedd765067b24a31a47fdeca3198583db635338ce74ac340f3a465f6"

URI_aarch64_rust-netmap_sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netmap_sys+default-devel-0.1.4-17.el10_1.noarch.rpm;name=aarch64_rust-netmap_sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netmap_sys+default-devel}"
SRC_URI[aarch64_rust-netmap_sys+default-devel.sha256sum] = "e57f6ede1519810339ec9ad0b6c6c58911168a555dcd1447b05b01ef321a1b5e"

URI_aarch64_rust-netmap_sys+netmap_with_libs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netmap_sys+netmap_with_libs-devel-0.1.4-17.el10_1.noarch.rpm;name=aarch64_rust-netmap_sys+netmap_with_libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netmap_sys+netmap_with_libs-devel}"
SRC_URI[aarch64_rust-netmap_sys+netmap_with_libs-devel.sha256sum] = "4c0027e0375d148dc36689d2eda43e6db825f0220efbf45975b6173ac0e457c6"

URI_aarch64_rust-netmap_sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-netmap_sys-devel-0.1.4-17.el10_1.noarch.rpm;name=aarch64_rust-netmap_sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-netmap_sys-devel}"
SRC_URI[aarch64_rust-netmap_sys-devel.sha256sum] = "63a570d2a8ae61a0c14c82ee6edc561e34d65b68598d93c4f70109909dd05701"

RDEPENDS:rust-netmap_sys+default-devel = " \
 cargo \
 rust-netmap_sys-devel \
 "
RDEPENDS:rust-netmap_sys+netmap_with_libs-devel = " \
 cargo \
 rust-netmap_sys-devel \
 "
RDEPENDS:rust-netmap_sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-libc+default-devel \
 "
