# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oci-seccomp-bpf-hook"
PV = "1.3.0"
PR = "2.el10"
PACKAGES = " \
 oci-seccomp-bpf-hook \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/oci-seccomp-bpf-hook-1.3.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f0eef965c3febb28a02740136922326a42f703e05a12b10ce4389b62ef780c68"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/oci-seccomp-bpf-hook-1.3.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_oci-seccomp-bpf-hook;unpack=0"
SRC_URI[x86_64_v2_oci-seccomp-bpf-hook.sha256sum] = "35c93f5b81f8b010789e726619f811e90685a59b15e337f769f2c65c09e257ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/oci-seccomp-bpf-hook-1.3.0-2.el10.aarch64.rpm;name=aarch64_oci-seccomp-bpf-hook;unpack=0"
SRC_URI[aarch64_oci-seccomp-bpf-hook.sha256sum] = "9ce6171787507cbec9d71cebc54c1b2cf3ec1ee96b4866bd5d269862e3d18411"

RDEPENDS:oci-seccomp-bpf-hook = " \
 bcc \
 glibc \
 libseccomp \
 "
