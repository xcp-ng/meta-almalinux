# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numpy"
PE = "1"
PV = "1.26.4"
PR = "5.el10"
PACKAGES = " \
 python3-numpy \
 python3-numpy-f2py \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/numpy-1.26.4-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4719e106f3f83e5d38cb5cd38189453204b2df283dc53a0aca680bfac23602da"

URI_x86_64_v2_python3-numpy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-numpy-1.26.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-numpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numpy}"
SRC_URI[x86_64_v2_python3-numpy.sha256sum] = "92164daf2c2c5b01e4720043292d6064924db3407d8a803df745843d028c3ba5"

URI_x86_64_v2_python3-numpy-f2py = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-numpy-f2py-1.26.4-5.el10.x86_64_v2.rpm;name=x86_64_v2_python3-numpy-f2py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numpy-f2py}"
SRC_URI[x86_64_v2_python3-numpy-f2py.sha256sum] = "71279cad50a296f5fa916b638c7f8366b392eb59182c605baaf67dfd3638eaf0"

URI_aarch64_python3-numpy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-numpy-1.26.4-5.el10.aarch64.rpm;name=aarch64_python3-numpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numpy}"
SRC_URI[aarch64_python3-numpy.sha256sum] = "f1b8a9cc2db01965f8c57c6225cb4332700443534f531aeae91a0cbfb70f00f3"

URI_aarch64_python3-numpy-f2py = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-numpy-f2py-1.26.4-5.el10.aarch64.rpm;name=aarch64_python3-numpy-f2py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numpy-f2py}"
SRC_URI[aarch64_python3-numpy-f2py.sha256sum] = "953c39b57f9bb3afabe63f98bbf08609d0dc9cce42abaad8a3c991ff2f9c9ce6"

RDEPENDS:python3-numpy:x86_64_v2 = " \
 flexiblas-netlib \
 glibc \
 libstdc++ \
 python3 \
"
RDEPENDS:python3-numpy:aarch64 = " \
 flexiblas-netlib \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
"
RDEPENDS:python3-numpy-f2py = " \
 python3 \
 python3-devel \
 python3-numpy \
 "
