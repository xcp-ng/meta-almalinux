# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailcommon"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 mailcommon \
 mailcommon-devel \
 mailcommon-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mailcommon-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61cbd75e49091978bf2860779d13d7ae41e86a85a7061c854fc487457c49df12"

URI_x86_64_v2_mailcommon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon}"
SRC_URI[x86_64_v2_mailcommon.sha256sum] = "f34b4247b7a8c406311055faf84ef9b45dac61821bc13323a726ed0b53d8a298"

URI_x86_64_v2_mailcommon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailcommon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon-devel}"
SRC_URI[x86_64_v2_mailcommon-devel.sha256sum] = "62c33de7c4785d5011a4b3f822b77b5fdf119db6b34cafff3f0d4cb631a115c8"

URI_x86_64_v2_mailcommon-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailcommon-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mailcommon-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailcommon-doc}"
SRC_URI[x86_64_v2_mailcommon-doc.sha256sum] = "5ab0a9f46414948f2e1e66044e575de841eefb0e0232e4e52dc87d9eb4ce1c90"

URI_aarch64_mailcommon = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_mailcommon;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon}"
SRC_URI[aarch64_mailcommon.sha256sum] = "fda0138f384ee38770f6bf7a7aabfd137f86f8ed59a85256f583dd5a9adc3278"

URI_aarch64_mailcommon-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_mailcommon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon-devel}"
SRC_URI[aarch64_mailcommon-devel.sha256sum] = "fa4e5b1a0a1c7e644c1cc35e53d5736f4af1ba5cc992e7599ed915d483f7ce34"

URI_aarch64_mailcommon-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mailcommon-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_mailcommon-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailcommon-doc}"
SRC_URI[aarch64_mailcommon-doc.sha256sum] = "c20f27a560b0d045a43af96039d693c8d0a6ebc6293f81330a756ef8dd7e9aad"

RDEPENDS:mailcommon = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 glibc \
 gpgme2pp \
 kf6-karchive \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 kmime \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libkleo \
 libstdc++ \
 mailimporter \
 messagelib \
 pimcommon \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
RDEPENDS:mailcommon-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 mailcommon \
 messagelib-devel \
 pimcommon-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailcommon-doc = " \
 "
