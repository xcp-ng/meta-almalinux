# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "selinux-policy"
PV = "40.13.26"
PR = "1.el10"
PACKAGES = " \
 selinux-policy \
 selinux-policy-devel \
 selinux-policy-doc \
 selinux-policy-mls \
 selinux-policy-sandbox \
 selinux-policy-targeted \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/selinux-policy-40.13.26-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cf687d0bf3bc4380bdd798a893946d716fa3d8c81a26bc3fece8877c40a27f4"

URI_x86_64_v2_selinux-policy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-40.13.26-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy}"
SRC_URI[x86_64_v2_selinux-policy.sha256sum] = "8ebfbbd8b7cde1d7e10444fcec1620d77fef77653c3f599865ef4bbcd0b4793b"

URI_x86_64_v2_selinux-policy-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/selinux-policy-devel-40.13.26-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-devel}"
SRC_URI[x86_64_v2_selinux-policy-devel.sha256sum] = "adfaf0b76bec2cc8c62b567f80f76b158498899b2c83ad8a5c7c46b03eadea64"

URI_x86_64_v2_selinux-policy-doc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-doc-40.13.26-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-doc}"
SRC_URI[x86_64_v2_selinux-policy-doc.sha256sum] = "c00d3e587e25a3303fbce9374ce7f6f3889af2f8140e1a763b9a8e5981c6c2f4"

URI_x86_64_v2_selinux-policy-mls = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-mls-40.13.26-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-mls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-mls}"
SRC_URI[x86_64_v2_selinux-policy-mls.sha256sum] = "506b160121581fabe63049407cf645e5ae48fdb334cf151a755b5561f2246f38"
RPROVIDES:selinux-policy-mls:x86_64_v2 = "virtual/selinux-policy-any_eq_40.13.26-1.el10 virtual/selinux-policy-any_ge_40.13.26"

URI_x86_64_v2_selinux-policy-sandbox = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-sandbox-40.13.26-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-sandbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-sandbox}"
SRC_URI[x86_64_v2_selinux-policy-sandbox.sha256sum] = "c0c5232a6a82594e46ef3f4a90347b8cc63bb69e22f78026b7e904d47bc5baa1"

URI_x86_64_v2_selinux-policy-targeted = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/selinux-policy-targeted-40.13.26-1.el10.noarch.rpm;name=x86_64_v2_selinux-policy-targeted;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_selinux-policy-targeted}"
SRC_URI[x86_64_v2_selinux-policy-targeted.sha256sum] = "b3e61225d525c2c6372929cfb2b1c56134c19580617764f624b64f2806c253ec"
RPROVIDES:selinux-policy-targeted:x86_64_v2 = "virtual/selinux-policy-any_eq_40.13.26-1.el10 virtual/selinux-policy-any_ge_40.13.26"

URI_aarch64_selinux-policy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-40.13.26-1.el10.noarch.rpm;name=aarch64_selinux-policy;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy}"
SRC_URI[aarch64_selinux-policy.sha256sum] = "8ebfbbd8b7cde1d7e10444fcec1620d77fef77653c3f599865ef4bbcd0b4793b"

URI_aarch64_selinux-policy-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/selinux-policy-devel-40.13.26-1.el10.noarch.rpm;name=aarch64_selinux-policy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-devel}"
SRC_URI[aarch64_selinux-policy-devel.sha256sum] = "adfaf0b76bec2cc8c62b567f80f76b158498899b2c83ad8a5c7c46b03eadea64"

URI_aarch64_selinux-policy-doc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-doc-40.13.26-1.el10.noarch.rpm;name=aarch64_selinux-policy-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-doc}"
SRC_URI[aarch64_selinux-policy-doc.sha256sum] = "c00d3e587e25a3303fbce9374ce7f6f3889af2f8140e1a763b9a8e5981c6c2f4"

URI_aarch64_selinux-policy-mls = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-mls-40.13.26-1.el10.noarch.rpm;name=aarch64_selinux-policy-mls;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-mls}"
SRC_URI[aarch64_selinux-policy-mls.sha256sum] = "506b160121581fabe63049407cf645e5ae48fdb334cf151a755b5561f2246f38"
RPROVIDES:selinux-policy-mls:aarch64 = "virtual/selinux-policy-any_eq_40.13.26-1.el10 virtual/selinux-policy-any_ge_40.13.26"

URI_aarch64_selinux-policy-sandbox = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-sandbox-40.13.26-1.el10.noarch.rpm;name=aarch64_selinux-policy-sandbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-sandbox}"
SRC_URI[aarch64_selinux-policy-sandbox.sha256sum] = "c0c5232a6a82594e46ef3f4a90347b8cc63bb69e22f78026b7e904d47bc5baa1"

URI_aarch64_selinux-policy-targeted = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/selinux-policy-targeted-40.13.26-1.el10.noarch.rpm;name=aarch64_selinux-policy-targeted;unpack=0"
SRC_URI:append = " ${URI_aarch64_selinux-policy-targeted}"
SRC_URI[aarch64_selinux-policy-targeted.sha256sum] = "b3e61225d525c2c6372929cfb2b1c56134c19580617764f624b64f2806c253ec"
RPROVIDES:selinux-policy-targeted:aarch64 = "virtual/selinux-policy-any_eq_40.13.26-1.el10 virtual/selinux-policy-any_ge_40.13.26"

RDEPENDS:selinux-policy = " \
 bash \
 gawk \
 policycoreutils \
 rpm-plugin-selinux \
 virtual//usr/bin/sha512sum \
 virtual/selinux-policy-any_eq_40.13.26-1.el10 \
 "
RDEPENDS:selinux-policy-devel = " \
 bash \
 checkpolicy \
 m4 \
 make \
 policycoreutils-devel \
 selinux-policy \
 "
RDEPENDS:selinux-policy-doc = " \
 selinux-policy \
 "
RDEPENDS:selinux-policy-mls = " \
 bash \
 mcstrans \
 policycoreutils \
 policycoreutils-newrole \
 selinux-policy \
 virtual/coreutils \
 "
RDEPENDS:selinux-policy-sandbox = " \
 bash \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:selinux-policy-targeted = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/coreutils \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/selinux-policy-any_eq_40.13.26-1.el10 rpm/virtual/selinux-policy-any_ge_40.13.26"

PROVIDES:append:aarch64 = " rpm/virtual/selinux-policy-any_eq_40.13.26-1.el10 rpm/virtual/selinux-policy-any_ge_40.13.26"
