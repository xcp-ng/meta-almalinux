# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-proto"
PV = "0.24.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-hickory-proto+backtrace-devel \
 rust-hickory-proto+bytes-devel \
 rust-hickory-proto+default-devel \
 rust-hickory-proto+dns-over-native-tls-devel \
 rust-hickory-proto+dns-over-openssl-devel \
 rust-hickory-proto+dns-over-tls-devel \
 rust-hickory-proto+dnssec-devel \
 rust-hickory-proto+dnssec-openssl-devel \
 rust-hickory-proto+mdns-devel \
 rust-hickory-proto+native-tls-devel \
 rust-hickory-proto+openssl-devel \
 rust-hickory-proto+serde-config-devel \
 rust-hickory-proto+serde-devel \
 rust-hickory-proto+socket2-devel \
 rust-hickory-proto+testing-devel \
 rust-hickory-proto+text-parsing-devel \
 rust-hickory-proto+tokio-devel \
 rust-hickory-proto+tokio-native-tls-devel \
 rust-hickory-proto+tokio-openssl-devel \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-proto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-proto-0.24.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7e2b4448c93cbce4673a1803c9be786d83a8aad3a450f136f267455bb1fbd81"

URI_x86_64_v2_rust-hickory-proto+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+backtrace-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+backtrace-devel.sha256sum] = "9d3f6568436a84d572d8d565287c037a38ece33e0275e0ea1cb3ae5d07e44178"

URI_x86_64_v2_rust-hickory-proto+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+bytes-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+bytes-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+bytes-devel.sha256sum] = "e370840c902b394d8fbe5c97f2689aaf2031c1d0deae0f976f5905afc31c1c8c"

URI_x86_64_v2_rust-hickory-proto+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+default-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+default-devel.sha256sum] = "4b6a9d9db13e842af7d92e5d30fe0b6f24dcc61ca3e3cd40bbaa6bdaadd39eac"

URI_x86_64_v2_rust-hickory-proto+dns-over-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dns-over-native-tls-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dns-over-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dns-over-native-tls-devel.sha256sum] = "fd5b38d1677f95e760da23c84e80400662362488dde6296895b152cb76bb4661"

URI_x86_64_v2_rust-hickory-proto+dns-over-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dns-over-openssl-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dns-over-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dns-over-openssl-devel.sha256sum] = "dda3019e650a47f8535766686f53b856044e11649e2039dc7dd3975b8f5ded09"

URI_x86_64_v2_rust-hickory-proto+dns-over-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dns-over-tls-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dns-over-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dns-over-tls-devel.sha256sum] = "b09e87bceb7fced3d3934835d84ffd7902f209ef744e1c82ad33fdf2dc849a91"

URI_x86_64_v2_rust-hickory-proto+dnssec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dnssec-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dnssec-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dnssec-devel.sha256sum] = "fcc89aa151e8a4cf4c6a9a274413c53ba3862e6e1f5c172af6efc07956980035"

URI_x86_64_v2_rust-hickory-proto+dnssec-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dnssec-openssl-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dnssec-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dnssec-openssl-devel.sha256sum] = "c61611e396b1dee405673b0a99aacf810bc5217727b150aaa878adfc38a7a2d4"

URI_x86_64_v2_rust-hickory-proto+mdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+mdns-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+mdns-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+mdns-devel.sha256sum] = "7810a31d92acc850563fb3a1e02d5ca8bea3fd13b368b095b629880c58f59cde"

URI_x86_64_v2_rust-hickory-proto+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+native-tls-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+native-tls-devel.sha256sum] = "c71f3d2dc7e12c800a3eb0650af4f6499d5400238e0ceb0c15c4f2be578a8ae9"

URI_x86_64_v2_rust-hickory-proto+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+openssl-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+openssl-devel.sha256sum] = "0085d26acce4f976743094f258086181dda85936f3ac3ab6c72d7ebd68c15c04"

URI_x86_64_v2_rust-hickory-proto+serde-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+serde-config-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+serde-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+serde-config-devel.sha256sum] = "b003069efa44c295918e0e8a6208cab9ed329c9c655eee0f5d1dc55055cb784e"

URI_x86_64_v2_rust-hickory-proto+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+serde-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+serde-devel.sha256sum] = "277072fcceb48e1719865ec2554528cbd655ab8704a074db2526f5fa5213eb29"

URI_x86_64_v2_rust-hickory-proto+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+socket2-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+socket2-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+socket2-devel.sha256sum] = "ca8d962ef22654ff4a502af3ddb942b2a033079ca132f1531fd558449a256b2f"

URI_x86_64_v2_rust-hickory-proto+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+testing-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+testing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+testing-devel.sha256sum] = "cdf110fd08b19824cba7b9599121867750599ebc5ffa7c6233949a8a25881d0f"

URI_x86_64_v2_rust-hickory-proto+text-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+text-parsing-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+text-parsing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+text-parsing-devel.sha256sum] = "fd07a79e832b44d3812413c8ab016d1eb06dae2d66fd79cae1d45368b2a2994b"

URI_x86_64_v2_rust-hickory-proto+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+tokio-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+tokio-devel.sha256sum] = "bed7f3cee334bbe4e5f87ad63460e1ddde7d612f8bfab1901992798237842054"

URI_x86_64_v2_rust-hickory-proto+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+tokio-native-tls-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+tokio-native-tls-devel.sha256sum] = "af3c939093c0747892a3746285bc388eebc1d1d227819aeda27aefee1df21669"

URI_x86_64_v2_rust-hickory-proto+tokio-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+tokio-openssl-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+tokio-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+tokio-openssl-devel.sha256sum] = "fb454a139c4a7f87462eedf1b44f1976e6eafaf7fb6b9900b7d67d417acc4915"

URI_x86_64_v2_rust-hickory-proto+tokio-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+tokio-runtime-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+tokio-runtime-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+tokio-runtime-devel.sha256sum] = "d25a46bfc42fc9cabbae3d67c74891ef48baed378edf53bfb76f74e2b0055e95"

URI_x86_64_v2_rust-hickory-proto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto-devel-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto-devel.sha256sum] = "4d54c2a32c2a59b17574bbfd511a9fb0579ffc745f27f11b17fa0ed3af610471"

URI_aarch64_rust-hickory-proto+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+backtrace-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-proto+backtrace-devel.sha256sum] = "846a74983e6652200876069ebebd2cc2f6847929243dfc557e2d0053c16397fe"

URI_aarch64_rust-hickory-proto+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+bytes-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+bytes-devel}"
SRC_URI[aarch64_rust-hickory-proto+bytes-devel.sha256sum] = "67f45200258c7360d70b0b450b861c4a23756be6173f12869c53d2b706b83396"

URI_aarch64_rust-hickory-proto+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+default-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+default-devel}"
SRC_URI[aarch64_rust-hickory-proto+default-devel.sha256sum] = "bf905abdab990a5e1afaa3e45a52987cc14b56e78bd3ba660f9c01a94c564866"

URI_aarch64_rust-hickory-proto+dns-over-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dns-over-native-tls-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dns-over-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto+dns-over-native-tls-devel.sha256sum] = "21ba587ab8c5c3d41a860ffea3a00682a7391424bf60735dffdef478d2a0a37d"

URI_aarch64_rust-hickory-proto+dns-over-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dns-over-openssl-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dns-over-openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto+dns-over-openssl-devel.sha256sum] = "3297c82b04c46a1e2eeee3cd72f2bd4035120f2fb4651949695d3b14e76d00c0"

URI_aarch64_rust-hickory-proto+dns-over-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dns-over-tls-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dns-over-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto+dns-over-tls-devel.sha256sum] = "2bd7fced3412c5c4b2a0f820e4d5534cfde1c3b451e82b16b88c6a98511385af"

URI_aarch64_rust-hickory-proto+dnssec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dnssec-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dnssec-devel}"
SRC_URI[aarch64_rust-hickory-proto+dnssec-devel.sha256sum] = "1b98a6c9127dff50ef051d58745fb48157fc67e98311d7cefd164868f660da94"

URI_aarch64_rust-hickory-proto+dnssec-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dnssec-openssl-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dnssec-openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto+dnssec-openssl-devel.sha256sum] = "fe6ceb586192d448dcf8c17ccf1bf5f25e896b6de8264143d968b75b5087cc9f"

URI_aarch64_rust-hickory-proto+mdns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+mdns-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+mdns-devel}"
SRC_URI[aarch64_rust-hickory-proto+mdns-devel.sha256sum] = "dc7513166f9065c9b475a32612a6eaafa326b0dbbcfa467184e0244286388c65"

URI_aarch64_rust-hickory-proto+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+native-tls-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+native-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto+native-tls-devel.sha256sum] = "ea047813395339c5185e9d7743601202a6e04f13958e2cf170555d7a98be3544"

URI_aarch64_rust-hickory-proto+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+openssl-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto+openssl-devel.sha256sum] = "c2622c68c4514cec2fbcd3a364357554d6abd17fa3f0d1b2ca25146bc574a107"

URI_aarch64_rust-hickory-proto+serde-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+serde-config-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+serde-config-devel}"
SRC_URI[aarch64_rust-hickory-proto+serde-config-devel.sha256sum] = "aa20828e0bf3ae116eba9f9311e922201f255bec4434994f6a9734052a03834c"

URI_aarch64_rust-hickory-proto+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+serde-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+serde-devel}"
SRC_URI[aarch64_rust-hickory-proto+serde-devel.sha256sum] = "89e8627413c9e3baade528603efdebd9a692126c29d1b916a7a63e8d62a14334"

URI_aarch64_rust-hickory-proto+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+socket2-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+socket2-devel}"
SRC_URI[aarch64_rust-hickory-proto+socket2-devel.sha256sum] = "80d0119a039075992585b3ff9fb177555bc23007d9056e4dec606ae49d6bdfde"

URI_aarch64_rust-hickory-proto+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+testing-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+testing-devel}"
SRC_URI[aarch64_rust-hickory-proto+testing-devel.sha256sum] = "350ab484a40a36f45ab75a51d25326e606995ba3854531ea1fbdfdfeafb1eed7"

URI_aarch64_rust-hickory-proto+text-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+text-parsing-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+text-parsing-devel}"
SRC_URI[aarch64_rust-hickory-proto+text-parsing-devel.sha256sum] = "f8dc1aac7fadb60c917c08472d235bacd7513b22b4069b9545f0bd2523e1111f"

URI_aarch64_rust-hickory-proto+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+tokio-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+tokio-devel}"
SRC_URI[aarch64_rust-hickory-proto+tokio-devel.sha256sum] = "a8410f4aa990d4bde0428b89fbb6a57717515c2dd740b02db271dc437b62b72d"

URI_aarch64_rust-hickory-proto+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+tokio-native-tls-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto+tokio-native-tls-devel.sha256sum] = "92a3a868ba08b6a3efc619e383c33bb24149e6d528fa3f63e94af012e67119ac"

URI_aarch64_rust-hickory-proto+tokio-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+tokio-openssl-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+tokio-openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto+tokio-openssl-devel.sha256sum] = "e8141f37840fba94609eff59df48158faebf18fd01a00e949a4b7bda47450da8"

URI_aarch64_rust-hickory-proto+tokio-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+tokio-runtime-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+tokio-runtime-devel}"
SRC_URI[aarch64_rust-hickory-proto+tokio-runtime-devel.sha256sum] = "4a08a90735395ff8635407a6d7cf013f5c7b6722df6c7d30f2a2573abec633ab"

URI_aarch64_rust-hickory-proto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto-devel-0.24.1-4.el10_0.noarch.rpm;name=aarch64_rust-hickory-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto-devel}"
SRC_URI[aarch64_rust-hickory-proto-devel.sha256sum] = "7b5e4f865321b2cff4aa14ba344868f3cec7a36ab2ab9e5a7b40c14d95ef83ff"

RDEPENDS:rust-hickory-proto+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+default-devel = " \
 cargo \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dns-over-native-tls-devel = " \
 cargo \
 rust-hickory-proto+dns-over-tls-devel \
 rust-hickory-proto+native-tls-devel \
 rust-hickory-proto+tokio-native-tls-devel \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dns-over-openssl-devel = " \
 cargo \
 rust-hickory-proto+dns-over-tls-devel \
 rust-hickory-proto+openssl-devel \
 rust-hickory-proto+tokio-openssl-devel \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dns-over-tls-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dnssec-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dnssec-openssl-devel = " \
 cargo \
 rust-hickory-proto+dnssec-devel \
 rust-hickory-proto+openssl-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+mdns-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 "
RDEPENDS:rust-hickory-proto+native-tls-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-native-tls+default-devel \
 "
RDEPENDS:rust-hickory-proto+openssl-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-openssl+default-devel \
 rust-openssl+v102-devel \
 rust-openssl+v110-devel \
 "
RDEPENDS:rust-hickory-proto+serde-config-devel = " \
 cargo \
 rust-hickory-proto+serde-devel \
 rust-hickory-proto-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-hickory-proto+serde-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-hickory-proto+socket2-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-socket2+default-devel \
 "
RDEPENDS:rust-hickory-proto+testing-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+text-parsing-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+tokio-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-hickory-proto+tokio-native-tls-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-hickory-proto+tokio-openssl-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-tokio-openssl+default-devel \
 "
RDEPENDS:rust-hickory-proto+tokio-runtime-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-hickory-proto-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-cfg-if+default-devel \
 rust-data-encoding+default-devel \
 rust-enum-as-inner+default-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-idna0.4+default-devel \
 rust-ipnet+default-devel \
 rust-once_cell+default-devel \
 rust-rand0.8+default-devel \
 rust-thiserror1+default-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 rust-tracing+default-devel \
 rust-url+default-devel \
 "
