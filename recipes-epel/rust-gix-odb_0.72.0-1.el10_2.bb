# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-odb"
PV = "0.72.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-odb+default-devel \
 rust-gix-odb+document-features-devel \
 rust-gix-odb+serde-devel \
 rust-gix-odb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-odb-0.72.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7499ecfce9f178935f4c5aee2e8c7fce5a20274762eabd95439114bfb44154fe"

URI_x86_64_v2_rust-gix-odb+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+default-devel-0.72.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+default-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+default-devel.sha256sum] = "58778115fa1d7e2726763b0097a0eddcbf7782b0c72b8dc5500c99983cc1038e"

URI_x86_64_v2_rust-gix-odb+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+document-features-devel-0.72.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+document-features-devel.sha256sum] = "b5fb861c145d85da4d061ffab87909f71af7cec49331bd383f06eb862a0efab5"

URI_x86_64_v2_rust-gix-odb+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb+serde-devel-0.72.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-odb+serde-devel.sha256sum] = "2390d05789aa3313c912108437536f7075a155a3a5c376e285c9c95ab3677b2d"

URI_x86_64_v2_rust-gix-odb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-odb-devel-0.72.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-odb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-odb-devel}"
SRC_URI[x86_64_v2_rust-gix-odb-devel.sha256sum] = "600c7edfec8207be95e2197a73ab7924ab401e6ea7e0746f62f291821e0856be"

URI_aarch64_rust-gix-odb+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+default-devel-0.72.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-odb+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+default-devel}"
SRC_URI[aarch64_rust-gix-odb+default-devel.sha256sum] = "676f76a5a812df1ae6089ec5af080d9937313ce0015fd832fcdf3e6da30be626"

URI_aarch64_rust-gix-odb+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+document-features-devel-0.72.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-odb+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+document-features-devel}"
SRC_URI[aarch64_rust-gix-odb+document-features-devel.sha256sum] = "02c2695d898ece0bd303205e34e6b686a58a011a3778b648224dcff1535b984e"

URI_aarch64_rust-gix-odb+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb+serde-devel-0.72.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-odb+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb+serde-devel}"
SRC_URI[aarch64_rust-gix-odb+serde-devel.sha256sum] = "32cc31f9c7c3b4e70c71ec727efcc93affe7d97c983fb3923bfa8af36ce7525c"

URI_aarch64_rust-gix-odb-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-odb-devel-0.72.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-odb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-odb-devel}"
SRC_URI[aarch64_rust-gix-odb-devel.sha256sum] = "b7392cf2518313112d3a6934d49515f1df791c7010a1fe2e0e3aab855617c5bf"

RDEPENDS:rust-gix-odb+default-devel = " \
 cargo \
 rust-gix-odb-devel \
 "
RDEPENDS:rust-gix-odb+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-odb-devel \
 "
RDEPENDS:rust-gix-odb+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-odb-devel \
 rust-gix-pack+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-odb-devel = " \
 cargo \
 rust \
 rust-arc-swap+default-devel \
 rust-gix-date+default-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-features+zlib-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-object+default-devel \
 rust-gix-pack-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-parking_lot+default-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 "
