# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-partitionmanager"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kde-partitionmanager \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kde-partitionmanager-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9f6346e207a8f87efe48b6fa7efa4ffb13c51507306f7b15abdd00579c9cc006"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-partitionmanager-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-partitionmanager;unpack=0"
SRC_URI[x86_64_v2_kde-partitionmanager.sha256sum] = "05550adef2249305901bf521914be15caf732019547e5bb56684100ab8a21747"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kde-partitionmanager-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kde-partitionmanager;unpack=0"
SRC_URI[aarch64_kde-partitionmanager.sha256sum] = "0e821afcdeafdd6b124249aebe51744c0486ada2b7ebd97163423d10b989386d"

RDEPENDS:kde-partitionmanager = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kpmcore \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
