# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Types-URI"
PV = "0.007"
PR = "19.el10_0"
PACKAGES = " \
 perl-Types-URI \
 perl-Types-URI-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Types-URI-0.007-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca778b9f10eff3e576187aac7fffc1dc215622bc9bbd9ff43a649f87801f1003"

URI_x86_64_v2_perl-Types-URI = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Types-URI-0.007-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Types-URI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Types-URI}"
SRC_URI[x86_64_v2_perl-Types-URI.sha256sum] = "55edfe520ce229d63836c04df4adf83d86dac41374b23da4023840909e51cd18"

URI_x86_64_v2_perl-Types-URI-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Types-URI-tests-0.007-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Types-URI-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Types-URI-tests}"
SRC_URI[x86_64_v2_perl-Types-URI-tests.sha256sum] = "079bce0051675c6bab176f7ceecd5da2dd1c5bc4dcad5cc73b87c7ee78bd040b"

URI_aarch64_perl-Types-URI = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Types-URI-0.007-19.el10_0.noarch.rpm;name=aarch64_perl-Types-URI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Types-URI}"
SRC_URI[aarch64_perl-Types-URI.sha256sum] = "94c0624906fd0f23e92e828f0ea9eb0f556ec8a57ba1e33d09a5b7665f60268c"

URI_aarch64_perl-Types-URI-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Types-URI-tests-0.007-19.el10_0.noarch.rpm;name=aarch64_perl-Types-URI-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Types-URI-tests}"
SRC_URI[aarch64_perl-Types-URI-tests.sha256sum] = "f56024698c116aa3e4008dd48eed68b7e0263ee55064746f72e46cce36eea56b"

RDEPENDS:perl-Types-URI = " \
 perl-Type-Tiny \
 perl-Types-Path-Tiny \
 perl-Types-UUID \
 perl-URI \
 perl-URI-FromHash \
 perl-libs \
 "
RDEPENDS:perl-Types-URI-tests = " \
 bash \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Types-URI \
 perl-interpreter \
 perl-libs \
 "
