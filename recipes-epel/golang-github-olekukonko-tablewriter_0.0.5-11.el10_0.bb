# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-olekukonko-tablewriter"
PV = "0.0.5"
PR = "11.el10_0"
PACKAGES = " \
 golang-github-olekukonko-tablewriter \
 golang-github-olekukonko-tablewriter-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-olekukonko-tablewriter-0.0.5-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6fbbe0cc361631e5bc0b0f6e4273eaa7a269c8644bb47bfd3242cce26c8d462f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-olekukonko-tablewriter-0.0.5-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-olekukonko-tablewriter;unpack=0"
SRC_URI[x86_64_v2_golang-github-olekukonko-tablewriter.sha256sum] = "2974def1e352d9f64e1ec0c1b73695048f2bd43a89d7cbe16eb04164e936af05"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-olekukonko-tablewriter-devel-0.0.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-olekukonko-tablewriter-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-olekukonko-tablewriter-devel.sha256sum] = "a238364cb5c705f0f489af286f7bcce7b4dd9219d97af6fb3ae05e9e37999412"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-olekukonko-tablewriter-0.0.5-11.el10_0.aarch64.rpm;name=aarch64_golang-github-olekukonko-tablewriter;unpack=0"
SRC_URI[aarch64_golang-github-olekukonko-tablewriter.sha256sum] = "e5779a6848ba9a4fc96f8075f36b26e6fed89e6f5f3673ce3939054a5c6b26ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-olekukonko-tablewriter-devel-0.0.5-11.el10_0.noarch.rpm;name=aarch64_golang-github-olekukonko-tablewriter-devel;unpack=0"
SRC_URI[aarch64_golang-github-olekukonko-tablewriter-devel.sha256sum] = "d552d6d9e31e568adf29b507fc4ecd76d61936f739b017f070224e6b1b5ea9e1"

RDEPENDS:golang-github-olekukonko-tablewriter = " \
 glibc \
 "
RDEPENDS:golang-github-olekukonko-tablewriter-devel = " \
 go-filesystem \
 golang-github-mattn-runewidth-devel \
 "
