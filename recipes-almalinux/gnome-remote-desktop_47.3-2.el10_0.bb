# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-remote-desktop"
PV = "47.3"
PR = "2.el10_0"
PACKAGES = " \
 gnome-remote-desktop \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-remote-desktop-47.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ef88ce1e18ef6ab0f9f4711109da991e215a8f8612eaad4fa781f5ad34e211c"

URI_x86_64_v2_gnome-remote-desktop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-remote-desktop-47.3-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_gnome-remote-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-remote-desktop}"
SRC_URI[x86_64_v2_gnome-remote-desktop.sha256sum] = "71e60c73d27b1ce4dc779644b51a98b4e2e69a8d489bb6b594b3cfd1ec0a7e2e"

URI_aarch64_gnome-remote-desktop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-remote-desktop-47.3-2.el10_0.aarch64.rpm;name=aarch64_gnome-remote-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-remote-desktop}"
SRC_URI[aarch64_gnome-remote-desktop.sha256sum] = "8a2b7a2bae05bbfb4870a6828373947eee53f07d7d2a7ac56c6b27eae7369a4b"

RDEPENDS:gnome-remote-desktop = " \
 bash \
 cairo \
 fdk-aac-free \
 freerdp-libs \
 fuse3-libs \
 glib2 \
 glibc \
 libei \
 libepoxy \
 libgcc \
 libnotify \
 libsecret \
 libwinpr \
 libxkbcommon \
 opus \
 pipewire \
 pipewire-libs \
 polkit-libs \
 systemd-libs \
 tpm2-tss \
 "
