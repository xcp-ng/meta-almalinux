# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inout"
PV = "0.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-inout+block-padding-devel \
 rust-inout+default-devel \
 rust-inout-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inout-0.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "702d01cdf36e50481c652da76edef6abf10d61ccb6c5ec3b031291b047050129"

URI_x86_64_v2_rust-inout+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout+block-padding-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout+block-padding-devel}"
SRC_URI[x86_64_v2_rust-inout+block-padding-devel.sha256sum] = "799383b3dc91a51673f66376e89c52b0ecb8a44a702eb377d49d6be96bb90ae3"

URI_x86_64_v2_rust-inout+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout+default-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout+default-devel}"
SRC_URI[x86_64_v2_rust-inout+default-devel.sha256sum] = "2bbc5079360cb613de5dfe1ade05c5f1afb16330093be67a6949c6b86be0327a"

URI_x86_64_v2_rust-inout-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inout-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inout-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inout-devel}"
SRC_URI[x86_64_v2_rust-inout-devel.sha256sum] = "f4e070ad1c9e843c4c0eda63d73296a0bc6dcde632e3cd9e8eeaf79cc3b85f8e"

URI_aarch64_rust-inout+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout+block-padding-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-inout+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout+block-padding-devel}"
SRC_URI[aarch64_rust-inout+block-padding-devel.sha256sum] = "ce525e52486fd25421df526a41f451d50b9099ced65821d3ecfd3646d374b532"

URI_aarch64_rust-inout+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout+default-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-inout+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout+default-devel}"
SRC_URI[aarch64_rust-inout+default-devel.sha256sum] = "fa674cb78f01f0b773f9d718326d9ee926dc4b220f60dc7c2bfdfb62507d15f5"

URI_aarch64_rust-inout-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inout-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-inout-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inout-devel}"
SRC_URI[aarch64_rust-inout-devel.sha256sum] = "d3d9a63209afc616a47a6dbe1a685f00f2d6b7450204af148b29b011e498d9c1"

RDEPENDS:rust-inout+block-padding-devel = " \
 cargo \
 rust-block-padding+default-devel \
 rust-inout-devel \
 "
RDEPENDS:rust-inout+default-devel = " \
 cargo \
 rust-inout-devel \
 "
RDEPENDS:rust-inout-devel = " \
 cargo \
 rust \
 rust-hybrid-array+default-devel \
 "
