# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openldap"
PV = "2.6.8"
PR = "3.el10"
PACKAGES = " \
 openldap \
 openldap-clients \
 openldap-compat \
 openldap-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/openldap-2.6.8-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae5435865581601c97775138899ab24742380fbae8118bee4781f9e4baebab0a"

URI_x86_64_v2_openldap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-2.6.8-3.el10.x86_64_v2.rpm;name=x86_64_v2_openldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap}"
SRC_URI[x86_64_v2_openldap.sha256sum] = "d848551a02bb8edcfb8535238d88497357add4797950bb4593bc5d78a8a59a6c"

URI_x86_64_v2_openldap-clients = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-clients-2.6.8-3.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-clients}"
SRC_URI[x86_64_v2_openldap-clients.sha256sum] = "9ed3f2be5e965eb50b72e0ea9930e205e95d84ac916ec532d7f6f517fa2408ce"

URI_x86_64_v2_openldap-compat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/openldap-compat-2.6.8-3.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-compat}"
SRC_URI[x86_64_v2_openldap-compat.sha256sum] = "96c53de98ca5aa30068bec4ccdcac60210fb15ede2f405aa016a6ab2ab917528"

URI_x86_64_v2_openldap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openldap-devel-2.6.8-3.el10.x86_64_v2.rpm;name=x86_64_v2_openldap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openldap-devel}"
SRC_URI[x86_64_v2_openldap-devel.sha256sum] = "50e4152f221ccb4cd7740b4f13ef489430d6747e32b733d2e9024aaa524da1ca"

URI_aarch64_openldap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-2.6.8-3.el10.aarch64.rpm;name=aarch64_openldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap}"
SRC_URI[aarch64_openldap.sha256sum] = "bcb849080a8da45c7321ff691af598fa82b1439af212d26e7e411dfdf82d821d"

URI_aarch64_openldap-clients = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-clients-2.6.8-3.el10.aarch64.rpm;name=aarch64_openldap-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-clients}"
SRC_URI[aarch64_openldap-clients.sha256sum] = "c7d8a678fdefb3ee8c106a8b9c5eefb66fb88bf99ec7c8419e68388f823dd299"

URI_aarch64_openldap-compat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/openldap-compat-2.6.8-3.el10.aarch64.rpm;name=aarch64_openldap-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-compat}"
SRC_URI[aarch64_openldap-compat.sha256sum] = "10ab84606f886dd98b205980b584c23ad18f35b40bcd1294a0891e38b1ec356e"

URI_aarch64_openldap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openldap-devel-2.6.8-3.el10.aarch64.rpm;name=aarch64_openldap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openldap-devel}"
SRC_URI[aarch64_openldap-devel.sha256sum] = "57e78c5a510948ef56fcc9bce3a9fb02e69c7bc5d43247c0d6f4908835a2051e"

RDEPENDS:openldap = " \
 cyrus-sasl-lib \
 glibc \
 libevent \
 openssl-libs \
 shadow-utils \
 "
RDEPENDS:openldap-clients = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 "
RDEPENDS:openldap-compat = " \
 glibc \
 openldap \
 "
RDEPENDS:openldap-devel = " \
 cyrus-sasl-devel \
 openldap \
 openldap-devel \
 pkgconf-pkg-config \
 "
