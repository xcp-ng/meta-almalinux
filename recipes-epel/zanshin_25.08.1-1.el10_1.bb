# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zanshin"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 zanshin \
 zanshin-common \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zanshin-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a66b0a4bde3a1746eaead33b00502f87ddd47cca442d3841baf0daf1b090f92"

URI_x86_64_v2_zanshin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zanshin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zanshin}"
SRC_URI[x86_64_v2_zanshin.sha256sum] = "fbcb394941f4d666b491890bb6bed0144d203ae9f10fde07743c9d16bbed4043"

URI_x86_64_v2_zanshin-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zanshin-common-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_zanshin-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zanshin-common}"
SRC_URI[x86_64_v2_zanshin-common.sha256sum] = "2a02525952ce6c8f6fcdef3e13c6b6558e8e2ea47375cff4b1e50012ac348cde"

URI_aarch64_zanshin = "${EPEL_MIRROR}/aarch64/Packages/z/zanshin-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_zanshin;unpack=0"
SRC_URI:append = " ${URI_aarch64_zanshin}"
SRC_URI[aarch64_zanshin.sha256sum] = "028b48551052d758fe470fc47b4e1da551c06e16ce96eea80741af88e5a9c45b"

URI_aarch64_zanshin-common = "${EPEL_MIRROR}/aarch64/Packages/z/zanshin-common-25.08.1-1.el10_1.noarch.rpm;name=aarch64_zanshin-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_zanshin-common}"
SRC_URI[aarch64_zanshin-common.sha256sum] = "760edb3fbafe2e317e8ae0c83fd339727e23113ba386cf899f9f5ffe1ca2347e"

RDEPENDS:zanshin = " \
 akonadi-server \
 glibc \
 kdepim-runtime \
 kf6-kcalendarcore \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-krunner \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kontactinterface \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 zanshin-common \
 "
RDEPENDS:zanshin-common = " \
 zanshin \
 "
