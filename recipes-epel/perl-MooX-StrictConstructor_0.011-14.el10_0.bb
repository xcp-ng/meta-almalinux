# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MooX-StrictConstructor"
PV = "0.011"
PR = "14.el10_0"
PACKAGES = " \
 perl-MooX-StrictConstructor \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-MooX-StrictConstructor-0.011-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1c9da7489ec547bcfa4730604cbf482d74219ffa8787aebd51584cac98566c24"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooX-StrictConstructor-0.011-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooX-StrictConstructor;unpack=0"
SRC_URI[x86_64_v2_perl-MooX-StrictConstructor.sha256sum] = "4f52d2000e477ebb4331f482a77384daf7986456252daedc83c9405e4d7dd28c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-MooX-StrictConstructor-0.011-14.el10_0.noarch.rpm;name=aarch64_perl-MooX-StrictConstructor;unpack=0"
SRC_URI[aarch64_perl-MooX-StrictConstructor.sha256sum] = "7ee60d869bb8dfac8005cec6c6781438da84859d784c19ff11d11a10865d5858"

RDEPENDS:perl-MooX-StrictConstructor = " \
 perl-B \
 perl-Class-Method-Modifiers \
 perl-Moo \
 perl-constant \
 perl-libs \
 perl-strictures \
 "
