# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GooCanvas2"
PV = "0.06"
PR = "23.el10_0"
PACKAGES = " \
 perl-GooCanvas2 \
 perl-GooCanvas2-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GooCanvas2-0.06-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8af92a247578998e8c639300969c07bae154d8ae42651ec1e5f1c3dafd752325"

URI_x86_64_v2_perl-GooCanvas2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GooCanvas2-0.06-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GooCanvas2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GooCanvas2}"
SRC_URI[x86_64_v2_perl-GooCanvas2.sha256sum] = "e36c2be9d0b5ce59123f533e1dcc1cd6bf6b3087ff07aa36b2658e4599875e37"

URI_x86_64_v2_perl-GooCanvas2-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GooCanvas2-tests-0.06-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-GooCanvas2-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GooCanvas2-tests}"
SRC_URI[x86_64_v2_perl-GooCanvas2-tests.sha256sum] = "69e5d5edcecf30fcd0075a9b1a07966edfc62a120cca31e63e0d22b63d0b4e60"

URI_aarch64_perl-GooCanvas2 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GooCanvas2-0.06-23.el10_0.noarch.rpm;name=aarch64_perl-GooCanvas2;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GooCanvas2}"
SRC_URI[aarch64_perl-GooCanvas2.sha256sum] = "ae64b3cae8e07f38264798fc98b264b45f55397b14cac6608ce3e56350a287af"

URI_aarch64_perl-GooCanvas2-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GooCanvas2-tests-0.06-23.el10_0.noarch.rpm;name=aarch64_perl-GooCanvas2-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GooCanvas2-tests}"
SRC_URI[aarch64_perl-GooCanvas2-tests.sha256sum] = "a8e69d186171a7bb6d247c0dd594da66adc05071fc00037032e0c5584f12b6d9"

RDEPENDS:perl-GooCanvas2 = " \
 goocanvas2 \
 perl-Glib-Object-Introspection \
 perl-libs \
 "
RDEPENDS:perl-GooCanvas2-tests = " \
 bash \
 perl-GooCanvas2 \
 perl-Test \
 perl-Test-Harness \
 perl-libs \
 "
