# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbench"
PV = "4.0"
PR = "32.el10_0"
PACKAGES = " \
 dbench \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dbench-4.0-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b1a081598fbfbf65f7cb7cc7f50369fd97c6724289e36330bdff8df4cfe7e278"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dbench-4.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dbench;unpack=0"
SRC_URI[x86_64_v2_dbench.sha256sum] = "515185d31e134ccd4123c62b5c55013138e235ab4f113fee999b474c02365701"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dbench-4.0-32.el10_0.aarch64.rpm;name=aarch64_dbench;unpack=0"
SRC_URI[aarch64_dbench.sha256sum] = "351cdb170ade4871a3dcaafa7ff3fb169ece47b38f0195fe216f6853875750f1"

RDEPENDS:dbench = " \
 glibc \
 popt \
 "
