# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-fs"
PV = "0.21.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-fs+default-devel \
 rust-gix-fs+serde-devel \
 rust-gix-fs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-fs-0.21.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6927435216cfcaa12c7ed3860933f6903c3e76d83ead0262cfad366f9ee76e5a"

URI_x86_64_v2_rust-gix-fs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs+default-devel-0.21.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs+default-devel}"
SRC_URI[x86_64_v2_rust-gix-fs+default-devel.sha256sum] = "7b3c41476822e095d1155602240b3e53140ab32080e1d1e603846bd89b823246"

URI_x86_64_v2_rust-gix-fs+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs+serde-devel-0.21.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-fs+serde-devel.sha256sum] = "12008386424d389d4023edef699374bec3d476e1f5144bd0232c6cb4ce972970"

URI_x86_64_v2_rust-gix-fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-fs-devel-0.21.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-fs-devel}"
SRC_URI[x86_64_v2_rust-gix-fs-devel.sha256sum] = "48e8f229b943ae3264e5fcbdf8733a50b70f2d9ca841cfee4f01f37e3dd2f8a3"

URI_aarch64_rust-gix-fs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs+default-devel-0.21.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-fs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs+default-devel}"
SRC_URI[aarch64_rust-gix-fs+default-devel.sha256sum] = "f6e9815721fcd95de72989274a640af2209e7cd1b5d79e5731b75a6aed0000d7"

URI_aarch64_rust-gix-fs+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs+serde-devel-0.21.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-fs+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs+serde-devel}"
SRC_URI[aarch64_rust-gix-fs+serde-devel.sha256sum] = "eb1dc4698478bd4934a4df6611ad65905e8607dd5b5ad30a0582a5a9ad7ab394"

URI_aarch64_rust-gix-fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-fs-devel-0.21.2-1.el10_3.noarch.rpm;name=aarch64_rust-gix-fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-fs-devel}"
SRC_URI[aarch64_rust-gix-fs-devel.sha256sum] = "651309bf8bedfb3ac63cd10ab0bb28ef438cc5db9a65534852e4ddcfb29a15ae"

RDEPENDS:rust-gix-fs+default-devel = " \
 cargo \
 rust-gix-fs-devel \
 "
RDEPENDS:rust-gix-fs+serde-devel = " \
 cargo \
 rust-gix-fs-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-fs-devel = " \
 cargo \
 rust \
 rust-bstr+default-devel \
 rust-fastrand+std-devel \
 rust-fastrand-devel \
 rust-gix-features+default-devel \
 rust-gix-features+fs-read-dir-devel \
 rust-gix-path+default-devel \
 rust-gix-utils+default-devel \
 rust-thiserror+default-devel \
 "
