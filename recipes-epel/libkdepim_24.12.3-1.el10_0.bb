# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkdepim"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkdepim \
 libkdepim-devel \
 libkdepim-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkdepim-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c17631fbb8a99645def28c9c7828bae9ccfcb19cd4e259c43dd54b0e3eae0d8"

URI_x86_64_v2_libkdepim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim}"
SRC_URI[x86_64_v2_libkdepim.sha256sum] = "b16943ebee935e98aaeb024a5456209db28df15006fcbccbf104ded809972d64"

URI_x86_64_v2_libkdepim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkdepim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim-devel}"
SRC_URI[x86_64_v2_libkdepim-devel.sha256sum] = "7ca14a1521bd6d241bde0c8a88e25c3f82a06308f203fd9b08b0b847b5e0f269"

URI_x86_64_v2_libkdepim-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkdepim-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libkdepim-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkdepim-doc}"
SRC_URI[x86_64_v2_libkdepim-doc.sha256sum] = "94f50ccd4c7deb0ed33fff069a6e4d166f5b2c12ced326666f051ecbfa73c136"

URI_aarch64_libkdepim = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkdepim;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim}"
SRC_URI[aarch64_libkdepim.sha256sum] = "e641fb3219e00bf6bcd9d27c2527ffcad552e6e956c7b14fb34a943b7414c8f1"

URI_aarch64_libkdepim-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkdepim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim-devel}"
SRC_URI[aarch64_libkdepim-devel.sha256sum] = "9c585fe3cd550ac0d38d3c02145c7bec56dd5027b53b66a66b0c2c573eb2a204"

URI_aarch64_libkdepim-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkdepim-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_libkdepim-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkdepim-doc}"
SRC_URI[aarch64_libkdepim-doc.sha256sum] = "69000bf8a2fda381f547e983518cd58dc22cc6eb81d4bb727c247c584bf42a67"

RDEPENDS:libkdepim = " \
 glibc \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-devel = " \
 cmake-filesystem \
 glibc \
 libkdepim \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkdepim-doc = " \
 "
