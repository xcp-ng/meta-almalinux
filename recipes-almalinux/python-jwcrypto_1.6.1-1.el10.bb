# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jwcrypto"
PV = "1.6.1"
PR = "1.el10"
PACKAGES = " \
 python3-jwcrypto \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-jwcrypto-1.6.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5fd7baab86c6422294807f14c9d5980dfa360a9e9bf165ec2d714c580762d4a0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-jwcrypto-1.6.1-1.el10.noarch.rpm;name=x86_64_v2_python3-jwcrypto;unpack=0"
SRC_URI[x86_64_v2_python3-jwcrypto.sha256sum] = "7ff10849d518aad0483fcc7fc1551b30098556f0a19cdd326a9b12b1fd6c3d37"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-jwcrypto-1.6.1-1.el10.noarch.rpm;name=aarch64_python3-jwcrypto;unpack=0"
SRC_URI[aarch64_python3-jwcrypto.sha256sum] = "7ff10849d518aad0483fcc7fc1551b30098556f0a19cdd326a9b12b1fd6c3d37"

RDEPENDS:python3-jwcrypto = " \
 python3 \
 python3-cryptography \
 python3-typing-extensions \
 "
