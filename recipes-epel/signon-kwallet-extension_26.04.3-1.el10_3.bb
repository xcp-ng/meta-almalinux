# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "signon-kwallet-extension"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 signon-kwallet-extension \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/signon-kwallet-extension-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cdc5172de66cee99914151745f1b5032f2ba0254a897918fc7268c900141108"

URI_x86_64_v2_signon-kwallet-extension = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/signon-kwallet-extension-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_signon-kwallet-extension;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_signon-kwallet-extension}"
SRC_URI[x86_64_v2_signon-kwallet-extension.sha256sum] = "31aca85c6229f47a13cc5b0533e0381afd7042629326d4ae261849e176c497c7"

URI_aarch64_signon-kwallet-extension = "${EPEL_MIRROR}/aarch64/Packages/s/signon-kwallet-extension-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_signon-kwallet-extension;unpack=0"
SRC_URI:append = " ${URI_aarch64_signon-kwallet-extension}"
SRC_URI[aarch64_signon-kwallet-extension.sha256sum] = "fbb02b7006a85848b4d7a2703a335c733de11095a6c62203afc09cf8af9fb020"

RDEPENDS:signon-kwallet-extension = " \
 glibc \
 kf6-kwallet-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 signon \
 "
