# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chacha20"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-chacha20+cipher-devel \
 rust-chacha20+default-devel \
 rust-chacha20+legacy-devel \
 rust-chacha20+rng-devel \
 rust-chacha20+xchacha-devel \
 rust-chacha20+zeroize-devel \
 rust-chacha20-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chacha20-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf43c901e4b1c1dbbe4caf850be403f56d7c77edb5a40150d83c509998488e8a"

URI_x86_64_v2_rust-chacha20+cipher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+cipher-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+cipher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20+cipher-devel}"
SRC_URI[x86_64_v2_rust-chacha20+cipher-devel.sha256sum] = "41435c18e6bbac736f7fb95324281850bc4a61306dceedd5ee80d4b49fdb4c03"

URI_x86_64_v2_rust-chacha20+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+default-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20+default-devel}"
SRC_URI[x86_64_v2_rust-chacha20+default-devel.sha256sum] = "5b4e2a6f6fbbcc97442ea73591fd1341e281befb02b4a0166994b1d588d8f176"

URI_x86_64_v2_rust-chacha20+legacy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+legacy-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20+legacy-devel}"
SRC_URI[x86_64_v2_rust-chacha20+legacy-devel.sha256sum] = "f7cebdaaca432b1bd11c1d19ed9136972be07ed66ab72e8f37e211bce0685e02"

URI_x86_64_v2_rust-chacha20+rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+rng-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20+rng-devel}"
SRC_URI[x86_64_v2_rust-chacha20+rng-devel.sha256sum] = "6d4c818b9a492bbd76bc82686b75b2320b909b31311267f484c28ab88dffb5b9"

URI_x86_64_v2_rust-chacha20+xchacha-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+xchacha-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+xchacha-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20+xchacha-devel}"
SRC_URI[x86_64_v2_rust-chacha20+xchacha-devel.sha256sum] = "933eebbc78f46a3502526580a5a2950a243199c27bc4ba49a5c334bf4ea2cd6f"

URI_x86_64_v2_rust-chacha20+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20+zeroize-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20+zeroize-devel}"
SRC_URI[x86_64_v2_rust-chacha20+zeroize-devel.sha256sum] = "cf28d74b27c26c136af29bed67d3a93c926661b0ad9f42bdf11ad8f75cde1ee8"

URI_x86_64_v2_rust-chacha20-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chacha20-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chacha20-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chacha20-devel}"
SRC_URI[x86_64_v2_rust-chacha20-devel.sha256sum] = "9891a97ca1accfc3dfacb6fbedfcfe53c0a1136b7514792c0c4c9bbbc1c7f4f7"

URI_aarch64_rust-chacha20+cipher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+cipher-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+cipher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20+cipher-devel}"
SRC_URI[aarch64_rust-chacha20+cipher-devel.sha256sum] = "644040d7bab1985e4e5e63ea6a1afec149bbcc55386e7e61cc5182a0a1564779"

URI_aarch64_rust-chacha20+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+default-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20+default-devel}"
SRC_URI[aarch64_rust-chacha20+default-devel.sha256sum] = "1a8b5b7aec6caec4f62687fb835374c5d6293986637ed1faa6d8b0770cd2b9ad"

URI_aarch64_rust-chacha20+legacy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+legacy-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+legacy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20+legacy-devel}"
SRC_URI[aarch64_rust-chacha20+legacy-devel.sha256sum] = "97b0261c451f949d8aa735d46e9b8facb38dd1f230f0c88d6bb73e88a9d338cd"

URI_aarch64_rust-chacha20+rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+rng-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20+rng-devel}"
SRC_URI[aarch64_rust-chacha20+rng-devel.sha256sum] = "016c95a7652ec9e3361bb7abf89882f1503cbed3f0530615f0fb84a7c7965485"

URI_aarch64_rust-chacha20+xchacha-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+xchacha-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+xchacha-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20+xchacha-devel}"
SRC_URI[aarch64_rust-chacha20+xchacha-devel.sha256sum] = "764cbf77de5dacec849953a45c682cf47e423691b956ec04ecdd65054c6a53c2"

URI_aarch64_rust-chacha20+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20+zeroize-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20+zeroize-devel}"
SRC_URI[aarch64_rust-chacha20+zeroize-devel.sha256sum] = "a9f4e58639fc8bb406d0969f72455bfd397ad1799bc21ca8b2968165905343f8"

URI_aarch64_rust-chacha20-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chacha20-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-chacha20-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chacha20-devel}"
SRC_URI[aarch64_rust-chacha20-devel.sha256sum] = "3fc489386aa03a433319e631d746b010f676c0096e03426f3bd67861746cbf72"

RDEPENDS:rust-chacha20+cipher-devel = " \
 cargo \
 rust-chacha20-devel \
 rust-cipher+default-devel \
 rust-cipher+stream-wrapper-devel \
 "
RDEPENDS:rust-chacha20+default-devel = " \
 cargo \
 rust-chacha20+cipher-devel \
 rust-chacha20-devel \
 "
RDEPENDS:rust-chacha20+legacy-devel = " \
 cargo \
 rust-chacha20+cipher-devel \
 rust-chacha20-devel \
 "
RDEPENDS:rust-chacha20+rng-devel = " \
 cargo \
 rust-chacha20-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-chacha20+xchacha-devel = " \
 cargo \
 rust-chacha20+cipher-devel \
 rust-chacha20-devel \
 "
RDEPENDS:rust-chacha20+zeroize-devel = " \
 cargo \
 rust-chacha20-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-chacha20-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cpufeatures+default-devel \
 "
