# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ravif"
PV = "0.12.0"
PR = "2.el10_2"
PACKAGES = " \
 rust-ravif+asm-devel \
 rust-ravif+default-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ravif-0.12.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40e22cfeea2b8ee4193f0dfe23ea9cb766ed6e6b07876d43de23a4808ce4d1ac"

URI_x86_64_v2_rust-ravif+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+asm-devel-0.12.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+asm-devel}"
SRC_URI[x86_64_v2_rust-ravif+asm-devel.sha256sum] = "94c0bf380a5b20697b20e1e7a3ce8ee900ced69f0e8641f6788227c492edc15d"

URI_x86_64_v2_rust-ravif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+default-devel-0.12.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+default-devel}"
SRC_URI[x86_64_v2_rust-ravif+default-devel.sha256sum] = "f89a7bd3d127a73c5bbcabb6dbebda4a02725712237ecc9c2db816d2c7840b59"

URI_x86_64_v2_rust-ravif+threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+threading-devel-0.12.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+threading-devel}"
SRC_URI[x86_64_v2_rust-ravif+threading-devel.sha256sum] = "54d5dea0dba36b1f071a32aeba54c93d01a63382d97fd46178353b838d0bb5d1"

URI_x86_64_v2_rust-ravif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif-devel-0.12.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif-devel}"
SRC_URI[x86_64_v2_rust-ravif-devel.sha256sum] = "55f203b53c2bb77ee9a87a2b5ab28286e8abb0f3e2308cef5a458cb1a473581b"

URI_aarch64_rust-ravif+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+asm-devel-0.12.0-2.el10_2.noarch.rpm;name=aarch64_rust-ravif+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+asm-devel}"
SRC_URI[aarch64_rust-ravif+asm-devel.sha256sum] = "885dc2100edfa773a7c1efa8a17e84ba4b784897c2212bb99fac5d6b5e0a2bbc"

URI_aarch64_rust-ravif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+default-devel-0.12.0-2.el10_2.noarch.rpm;name=aarch64_rust-ravif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+default-devel}"
SRC_URI[aarch64_rust-ravif+default-devel.sha256sum] = "5c33858c03ae73fccd8e8065b22365412b080668370f672c0866963ff83c6bf0"

URI_aarch64_rust-ravif+threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+threading-devel-0.12.0-2.el10_2.noarch.rpm;name=aarch64_rust-ravif+threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+threading-devel}"
SRC_URI[aarch64_rust-ravif+threading-devel.sha256sum] = "3cb24ed0caf5a33e8d2d321156b373d8f15ed5a8c7e427aa7478bd3575a0ec79"

URI_aarch64_rust-ravif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif-devel-0.12.0-2.el10_2.noarch.rpm;name=aarch64_rust-ravif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif-devel}"
SRC_URI[aarch64_rust-ravif-devel.sha256sum] = "ff98c58253d03d5c270dc1f6b79e858ceef3f5bb0db6614079680529a20fb8c1"

RDEPENDS:rust-ravif+asm-devel = " \
 cargo \
 rust-rav1e+asm-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-ravif+default-devel = " \
 cargo \
 rust-ravif+asm-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-ravif+threading-devel = " \
 cargo \
 rust-rav1e+threading-devel \
 rust-ravif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ravif-devel = " \
 cargo \
 rust \
 rust-avif-serialize+default-devel \
 rust-imgref+default-devel \
 rust-loop9+default-devel \
 rust-quick-error+default-devel \
 rust-rav1e-devel \
 rust-rgb-devel \
 "
