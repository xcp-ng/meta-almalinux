# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-examples"
PV = "7.1.0"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 rocm-examples \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocm-examples-7.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa3f42e619c787175189c27774f6c12904e3247596b0f8a6db7153c57c9062b7"

URI_x86_64_v2_rocm-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-examples-7.1.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocm-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocm-examples}"
SRC_URI[x86_64_v2_rocm-examples.sha256sum] = "ae3152486b9996729eaeb948760b5c723c59420ec476a3c7e83ef23e188d9f9f"

RDEPENDS:rocm-examples = " \
 glibc \
 hipblas \
 hipfft \
 hiprand \
 hipsolver \
 libgcc \
 libstdc++ \
 rocblas \
 rocfft \
 rocm-hip \
 rocrand \
 rocsolver \
 rocsparse \
 "
