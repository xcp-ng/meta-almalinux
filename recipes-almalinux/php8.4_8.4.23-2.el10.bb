# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4"
PV = "8.4.23"
PR = "2.el10"
PACKAGES = " \
 php8.4 \
 php8.4-bcmath \
 php8.4-cli \
 php8.4-common \
 php8.4-dba \
 php8.4-dbg \
 php8.4-devel \
 php8.4-embedded \
 php8.4-enchant \
 php8.4-ffi \
 php8.4-fpm \
 php8.4-gd \
 php8.4-gmp \
 php8.4-intl \
 php8.4-ldap \
 php8.4-mbstring \
 php8.4-mysqlnd \
 php8.4-odbc \
 php8.4-opcache \
 php8.4-pdo \
 php8.4-pgsql \
 php8.4-process \
 php8.4-snmp \
 php8.4-soap \
 php8.4-xml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php8.4-8.4.23-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c93ad7382480bf156d20803413dba948be0810c2c5e30b1b6d685deaf1fc605"

URI_x86_64_v2_php8.4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4}"
SRC_URI[x86_64_v2_php8.4.sha256sum] = "2075016146c6e0ad58c38581b85e5d94bf416fe62bdedabb18170c2e6fe365dd"
RPROVIDES:php8.4:x86_64_v2 = "virtual/php"

URI_x86_64_v2_php8.4-bcmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-bcmath-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-bcmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-bcmath}"
SRC_URI[x86_64_v2_php8.4-bcmath.sha256sum] = "6b4fee596bf18415a3e89163f006d9745a1256455174ffa2f1e6ec564bad9f82"
RPROVIDES:php8.4-bcmath:x86_64_v2 = "virtual/php-bcmath"

URI_x86_64_v2_php8.4-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-cli-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-cli}"
SRC_URI[x86_64_v2_php8.4-cli.sha256sum] = "79db97f5ea5a29e88bb3f4a581293ab27ac260aa3ecf67b5dad9c3efad36a533"
RPROVIDES:php8.4-cli:x86_64_v2 = "virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

URI_x86_64_v2_php8.4-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-common-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-common}"
SRC_URI[x86_64_v2_php8.4-common.sha256sum] = "f19dc60c0db2c10f0e0cdb75a149d803e91d88f4240c7caa4cd30073e9386eb5"
RPROVIDES:php8.4-common:x86_64_v2 = "virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_x86-64_ virtual/php-json virtual/php-json_x86-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_x86-64_ virtual/php-spl virtual/php-spl_x86-64_ virtual/php-tokenizer virtual/php-tokenizer_x86-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

URI_x86_64_v2_php8.4-dba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-dba-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-dba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-dba}"
SRC_URI[x86_64_v2_php8.4-dba.sha256sum] = "b5eb8131e60ab5e633560c2740f09d434f881b99e03078e01ebf2e599215e642"

URI_x86_64_v2_php8.4-dbg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-dbg-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-dbg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-dbg}"
SRC_URI[x86_64_v2_php8.4-dbg.sha256sum] = "f94a94f889b0b76e959b2dcfdaf80b6637bf5184f434d2c5933774bc589ac004"

URI_x86_64_v2_php8.4-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-devel-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-devel}"
SRC_URI[x86_64_v2_php8.4-devel.sha256sum] = "62beb177cfeb57cb16959ec208ad8d9af4c069430d5f938c18e76f75528c77a0"

URI_x86_64_v2_php8.4-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-embedded-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-embedded}"
SRC_URI[x86_64_v2_php8.4-embedded.sha256sum] = "16f6b21e76d836385d8167d4961a543ae210a2b5e76eb4e2a8fca3fd70d1318b"

URI_x86_64_v2_php8.4-enchant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-enchant-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-enchant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-enchant}"
SRC_URI[x86_64_v2_php8.4-enchant.sha256sum] = "8a200603e5ad30a7df55eb32720bbd57ca5b916431c5ef22c698868c0552fdd2"

URI_x86_64_v2_php8.4-ffi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-ffi-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-ffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-ffi}"
SRC_URI[x86_64_v2_php8.4-ffi.sha256sum] = "0c7164ab01c745e6ae0f82f2103ca361d46d8cbbbf2e62ea11f39a7762200f43"

URI_x86_64_v2_php8.4-fpm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-fpm-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-fpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-fpm}"
SRC_URI[x86_64_v2_php8.4-fpm.sha256sum] = "8a39e45cf26a03f4dc93b85b2428c4c23946f320382ea0b0351cf5308e61d3f1"
RPROVIDES:php8.4-fpm:x86_64_v2 = "virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

URI_x86_64_v2_php8.4-gd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-gd-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-gd}"
SRC_URI[x86_64_v2_php8.4-gd.sha256sum] = "168b5508246ebdc1262e90ec9f7b12fb19741902598d71e500107acef75362b2"
RPROVIDES:php8.4-gd:x86_64_v2 = "virtual/php-gd virtual/php-gd_x86-64_"

URI_x86_64_v2_php8.4-gmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-gmp-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-gmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-gmp}"
SRC_URI[x86_64_v2_php8.4-gmp.sha256sum] = "2818a23c8558e952a02ba87e98cd1045493499bb74754d0c7f14a3f4b4c523a3"
RPROVIDES:php8.4-gmp:x86_64_v2 = "virtual/php-gmp"

URI_x86_64_v2_php8.4-intl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-intl-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-intl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-intl}"
SRC_URI[x86_64_v2_php8.4-intl.sha256sum] = "e1dd0df451975cca719cce6d4b5b2a3e1bf9f54a67ec3e5a64bbf53a1c0fd4b3"
RPROVIDES:php8.4-intl:x86_64_v2 = "virtual/php-intl"

URI_x86_64_v2_php8.4-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-ldap-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-ldap}"
SRC_URI[x86_64_v2_php8.4-ldap.sha256sum] = "01ff77c8e3b5f8209fb4f2475ed7cbbae9136c1b26e78a7861548ace77119557"
RPROVIDES:php8.4-ldap:x86_64_v2 = "virtual/php-ldap"

URI_x86_64_v2_php8.4-mbstring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-mbstring-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-mbstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-mbstring}"
SRC_URI[x86_64_v2_php8.4-mbstring.sha256sum] = "319766683a849e035c8b61811090c86076cb6014133730fd59e9d2626a2f5e90"
RPROVIDES:php8.4-mbstring:x86_64_v2 = "virtual/php-mbstring"

URI_x86_64_v2_php8.4-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-mysqlnd-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-mysqlnd}"
SRC_URI[x86_64_v2_php8.4-mysqlnd.sha256sum] = "1ef3b4fc8880aa6f7e388cd379baa6a36523d434d9f8e5d059b6b3524da57367"
RPROVIDES:php8.4-mysqlnd:x86_64_v2 = "virtual/php-mysqli virtual/php-mysqlnd"

URI_x86_64_v2_php8.4-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-odbc-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-odbc}"
SRC_URI[x86_64_v2_php8.4-odbc.sha256sum] = "647490c05c04c96110cdafae2eafa1566e1042a99aaa251afafcf7015b1f7d5b"

URI_x86_64_v2_php8.4-opcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-opcache-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-opcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-opcache}"
SRC_URI[x86_64_v2_php8.4-opcache.sha256sum] = "01cb623ccbba71ade80b81f90338353b7080806769a097db9ecf12641aff8538"
RPROVIDES:php8.4-opcache:x86_64_v2 = "virtual/php-opcache"

URI_x86_64_v2_php8.4-pdo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-pdo-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-pdo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pdo}"
SRC_URI[x86_64_v2_php8.4-pdo.sha256sum] = "ad132920dbd513a55eece0df4867ce76b22cf33e4e7188ab42db2cf15b049c67"
RPROVIDES:php8.4-pdo:x86_64_v2 = "virtual/php-pdo virtual/php-sqlite3"

URI_x86_64_v2_php8.4-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-pgsql-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-pgsql}"
SRC_URI[x86_64_v2_php8.4-pgsql.sha256sum] = "d06da081e6b2d0def2afa871cf73df94a9f62a349f5d48e88e7cd6ba54d028a8"
RPROVIDES:php8.4-pgsql:x86_64_v2 = "virtual/php-pgsql"

URI_x86_64_v2_php8.4-process = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-process-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-process}"
SRC_URI[x86_64_v2_php8.4-process.sha256sum] = "c265118870e9148a88e52d5cf59dffc41c1191ef9aa4be464ffa5706ad33e2a3"
RPROVIDES:php8.4-process:x86_64_v2 = "virtual/php-posix virtual/php-process"

URI_x86_64_v2_php8.4-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-snmp-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-snmp}"
SRC_URI[x86_64_v2_php8.4-snmp.sha256sum] = "6bab75ad7d6833e9ac6fe70c0afe03e40b283a04163d2869cc361fd80c2f072d"

URI_x86_64_v2_php8.4-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-soap-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-soap}"
SRC_URI[x86_64_v2_php8.4-soap.sha256sum] = "04ae0737d4b14be4d7f7f381cfbd2b26e30797f7121e9162828090e5192c20a6"

URI_x86_64_v2_php8.4-xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php8.4-xml-8.4.23-2.el10.x86_64_v2.rpm;name=x86_64_v2_php8.4-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php8.4-xml}"
SRC_URI[x86_64_v2_php8.4-xml.sha256sum] = "cd5b24270d8844f54d0cd3271332d4172d13ab5be9dd4726a9f35d26b149660b"
RPROVIDES:php8.4-xml:x86_64_v2 = "virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

URI_aarch64_php8.4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4}"
SRC_URI[aarch64_php8.4.sha256sum] = "01844e7109d6b1d2262de844c6202c41e3e28f52e2aaffc6703f32810efd2155"
RPROVIDES:php8.4:aarch64 = "virtual/php"

URI_aarch64_php8.4-bcmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-bcmath-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-bcmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-bcmath}"
SRC_URI[aarch64_php8.4-bcmath.sha256sum] = "a81f26adba7cceb45f0c02c7cab7f0ed79970a6d9f85de5a2ac987e196422a3c"
RPROVIDES:php8.4-bcmath:aarch64 = "virtual/php-bcmath"

URI_aarch64_php8.4-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-cli-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-cli}"
SRC_URI[aarch64_php8.4-cli.sha256sum] = "5395fbebfb08911bcb6aac37747ec61509f253c0ea3a4cf5d150d6b1d71192c7"
RPROVIDES:php8.4-cli:aarch64 = "virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

URI_aarch64_php8.4-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-common-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-common}"
SRC_URI[aarch64_php8.4-common.sha256sum] = "ce50120ee29b182024e7412caf727d5e0bf459ed6dc1c08f43f55fd471492a60"
RPROVIDES:php8.4-common:aarch64 = "virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_aarch-64_ virtual/php-json virtual/php-json_aarch-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_aarch-64_ virtual/php-spl virtual/php-spl_aarch-64_ virtual/php-tokenizer virtual/php-tokenizer_aarch-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

URI_aarch64_php8.4-dba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-dba-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-dba;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-dba}"
SRC_URI[aarch64_php8.4-dba.sha256sum] = "a2bcb348374c4119349c68a4168b01b57d752e33c6e4accedc9590557d640e5b"

URI_aarch64_php8.4-dbg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-dbg-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-dbg;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-dbg}"
SRC_URI[aarch64_php8.4-dbg.sha256sum] = "66846f4698ee60de8f271dacbda583a69328ecdd3d20b37495c4380efceda140"

URI_aarch64_php8.4-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-devel-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-devel}"
SRC_URI[aarch64_php8.4-devel.sha256sum] = "a3ef97de73d38a0c0904e36147dcdaf3939cf6e73d5378de90ca9bb00e65f7f0"

URI_aarch64_php8.4-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-embedded-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-embedded}"
SRC_URI[aarch64_php8.4-embedded.sha256sum] = "4cac1e51c1649cb65ddb452a5c9d161b1409444d865f896c37ee18bcd3aecf1b"

URI_aarch64_php8.4-enchant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-enchant-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-enchant;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-enchant}"
SRC_URI[aarch64_php8.4-enchant.sha256sum] = "6c90004dec1501f5778c77c88de291dbfebeb4f496c6c481338af29e8cb00e9c"

URI_aarch64_php8.4-ffi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-ffi-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-ffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-ffi}"
SRC_URI[aarch64_php8.4-ffi.sha256sum] = "7ab9674d40594c3491cd3f43f65ae7f84d60c5a807e058244a2f83fe14019730"

URI_aarch64_php8.4-fpm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-fpm-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-fpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-fpm}"
SRC_URI[aarch64_php8.4-fpm.sha256sum] = "e182a3bb64c51d3f35b8d04218988e3693468c71e2bc43302d0d5ffcd8f7bfd4"
RPROVIDES:php8.4-fpm:aarch64 = "virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

URI_aarch64_php8.4-gd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-gd-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-gd}"
SRC_URI[aarch64_php8.4-gd.sha256sum] = "0b8a9fc588f61afc96b7c038ed6c4d9609330c05b971b7b732b57ffd0364395f"
RPROVIDES:php8.4-gd:aarch64 = "virtual/php-gd virtual/php-gd_aarch-64_"

URI_aarch64_php8.4-gmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-gmp-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-gmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-gmp}"
SRC_URI[aarch64_php8.4-gmp.sha256sum] = "4310c10c35a3268f8262a5317573e0405cf7d1c5d334c328252d10eef33ad0cf"
RPROVIDES:php8.4-gmp:aarch64 = "virtual/php-gmp"

URI_aarch64_php8.4-intl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-intl-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-intl;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-intl}"
SRC_URI[aarch64_php8.4-intl.sha256sum] = "5e68e16edd3289294954174140d7e834e55c3cbd5ede115c43fccfa6cd17f0f2"
RPROVIDES:php8.4-intl:aarch64 = "virtual/php-intl"

URI_aarch64_php8.4-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-ldap-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-ldap}"
SRC_URI[aarch64_php8.4-ldap.sha256sum] = "b26d25f4b669fa34692388f508b64181f0c6432c72fd5d677da877bbe44f1d84"
RPROVIDES:php8.4-ldap:aarch64 = "virtual/php-ldap"

URI_aarch64_php8.4-mbstring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-mbstring-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-mbstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-mbstring}"
SRC_URI[aarch64_php8.4-mbstring.sha256sum] = "2d07775985dcfa81999c2d78108c8f283c8cb511213a89ae9f91951eabf496c8"
RPROVIDES:php8.4-mbstring:aarch64 = "virtual/php-mbstring"

URI_aarch64_php8.4-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-mysqlnd-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-mysqlnd}"
SRC_URI[aarch64_php8.4-mysqlnd.sha256sum] = "5277439d7b002cfe7171f03bac7e5573eaeba30ffe38c042f76f40fac056356e"
RPROVIDES:php8.4-mysqlnd:aarch64 = "virtual/php-mysqli virtual/php-mysqlnd"

URI_aarch64_php8.4-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-odbc-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-odbc}"
SRC_URI[aarch64_php8.4-odbc.sha256sum] = "24423ce629c00f649960bd1ea8b24ee35cc970d2e5969f7996a20ee016fad76d"

URI_aarch64_php8.4-opcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-opcache-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-opcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-opcache}"
SRC_URI[aarch64_php8.4-opcache.sha256sum] = "ebde1839a3479a191b195930ef06e7efedbef947d21729dfeba3629e7326b761"
RPROVIDES:php8.4-opcache:aarch64 = "virtual/php-opcache"

URI_aarch64_php8.4-pdo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-pdo-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-pdo;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pdo}"
SRC_URI[aarch64_php8.4-pdo.sha256sum] = "21b4e317eb2c034bd381afda6329e98c1b6743f47af7ba24d8fb55568eeb79c0"
RPROVIDES:php8.4-pdo:aarch64 = "virtual/php-pdo virtual/php-sqlite3"

URI_aarch64_php8.4-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-pgsql-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-pgsql}"
SRC_URI[aarch64_php8.4-pgsql.sha256sum] = "8bb00f9d380e4533b2d8c507fce176aab8a6b938dd19f23ca3e556dfd3e1b058"
RPROVIDES:php8.4-pgsql:aarch64 = "virtual/php-pgsql"

URI_aarch64_php8.4-process = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-process-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-process}"
SRC_URI[aarch64_php8.4-process.sha256sum] = "5a1704a01b4fcb4146b406359025d5e8465ed524e4261c72a3c5274b6dd6d6ab"
RPROVIDES:php8.4-process:aarch64 = "virtual/php-posix virtual/php-process"

URI_aarch64_php8.4-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-snmp-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-snmp}"
SRC_URI[aarch64_php8.4-snmp.sha256sum] = "6dbc2a3ca0080a005149a35966e395d687ba65a05b591d2f71aca44a79fcebb9"

URI_aarch64_php8.4-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-soap-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-soap}"
SRC_URI[aarch64_php8.4-soap.sha256sum] = "d1460e1e25dca7ab23b858a8c877ac96e18af61fbc4951281dbad19f800faa43"

URI_aarch64_php8.4-xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php8.4-xml-8.4.23-2.el10.aarch64.rpm;name=aarch64_php8.4-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_php8.4-xml}"
SRC_URI[aarch64_php8.4-xml.sha256sum] = "f295b1da52e3ca331345ae261021c2953af9d9c4902a710e74cf8ee1de95979a"
RPROVIDES:php8.4-xml:aarch64 = "virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

RDEPENDS:php8.4 = " \
 php8.4-common \
 "
RDEPENDS:php8.4-bcmath = " \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-cli = " \
 bash \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php8.4-common \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-common = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 tzdata \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:php8.4-dba = " \
 glibc \
 lmdb-libs \
 php8.4-common \
 tokyocabinet \
 "
RDEPENDS:php8.4-dbg = " \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php8.4-common \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-devel = " \
 autoconf \
 automake \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
 libtool \
 libxml2-devel \
 make \
 openssl-devel \
 pcre2-devel \
 php8.4-cli \
 php8.4-common \
 zlib-ng-compat-devel \
 "
RDEPENDS:php8.4-embedded = " \
 glibc \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php8.4-common \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-enchant = " \
 enchant2 \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-ffi = " \
 glibc \
 libffi \
 php8.4-common \
 "
RDEPENDS:php8.4-fpm = " \
 bash \
 glibc \
 httpd-filesystem \
 libacl \
 libselinux \
 libxcrypt \
 libxml2 \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 php8.4-common \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-gd = " \
 gd \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-gmp = " \
 glibc \
 gmp \
 php8.4-common \
 "
RDEPENDS:php8.4-intl = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 php8.4-common \
 "
RDEPENDS:php8.4-ldap = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 php8.4-common \
 "
RDEPENDS:php8.4-mbstring = " \
 glibc \
 oniguruma \
 php8.4-common \
 "
RDEPENDS:php8.4-mysqlnd = " \
 glibc \
 openssl-libs \
 php8.4-common \
 php8.4-pdo \
 zlib-ng-compat \
 "
RDEPENDS:php8.4-odbc = " \
 glibc \
 php8.4-common \
 php8.4-pdo \
 unixODBC \
 "
RDEPENDS:php8.4-opcache:x86_64_v2 = " \
 capstone \
 glibc \
 libgcc \
 php8.4-common \
"
RDEPENDS:php8.4-opcache:aarch64 = " \
 capstone \
 glibc \
 php8.4-common \
"
RDEPENDS:php8.4-pdo = " \
 glibc \
 php8.4-common \
 sqlite-libs \
 "
RDEPENDS:php8.4-pgsql = " \
 glibc \
 libpq \
 php8.4-common \
 php8.4-pdo \
 "
RDEPENDS:php8.4-process = " \
 glibc \
 php8.4-common \
 "
RDEPENDS:php8.4-snmp = " \
 glibc \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php8.4-common \
 "
RDEPENDS:php8.4-soap = " \
 glibc \
 libxml2 \
 php8.4-common \
 "
RDEPENDS:php8.4-xml = " \
 glibc \
 libxml2 \
 libxslt \
 php8.4-common \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/php rpm/virtual/php rpm/virtual/php-bcmath rpm/virtual/php-bz2 rpm/virtual/php-cli rpm/virtual/php-ctype rpm/virtual/php-curl rpm/virtual/php-date rpm/virtual/php-dom rpm/virtual/php-exif rpm/virtual/php-fileinfo rpm/virtual/php-filter rpm/virtual/php-fpm rpm/virtual/php-fpm_ge_8.0 rpm/virtual/php-ftp rpm/virtual/php-gd rpm/virtual/php-gd_x86-64_ rpm/virtual/php-gettext rpm/virtual/php-gmp rpm/virtual/php-hash rpm/virtual/php-iconv rpm/virtual/php-iconv_x86-64_ rpm/virtual/php-intl rpm/virtual/php-json rpm/virtual/php-json_x86-64_ rpm/virtual/php-ldap rpm/virtual/php-libxml rpm/virtual/php-mbstring rpm/virtual/php-mhash rpm/virtual/php-mysqli rpm/virtual/php-mysqlnd rpm/virtual/php-opcache rpm/virtual/php-openssl rpm/virtual/php-pcntl rpm/virtual/php-pcre rpm/virtual/php-pdo rpm/virtual/php-pgsql rpm/virtual/php-phar rpm/virtual/php-posix rpm/virtual/php-process rpm/virtual/php-reflection rpm/virtual/php-session rpm/virtual/php-simplexml rpm/virtual/php-sockets rpm/virtual/php-sockets_x86-64_ rpm/virtual/php-spl rpm/virtual/php-spl_x86-64_ rpm/virtual/php-sqlite3 rpm/virtual/php-tokenizer rpm/virtual/php-tokenizer_x86-64_ rpm/virtual/php-xml rpm/virtual/php-xmlreader rpm/virtual/php-xmlwriter rpm/virtual/php-xsl rpm/virtual/php-zlib rpm/virtual/php_httpd_ rpm/virtual/php_language__ge_5.3.0 rpm/virtual/php_language__ge_5.3.1 rpm/virtual/php_language__ge_5.3.3 rpm/virtual/php_language__ge_7.1 rpm/virtual/php_language__ge_7.2 rpm/virtual/php_language__ge_7.2.5 rpm/virtual/php_language__ge_7.3 rpm/virtual/php_language__ge_7.4 rpm/virtual/php_language__ge_8.1 rpm/virtual/php_language__gt_5.3 rpm/virtual/php_language__gt_5.4"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/php rpm/virtual/php rpm/virtual/php-bcmath rpm/virtual/php-bz2 rpm/virtual/php-cli rpm/virtual/php-ctype rpm/virtual/php-curl rpm/virtual/php-date rpm/virtual/php-dom rpm/virtual/php-exif rpm/virtual/php-fileinfo rpm/virtual/php-filter rpm/virtual/php-fpm rpm/virtual/php-fpm_ge_8.0 rpm/virtual/php-ftp rpm/virtual/php-gd rpm/virtual/php-gd_aarch-64_ rpm/virtual/php-gettext rpm/virtual/php-gmp rpm/virtual/php-hash rpm/virtual/php-iconv rpm/virtual/php-iconv_aarch-64_ rpm/virtual/php-intl rpm/virtual/php-json rpm/virtual/php-json_aarch-64_ rpm/virtual/php-ldap rpm/virtual/php-libxml rpm/virtual/php-mbstring rpm/virtual/php-mhash rpm/virtual/php-mysqli rpm/virtual/php-mysqlnd rpm/virtual/php-opcache rpm/virtual/php-openssl rpm/virtual/php-pcntl rpm/virtual/php-pcre rpm/virtual/php-pdo rpm/virtual/php-pgsql rpm/virtual/php-phar rpm/virtual/php-posix rpm/virtual/php-process rpm/virtual/php-reflection rpm/virtual/php-session rpm/virtual/php-simplexml rpm/virtual/php-sockets rpm/virtual/php-sockets_aarch-64_ rpm/virtual/php-spl rpm/virtual/php-spl_aarch-64_ rpm/virtual/php-sqlite3 rpm/virtual/php-tokenizer rpm/virtual/php-tokenizer_aarch-64_ rpm/virtual/php-xml rpm/virtual/php-xmlreader rpm/virtual/php-xmlwriter rpm/virtual/php-xsl rpm/virtual/php-zlib rpm/virtual/php_httpd_ rpm/virtual/php_language__ge_5.3.0 rpm/virtual/php_language__ge_5.3.1 rpm/virtual/php_language__ge_5.3.3 rpm/virtual/php_language__ge_7.1 rpm/virtual/php_language__ge_7.2 rpm/virtual/php_language__ge_7.2.5 rpm/virtual/php_language__ge_7.3 rpm/virtual/php_language__ge_7.4 rpm/virtual/php_language__ge_8.1 rpm/virtual/php_language__gt_5.3 rpm/virtual/php_language__gt_5.4"
