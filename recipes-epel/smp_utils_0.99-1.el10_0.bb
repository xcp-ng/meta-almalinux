# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smp_utils"
PV = "0.99"
PR = "1.el10_0"
PACKAGES = " \
 smp_utils \
 smp_utils-devel \
 smp_utils-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/smp_utils-0.99-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7c5de7699f6b2fab00774b80c3f15e7d635a0c2ff4d372eeaec6ef360948322"

URI_x86_64_v2_smp_utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/smp_utils-0.99-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_smp_utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_smp_utils}"
SRC_URI[x86_64_v2_smp_utils.sha256sum] = "4ed5566f0780aba86fff8216cc9db6fb78990ad0e064d0ce89970584ce7a44c0"

URI_x86_64_v2_smp_utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/smp_utils-devel-0.99-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_smp_utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_smp_utils-devel}"
SRC_URI[x86_64_v2_smp_utils-devel.sha256sum] = "5f6522a9f25d809e71e3bfaec403c9a56e28d9979bbb6f233ff46f23a00d9fc7"

URI_x86_64_v2_smp_utils-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/smp_utils-libs-0.99-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_smp_utils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_smp_utils-libs}"
SRC_URI[x86_64_v2_smp_utils-libs.sha256sum] = "a4a50e51e61eeb8a57191c2c035afcd75a76cc5c42e360cdb8f5c519b4e68ae9"

URI_aarch64_smp_utils = "${EPEL_MIRROR}/aarch64/Packages/s/smp_utils-0.99-1.el10_0.aarch64.rpm;name=aarch64_smp_utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_smp_utils}"
SRC_URI[aarch64_smp_utils.sha256sum] = "08de70793ae40466b0cd57e86f96f4d3b69025ed7d468df97d8bf01fd803c792"

URI_aarch64_smp_utils-devel = "${EPEL_MIRROR}/aarch64/Packages/s/smp_utils-devel-0.99-1.el10_0.aarch64.rpm;name=aarch64_smp_utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_smp_utils-devel}"
SRC_URI[aarch64_smp_utils-devel.sha256sum] = "c15176117f71b7e9aad078d987ba7b6045f5217a048a1896491d5b1a2f171c85"

URI_aarch64_smp_utils-libs = "${EPEL_MIRROR}/aarch64/Packages/s/smp_utils-libs-0.99-1.el10_0.aarch64.rpm;name=aarch64_smp_utils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_smp_utils-libs}"
SRC_URI[aarch64_smp_utils-libs.sha256sum] = "4510670ecf667bc086ca43d3d7aa6b22f9016eb6dd097573089c9fd224ad1760"

RDEPENDS:smp_utils = " \
 glibc \
 smp_utils-libs \
 "
RDEPENDS:smp_utils-devel = " \
 smp_utils-libs \
 "
RDEPENDS:smp_utils-libs = " \
 glibc \
 "
