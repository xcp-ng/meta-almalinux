# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-regex-tdfa"
PV = "1.3.2.2"
PR = "1.el10_0"
PACKAGES = " \
 ghc-regex-tdfa \
 ghc-regex-tdfa-devel \
 ghc-regex-tdfa-doc \
 ghc-regex-tdfa-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-regex-tdfa-1.3.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f58b30ec4b9102068b704725623c7bf1efbc6ecf7840dc22cae1494bd87460d2"

URI_x86_64_v2_ghc-regex-tdfa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-tdfa-1.3.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-tdfa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-tdfa}"
SRC_URI[x86_64_v2_ghc-regex-tdfa.sha256sum] = "2181efcc629b9c9c2503a7409930d367e1130ea86852efa0976f560e4388caa6"

URI_x86_64_v2_ghc-regex-tdfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-tdfa-devel-1.3.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-tdfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-tdfa-devel}"
SRC_URI[x86_64_v2_ghc-regex-tdfa-devel.sha256sum] = "126be9c816d3b408444b57cde276d18f21d0265fa5b28f79d6de2244057534c0"

URI_x86_64_v2_ghc-regex-tdfa-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-tdfa-doc-1.3.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-regex-tdfa-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-tdfa-doc}"
SRC_URI[x86_64_v2_ghc-regex-tdfa-doc.sha256sum] = "bb5b03e68bacd888567348a7f9470cf14a717052a4ffbd3ab9da82025abf2d8a"

URI_x86_64_v2_ghc-regex-tdfa-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-tdfa-prof-1.3.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-tdfa-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-tdfa-prof}"
SRC_URI[x86_64_v2_ghc-regex-tdfa-prof.sha256sum] = "fa95cfde3e838642d31bb8030e5a5968a1679148ab27bb77fba24e4e3558d915"

URI_aarch64_ghc-regex-tdfa = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-tdfa-1.3.2.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-regex-tdfa;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-tdfa}"
SRC_URI[aarch64_ghc-regex-tdfa.sha256sum] = "1c4c82d8351f8d6e726adc1575eac6a589030fad024bb229c4e41b35ebc9a68d"

URI_aarch64_ghc-regex-tdfa-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-tdfa-devel-1.3.2.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-regex-tdfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-tdfa-devel}"
SRC_URI[aarch64_ghc-regex-tdfa-devel.sha256sum] = "52cfe6497b790383948e5774d7c35441a269d762d0e56da86ddcafe13c912084"

URI_aarch64_ghc-regex-tdfa-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-tdfa-doc-1.3.2.2-1.el10_0.noarch.rpm;name=aarch64_ghc-regex-tdfa-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-tdfa-doc}"
SRC_URI[aarch64_ghc-regex-tdfa-doc.sha256sum] = "0e05a30605ebc078619c51ee35917b7d37ebedb0f63542e4ea1c8581476d8637"

URI_aarch64_ghc-regex-tdfa-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-tdfa-prof-1.3.2.2-1.el10_0.aarch64.rpm;name=aarch64_ghc-regex-tdfa-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-tdfa-prof}"
SRC_URI[aarch64_ghc-regex-tdfa-prof.sha256sum] = "c3f072cc5c0a929f47fe3d479d8c9fe93d88173c9599d16b5bfeeb6979b01112"

RDEPENDS:ghc-regex-tdfa = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-regex-base \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-regex-tdfa-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-mtl-devel \
 ghc-parsec-devel \
 ghc-regex-base-devel \
 ghc-regex-tdfa \
 ghc-text-devel \
 "
RDEPENDS:ghc-regex-tdfa-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-regex-tdfa-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-mtl-prof \
 ghc-parsec-prof \
 ghc-regex-base-prof \
 ghc-regex-tdfa-devel \
 ghc-text-prof \
 "
