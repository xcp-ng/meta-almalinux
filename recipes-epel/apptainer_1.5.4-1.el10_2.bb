# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apptainer"
PV = "1.5.4"
PR = "1.el10_2"
PACKAGES = " \
 apptainer \
 apptainer-suid \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/apptainer-1.5.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fa625d687aba64e4d730eebc5751a775c6f59290a9a0c58832323ca261f6ccf9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer;unpack=0"
SRC_URI[x86_64_v2_apptainer.sha256sum] = "1c1fda1d6f2ccff1c20f2b9c3f01b69e7c9b5e5a6daba6e20b24d6531d1101f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apptainer-suid-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apptainer-suid;unpack=0"
SRC_URI[x86_64_v2_apptainer-suid.sha256sum] = "3c01f67fc37bd45d655be9caff1049c65abe349db639be3515341826b6b00260"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apptainer-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_apptainer;unpack=0"
SRC_URI[aarch64_apptainer.sha256sum] = "729e088bd9efbd5f601d96193137d86b0938e7327faff1f31672e15ba8fc346f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/apptainer-suid-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_apptainer-suid;unpack=0"
SRC_URI[aarch64_apptainer-suid.sha256sum] = "bfb8f14bd85ddbfe7e87d427dfc8e97bf48c2b5dc2655915b1a9fe0796328123"

RDEPENDS:apptainer = " \
 bash \
 fakeroot \
 fuse3-libs \
 glibc \
 libgcc \
 libseccomp \
 libtalloc \
 libzstd \
 lz4-libs \
 lzo \
 protobuf-c \
 shadow-utils-subid \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:apptainer-suid = " \
 apptainer \
 fuse3-libs \
 glibc \
 libseccomp \
 shadow-utils-subid \
 "
