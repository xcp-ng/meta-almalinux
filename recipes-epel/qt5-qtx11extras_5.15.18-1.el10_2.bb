# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtx11extras"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtx11extras \
 qt5-qtx11extras-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtx11extras-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5223a985893ca7e2940016c4651e0df24ad18da97492d24bf97388b536257d21"

URI_x86_64_v2_qt5-qtx11extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtx11extras-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtx11extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtx11extras}"
SRC_URI[x86_64_v2_qt5-qtx11extras.sha256sum] = "685e540cf584c87910db65a0627e51b174ae9017834288db52b7daec43fd938a"

URI_x86_64_v2_qt5-qtx11extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtx11extras-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtx11extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtx11extras-devel}"
SRC_URI[x86_64_v2_qt5-qtx11extras-devel.sha256sum] = "93fa653f8b9580048553b0e1264ea967fe6b10c603758ed2eeeb853102f9bed8"

URI_aarch64_qt5-qtx11extras = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtx11extras-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtx11extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtx11extras}"
SRC_URI[aarch64_qt5-qtx11extras.sha256sum] = "e4c562eb3dd187da4ff1915e3498a91b0dc79d51e66c7ce0c404b230c36309bf"

URI_aarch64_qt5-qtx11extras-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtx11extras-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtx11extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtx11extras-devel}"
SRC_URI[aarch64_qt5-qtx11extras-devel.sha256sum] = "47df12863cdcf015948b6e1d57041e6ba36a94a1dce1fa19a42aac44af996e38"

RDEPENDS:qt5-qtx11extras = " \
 glibc \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:qt5-qtx11extras-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtx11extras \
 "
