# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-font-viewer"
PV = "46.0"
PR = "1.el10"
PACKAGES = " \
 gnome-font-viewer \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-font-viewer-46.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d15935757534b48ec3d2cf6d0b2ba660339c84e4c84940fab042085cc6b33630"

URI_x86_64_v2_gnome-font-viewer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-font-viewer-46.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-font-viewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-font-viewer}"
SRC_URI[x86_64_v2_gnome-font-viewer.sha256sum] = "a6f463855ddca680b2da35ac51a2111bf4150eb579587dcbb13cb8fdb5c527a5"

URI_aarch64_gnome-font-viewer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-font-viewer-46.0-1.el10.aarch64.rpm;name=aarch64_gnome-font-viewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-font-viewer}"
SRC_URI[aarch64_gnome-font-viewer.sha256sum] = "9429580e5b7fe7a453e6548349933a04315c823bb89484244d7d62fe3eb5ef36"

RDEPENDS:gnome-font-viewer = " \
 cairo \
 fontconfig \
 freetype \
 fribidi \
 glib2 \
 glibc \
 graphene \
 gtk4 \
 harfbuzz \
 libadwaita \
 libgcc \
 pango \
 "
