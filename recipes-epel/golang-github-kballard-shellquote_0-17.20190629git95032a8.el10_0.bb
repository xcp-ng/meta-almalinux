# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kballard-shellquote"
PV = "0"
PR = "17.20190629git95032a8.el10_0"
PACKAGES = " \
 golang-github-kballard-shellquote-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kballard-shellquote-0-17.20190629git95032a8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2256aac2769a25f7d20c2cbdad43a5960720485d3b776ed9ff84725a1efd8a8"

URI_aarch64_golang-github-kballard-shellquote-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kballard-shellquote-devel-0-17.20190629git95032a8.el10_0.noarch.rpm;name=aarch64_golang-github-kballard-shellquote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kballard-shellquote-devel}"
SRC_URI[aarch64_golang-github-kballard-shellquote-devel.sha256sum] = "9396e6aff4b36936c165599098974c3b74b02a49b6df65990e874d6c4258a7e5"

RDEPENDS:golang-github-kballard-shellquote-devel = " \
 go-filesystem \
 "
