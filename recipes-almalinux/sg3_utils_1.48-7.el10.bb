# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sg3_utils"
PV = "1.48"
PR = "7.el10"
PACKAGES = " \
 sg3_utils \
 sg3_utils-devel \
 sg3_utils-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sg3_utils-1.48-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d45c24a2839caa6c2733aaada6ab289159fadbaea050ef587922b52da445abc7"

URI_x86_64_v2_sg3_utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sg3_utils-1.48-7.el10.x86_64_v2.rpm;name=x86_64_v2_sg3_utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sg3_utils}"
SRC_URI[x86_64_v2_sg3_utils.sha256sum] = "dd832e29f219c6660c1601c8a37b4f7a7b019f7964363e6d89e262b8f8b713ea"

URI_x86_64_v2_sg3_utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sg3_utils-devel-1.48-7.el10.x86_64_v2.rpm;name=x86_64_v2_sg3_utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sg3_utils-devel}"
SRC_URI[x86_64_v2_sg3_utils-devel.sha256sum] = "9a861934a0e68824515756cd846252277f5db7ba04ca2ddeb266351c39987e4e"

URI_x86_64_v2_sg3_utils-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sg3_utils-libs-1.48-7.el10.x86_64_v2.rpm;name=x86_64_v2_sg3_utils-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sg3_utils-libs}"
SRC_URI[x86_64_v2_sg3_utils-libs.sha256sum] = "b41e46cf438fb11fbe155a634a80b66d7b9582f93682d2bc4b2cd5c420c98fad"

URI_aarch64_sg3_utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sg3_utils-1.48-7.el10.aarch64.rpm;name=aarch64_sg3_utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_sg3_utils}"
SRC_URI[aarch64_sg3_utils.sha256sum] = "674a767d4e665f143992a6a9f675979cb0fd0d6d7f34e8071caf2139f5c9d7b2"

URI_aarch64_sg3_utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sg3_utils-devel-1.48-7.el10.aarch64.rpm;name=aarch64_sg3_utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sg3_utils-devel}"
SRC_URI[aarch64_sg3_utils-devel.sha256sum] = "07f11815fc2dba140cffcd966948d946e34a93efb7b5becb555c76d3efdc76f1"

URI_aarch64_sg3_utils-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sg3_utils-libs-1.48-7.el10.aarch64.rpm;name=aarch64_sg3_utils-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_sg3_utils-libs}"
SRC_URI[aarch64_sg3_utils-libs.sha256sum] = "25aed82c6279f37eda8e2c5149f8dc76cf2b12c515636fe959bc21660bda69a7"

RDEPENDS:sg3_utils = " \
 bash \
 glibc \
 libgcc \
 sg3_utils-libs \
 "
RDEPENDS:sg3_utils-devel = " \
 sg3_utils-libs \
 "
RDEPENDS:sg3_utils-libs = " \
 glibc \
 "
