# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-OpenSSH"
PV = "0.84"
PR = "10.el10_2"
PACKAGES = " \
 perl-Net-OpenSSH \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-OpenSSH-0.84-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2b48691565b28a01499ee132880683f6e54320714bd24622e16e29d02789b3c"

URI_x86_64_v2_perl-Net-OpenSSH = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-OpenSSH-0.84-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-OpenSSH;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-OpenSSH}"
SRC_URI[x86_64_v2_perl-Net-OpenSSH.sha256sum] = "d4038ed1b0306db79406e17adce01eb7d90db6c6840b2f88489d7caac9320be3"

URI_aarch64_perl-Net-OpenSSH = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-OpenSSH-0.84-10.el10_2.noarch.rpm;name=aarch64_perl-Net-OpenSSH;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-OpenSSH}"
SRC_URI[aarch64_perl-Net-OpenSSH.sha256sum] = "54a7b815ed93fa5675d5fea1cb5d458a0406fae245c5fa4bbda705ad6f5af721"

RDEPENDS:perl-Net-OpenSSH = " \
 openssh-clients \
 perl-Carp \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Errno \
 perl-Exporter \
 perl-IO-Tty \
 perl-Moo \
 perl-Net-OpenSSH \
 perl-Object-Remote \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Socket \
 perl-libs \
 "
