# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kajongg"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kajongg \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kajongg-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4c95d475a16be3d5d047f0e3e54d3250d7d76817258d3e5f3efdfa39e7200e13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kajongg-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kajongg;unpack=0"
SRC_URI[x86_64_v2_kajongg.sha256sum] = "2df3118b986db3b2d4f4c4281ba10e4ce1615987dfacd1833e1204c565652a51"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kajongg-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kajongg;unpack=0"
SRC_URI[aarch64_kajongg.sha256sum] = "b881d938848041637cab9baf0fd350c1999052118cc24922584e13e9d8249b91"

RDEPENDS:kajongg = " \
 libkmahjongg-data \
 python3 \
 python3-QtPy \
 python3-pyqt6 \
 python3-twisted \
 vorbis-tools \
 "
