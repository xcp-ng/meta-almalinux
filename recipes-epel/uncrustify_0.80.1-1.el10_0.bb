# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uncrustify"
PV = "0.80.1"
PR = "1.el10_0"
PACKAGES = " \
 uncrustify \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/u/uncrustify-0.80.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8a2d2a3a98d0c1b1d2c6a05b20762dfba271bacf2007fb36e7e3a6f6e26bc733"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uncrustify-0.80.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uncrustify;unpack=0"
SRC_URI[x86_64_v2_uncrustify.sha256sum] = "19905d2d6e89b7b43ca8046be9b32a147755ee70995ea60bd17e3efdd26eda15"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/u/uncrustify-0.80.1-1.el10_0.aarch64.rpm;name=aarch64_uncrustify;unpack=0"
SRC_URI[aarch64_uncrustify.sha256sum] = "25a63d68e08e41015bf0fd0df6249bca8b57df12e104cb169c6f00eefbbfe59d"

RDEPENDS:uncrustify = " \
 glibc \
 libgcc \
 libstdc++ \
 "
