# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ansi_term0.11"
PV = "0.11.0"
PR = "18.el10_0"
PACKAGES = " \
 rust-ansi_term0.11+default-devel \
 rust-ansi_term0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ansi_term0.11-0.11.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7936471163258435a757090f62dfe6ac69e52b7d66535a45163a64c668cbc676"

URI_x86_64_v2_rust-ansi_term0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_term0.11+default-devel-0.11.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_term0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_term0.11+default-devel}"
SRC_URI[x86_64_v2_rust-ansi_term0.11+default-devel.sha256sum] = "0fc3af66139bcc8f41430c84ced9dc184334f5ca838f7c84c819322a62f8be97"

URI_x86_64_v2_rust-ansi_term0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansi_term0.11-devel-0.11.0-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansi_term0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansi_term0.11-devel}"
SRC_URI[x86_64_v2_rust-ansi_term0.11-devel.sha256sum] = "895906316b9c86d65a52f72a1b2b3c12f7a4ca932dd1a3a9549e8c0aaf374531"

URI_aarch64_rust-ansi_term0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_term0.11+default-devel-0.11.0-18.el10_0.noarch.rpm;name=aarch64_rust-ansi_term0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_term0.11+default-devel}"
SRC_URI[aarch64_rust-ansi_term0.11+default-devel.sha256sum] = "1ba9a472a2cdc858e80aeac815ee2fa2b2ff2eaee0184b64897d0208a9ad7248"

URI_aarch64_rust-ansi_term0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansi_term0.11-devel-0.11.0-18.el10_0.noarch.rpm;name=aarch64_rust-ansi_term0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansi_term0.11-devel}"
SRC_URI[aarch64_rust-ansi_term0.11-devel.sha256sum] = "c25cdf74aa378f0ea4f13da6c0e5f578429076666ea3ae0212a0e00c7f9333d7"

RDEPENDS:rust-ansi_term0.11+default-devel = " \
 cargo \
 rust-ansi_term0.11-devel \
 "
RDEPENDS:rust-ansi_term0.11-devel = " \
 cargo \
 "
