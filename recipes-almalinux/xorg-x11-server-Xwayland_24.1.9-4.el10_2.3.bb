# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-server-Xwayland"
PV = "24.1.9"
PR = "4.el10_2.3"
PACKAGES = " \
 xorg-x11-server-Xwayland \
 xorg-x11-server-Xwayland-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xorg-x11-server-Xwayland-24.1.9-4.el10_2.3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cea397e6bce36a139d9dc4f71868a43d1095f976824d90c71e338a2f14dc30c"

URI_x86_64_v2_xorg-x11-server-Xwayland = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-24.1.9-4.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-server-Xwayland}"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland.sha256sum] = "cbd5381be0c5ba1f06ceb10d8dcf9ccaef0dc1eda999cce103580753c7a51ab7"

URI_x86_64_v2_xorg-x11-server-Xwayland-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-devel-24.1.9-4.el10_2.3.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-server-Xwayland-devel}"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland-devel.sha256sum] = "9c14ea7559bbdf0671e5d03dea8bcc2f574fef6bb453883842a38ff105934788"

URI_aarch64_xorg-x11-server-Xwayland = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xorg-x11-server-Xwayland-24.1.9-4.el10_2.3.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-server-Xwayland}"
SRC_URI[aarch64_xorg-x11-server-Xwayland.sha256sum] = "2ce522fbe26a81a103eebb1a30501d208b28184b472bd894ab50acde0c418b28"

URI_aarch64_xorg-x11-server-Xwayland-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xorg-x11-server-Xwayland-devel-24.1.9-4.el10_2.3.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-server-Xwayland-devel}"
SRC_URI[aarch64_xorg-x11-server-Xwayland-devel.sha256sum] = "798ea8d52aa82ffd4cc0a0c92c5256b8539e765babe3eaf50bf71463ea95ca99"

RDEPENDS:xorg-x11-server-Xwayland = " \
 audit-libs \
 glibc \
 libXau \
 libXdmcp \
 libXfont2 \
 libdecor \
 libdrm \
 libei \
 libepoxy \
 libglvnd-egl \
 libglvnd-glx \
 liboeffis \
 libselinux \
 libtirpc \
 libwayland-client \
 libxcvt \
 libxshmfence \
 mesa-libgbm \
 openssl-libs \
 pixman \
 xkbcomp \
 xkeyboard-config \
 "
RDEPENDS:xorg-x11-server-Xwayland-devel = " \
 pkgconf-pkg-config \
 xorg-x11-server-Xwayland \
 "
