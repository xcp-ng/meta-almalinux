# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libabigail"
PV = "2.8"
PR = "2.el10"
PACKAGES = " \
 libabigail \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/libabigail-2.8-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2adb2e7ba0ebd44fb7bd8d613d0a39de52941534e26fd1a5de78d50d363ab0ce"

URI_x86_64_v2_libabigail = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libabigail-2.8-2.el10.x86_64_v2.rpm;name=x86_64_v2_libabigail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libabigail}"
SRC_URI[x86_64_v2_libabigail.sha256sum] = "4c1d6ba086280dac1e19008a44b798accdf19fea7098e8795b723ff5e1ca3561"

URI_aarch64_libabigail = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libabigail-2.8-2.el10.aarch64.rpm;name=aarch64_libabigail;unpack=0"
SRC_URI:append = " ${URI_aarch64_libabigail}"
SRC_URI[aarch64_libabigail.sha256sum] = "992978f65a4cd1a0df9f53d1054b970ad4bc298c58e77b4d4a60c5b6d8dcc9cf"

RDEPENDS:libabigail = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 libxml2 \
 virtual/libctf.so.0_LIBCTF_1.0__64bit_ \
 virtual/libctf.so.0_LIBCTF_1.1__64bit_ \
 virtual/libctf.so.0_LIBCTF_1.2__64bit_ \
 virtual/libctf.so.0___64bit_ \
 xz-libs \
 "
