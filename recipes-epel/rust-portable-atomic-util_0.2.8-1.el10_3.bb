# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-portable-atomic-util"
PV = "0.2.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 rust-portable-atomic-util+serde-devel \
 rust-portable-atomic-util+std-devel \
 rust-portable-atomic-util-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-portable-atomic-util-0.2.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "04217873e6d1adfad364c023be5c08ccd14a65caf690fc86d4c211c2548e3d6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+alloc-devel-0.2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util+alloc-devel.sha256sum] = "68533da90dead4db5b66b26fe1aeab5bef074d25aaeefe86227e303af8e72ff9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+default-devel-0.2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util+default-devel.sha256sum] = "d4f4e4f8c4fefa6aaae2367e03fa6f219699a6d98d542aa0705095734ba47ce6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+serde-devel-0.2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util+serde-devel.sha256sum] = "dbf0b9fa3c3f5b63feea5952e09275e232fdbc3cc3f17566ad22e3606d640ad3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util+std-devel-0.2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util+std-devel.sha256sum] = "984430e26faec02d7fc38900f51b0bbba46ee73f6f5da2bff3abed30fbe65898"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-portable-atomic-util-devel-0.2.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-portable-atomic-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-portable-atomic-util-devel.sha256sum] = "57f9b16bcba5792349cb8138b2f82e8dfe2af31fff5bb9c045bbfba9d799e7c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+alloc-devel-0.2.8-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util+alloc-devel.sha256sum] = "b39f8811fbffecad31781ff027747260187b8f66a6a2bd54d23ac3bb7f3c57c8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+default-devel-0.2.8-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util+default-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util+default-devel.sha256sum] = "a9246d3bea7f962f2f5e2d12208f5ce6557252253e45a82637b3367bb746653e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+serde-devel-0.2.8-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util+serde-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util+serde-devel.sha256sum] = "8a6cc25112b92dd89816a11df5f2833e7ca365b4b703ac704fbd7b607c50145c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util+std-devel-0.2.8-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util+std-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util+std-devel.sha256sum] = "1f388d88f58b61da872c23c3c01361605b5a8c86f2bbb6d49880de5a78952fb9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-portable-atomic-util-devel-0.2.8-1.el10_3.noarch.rpm;name=aarch64_rust-portable-atomic-util-devel;unpack=0"
SRC_URI[aarch64_rust-portable-atomic-util-devel.sha256sum] = "9f4642cafe63c93fadd40b79f9d093be7b61ed6104603e9c5e6c2b4bff5d49d2"

RDEPENDS:rust-portable-atomic-util+alloc-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+default-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util+serde-devel = " \
 cargo \
 rust-portable-atomic-util-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-portable-atomic-util+std-devel = " \
 cargo \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-portable-atomic-util-devel = " \
 cargo \
 rust \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 "
