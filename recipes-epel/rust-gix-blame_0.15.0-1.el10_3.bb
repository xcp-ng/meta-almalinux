# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-blame"
PV = "0.15.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-blame+default-devel \
 rust-gix-blame+sha1-devel \
 rust-gix-blame+sha256-devel \
 rust-gix-blame-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-blame-0.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "051e3f66a74b7509cbb3378965d6ff7d4e1ea7b640ff9339e0ffabf2ad39f2ed"

URI_x86_64_v2_rust-gix-blame+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-blame+default-devel-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-blame+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-blame+default-devel}"
SRC_URI[x86_64_v2_rust-gix-blame+default-devel.sha256sum] = "986c3cfc82d786a6968c01a41d1a349ca3ebee38c573a3000d9918321500ef5f"

URI_x86_64_v2_rust-gix-blame+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-blame+sha1-devel-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-blame+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-blame+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-blame+sha1-devel.sha256sum] = "c6d3117bf3d966e79fb75d0883cb5695536758cb902ec89686d1cc2b096f035c"

URI_x86_64_v2_rust-gix-blame+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-blame+sha256-devel-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-blame+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-blame+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-blame+sha256-devel.sha256sum] = "b8bb3313ba6463282875a4f797a635c8a20d54d6ff96204f05258266e2fb9552"

URI_x86_64_v2_rust-gix-blame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-blame-devel-0.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-blame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-blame-devel}"
SRC_URI[x86_64_v2_rust-gix-blame-devel.sha256sum] = "280202337f9610291911cf8d036d2e5f58a0867746c0569bf54cc4205280f310"

URI_aarch64_rust-gix-blame+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-blame+default-devel-0.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-blame+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-blame+default-devel}"
SRC_URI[aarch64_rust-gix-blame+default-devel.sha256sum] = "e9f97b7e262f52cab94615c29f8828eadc8ec4bfbdbe9a24b64c2d03e2331ee8"

URI_aarch64_rust-gix-blame+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-blame+sha1-devel-0.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-blame+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-blame+sha1-devel}"
SRC_URI[aarch64_rust-gix-blame+sha1-devel.sha256sum] = "a61ff246495cd43b5beb6d9d786f813c43e1c4bceedd636ea2ce79d323249cac"

URI_aarch64_rust-gix-blame+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-blame+sha256-devel-0.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-blame+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-blame+sha256-devel}"
SRC_URI[aarch64_rust-gix-blame+sha256-devel.sha256sum] = "12d3125ab435dec86443b04507b1ff37067b94f77569468c0c36bcc85dfdc7b8"

URI_aarch64_rust-gix-blame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-blame-devel-0.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-blame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-blame-devel}"
SRC_URI[aarch64_rust-gix-blame-devel.sha256sum] = "c9b86c1770dec41e8b32beb5af19074a7f392e3cc059e8871662e9850b079e12"

RDEPENDS:rust-gix-blame+default-devel = " \
 cargo \
 rust-gix-blame-devel \
 "
RDEPENDS:rust-gix-blame+sha1-devel = " \
 cargo \
 rust-gix-blame-devel \
 rust-gix-hash+sha1-devel \
 "
RDEPENDS:rust-gix-blame+sha256-devel = " \
 cargo \
 rust-gix-blame-devel \
 rust-gix-hash+sha256-devel \
 "
RDEPENDS:rust-gix-blame-devel = " \
 cargo \
 rust \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-error+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
