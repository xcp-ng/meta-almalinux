# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mapserver"
PV = "8.6.5"
PR = "1.el10_3"
PACKAGES = " \
 mapserver \
 mapserver-devel \
 mapserver-java \
 mapserver-libs \
 mapserver-perl \
 mapserver-ruby \
 php-mapserver \
 python3-mapserver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mapserver-8.6.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "164fbde09cb1cf63faae9e8b0cc16d496bfb10809a9c6d237fb21c177cd27115"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - mapserver-libs: libgeos_c.so.1()(64bit)

URI_x86_64_v2_mapserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-8.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver}"
SRC_URI[x86_64_v2_mapserver.sha256sum] = "37501cc1b6720aa958a582b736ec6beeff6ced70293d0744595e6714cebb7b21"

URI_x86_64_v2_mapserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-devel-8.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-devel}"
SRC_URI[x86_64_v2_mapserver-devel.sha256sum] = "0bd50704eeee8e52d0cad7b1b80cbc47c59030b5f64fb1c2cad513aabf8c8976"

URI_x86_64_v2_mapserver-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-java-8.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-java}"
SRC_URI[x86_64_v2_mapserver-java.sha256sum] = "584787057d7e9c303f32a3c1d346732c2926d9ba31df26edb657e30fe47e8b1e"

URI_x86_64_v2_mapserver-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-libs-8.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-libs}"
SRC_URI[x86_64_v2_mapserver-libs.sha256sum] = "5368ac8e07abe2819a33ac9891906ba9e53a91036139288f4907d5223ef43843"

URI_x86_64_v2_mapserver-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-perl-8.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-perl}"
SRC_URI[x86_64_v2_mapserver-perl.sha256sum] = "cbf5f159f59b0bc6275d9c599a614993f8b034cf5c1541e48bfdaa0145237fa0"

URI_x86_64_v2_mapserver-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mapserver-ruby-8.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mapserver-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mapserver-ruby}"
SRC_URI[x86_64_v2_mapserver-ruby.sha256sum] = "323580f485106a1feef6887cd1352330f6995e4b093ee372693a4b2c5dcf204c"

URI_x86_64_v2_php-mapserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-mapserver-8.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-mapserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mapserver}"
SRC_URI[x86_64_v2_php-mapserver.sha256sum] = "2ac6b9ecf4151e8184f581006440545f9790c7b187fd561b7fac78638eecae40"

URI_x86_64_v2_python3-mapserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mapserver-8.6.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-mapserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mapserver}"
SRC_URI[x86_64_v2_python3-mapserver.sha256sum] = "f68e896a3b5bab57f14510c97ccec86d717f9d71435d4f7b833f181f2d96b561"

URI_aarch64_mapserver = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-8.6.5-1.el10_3.aarch64.rpm;name=aarch64_mapserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver}"
SRC_URI[aarch64_mapserver.sha256sum] = "314930f7ac4e64b6351453c215f4fb3bead9d62b537cb6f16659d76358ff50d5"

URI_aarch64_mapserver-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-devel-8.6.5-1.el10_3.aarch64.rpm;name=aarch64_mapserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-devel}"
SRC_URI[aarch64_mapserver-devel.sha256sum] = "262b77325fc756b14c267309672d291e263bb2e622de4abd595e0be6410e7057"

URI_aarch64_mapserver-java = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-java-8.6.5-1.el10_3.aarch64.rpm;name=aarch64_mapserver-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-java}"
SRC_URI[aarch64_mapserver-java.sha256sum] = "3dc4d8eaecf0725ad0b0a92022641ff4e22a7277c2f2b3ef44384ae3dedbede2"

URI_aarch64_mapserver-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-libs-8.6.5-1.el10_3.aarch64.rpm;name=aarch64_mapserver-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-libs}"
SRC_URI[aarch64_mapserver-libs.sha256sum] = "b59b9718e595d63c918f6e277bc8507f4df80ed18c8d7d76f7941c9ff88bc4a3"

URI_aarch64_mapserver-perl = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-perl-8.6.5-1.el10_3.aarch64.rpm;name=aarch64_mapserver-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-perl}"
SRC_URI[aarch64_mapserver-perl.sha256sum] = "70bd14617951295b10e7a13dfa7517588d4cf2ef0fda1d666cf1921c4d4c8549"

URI_aarch64_mapserver-ruby = "${EPEL_MIRROR}/aarch64/Packages/m/mapserver-ruby-8.6.5-1.el10_3.aarch64.rpm;name=aarch64_mapserver-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_mapserver-ruby}"
SRC_URI[aarch64_mapserver-ruby.sha256sum] = "ac57816398662d713312f351159c13969fc7924e56f99f4fcd7269b16c882f6e"

URI_aarch64_php-mapserver = "${EPEL_MIRROR}/aarch64/Packages/p/php-mapserver-8.6.5-1.el10_3.aarch64.rpm;name=aarch64_php-mapserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mapserver}"
SRC_URI[aarch64_php-mapserver.sha256sum] = "cac30b182ec027af576dabfb3c2f0690b5317a5a9cb018f9e409918c4633d508"

URI_aarch64_python3-mapserver = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mapserver-8.6.5-1.el10_3.aarch64.rpm;name=aarch64_python3-mapserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mapserver}"
SRC_URI[aarch64_python3-mapserver.sha256sum] = "d6bc3b0af5baf9276640dc438087822ab8001a7b7bb2ecf4fdfed59f426ff6b9"

RDEPENDS:mapserver = " \
 dejavu-sans-fonts \
 fcgi \
 glibc \
 httpd \
 mapserver-libs \
 "
RDEPENDS:mapserver-devel = " \
 mapserver \
 mapserver-libs \
 "
RDEPENDS:mapserver-java = " \
 glibc \
 java-21-openjdk-headless \
 mapserver \
 mapserver-libs \
 "
RDEPENDS:mapserver-libs:x86_64_v2 = " \
 cairo \
 freetype \
 fribidi \
 gdal-libs \
 giflib \
 glibc \
 harfbuzz \
 libgcc \
 libjpeg-turbo \
 libpng \
 libpq \
 libstdc++ \
 libxml2 \
 libxslt \
 mariadb-connector-c \
 pcre2 \
 proj \
 protobuf-c \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:mapserver-libs:aarch64 = " \
 cairo \
 freetype \
 fribidi \
 gdal-libs \
 geos \
 giflib \
 glibc \
 harfbuzz \
 libgcc \
 libjpeg-turbo \
 libpng \
 libpq \
 libstdc++ \
 libxml2 \
 libxslt \
 mariadb-connector-c \
 pcre2 \
 proj \
 protobuf-c \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:mapserver-perl = " \
 glibc \
 mapserver \
 mapserver-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:mapserver-ruby = " \
 glibc \
 mapserver \
 mapserver-libs \
 ruby-libs \
 "
RDEPENDS:php-mapserver:x86_64_v2 = " \
 glibc \
 mapserver-libs \
 php8.4-common \
 virtual/php-gd_x86-64_ \
"
RDEPENDS:php-mapserver:aarch64 = " \
 glibc \
 mapserver-libs \
 php8.4-common \
 virtual/php-gd_aarch-64_ \
"
RDEPENDS:python3-mapserver = " \
 mapserver \
 python3 \
 "
