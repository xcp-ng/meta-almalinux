# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-microlens-th"
PV = "0.4.3.15"
PR = "1.el10_0"
PACKAGES = " \
 ghc-microlens-th \
 ghc-microlens-th-devel \
 ghc-microlens-th-doc \
 ghc-microlens-th-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-microlens-th-0.4.3.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4035c3dd43d7a38b32792d18475f993f097059c1a1298c640842a35f94cb561"

URI_x86_64_v2_ghc-microlens-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-th-0.4.3.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-th}"
SRC_URI[x86_64_v2_ghc-microlens-th.sha256sum] = "914dfb4d86c0764ffa0ad4ea05b6ae31a6f4513bc8ba7b4bca250f1e59b47932"

URI_x86_64_v2_ghc-microlens-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-th-devel-0.4.3.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-th-devel}"
SRC_URI[x86_64_v2_ghc-microlens-th-devel.sha256sum] = "e08feef1d93735a5dc956e3e12506a3d2e54cfb706401f5682f02bc2914cc7a3"

URI_x86_64_v2_ghc-microlens-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-th-doc-0.4.3.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-microlens-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-th-doc}"
SRC_URI[x86_64_v2_ghc-microlens-th-doc.sha256sum] = "b728b7087e819a3e5a56a1345993911a25763fa1d35793b963efd824130ab51e"

URI_x86_64_v2_ghc-microlens-th-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-th-prof-0.4.3.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-th-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-th-prof}"
SRC_URI[x86_64_v2_ghc-microlens-th-prof.sha256sum] = "37c4937755208534b32b04ebd0c0f96f3f955c62195b8269e2b802d90a59e94e"

URI_aarch64_ghc-microlens-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-th-0.4.3.15-1.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-th}"
SRC_URI[aarch64_ghc-microlens-th.sha256sum] = "040be57c6260fd428030ac5f38aaa46e7b3016e7e78ba9f1ab86d0cbfcb14b68"

URI_aarch64_ghc-microlens-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-th-devel-0.4.3.15-1.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-th-devel}"
SRC_URI[aarch64_ghc-microlens-th-devel.sha256sum] = "7a2db8b16c78164dd6c7d8ac5d1b95863183ff0f3cf1187592a81c84cdf0b43a"

URI_aarch64_ghc-microlens-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-th-doc-0.4.3.15-1.el10_0.noarch.rpm;name=aarch64_ghc-microlens-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-th-doc}"
SRC_URI[aarch64_ghc-microlens-th-doc.sha256sum] = "bb83ca438c6af846761cb0f17e18cf26083bd5d8d58be0a14b0b0d3589359269"

URI_aarch64_ghc-microlens-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-th-prof-0.4.3.15-1.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-th-prof}"
SRC_URI[aarch64_ghc-microlens-th-prof.sha256sum] = "4553eacb5c5ff7dcfed366a89cec1c3eb000b1aab167c24961592e590467cbbe"

RDEPENDS:ghc-microlens-th = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-microlens \
 ghc-pretty \
 ghc-template-haskell \
 ghc-th-abstraction \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-microlens-th-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-microlens-devel \
 ghc-microlens-th \
 ghc-template-haskell-devel \
 ghc-th-abstraction-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-microlens-th-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-microlens-th-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-microlens-prof \
 ghc-microlens-th-devel \
 ghc-template-haskell-prof \
 ghc-th-abstraction-prof \
 ghc-transformers-prof \
 "
