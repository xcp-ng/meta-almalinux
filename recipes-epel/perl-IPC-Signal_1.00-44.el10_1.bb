# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IPC-Signal"
PV = "1.00"
PR = "44.el10_1"
PACKAGES = " \
 perl-IPC-Signal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IPC-Signal-1.00-44.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f05e8b1ec33790fb8dc2d0030439c626d564a7c81419ab488d380c4a5d21f47"

URI_x86_64_v2_perl-IPC-Signal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IPC-Signal-1.00-44.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IPC-Signal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IPC-Signal}"
SRC_URI[x86_64_v2_perl-IPC-Signal.sha256sum] = "dd4a0539439aee940f2b4c11523e29e91e2516f3a2e723a57acb1511b1bb21d8"

URI_aarch64_perl-IPC-Signal = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IPC-Signal-1.00-44.el10_1.noarch.rpm;name=aarch64_perl-IPC-Signal;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IPC-Signal}"
SRC_URI[aarch64_perl-IPC-Signal.sha256sum] = "fbb1cd9ed11ba135725cc500afee5a30f8ec2a678962a311a798c30ad49901a2"

RDEPENDS:perl-IPC-Signal = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
