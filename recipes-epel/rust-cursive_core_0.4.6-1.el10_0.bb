# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive_core"
PV = "0.4.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-cursive_core+builder-devel \
 rust-cursive_core+default-devel \
 rust-cursive_core+doc-cfg-devel \
 rust-cursive_core+toml-devel \
 rust-cursive_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive_core-0.4.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57b16a058a6fb987090467e05f1dee38ee33716516c3dddd36289444ccccb66e"

URI_x86_64_v2_rust-cursive_core+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core+builder-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core+builder-devel}"
SRC_URI[x86_64_v2_rust-cursive_core+builder-devel.sha256sum] = "96631b5e514e16ffe0ba97260519bd89a0abd53f7091aebdfa4e391176f05fdb"

URI_x86_64_v2_rust-cursive_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core+default-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core+default-devel}"
SRC_URI[x86_64_v2_rust-cursive_core+default-devel.sha256sum] = "78eadbc6d248cfe64c3f025d8120a02c91b06c80c7ea8f7844d5c64da195c3cd"

URI_x86_64_v2_rust-cursive_core+doc-cfg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core+doc-cfg-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core+doc-cfg-devel}"
SRC_URI[x86_64_v2_rust-cursive_core+doc-cfg-devel.sha256sum] = "46a22ff2ed733f4335e60525e9ab3c9ec42f39ed90744ff55025bb3778ce7b4f"

URI_x86_64_v2_rust-cursive_core+toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core+toml-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core+toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core+toml-devel}"
SRC_URI[x86_64_v2_rust-cursive_core+toml-devel.sha256sum] = "19ecc1cca4821862da4ac8cfa42b8ee7b518b36549aac630859f6e00f7401166"

URI_x86_64_v2_rust-cursive_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive_core-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive_core-devel}"
SRC_URI[x86_64_v2_rust-cursive_core-devel.sha256sum] = "f1f2aff9213419586d0cd772445c910f4c2e45bda40fe3001a96e8f825aa2403"

URI_aarch64_rust-cursive_core+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core+builder-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core+builder-devel}"
SRC_URI[aarch64_rust-cursive_core+builder-devel.sha256sum] = "e4809fd2f92a796252f87c1b22fd25121ff4c4f80f8aff7187c3e77184e18c54"

URI_aarch64_rust-cursive_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core+default-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core+default-devel}"
SRC_URI[aarch64_rust-cursive_core+default-devel.sha256sum] = "3d6091d5ef27bbecb614ba63f906001e6fcdbe3ee7933e7cbe44e2495a9d2f28"

URI_aarch64_rust-cursive_core+doc-cfg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core+doc-cfg-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core+doc-cfg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core+doc-cfg-devel}"
SRC_URI[aarch64_rust-cursive_core+doc-cfg-devel.sha256sum] = "729055635425d98084f959fce7a341fa2d3a5bde83b9bbfac0491c8ea28706f3"

URI_aarch64_rust-cursive_core+toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core+toml-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core+toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core+toml-devel}"
SRC_URI[aarch64_rust-cursive_core+toml-devel.sha256sum] = "f5bdd4cc8e08d5ec8f7388de23d46a1348126b50f62060a03d379766c48b0786"

URI_aarch64_rust-cursive_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive_core-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-cursive_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive_core-devel}"
SRC_URI[aarch64_rust-cursive_core-devel.sha256sum] = "e7d643842c046f1f779533cb29ab556b848b7d54f7cfd3fc9728b576861f5642"

RDEPENDS:rust-cursive_core+builder-devel = " \
 cargo \
 rust-cursive-macros+builder-devel \
 rust-cursive_core-devel \
 rust-inventory+default-devel \
 "
RDEPENDS:rust-cursive_core+default-devel = " \
 cargo \
 rust-cursive_core-devel \
 "
RDEPENDS:rust-cursive_core+doc-cfg-devel = " \
 cargo \
 rust-cursive_core-devel \
 "
RDEPENDS:rust-cursive_core+toml-devel = " \
 cargo \
 rust-cursive_core-devel \
 rust-toml+default-devel \
 "
RDEPENDS:rust-cursive_core-devel = " \
 cargo \
 rust \
 rust-ahash+default-devel \
 rust-compact_str+default-devel \
 rust-crossbeam-channel+default-devel \
 rust-cursive-macros+default-devel \
 rust-enum-map+default-devel \
 rust-enumset+default-devel \
 rust-lazy_static+default-devel \
 rust-log+default-devel \
 rust-num-devel \
 rust-parking_lot+arc_lock-devel \
 rust-parking_lot+default-devel \
 rust-serde_json+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width0.1+default-devel \
 rust-xi-unicode+default-devel \
 "
