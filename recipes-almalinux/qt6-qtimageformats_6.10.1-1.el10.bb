# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtimageformats"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtimageformats \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtimageformats-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dbb6566ef9646dd5fce9ec8344ac0615920e201eef269bf002739ce046ad488"

URI_x86_64_v2_qt6-qtimageformats = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtimageformats-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtimageformats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtimageformats}"
SRC_URI[x86_64_v2_qt6-qtimageformats.sha256sum] = "78001c4ba607f544cad56f89d2c3afe0913a311fc70df7941f4ca29ae372ae9b"

URI_aarch64_qt6-qtimageformats = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtimageformats-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtimageformats;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtimageformats}"
SRC_URI[aarch64_qt6-qtimageformats.sha256sum] = "b0e59750f2b7d3aebf439a44a92718e174b571b069fdae8d3ddb420338358f01"

RDEPENDS:qt6-qtimageformats = " \
 cmake-filesystem \
 glibc \
 jasper-libs \
 libmng \
 libstdc++ \
 libtiff \
 libwebp \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
