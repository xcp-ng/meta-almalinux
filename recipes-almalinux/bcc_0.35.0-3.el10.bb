# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcc"
PV = "0.35.0"
PR = "3.el10"
PACKAGES = " \
 bcc \
 bcc-devel \
 bcc-doc \
 bcc-tools \
 libbpf-tools \
 python3-bcc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bcc-0.35.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ec9113c4687db2010553870139874863e5fa5d8d2a8f29a8daae06cbefc378d"

URI_x86_64_v2_bcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bcc-0.35.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_bcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc}"
SRC_URI[x86_64_v2_bcc.sha256sum] = "213357c3d628ee5846abc45d40842d69d7f3db0673793f7ada4510b9bb6f8c62"

URI_x86_64_v2_bcc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bcc-devel-0.35.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_bcc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc-devel}"
SRC_URI[x86_64_v2_bcc-devel.sha256sum] = "4728c7a3081bb2b85968305172ae506ad814b9cb02822b368c8b33d85115a42d"

URI_x86_64_v2_bcc-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bcc-doc-0.35.0-3.el10.noarch.rpm;name=x86_64_v2_bcc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc-doc}"
SRC_URI[x86_64_v2_bcc-doc.sha256sum] = "08ef93a53fed255f7a6a4fc958c58a62586bdd0ee16bcab922113d6506ffe459"

URI_x86_64_v2_bcc-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bcc-tools-0.35.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_bcc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc-tools}"
SRC_URI[x86_64_v2_bcc-tools.sha256sum] = "cae4cfda823a9ca5d6878f257555b8b756de7e5b88ec3a422344a92321325e39"

URI_x86_64_v2_libbpf-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libbpf-tools-0.35.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbpf-tools}"
SRC_URI[x86_64_v2_libbpf-tools.sha256sum] = "70f6ac35ea14956c8f16c322332e763f776c7b2001168686f818df25308199d9"

URI_x86_64_v2_python3-bcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-bcc-0.35.0-3.el10.noarch.rpm;name=x86_64_v2_python3-bcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bcc}"
SRC_URI[x86_64_v2_python3-bcc.sha256sum] = "d66e65f92dd6e23e1481561ca6ce940945399de4af23b60102b7be88bba50a31"

URI_aarch64_bcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bcc-0.35.0-3.el10.aarch64.rpm;name=aarch64_bcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc}"
SRC_URI[aarch64_bcc.sha256sum] = "6465b452995738ab7809883e6976f9b41a5cb94a77bc4120b487e3890df443fa"

URI_aarch64_bcc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bcc-devel-0.35.0-3.el10.aarch64.rpm;name=aarch64_bcc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc-devel}"
SRC_URI[aarch64_bcc-devel.sha256sum] = "e11b5fe94af11d0e11c4e2f94e1705f2cc97c3d840b0d5130923d6d4f6b81390"

URI_aarch64_bcc-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bcc-doc-0.35.0-3.el10.noarch.rpm;name=aarch64_bcc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc-doc}"
SRC_URI[aarch64_bcc-doc.sha256sum] = "08ef93a53fed255f7a6a4fc958c58a62586bdd0ee16bcab922113d6506ffe459"

URI_aarch64_bcc-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bcc-tools-0.35.0-3.el10.aarch64.rpm;name=aarch64_bcc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc-tools}"
SRC_URI[aarch64_bcc-tools.sha256sum] = "238384b75f116ab39be30bc6eab8b7337406cb6414b12d9e6a6136a32a4134fe"

URI_aarch64_libbpf-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libbpf-tools-0.35.0-3.el10.aarch64.rpm;name=aarch64_libbpf-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbpf-tools}"
SRC_URI[aarch64_libbpf-tools.sha256sum] = "8eaf26e93c97ee416757730fc2dbe0c8261f4099e90d942fd5e765a8b9441f9f"

URI_aarch64_python3-bcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-bcc-0.35.0-3.el10.noarch.rpm;name=aarch64_python3-bcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bcc}"
SRC_URI[aarch64_python3-bcc.sha256sum] = "d66e65f92dd6e23e1481561ca6ce940945399de4af23b60102b7be88bba50a31"

RDEPENDS:bcc = " \
 clang-libs \
 elfutils-debuginfod-client \
 elfutils-libelf \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 llvm-libs \
 tar \
 xz-libs \
 "
RDEPENDS:bcc-devel = " \
 bcc \
 pkgconf-pkg-config \
 "
RDEPENDS:bcc-doc = " \
 "
RDEPENDS:bcc-tools = " \
 bash \
 bcc \
 glibc \
 libbpf \
 python3 \
 python3-bcc \
 python3-netaddr \
 "
RDEPENDS:libbpf-tools = " \
 elfutils-libelf \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:python3-bcc = " \
 bcc \
 python3 \
 "
