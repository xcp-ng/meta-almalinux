# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Soundex"
PV = "3.05"
PR = "33.el10"
PACKAGES = " \
 perl-Text-Soundex \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Text-Soundex-3.05-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96c5502edb2b17b57000a59de9006a88278aa5fae9bab5830f7a9a9809dc29a3"

URI_x86_64_v2_perl-Text-Soundex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Soundex-3.05-33.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Text-Soundex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Soundex}"
SRC_URI[x86_64_v2_perl-Text-Soundex.sha256sum] = "2c1ce9c724e9eb747e6d07018e9f7c9fc70e06f1e0d7b184def159af445ae855"

URI_aarch64_perl-Text-Soundex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Soundex-3.05-33.el10.aarch64.rpm;name=aarch64_perl-Text-Soundex;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Soundex}"
SRC_URI[aarch64_perl-Text-Soundex.sha256sum] = "2e8b40819443aaa81f3ec163503cde39086b39e0ff1b56fda0f0f6d0eef31171"

RDEPENDS:perl-Text-Soundex = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Text-Unidecode \
 perl-deprecate \
 perl-if \
 perl-libs \
 "
