# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-lb"
PV = "0.20121128"
PR = "26.el10"
PACKAGES = " \
 hunspell-lb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-lb-0.20121128-26.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7556e8e6a79c2f2664e403a4437ac094bd189de78005b84b651c5b324c323790"

URI_x86_64_v2_hunspell-lb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-lb-0.20121128-26.el10.noarch.rpm;name=x86_64_v2_hunspell-lb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-lb}"
SRC_URI[x86_64_v2_hunspell-lb.sha256sum] = "28c22107ae6342712d61628a2e95afed5d8dc7930ff80d9a083c80b8c27e77c3"

URI_aarch64_hunspell-lb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-lb-0.20121128-26.el10.noarch.rpm;name=aarch64_hunspell-lb;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-lb}"
SRC_URI[aarch64_hunspell-lb.sha256sum] = "28c22107ae6342712d61628a2e95afed5d8dc7930ff80d9a083c80b8c27e77c3"

RDEPENDS:hunspell-lb = " \
 hunspell-filesystem \
 "
