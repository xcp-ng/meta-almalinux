# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tame-index"
PV = "0.26.3"
PR = "2.el10_3"
PACKAGES = " \
 rust-tame-index+default-devel \
 rust-tame-index+local-builder-devel \
 rust-tame-index+local-devel \
 rust-tame-index+sparse-devel \
 rust-tame-index-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tame-index-0.26.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a2ab5d50362ed581e35ba7fb40344b653610de53511726798fe576c6057921e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tame-index+default-devel-0.26.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tame-index+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tame-index+default-devel.sha256sum] = "81c768a8d00397cc9614870136807302fe489cece9997888f8b06369bf9090bc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tame-index+local-builder-devel-0.26.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tame-index+local-builder-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tame-index+local-builder-devel.sha256sum] = "1df0c39c4fb975d22c619cad972b8f20d814c9b11437539ea523bbd4b2a944ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tame-index+local-devel-0.26.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tame-index+local-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tame-index+local-devel.sha256sum] = "eb60639cbaa333814740101512a4052dab4f3693b7db958c3f73df90ea40cc15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tame-index+sparse-devel-0.26.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tame-index+sparse-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tame-index+sparse-devel.sha256sum] = "b953bb10262d49f28da82a6640aae00f67c8ffae7c19aeb0408122fecdcc9453"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tame-index-devel-0.26.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tame-index-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tame-index-devel.sha256sum] = "030ff431a29028dd4c9dd488dc5357b68e41b785c93cd3549e8131f4e0856c49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tame-index+default-devel-0.26.3-2.el10_3.noarch.rpm;name=aarch64_rust-tame-index+default-devel;unpack=0"
SRC_URI[aarch64_rust-tame-index+default-devel.sha256sum] = "ccc191e5ce9f13f9332a45344d734bb1a84da5a041fa6a4b25a3c3ba78478a45"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tame-index+local-builder-devel-0.26.3-2.el10_3.noarch.rpm;name=aarch64_rust-tame-index+local-builder-devel;unpack=0"
SRC_URI[aarch64_rust-tame-index+local-builder-devel.sha256sum] = "6bde2686177d7c07655f28b4619e3b1dc0f0cc13163f21534c204153a3b52ad9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tame-index+local-devel-0.26.3-2.el10_3.noarch.rpm;name=aarch64_rust-tame-index+local-devel;unpack=0"
SRC_URI[aarch64_rust-tame-index+local-devel.sha256sum] = "44dc72fbb5db697c894487350ae0d806870ccc99ecaee226babc293384e9e4d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tame-index+sparse-devel-0.26.3-2.el10_3.noarch.rpm;name=aarch64_rust-tame-index+sparse-devel;unpack=0"
SRC_URI[aarch64_rust-tame-index+sparse-devel.sha256sum] = "110171a48fab9e017fd74ccf677fe973fa2e5dce102df341d9de05edc1a72872"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tame-index-devel-0.26.3-2.el10_3.noarch.rpm;name=aarch64_rust-tame-index-devel;unpack=0"
SRC_URI[aarch64_rust-tame-index-devel.sha256sum] = "6714f5c0aff48afeb75dfe357f8cf7fc1b65b439ef05b298842d3ebaa8fd0c09"

RDEPENDS:rust-tame-index+default-devel = " \
 cargo \
 rust-tame-index-devel \
 "
RDEPENDS:rust-tame-index+local-builder-devel = " \
 cargo \
 rust-reqwest+blocking-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+http2-devel \
 rust-reqwest-devel \
 rust-tame-index+local-devel \
 rust-tame-index-devel \
 "
RDEPENDS:rust-tame-index+local-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-sha2_0.10+std-devel \
 rust-sha2_0.10-devel \
 rust-tame-index-devel \
 "
RDEPENDS:rust-tame-index+sparse-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-rayon+default-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+http2-devel \
 rust-reqwest-devel \
 rust-tame-index-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tame-index-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-http+default-devel \
 rust-libc+default-devel \
 rust-memchr+default-devel \
 rust-rustc-stable-hash+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-smol_str+default-devel \
 rust-smol_str+serde-devel \
 rust-thiserror+default-devel \
 rust-toml-span+default-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "
