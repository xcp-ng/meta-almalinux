# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdepim-addons"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdepim-addons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdepim-addons-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4145c74bbdefeb044183ff837065a397f967c903659926d1c1bd9fb5078dd140"

URI_x86_64_v2_kdepim-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdepim-addons-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdepim-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdepim-addons}"
SRC_URI[x86_64_v2_kdepim-addons.sha256sum] = "d97aafae77462c5c7d3caca1175e5a4d652d455b344780b67a5a1457fe636405"

URI_aarch64_kdepim-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kdepim-addons-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdepim-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdepim-addons}"
SRC_URI[aarch64_kdepim-addons.sha256sum] = "cb95e294ccc83608087104a8659ee9e5360589d3ac1e9b4779844d7ad3fd5a1c"

RDEPENDS:kdepim-addons = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-import-wizard \
 akonadi-mime \
 akonadi-server \
 bash \
 calendarsupport \
 glibc \
 gpgmepp \
 grantleetheme \
 incidenceeditor \
 kaddressbook-libs \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kdeclarative \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-prison \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kimap \
 kitinerary \
 kldap \
 kmailtransport \
 kmime \
 kpimtextedit \
 kpkpass \
 ktextaddons-qt6 \
 ktnef \
 libgcc \
 libgravatar \
 libkleo \
 libksieve \
 libmarkdown \
 libstdc++ \
 mailcommon \
 mailimporter \
 messagelib \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebengine \
 "
