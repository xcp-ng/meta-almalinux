# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wasmparser"
PV = "0.224.0"
PR = "3.el10_2"
PACKAGES = " \
 rust-wasmparser+component-model-devel \
 rust-wasmparser+default-devel \
 rust-wasmparser+features-devel \
 rust-wasmparser+hash-collections-devel \
 rust-wasmparser+prefer-btree-collections-devel \
 rust-wasmparser+serde-devel \
 rust-wasmparser+simd-devel \
 rust-wasmparser+std-devel \
 rust-wasmparser+validate-devel \
 rust-wasmparser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wasmparser-0.224.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d68471154ab607480f12efd78a003cde0901d70281103c421804890c45431be3"

URI_x86_64_v2_rust-wasmparser+component-model-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser+component-model-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser+component-model-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser+component-model-devel}"
SRC_URI[x86_64_v2_rust-wasmparser+component-model-devel.sha256sum] = "6bc747c628f5d015d5e6a9f0f09bca0aaa0f9b77ccf4d7e0cfb5266d8445d0d7"

URI_x86_64_v2_rust-wasmparser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser+default-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser+default-devel}"
SRC_URI[x86_64_v2_rust-wasmparser+default-devel.sha256sum] = "33552120647a6747c0afa0589c203ed00cf70807adc033d2620ec8322a6bc532"

URI_x86_64_v2_rust-wasmparser+features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser+features-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser+features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser+features-devel}"
SRC_URI[x86_64_v2_rust-wasmparser+features-devel.sha256sum] = "a8651ff0548ee5e0478ba530cf06312e102a0eae081ccce2437d53147dbd8f6f"

URI_x86_64_v2_rust-wasmparser+hash-collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser+hash-collections-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser+hash-collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser+hash-collections-devel}"
SRC_URI[x86_64_v2_rust-wasmparser+hash-collections-devel.sha256sum] = "13365315ad89115b322489a930fc1620c2277568f0f6946a583be064b9b0345e"

URI_x86_64_v2_rust-wasmparser+prefer-btree-collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser+prefer-btree-collections-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser+prefer-btree-collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser+prefer-btree-collections-devel}"
SRC_URI[x86_64_v2_rust-wasmparser+prefer-btree-collections-devel.sha256sum] = "40178ac5224cca9e0ba9c1ef18a96fb73df2c23c925c0f0789184353fa2039a0"

URI_x86_64_v2_rust-wasmparser+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser+serde-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser+serde-devel}"
SRC_URI[x86_64_v2_rust-wasmparser+serde-devel.sha256sum] = "6697bed8782c8ec77857d418eaa2ca7a0c2ec25b0673022912ba32f176db49b8"

URI_x86_64_v2_rust-wasmparser+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser+simd-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser+simd-devel}"
SRC_URI[x86_64_v2_rust-wasmparser+simd-devel.sha256sum] = "d2ba0a620e101bffea571f157e4ce35e6fd39c2a7ac7344532b5d32807b0a0e7"

URI_x86_64_v2_rust-wasmparser+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser+std-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser+std-devel}"
SRC_URI[x86_64_v2_rust-wasmparser+std-devel.sha256sum] = "c01d9fe211df2fc765781340b17debd5b33c805eb043aab3b85054a54628d78e"

URI_x86_64_v2_rust-wasmparser+validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser+validate-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser+validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser+validate-devel}"
SRC_URI[x86_64_v2_rust-wasmparser+validate-devel.sha256sum] = "1455960f9d99d82ef5ec814ba274f6d0f463c45e08a516461c4c37b213f2dbe3"

URI_x86_64_v2_rust-wasmparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wasmparser-devel-0.224.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wasmparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wasmparser-devel}"
SRC_URI[x86_64_v2_rust-wasmparser-devel.sha256sum] = "b233e72e5f648bdc75dc39c593812fc917a80d16f565879692f6c446e0d7d7fb"

URI_aarch64_rust-wasmparser+component-model-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser+component-model-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser+component-model-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser+component-model-devel}"
SRC_URI[aarch64_rust-wasmparser+component-model-devel.sha256sum] = "0daf338059954d7c30666f033f3828ad0af215d0cb069c9d81a03e0db3d56bc7"

URI_aarch64_rust-wasmparser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser+default-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser+default-devel}"
SRC_URI[aarch64_rust-wasmparser+default-devel.sha256sum] = "e772c1db2b344583e5f7df44b4c2973cee197280104ff94f8d7fc63056bacef1"

URI_aarch64_rust-wasmparser+features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser+features-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser+features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser+features-devel}"
SRC_URI[aarch64_rust-wasmparser+features-devel.sha256sum] = "50e229de0c4fd3b7010c6384e2d605f71b73a3a47337097b6c112e477f39c624"

URI_aarch64_rust-wasmparser+hash-collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser+hash-collections-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser+hash-collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser+hash-collections-devel}"
SRC_URI[aarch64_rust-wasmparser+hash-collections-devel.sha256sum] = "8454ee79fc7b95c77190075a9f29dfdf0e0e1c10bbd02e6800d6b16eec076a8b"

URI_aarch64_rust-wasmparser+prefer-btree-collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser+prefer-btree-collections-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser+prefer-btree-collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser+prefer-btree-collections-devel}"
SRC_URI[aarch64_rust-wasmparser+prefer-btree-collections-devel.sha256sum] = "154753dd6d30655affc822c4b9e2a2849613989fbfe9b9852f616bf8073b0291"

URI_aarch64_rust-wasmparser+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser+serde-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser+serde-devel}"
SRC_URI[aarch64_rust-wasmparser+serde-devel.sha256sum] = "e87094d4f2b3fba2392f3db526dae3f28a968c57e9fdab595ee2e3c6610565e7"

URI_aarch64_rust-wasmparser+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser+simd-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser+simd-devel}"
SRC_URI[aarch64_rust-wasmparser+simd-devel.sha256sum] = "89b571da3bae3201d85e7a822657fbb0f37a3916f70d8e67a84a91d023e88472"

URI_aarch64_rust-wasmparser+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser+std-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser+std-devel}"
SRC_URI[aarch64_rust-wasmparser+std-devel.sha256sum] = "545e47ac015211fb55ea81b7107ed694390eb36ff522277b7ea73aee3086eeb6"

URI_aarch64_rust-wasmparser+validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser+validate-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser+validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser+validate-devel}"
SRC_URI[aarch64_rust-wasmparser+validate-devel.sha256sum] = "c09c14c5aad329eb890a8e85e16b7b6befb14e2487d75881c043e97e0940d125"

URI_aarch64_rust-wasmparser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wasmparser-devel-0.224.0-3.el10_2.noarch.rpm;name=aarch64_rust-wasmparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wasmparser-devel}"
SRC_URI[aarch64_rust-wasmparser-devel.sha256sum] = "7a770efa4cf907bd54ed1d794b8373e7182828286687ccd09559cd23498030a8"

RDEPENDS:rust-wasmparser+component-model-devel = " \
 cargo \
 rust-semver-devel \
 rust-wasmparser-devel \
 "
RDEPENDS:rust-wasmparser+default-devel = " \
 cargo \
 rust-wasmparser+component-model-devel \
 rust-wasmparser+features-devel \
 rust-wasmparser+hash-collections-devel \
 rust-wasmparser+serde-devel \
 rust-wasmparser+simd-devel \
 rust-wasmparser+std-devel \
 rust-wasmparser+validate-devel \
 rust-wasmparser-devel \
 "
RDEPENDS:rust-wasmparser+features-devel = " \
 cargo \
 rust-wasmparser-devel \
 "
RDEPENDS:rust-wasmparser+hash-collections-devel = " \
 cargo \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15-devel \
 rust-indexmap-devel \
 rust-wasmparser-devel \
 "
RDEPENDS:rust-wasmparser+prefer-btree-collections-devel = " \
 cargo \
 rust-wasmparser-devel \
 "
RDEPENDS:rust-wasmparser+serde-devel = " \
 cargo \
 rust-hashbrown0.15+default-hasher-devel \
 rust-hashbrown0.15+serde-devel \
 rust-hashbrown0.15-devel \
 rust-indexmap+serde-devel \
 rust-indexmap-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-wasmparser-devel \
 "
RDEPENDS:rust-wasmparser+simd-devel = " \
 cargo \
 rust-wasmparser-devel \
 "
RDEPENDS:rust-wasmparser+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-wasmparser-devel \
 "
RDEPENDS:rust-wasmparser+validate-devel = " \
 cargo \
 rust-wasmparser-devel \
 "
RDEPENDS:rust-wasmparser-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 "
