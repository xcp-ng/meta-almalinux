# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pure-rust-locales"
PV = "0.8.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-pure-rust-locales+default-devel \
 rust-pure-rust-locales-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pure-rust-locales-0.8.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "079e8de24faaad02c7c48b6d65ea2e485f39aaeda286aa1055cfde107d6c57ea"

URI_x86_64_v2_rust-pure-rust-locales+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pure-rust-locales+default-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pure-rust-locales+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pure-rust-locales+default-devel}"
SRC_URI[x86_64_v2_rust-pure-rust-locales+default-devel.sha256sum] = "6d0c11d54c9926b79cd73ad707f14e8d1ea5140fb790773807cf423062f5b64d"

URI_x86_64_v2_rust-pure-rust-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pure-rust-locales-devel-0.8.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pure-rust-locales-devel}"
SRC_URI[x86_64_v2_rust-pure-rust-locales-devel.sha256sum] = "583768a6e38b98e8694b568a50ac0609e2421403edca535434606e1a0a22b203"

URI_aarch64_rust-pure-rust-locales+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pure-rust-locales+default-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-pure-rust-locales+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pure-rust-locales+default-devel}"
SRC_URI[aarch64_rust-pure-rust-locales+default-devel.sha256sum] = "d71daf62de86ca6fb4a6571fe550c063781069392f1be74d3b5a7e1c4da865cf"

URI_aarch64_rust-pure-rust-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pure-rust-locales-devel-0.8.2-1.el10_1.noarch.rpm;name=aarch64_rust-pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pure-rust-locales-devel}"
SRC_URI[aarch64_rust-pure-rust-locales-devel.sha256sum] = "bb2465c7cfdd67ba55be488fa72beb8704b4078d38e7d8abb72e2ade7300cba7"

RDEPENDS:rust-pure-rust-locales+default-devel = " \
 cargo \
 rust-pure-rust-locales-devel \
 "
RDEPENDS:rust-pure-rust-locales-devel = " \
 cargo \
 rust \
 "
