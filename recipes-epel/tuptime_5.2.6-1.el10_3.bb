# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuptime"
PV = "5.2.6"
PR = "1.el10_3"
PACKAGES = " \
 tuptime \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tuptime-5.2.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec1021a4f4f0a6086e2973c956fb0a19478b0443cdca42b0938693f3dcf497d4"

URI_x86_64_v2_tuptime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tuptime-5.2.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_tuptime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tuptime}"
SRC_URI[x86_64_v2_tuptime.sha256sum] = "6bc8d60456b296a407d52bb0a1c4ba90ca2952e406e25b1a0648d7736d27421c"

URI_aarch64_tuptime = "${EPEL_MIRROR}/aarch64/Packages/t/tuptime-5.2.6-1.el10_3.noarch.rpm;name=aarch64_tuptime;unpack=0"
SRC_URI:append = " ${URI_aarch64_tuptime}"
SRC_URI[aarch64_tuptime.sha256sum] = "d987c90291849da69727128ba64465d0fda8879eb8be495d17b4984c3358eded"

RDEPENDS:tuptime = " \
 bash \
 systemd \
 "
