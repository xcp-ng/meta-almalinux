# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koji-tool"
PV = "1.3"
PR = "2.el10_1"
PACKAGES = " \
 koji-tool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koji-tool-1.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ee58af9483c673c961d2dace69997ef1f03dc960d58b76aea0a06f53a85f026"

URI_x86_64_v2_koji-tool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-tool-1.3-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_koji-tool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-tool}"
SRC_URI[x86_64_v2_koji-tool.sha256sum] = "46ab551c1f0b76ae1007db69a21fd0a79ef62daee38818955f46b020bf32ed87"

URI_aarch64_koji-tool = "${EPEL_MIRROR}/aarch64/Packages/k/koji-tool-1.3-2.el10_1.aarch64.rpm;name=aarch64_koji-tool;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-tool}"
SRC_URI[aarch64_koji-tool.sha256sum] = "0c45e9f2e75297917b23d9979f170ddbfdab6fc08e04687a7b4f13ece82d5b8c"

RDEPENDS:koji-tool = " \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 openssl-libs \
 zlib-ng-compat \
 "
