# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "avahi"
PV = "0.9~rc2"
PR = "3.el10"
PACKAGES = " \
 avahi \
 avahi-autoipd \
 avahi-compat-howl \
 avahi-compat-howl-devel \
 avahi-compat-libdns_sd \
 avahi-compat-libdns_sd-devel \
 avahi-devel \
 avahi-glib \
 avahi-glib-devel \
 avahi-libs \
 avahi-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/avahi-0.9~rc2-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86a6d188ca2dc73c516b7211d8f6e028924e7f5483df805ce7ed37dc733010f1"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - avahi: libcap.so.2()(64bit)

URI_x86_64_v2_avahi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/avahi-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi}"
SRC_URI[x86_64_v2_avahi.sha256sum] = "100a697f1290a4e81fb77f4228a37b0202c6b439d73117ec7f6e821864e35e69"

URI_x86_64_v2_avahi-autoipd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-autoipd-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-autoipd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-autoipd}"
SRC_URI[x86_64_v2_avahi-autoipd.sha256sum] = "7cb01c9958d1e6bf12660dce292833f6fab32aa6ae8bb348b3e988da90dbef53"

URI_x86_64_v2_avahi-compat-howl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-howl-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-howl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-howl}"
SRC_URI[x86_64_v2_avahi-compat-howl.sha256sum] = "9589f7cd3ed34626af1555d4902967294cb1e681d5d21ef80b83661cb097f298"

URI_x86_64_v2_avahi-compat-howl-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-howl-devel-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-howl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-howl-devel}"
SRC_URI[x86_64_v2_avahi-compat-howl-devel.sha256sum] = "6d36e994070ca680f5f214bb321f01fb01d793042523a5d2229ffb7a6c91159b"

URI_x86_64_v2_avahi-compat-libdns_sd = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-libdns_sd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-libdns_sd}"
SRC_URI[x86_64_v2_avahi-compat-libdns_sd.sha256sum] = "7149e10fd4992aaf30a8e4e1ea018b75c4513c7611e8f99f58d25ab1ffae965f"

URI_x86_64_v2_avahi-compat-libdns_sd-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-compat-libdns_sd-devel-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-compat-libdns_sd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-compat-libdns_sd-devel}"
SRC_URI[x86_64_v2_avahi-compat-libdns_sd-devel.sha256sum] = "314b52337d67eaa3b2e362457e706bc5fb07345e63941bae659a174c311d69f4"

URI_x86_64_v2_avahi-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-devel-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-devel}"
SRC_URI[x86_64_v2_avahi-devel.sha256sum] = "6f047f51e4076bfe7253897dcadf4db3e0cbc6dd058ed15183aed349d326fc67"

URI_x86_64_v2_avahi-glib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-glib-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-glib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-glib}"
SRC_URI[x86_64_v2_avahi-glib.sha256sum] = "6184eccc4bec8ffca0d1e9ffd66ab76e60039b69f9ae6fc547cc195cd5d313df"

URI_x86_64_v2_avahi-glib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/avahi-glib-devel-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-glib-devel}"
SRC_URI[x86_64_v2_avahi-glib-devel.sha256sum] = "feda8407083e6ee39635854cc3d34b03ace6c0c5c6dceb141b77807066915cbd"

URI_x86_64_v2_avahi-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/avahi-libs-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-libs}"
SRC_URI[x86_64_v2_avahi-libs.sha256sum] = "e7b1fcb52dc9a4cddfad5293f37b4d3ac512f29bcf8b087a3f52f9208d7d9c13"

URI_x86_64_v2_avahi-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/avahi-tools-0.9~rc2-3.el10.x86_64_v2.rpm;name=x86_64_v2_avahi-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_avahi-tools}"
SRC_URI[x86_64_v2_avahi-tools.sha256sum] = "d8740a784359543665f35e2452b217243764a2b85fb98afd1f97f78c518d77e5"

URI_aarch64_avahi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/avahi-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi}"
SRC_URI[aarch64_avahi.sha256sum] = "ec455ce1ffcc4cfda1af6ddbbeacd66963439b6972f8519c16e8d7d0d45ef92c"

URI_aarch64_avahi-autoipd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-autoipd-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-autoipd;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-autoipd}"
SRC_URI[aarch64_avahi-autoipd.sha256sum] = "e58a40fc6592a218f47249e3c71cb93ed72f8f647768a16051d491321c5e4dfc"

URI_aarch64_avahi-compat-howl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-howl-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-compat-howl;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-howl}"
SRC_URI[aarch64_avahi-compat-howl.sha256sum] = "cd266bda50ce564921b689d87002c2b2e3d28f6f09ef815649e5325afb9f4b19"

URI_aarch64_avahi-compat-howl-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-howl-devel-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-compat-howl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-howl-devel}"
SRC_URI[aarch64_avahi-compat-howl-devel.sha256sum] = "c5d98a19b5e96a3393307be512ea8bffde74fcbd9f387e7c56ba54c846bd7624"

URI_aarch64_avahi-compat-libdns_sd = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-libdns_sd-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-compat-libdns_sd;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-libdns_sd}"
SRC_URI[aarch64_avahi-compat-libdns_sd.sha256sum] = "f0a35609f79e3831b1991cd7296b9966174480392f4ab1fb48a09f2e81b6916f"

URI_aarch64_avahi-compat-libdns_sd-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-compat-libdns_sd-devel-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-compat-libdns_sd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-compat-libdns_sd-devel}"
SRC_URI[aarch64_avahi-compat-libdns_sd-devel.sha256sum] = "1f09ede900de909105fc1741c02279d9ce0077bdc165b8233a47b7029c731bc6"

URI_aarch64_avahi-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-devel-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-devel}"
SRC_URI[aarch64_avahi-devel.sha256sum] = "7d92fbaf4bad7ee06b098330209b90ff5220cc01b7aae569fce6600206ac2c30"

URI_aarch64_avahi-glib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-glib-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-glib;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-glib}"
SRC_URI[aarch64_avahi-glib.sha256sum] = "76bef1cc4ff4a92711a674169c96a4cf7655182acadabaf304eb2dff4259c2b2"

URI_aarch64_avahi-glib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/avahi-glib-devel-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-glib-devel}"
SRC_URI[aarch64_avahi-glib-devel.sha256sum] = "116a37385fcf5d53b006e2f54de19d98d75fd7bba4a45941595764878c07711c"

URI_aarch64_avahi-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/avahi-libs-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-libs}"
SRC_URI[aarch64_avahi-libs.sha256sum] = "48d0b4723146397015722a94af60d0aed5dc8ebf81e1ef7dd905a51dcc2167a1"

URI_aarch64_avahi-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/avahi-tools-0.9~rc2-3.el10.aarch64.rpm;name=aarch64_avahi-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_avahi-tools}"
SRC_URI[aarch64_avahi-tools.sha256sum] = "35935e4dacefce30ee16c055264fd31442962c834d46252cd4e5baa653d8b198"

RDEPENDS:avahi:x86_64_v2 = " \
 avahi-libs \
 bash \
 dbus \
 dbus-libs \
 expat \
 glibc \
 libcap \
 libdaemon \
 shadow-utils \
 systemd-libs \
 virtual/coreutils \
"
RDEPENDS:avahi:aarch64 = " \
 avahi-libs \
 bash \
 dbus \
 dbus-libs \
 expat \
 glibc \
 libdaemon \
 shadow-utils \
 systemd-libs \
 virtual/coreutils \
"
RDEPENDS:avahi-autoipd = " \
 avahi-libs \
 bash \
 glibc \
 libdaemon \
 shadow-utils \
 "
RDEPENDS:avahi-compat-howl = " \
 avahi-libs \
 dbus-libs \
 glibc \
 "
RDEPENDS:avahi-compat-howl-devel = " \
 avahi-compat-howl \
 avahi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-compat-libdns_sd = " \
 avahi-libs \
 dbus-libs \
 glibc \
 "
RDEPENDS:avahi-compat-libdns_sd-devel = " \
 avahi-compat-libdns_sd \
 avahi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-devel = " \
 avahi \
 avahi-libs \
 dbus-devel \
 libevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-glib = " \
 avahi-libs \
 glib2 \
 glibc \
 "
RDEPENDS:avahi-glib-devel = " \
 avahi-devel \
 avahi-glib \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:avahi-libs = " \
 dbus-libs \
 glibc \
 libevent \
 "
RDEPENDS:avahi-tools = " \
 avahi \
 avahi-libs \
 gdbm-libs \
 glibc \
 "
