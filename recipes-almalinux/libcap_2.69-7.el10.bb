# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcap"
PV = "2.69"
PR = "7.el10"
PACKAGES = " \
 libcap \
 libcap-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcap-2.69-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f8e599d088aab4ff7c52cd7041beed62eb9bc2d20d50cb8e6e4502fb60e1bd4"

URI_x86_64_v2_libcap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcap-2.69-7.el10.x86_64_v2.rpm;name=x86_64_v2_libcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap}"
SRC_URI[x86_64_v2_libcap.sha256sum] = "2cfb6f79c225b9175a7d2c696dcbd00fef9fe4a9881cf407d2beaeeca1da94d2"

URI_x86_64_v2_libcap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcap-devel-2.69-7.el10.x86_64_v2.rpm;name=x86_64_v2_libcap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcap-devel}"
SRC_URI[x86_64_v2_libcap-devel.sha256sum] = "080505f6f87c079cc91451594041969dcd712cb9ee2cef77adccfa2188bf0f65"

URI_aarch64_libcap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcap-2.69-7.el10.aarch64.rpm;name=aarch64_libcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap}"
SRC_URI[aarch64_libcap.sha256sum] = "54b37e5b652be11d2e77a29050ed6a6b62418764481ffbc6b8bf550d0cfb3217"

URI_aarch64_libcap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcap-devel-2.69-7.el10.aarch64.rpm;name=aarch64_libcap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcap-devel}"
SRC_URI[aarch64_libcap-devel.sha256sum] = "8dd68816f25360c77dae97e44ed9e0172472489e807eac2288a8a0c405dbfb6f"

RDEPENDS:libcap = " \
 glibc \
 libgcc \
 pam-libs \
 "
RDEPENDS:libcap-devel = " \
 libcap \
 pkgconf-pkg-config \
 "
