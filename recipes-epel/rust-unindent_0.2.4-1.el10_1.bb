# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unindent"
PV = "0.2.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-unindent+default-devel \
 rust-unindent-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unindent-0.2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7759df8590c8ea5b57c35a576ba718ca45cdc6338f30a413152ebfb3b3c5339"

URI_x86_64_v2_rust-unindent+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unindent+default-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unindent+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unindent+default-devel}"
SRC_URI[x86_64_v2_rust-unindent+default-devel.sha256sum] = "32d18b42a75ed10a3514ff381fe24ba7ecaf7fa232222cbbc74a006ca04b80aa"

URI_x86_64_v2_rust-unindent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unindent-devel-0.2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unindent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unindent-devel}"
SRC_URI[x86_64_v2_rust-unindent-devel.sha256sum] = "fda50ab78938b7cfdd38d3c77e4464a6976d4a97cbe1c9155e69929f3fe84dfa"

URI_aarch64_rust-unindent+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unindent+default-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-unindent+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unindent+default-devel}"
SRC_URI[aarch64_rust-unindent+default-devel.sha256sum] = "c2b852b5c6e2e8221d1fa22376fa8cd153c3b70e66c700293d86c0916cb79e87"

URI_aarch64_rust-unindent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unindent-devel-0.2.4-1.el10_1.noarch.rpm;name=aarch64_rust-unindent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unindent-devel}"
SRC_URI[aarch64_rust-unindent-devel.sha256sum] = "41b65e93e24ada3f6b880f4b41916279ab980827f404af6a8af60d4c01b91f38"

RDEPENDS:rust-unindent+default-devel = " \
 cargo \
 rust-unindent-devel \
 "
RDEPENDS:rust-unindent-devel = " \
 cargo \
 "
