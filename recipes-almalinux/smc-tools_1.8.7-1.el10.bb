# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "smc-tools"
PV = "1.8.7"
PR = "1.el10"
PACKAGES = " \
 smc-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/smc-tools-1.8.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a3511333462fb9a3b4b2c669a9d14707193d4f75e715da3acd422a6cc2fcf5ca"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/smc-tools-1.8.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_smc-tools;unpack=0"
SRC_URI[x86_64_v2_smc-tools.sha256sum] = "d45913f96a9f9867f4dd1ebb98865ffa978e207156fd3a6d33ff09d1cd3067eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/smc-tools-1.8.7-1.el10.aarch64.rpm;name=aarch64_smc-tools;unpack=0"
SRC_URI[aarch64_smc-tools.sha256sum] = "5d591a41c9a3aa8c6bc0a7518d411a501f87b558024f8aeb2b7348aca85404b7"

RDEPENDS:smc-tools = " \
 bash \
 glibc \
 libnl3 \
 "
