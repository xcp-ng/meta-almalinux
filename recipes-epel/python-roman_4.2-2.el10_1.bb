# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-roman"
PV = "4.2"
PR = "2.el10_1"
PACKAGES = " \
 python3-roman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-roman-4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80ce8c9b7fb7cf3036ef6e2b996032e39f89e5d435fe62b124d62ecabef3568b"

URI_x86_64_v2_python3-roman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-roman-4.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-roman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-roman}"
SRC_URI[x86_64_v2_python3-roman.sha256sum] = "f8d237ca6248c49d9fc6fea1b48b84c0f878950341bb30536fa72998507f896f"

URI_aarch64_python3-roman = "${EPEL_MIRROR}/aarch64/Packages/p/python3-roman-4.2-2.el10_1.noarch.rpm;name=aarch64_python3-roman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-roman}"
SRC_URI[aarch64_python3-roman.sha256sum] = "db47a1da2984d74e454818223f14ed049ea9d8b825edcc2be49d91943c5c44c5"

RDEPENDS:python3-roman = " \
 python3 \
 "
