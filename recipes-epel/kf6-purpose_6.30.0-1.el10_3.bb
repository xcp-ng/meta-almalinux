# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-purpose"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-purpose \
 kf6-purpose-devel \
 kf6-purpose-doc \
 kf6-purpose-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-purpose-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "78116159c278f51fd8b1b86007a34ae0e7bc94d5c3faee0e56b051cfc370a82d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose;unpack=0"
SRC_URI[x86_64_v2_kf6-purpose.sha256sum] = "8b8fe832d493af1c475b628b9f942dee811b1da2d3f7679e099d9d7f56473185"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-purpose-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-purpose-devel.sha256sum] = "13db92037cf9484ef4c2947a149d2192b8c23c5a01bd88181161b001faa177ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-purpose-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-purpose-doc.sha256sum] = "3138de84cfaa48c133c429b18814a4a27829a34e58988de3bc5238414cf0fb85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-purpose-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-purpose-html;unpack=0"
SRC_URI[x86_64_v2_kf6-purpose-html.sha256sum] = "bc4bb53fe91f8d0bb28ba5c136cebe43d2ddb92be469e3766f18f3049d732470"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-purpose;unpack=0"
SRC_URI[aarch64_kf6-purpose.sha256sum] = "404c4782ab781d86c40d490fb84680cf023630b5eec63133f8af94270542932c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-purpose-devel;unpack=0"
SRC_URI[aarch64_kf6-purpose-devel.sha256sum] = "d9c6b04a566b743debfef2f9b7aa26d6c4550e5f94880261bde7a85f760c94b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-purpose-doc;unpack=0"
SRC_URI[aarch64_kf6-purpose-doc.sha256sum] = "f0b8b6b0fc12512dcf7194bc2510e62835162931c109560c71743399e0c76f98"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-purpose-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-purpose-html;unpack=0"
SRC_URI[aarch64_kf6-purpose-html.sha256sum] = "dc373e8fe7a391fc5786f1ad85a1edc5140b66985fc0125a87d7576c7bc9318d"

RDEPENDS:kf6-purpose = " \
 accounts-qml-module-qt6 \
 glibc \
 hicolor-icon-theme \
 kaccounts-integration-qt6 \
 kf6-bluez-qt \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdeclarative \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kservice \
 kf6-prison \
 libaccounts-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-purpose-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-purpose \
 "
RDEPENDS:kf6-purpose-doc = " \
 "
RDEPENDS:kf6-purpose-html = " \
 "
