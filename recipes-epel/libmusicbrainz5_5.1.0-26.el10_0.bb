# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmusicbrainz5"
PV = "5.1.0"
PR = "26.el10_0"
PACKAGES = " \
 libmusicbrainz5 \
 libmusicbrainz5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmusicbrainz5-5.1.0-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a64f79e23637835619ed9a8dd846398e727ff800bd78ef7090d9e97fe12f6fd6"

URI_x86_64_v2_libmusicbrainz5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmusicbrainz5-5.1.0-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmusicbrainz5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmusicbrainz5}"
SRC_URI[x86_64_v2_libmusicbrainz5.sha256sum] = "e08ea1fa0e2543d7ef14c32641e2cd6292b1931c1d5e20fc078d6a6c931bd4b6"

URI_x86_64_v2_libmusicbrainz5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmusicbrainz5-devel-5.1.0-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmusicbrainz5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmusicbrainz5-devel}"
SRC_URI[x86_64_v2_libmusicbrainz5-devel.sha256sum] = "c4905a7fbfe6ab48141c456d2202419f1fee3f761b78470cc0dba6a9b1986134"

URI_aarch64_libmusicbrainz5 = "${EPEL_MIRROR}/aarch64/Packages/l/libmusicbrainz5-5.1.0-26.el10_0.aarch64.rpm;name=aarch64_libmusicbrainz5;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmusicbrainz5}"
SRC_URI[aarch64_libmusicbrainz5.sha256sum] = "17dca5bddb0c451bb486b52cbff85ecb3e5102561a83f14a027dc2374f75fb81"

URI_aarch64_libmusicbrainz5-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmusicbrainz5-devel-5.1.0-26.el10_0.aarch64.rpm;name=aarch64_libmusicbrainz5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmusicbrainz5-devel}"
SRC_URI[aarch64_libmusicbrainz5-devel.sha256sum] = "6012cfdae660f0e200edf84438107cc3c572befc6d265450c40691c01b277e60"

RDEPENDS:libmusicbrainz5 = " \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 neon \
 "
RDEPENDS:libmusicbrainz5-devel = " \
 libmusicbrainz5 \
 libxml2-devel \
 neon-devel \
 pkgconf-pkg-config \
 "
