# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pkgconf"
PV = "2.1.0"
PR = "3.el10"
PACKAGES = " \
 libpkgconf \
 pkgconf \
 pkgconf-m4 \
 pkgconf-pkg-config \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pkgconf-2.1.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9e27d557f93f409f936356969e9286df4008ec9c3209100c80c7652eae39a64"

URI_x86_64_v2_libpkgconf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libpkgconf-2.1.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libpkgconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpkgconf}"
SRC_URI[x86_64_v2_libpkgconf.sha256sum] = "6034b138cff02b148af4b1bbef757e88844abd5cd2a1c0bc6281516065a0c537"

URI_x86_64_v2_pkgconf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pkgconf-2.1.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_pkgconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pkgconf}"
SRC_URI[x86_64_v2_pkgconf.sha256sum] = "b1a196ca310d5f594b844cc5dee70c2712a1a5277ef4807baa630a3200a476ae"

URI_x86_64_v2_pkgconf-m4 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pkgconf-m4-2.1.0-3.el10.noarch.rpm;name=x86_64_v2_pkgconf-m4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pkgconf-m4}"
SRC_URI[x86_64_v2_pkgconf-m4.sha256sum] = "74cba7eb2aaa7c8bbc11f8125c01eb59b9be00fe60aa7f6b234ff448a7761824"

URI_x86_64_v2_pkgconf-pkg-config = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pkgconf-pkg-config-2.1.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_pkgconf-pkg-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pkgconf-pkg-config}"
SRC_URI[x86_64_v2_pkgconf-pkg-config.sha256sum] = "01cc1bd2dded7e637887d55edad8f9f0a15b499e97fed50f021380117134ce96"

URI_aarch64_libpkgconf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libpkgconf-2.1.0-3.el10.aarch64.rpm;name=aarch64_libpkgconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpkgconf}"
SRC_URI[aarch64_libpkgconf.sha256sum] = "f303c4871ce01e3878334f654015fe2b4972fb76159becc6b43f27285f920b82"

URI_aarch64_pkgconf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pkgconf-2.1.0-3.el10.aarch64.rpm;name=aarch64_pkgconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pkgconf}"
SRC_URI[aarch64_pkgconf.sha256sum] = "78623636893f9cd51632e6856f8e6817250deab5b5add3e8c3a6848b1f8005bd"

URI_aarch64_pkgconf-m4 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pkgconf-m4-2.1.0-3.el10.noarch.rpm;name=aarch64_pkgconf-m4;unpack=0"
SRC_URI:append = " ${URI_aarch64_pkgconf-m4}"
SRC_URI[aarch64_pkgconf-m4.sha256sum] = "74cba7eb2aaa7c8bbc11f8125c01eb59b9be00fe60aa7f6b234ff448a7761824"

URI_aarch64_pkgconf-pkg-config = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pkgconf-pkg-config-2.1.0-3.el10.aarch64.rpm;name=aarch64_pkgconf-pkg-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_pkgconf-pkg-config}"
SRC_URI[aarch64_pkgconf-pkg-config.sha256sum] = "9186439fe29d864ef26ce730504556081e500b94a64cffd58d754b41423e1463"

RDEPENDS:libpkgconf = " \
 glibc \
 "
RDEPENDS:pkgconf = " \
 glibc \
 libpkgconf \
 "
RDEPENDS:pkgconf-m4 = " \
 "
RDEPENDS:pkgconf-pkg-config = " \
 bash \
 pkgconf \
 pkgconf-m4 \
 "
