# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ena"
PV = "0.14.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-ena+default-devel \
 rust-ena-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ena-0.14.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ac686380e201d1e8e00563f181043181cba45a70e855807848b69ed3563e9f0"

URI_x86_64_v2_rust-ena+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ena+default-devel-0.14.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ena+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ena+default-devel}"
SRC_URI[x86_64_v2_rust-ena+default-devel.sha256sum] = "a41b01f218c5c1ae8760bfec71ec08ddf6c3253831a06e1579a0997907074293"

URI_x86_64_v2_rust-ena-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ena-devel-0.14.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ena-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ena-devel}"
SRC_URI[x86_64_v2_rust-ena-devel.sha256sum] = "61c1aee07fb71ef6f70a2de90ec7f4fd2ae6c7562deb2661f759f33e3ef827ce"

URI_aarch64_rust-ena+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ena+default-devel-0.14.4-1.el10_2.noarch.rpm;name=aarch64_rust-ena+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ena+default-devel}"
SRC_URI[aarch64_rust-ena+default-devel.sha256sum] = "e19e4eaefda9a4d4b2dda85d2e85277b721932e1ac2646200bec12ebb17e6dfc"

URI_aarch64_rust-ena-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ena-devel-0.14.4-1.el10_2.noarch.rpm;name=aarch64_rust-ena-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ena-devel}"
SRC_URI[aarch64_rust-ena-devel.sha256sum] = "81df43479a69828498849c0ac29d03a7f0d2fe9dbe9e9cdd891c3b97cb1d8fc8"

RDEPENDS:rust-ena+default-devel = " \
 cargo \
 rust-ena-devel \
 "
RDEPENDS:rust-ena-devel = " \
 cargo \
 rust-log+default-devel \
 "
