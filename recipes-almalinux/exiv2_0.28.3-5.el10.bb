# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "exiv2"
PV = "0.28.3"
PR = "5.el10"
PACKAGES = " \
 exiv2 \
 exiv2-devel \
 exiv2-doc \
 exiv2-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/exiv2-0.28.3-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09672fbbb578f95d3eae9996a126f41e87915bda63302238d8aca5eefdcca26e"

URI_x86_64_v2_exiv2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/exiv2-0.28.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_exiv2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exiv2}"
SRC_URI[x86_64_v2_exiv2.sha256sum] = "064a3c237640358d38f215728e8ef7f85a73a67d8835e4c3ca3602748a5197ef"

URI_x86_64_v2_exiv2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/exiv2-devel-0.28.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_exiv2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exiv2-devel}"
SRC_URI[x86_64_v2_exiv2-devel.sha256sum] = "9b9056499c94554905f137c3d3b7b1b9f6d79e941e6e0e43de437d5c2e561d5b"

URI_x86_64_v2_exiv2-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/exiv2-doc-0.28.3-5.el10.noarch.rpm;name=x86_64_v2_exiv2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exiv2-doc}"
SRC_URI[x86_64_v2_exiv2-doc.sha256sum] = "ea5b2c0ec7fd3af3dadb0062eec72b276bb9afb2b6a6ae4f9c01a15550a97d89"

URI_x86_64_v2_exiv2-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/exiv2-libs-0.28.3-5.el10.x86_64_v2.rpm;name=x86_64_v2_exiv2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_exiv2-libs}"
SRC_URI[x86_64_v2_exiv2-libs.sha256sum] = "597ebac8085aa5f504c75658e97954306d6e7f3f36d7180ab355193f22d8ea1c"

URI_aarch64_exiv2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/exiv2-0.28.3-5.el10.aarch64.rpm;name=aarch64_exiv2;unpack=0"
SRC_URI:append = " ${URI_aarch64_exiv2}"
SRC_URI[aarch64_exiv2.sha256sum] = "1ec8403a25cd36f405744a64e9183f1c7b16b5551f632661b4682d7abb6b3e7c"

URI_aarch64_exiv2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/exiv2-devel-0.28.3-5.el10.aarch64.rpm;name=aarch64_exiv2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_exiv2-devel}"
SRC_URI[aarch64_exiv2-devel.sha256sum] = "4c849295647ddf1e17997268c2da375bc05db5ff2473ecbee356e3e6f593eb94"

URI_aarch64_exiv2-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/exiv2-doc-0.28.3-5.el10.noarch.rpm;name=aarch64_exiv2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_exiv2-doc}"
SRC_URI[aarch64_exiv2-doc.sha256sum] = "ea5b2c0ec7fd3af3dadb0062eec72b276bb9afb2b6a6ae4f9c01a15550a97d89"

URI_aarch64_exiv2-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/exiv2-libs-0.28.3-5.el10.aarch64.rpm;name=aarch64_exiv2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_exiv2-libs}"
SRC_URI[aarch64_exiv2-libs.sha256sum] = "3c1801631220e5bc4dc01b9a560cbf696b90f29197f512c24d43186d6905937e"

RDEPENDS:exiv2 = " \
 exiv2-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:exiv2-devel = " \
 brotli-devel \
 cmake-filesystem \
 exiv2-libs \
 expat-devel \
 inih-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:exiv2-doc = " \
 "
RDEPENDS:exiv2-libs = " \
 expat \
 glibc \
 inih-cpp \
 libbrotli \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
