# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-tabular"
PV = "0.2.2.8"
PR = "14.el10_0"
PACKAGES = " \
 ghc-tabular \
 ghc-tabular-devel \
 ghc-tabular-doc \
 ghc-tabular-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-tabular-0.2.2.8-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76e8ab8aa5f1c1d32eb740f2a4be958f96783e92d5c2400ba25f5128581cc5b9"

URI_x86_64_v2_ghc-tabular = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tabular-0.2.2.8-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tabular;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tabular}"
SRC_URI[x86_64_v2_ghc-tabular.sha256sum] = "fa9a8fc0531653b26f78b55dd9479e8e826b24e328a99a5da43347547dbc8a4b"

URI_x86_64_v2_ghc-tabular-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tabular-devel-0.2.2.8-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tabular-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tabular-devel}"
SRC_URI[x86_64_v2_ghc-tabular-devel.sha256sum] = "93d3bc1509869f066475eb68573dc3c722e20822bf0e4f2b1351a735a6293e65"

URI_x86_64_v2_ghc-tabular-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tabular-doc-0.2.2.8-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-tabular-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tabular-doc}"
SRC_URI[x86_64_v2_ghc-tabular-doc.sha256sum] = "8c79444b9d6c278396b2cae4a1ec5b38f7f0c7b4bba85d1cd3bb27b39e38f6ad"

URI_x86_64_v2_ghc-tabular-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-tabular-prof-0.2.2.8-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-tabular-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-tabular-prof}"
SRC_URI[x86_64_v2_ghc-tabular-prof.sha256sum] = "92a4f7aa7444a357199a36ae1287bde34d387b08aa7e62d2241dbc1c524b713d"

URI_aarch64_ghc-tabular = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tabular-0.2.2.8-14.el10_0.aarch64.rpm;name=aarch64_ghc-tabular;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tabular}"
SRC_URI[aarch64_ghc-tabular.sha256sum] = "a538e397f6fb2c957cd2db12366b9db1430b473358a611679943c7f7662b62db"

URI_aarch64_ghc-tabular-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tabular-devel-0.2.2.8-14.el10_0.aarch64.rpm;name=aarch64_ghc-tabular-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tabular-devel}"
SRC_URI[aarch64_ghc-tabular-devel.sha256sum] = "5bdbbd95609e3ac16868031f6cafd29961902b15b0c77ff3fb8c3505f7657ba1"

URI_aarch64_ghc-tabular-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tabular-doc-0.2.2.8-14.el10_0.noarch.rpm;name=aarch64_ghc-tabular-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tabular-doc}"
SRC_URI[aarch64_ghc-tabular-doc.sha256sum] = "bf91281c5dae284e2ee66e991106676a94d12809133becfd1c368ae8370b5648"

URI_aarch64_ghc-tabular-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-tabular-prof-0.2.2.8-14.el10_0.aarch64.rpm;name=aarch64_ghc-tabular-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-tabular-prof}"
SRC_URI[aarch64_ghc-tabular-prof.sha256sum] = "d480670dcd5b8f24bffaa031f04e6e0b36f04933a375530aeb0d44fecfab3051"

RDEPENDS:ghc-tabular = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-csv \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-html \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-tabular-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-csv-devel \
 ghc-html-devel \
 ghc-mtl-devel \
 ghc-tabular \
 "
RDEPENDS:ghc-tabular-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-tabular-prof = " \
 ghc-base-prof \
 ghc-csv-prof \
 ghc-html-prof \
 ghc-mtl-prof \
 ghc-tabular-devel \
 "
