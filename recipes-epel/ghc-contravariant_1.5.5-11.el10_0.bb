# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-contravariant"
PV = "1.5.5"
PR = "11.el10_0"
PACKAGES = " \
 ghc-contravariant \
 ghc-contravariant-devel \
 ghc-contravariant-doc \
 ghc-contravariant-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-contravariant-1.5.5-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c79fe0d326ba67d25db975f07e990dc9b231597d9ce1d70a59c6cd6068f07083"

URI_x86_64_v2_ghc-contravariant = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-contravariant-1.5.5-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-contravariant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-contravariant}"
SRC_URI[x86_64_v2_ghc-contravariant.sha256sum] = "cfc850c308cf41e6aa4c9a66cfbb8f1cb31e155d25aeff100b061bf61e22217d"

URI_x86_64_v2_ghc-contravariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-contravariant-devel-1.5.5-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-contravariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-contravariant-devel}"
SRC_URI[x86_64_v2_ghc-contravariant-devel.sha256sum] = "3b2e1095cf6d279db991ba0bf26c4fd5dc2b0405264408f40d638278bf4b12c0"

URI_x86_64_v2_ghc-contravariant-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-contravariant-doc-1.5.5-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-contravariant-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-contravariant-doc}"
SRC_URI[x86_64_v2_ghc-contravariant-doc.sha256sum] = "3fb6910b1d02235fb2467605774fed136431581f4aeffc76392e243bc738fc3b"

URI_x86_64_v2_ghc-contravariant-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-contravariant-prof-1.5.5-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-contravariant-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-contravariant-prof}"
SRC_URI[x86_64_v2_ghc-contravariant-prof.sha256sum] = "5ee0545eea5eeb5f579fca94c6b067f3da48b9457f907156fe516402e4f9917b"

URI_aarch64_ghc-contravariant = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-contravariant-1.5.5-11.el10_0.aarch64.rpm;name=aarch64_ghc-contravariant;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-contravariant}"
SRC_URI[aarch64_ghc-contravariant.sha256sum] = "4f0463c7b867efbbbb45a279bd99e6d55fe606d83b895d148c22c78aafaf6809"

URI_aarch64_ghc-contravariant-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-contravariant-devel-1.5.5-11.el10_0.aarch64.rpm;name=aarch64_ghc-contravariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-contravariant-devel}"
SRC_URI[aarch64_ghc-contravariant-devel.sha256sum] = "5a1f5e63769bb3d6f6a8686edc2aa940941666ecc6d62b92605c859d7df7ab75"

URI_aarch64_ghc-contravariant-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-contravariant-doc-1.5.5-11.el10_0.noarch.rpm;name=aarch64_ghc-contravariant-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-contravariant-doc}"
SRC_URI[aarch64_ghc-contravariant-doc.sha256sum] = "52731ec601c2e5b494b6ada6c4343da5e360f52dab77c208e4860ec62395ec1a"

URI_aarch64_ghc-contravariant-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-contravariant-prof-1.5.5-11.el10_0.aarch64.rpm;name=aarch64_ghc-contravariant-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-contravariant-prof}"
SRC_URI[aarch64_ghc-contravariant-prof.sha256sum] = "9e3a7018edb48b22e0b3a14de7b1de3d83ac2d6699c17132c16ec3f764091726"

RDEPENDS:ghc-contravariant = " \
 ghc-StateVar \
 ghc-array \
 ghc-base \
 ghc-ghc-bignum \
 ghc-stm \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-contravariant-devel = " \
 ghc-StateVar-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-contravariant \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-contravariant-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-contravariant-prof = " \
 ghc-StateVar-prof \
 ghc-base-prof \
 ghc-contravariant-devel \
 ghc-transformers-prof \
 "
