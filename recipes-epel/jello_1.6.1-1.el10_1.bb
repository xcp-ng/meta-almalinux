# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jello"
PV = "1.6.1"
PR = "1.el10_1"
PACKAGES = " \
 jello \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jello-1.6.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a17447f75a201e93bfb685111232765bde39270760f2dcde68ab4076834985e4"

URI_x86_64_v2_jello = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jello-1.6.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_jello;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jello}"
SRC_URI[x86_64_v2_jello.sha256sum] = "ed6f0dc50f5d138bf81a1a9a2cca534495099a6537c96ce09b6ef2adf2f90f77"

URI_aarch64_jello = "${EPEL_MIRROR}/aarch64/Packages/j/jello-1.6.1-1.el10_1.noarch.rpm;name=aarch64_jello;unpack=0"
SRC_URI:append = " ${URI_aarch64_jello}"
SRC_URI[aarch64_jello.sha256sum] = "db38fd4fdd7eff802ed16e63a166c684bcc4fc67700cfb0c8ed51fa056843e19"

RDEPENDS:jello = " \
 python3 \
 python3-pygments \
 "
