# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-scopeguard"
PV = "1.2.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-scopeguard+default-devel \
 rust-scopeguard+use_std-devel \
 rust-scopeguard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-scopeguard-1.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13f27e775a3a721298f3cd25b6479daa28463e2a5143e74ff0edd073ff3db57f"

URI_x86_64_v2_rust-scopeguard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scopeguard+default-devel-1.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scopeguard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scopeguard+default-devel}"
SRC_URI[x86_64_v2_rust-scopeguard+default-devel.sha256sum] = "1e513e2215bb75e0ff8db1c8595dcc6df115280008941a4970af4257b0ad1061"

URI_x86_64_v2_rust-scopeguard+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scopeguard+use_std-devel-1.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scopeguard+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scopeguard+use_std-devel}"
SRC_URI[x86_64_v2_rust-scopeguard+use_std-devel.sha256sum] = "1cf5cf18c90de609e766e595e33ca4bbe1d6e051e644e8716063fdc6466c3df9"

URI_x86_64_v2_rust-scopeguard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-scopeguard-devel-1.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-scopeguard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-scopeguard-devel}"
SRC_URI[x86_64_v2_rust-scopeguard-devel.sha256sum] = "706484bcc3636c540f07191d711012a929410f4ceddb2b6a8bfed6e83da21154"

URI_aarch64_rust-scopeguard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scopeguard+default-devel-1.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-scopeguard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scopeguard+default-devel}"
SRC_URI[aarch64_rust-scopeguard+default-devel.sha256sum] = "1936b944d55ee8a20e3b49fb6a87d0a2f732efb9bb0f56786fbe8c4ad24105a2"

URI_aarch64_rust-scopeguard+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scopeguard+use_std-devel-1.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-scopeguard+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scopeguard+use_std-devel}"
SRC_URI[aarch64_rust-scopeguard+use_std-devel.sha256sum] = "cfd30bb9066e542b3db422d7cc19c5a332668596721df19925026aae365e9147"

URI_aarch64_rust-scopeguard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-scopeguard-devel-1.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-scopeguard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-scopeguard-devel}"
SRC_URI[aarch64_rust-scopeguard-devel.sha256sum] = "699b1a6209d95a92088dd6442374822cf748cca53601cbc7124fba76becaf734"

RDEPENDS:rust-scopeguard+default-devel = " \
 cargo \
 rust-scopeguard+use_std-devel \
 rust-scopeguard-devel \
 "
RDEPENDS:rust-scopeguard+use_std-devel = " \
 cargo \
 rust-scopeguard-devel \
 "
RDEPENDS:rust-scopeguard-devel = " \
 cargo \
 "
