# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "workrave"
PV = "1.11.4"
PR = "1.el10_3"
PACKAGES = " \
 workrave \
 workrave-common \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/workrave-1.11.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2068b28ab2616b4e72dfbfb080055f47ac658a8628128bd236d2bcf422333573"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/workrave-1.11.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_workrave;unpack=0"
SRC_URI[x86_64_v2_workrave.sha256sum] = "fe85bd5862cce9e3d4229eb0a95b21e7823ba8f860345a4ffcf19fed91f1a32f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/workrave-common-1.11.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_workrave-common;unpack=0"
SRC_URI[x86_64_v2_workrave-common.sha256sum] = "d74d8d1e1c0f1692c99c31532980fdf81e2cdc9d9cb19a4326940716fb4feda0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/workrave-1.11.4-1.el10_3.aarch64.rpm;name=aarch64_workrave;unpack=0"
SRC_URI[aarch64_workrave.sha256sum] = "70ca165db9b895cbf1edcf0dd972af2b1b2d2ea05b1766c595cf0c82bdeacc00"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/workrave-common-1.11.4-1.el10_3.noarch.rpm;name=aarch64_workrave-common;unpack=0"
SRC_URI[aarch64_workrave-common.sha256sum] = "846a356bed73011131b435f1998b472805ecbd7e0346d522777e6bef571c3946"

RDEPENDS:workrave = " \
 atkmm \
 cairo \
 cairomm \
 dbus-common \
 fmt \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 glibmm2.4 \
 gstreamer1 \
 gtk3 \
 gtkmm3.0 \
 hicolor-icon-theme \
 libX11 \
 libXScrnSaver \
 libXtst \
 libayatana-appindicator-gtk3 \
 libdbusmenu \
 libgcc \
 libsigc++20 \
 libstdc++ \
 libwayland-client \
 pango \
 pangomm \
 pulseaudio-libs \
 pulseaudio-libs-glib2 \
 spdlog \
 workrave-common \
 "
RDEPENDS:workrave-common = " \
 "
