# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsidplayfp"
PV = "2.15.0"
PR = "1.el10_0"
PACKAGES = " \
 libsidplayfp \
 libsidplayfp-devel \
 libsidplayfp-devel-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libsidplayfp-2.15.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e3c26c22fe718313c9ca8de70bae156f174ee996b439a8c56ceded466ba01e2"

URI_x86_64_v2_libsidplayfp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsidplayfp-2.15.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsidplayfp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsidplayfp}"
SRC_URI[x86_64_v2_libsidplayfp.sha256sum] = "6f92bd56ad8cdec0ddc6cdbc3f3a3714ae9cddc38f51d3417b11a2b99da19648"

URI_x86_64_v2_libsidplayfp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsidplayfp-devel-2.15.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsidplayfp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsidplayfp-devel}"
SRC_URI[x86_64_v2_libsidplayfp-devel.sha256sum] = "df5fb4ced3db4704b8e09fab212199454f90c6ad2147a491cd3dcf0ee7b8efb4"

URI_x86_64_v2_libsidplayfp-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsidplayfp-devel-doc-2.15.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libsidplayfp-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsidplayfp-devel-doc}"
SRC_URI[x86_64_v2_libsidplayfp-devel-doc.sha256sum] = "1f7acfdf4e0f2e8f11fb1133fc56c2ecfdfc8d3deeafe65a19255c4bb0f940aa"

URI_aarch64_libsidplayfp = "${EPEL_MIRROR}/aarch64/Packages/l/libsidplayfp-2.15.0-1.el10_0.aarch64.rpm;name=aarch64_libsidplayfp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsidplayfp}"
SRC_URI[aarch64_libsidplayfp.sha256sum] = "7517b343c8b03dba504962138130dc994967442976c1d3429be20b1406ae840c"

URI_aarch64_libsidplayfp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsidplayfp-devel-2.15.0-1.el10_0.aarch64.rpm;name=aarch64_libsidplayfp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsidplayfp-devel}"
SRC_URI[aarch64_libsidplayfp-devel.sha256sum] = "0af4b9607d49ba193c20ae12f1182bb5eec8ad233fb5316db483e09811fb6d65"

URI_aarch64_libsidplayfp-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libsidplayfp-devel-doc-2.15.0-1.el10_0.noarch.rpm;name=aarch64_libsidplayfp-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsidplayfp-devel-doc}"
SRC_URI[aarch64_libsidplayfp-devel-doc.sha256sum] = "b8a10e3c93cc1bc9e5804b255490e15565b44336b576e9e1fe98d1f79435c747"

RDEPENDS:libsidplayfp = " \
 glibc \
 libgcc \
 libgcrypt \
 libstdc++ \
 "
RDEPENDS:libsidplayfp-devel = " \
 libsidplayfp \
 pkgconf-pkg-config \
 "
RDEPENDS:libsidplayfp-devel-doc = " \
 "
