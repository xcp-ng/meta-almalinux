# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gengo-language"
PV = "0.14.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-gengo-language+default-devel \
 rust-gengo-language-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gengo-language-0.14.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c12f1442a2512257afc7c675a7107f30f0b73906a340e0bfd642241f152b1f3c"

URI_x86_64_v2_rust-gengo-language+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo-language+default-devel-0.14.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo-language+default-devel}"
SRC_URI[x86_64_v2_rust-gengo-language+default-devel.sha256sum] = "4c35c7330462c15a7b4f9f641fdd28647993fd6939ef729a5c7dbaa1fc21af0b"

URI_x86_64_v2_rust-gengo-language-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo-language-devel-0.14.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo-language-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo-language-devel}"
SRC_URI[x86_64_v2_rust-gengo-language-devel.sha256sum] = "14104dc50717a355680940091ece76b3592c195f455338e5db623d271c571cc3"

URI_aarch64_rust-gengo-language+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo-language+default-devel-0.14.3-1.el10_2.noarch.rpm;name=aarch64_rust-gengo-language+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo-language+default-devel}"
SRC_URI[aarch64_rust-gengo-language+default-devel.sha256sum] = "3ea3f4626aa05580c3a9bf944f538f37980137db63e538eca8d8e7f2733c3612"

URI_aarch64_rust-gengo-language-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo-language-devel-0.14.3-1.el10_2.noarch.rpm;name=aarch64_rust-gengo-language-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo-language-devel}"
SRC_URI[aarch64_rust-gengo-language-devel.sha256sum] = "56e3362f036df0436f3a499aea91025073af7626bccceef646dd75caa5f55083"

RDEPENDS:rust-gengo-language+default-devel = " \
 cargo \
 rust-gengo-language-devel \
 "
RDEPENDS:rust-gengo-language-devel = " \
 cargo \
 rust \
 rust-glob+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_yaml+default-devel \
 "
