# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lemonldap-ng"
PV = "2.22.3"
PR = "1.el10_1"
PACKAGES = " \
 lemonldap-ng \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-fastcgi-server \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 lemonldap-ng-uwsgi-app \
 perl-Lemonldap-NG-SSOaaS-Apache-Client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lemonldap-ng-2.22.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d87a656a9d95555b8db29eb240115eae7558830eab848e344c59ca47f7ff3ad"

URI_x86_64_v2_lemonldap-ng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng}"
SRC_URI[x86_64_v2_lemonldap-ng.sha256sum] = "c0436c17fdfcd76e6bbd052618dbf7626603a7106d24e2d83d4fed4fc8c38f9a"

URI_x86_64_v2_lemonldap-ng-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-common-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-common}"
SRC_URI[x86_64_v2_lemonldap-ng-common.sha256sum] = "568544d8113bc8fd355106d30dfe7ace8f1747558f7079763033542bb0fbe632"
RPROVIDES:lemonldap-ng-common:x86_64_v2 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_x86_64_v2_lemonldap-ng-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-doc-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-doc}"
SRC_URI[x86_64_v2_lemonldap-ng-doc.sha256sum] = "486761fbc98f5d2ce055731b53b1651b926d62713c00defcee52202cb957c3f7"

URI_x86_64_v2_lemonldap-ng-fastcgi-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-fastcgi-server-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-fastcgi-server}"
SRC_URI[x86_64_v2_lemonldap-ng-fastcgi-server.sha256sum] = "9857eab46b6c712638ce01ebd3629e8b21dba61237dc6d13d53c53bcff31de66"

URI_x86_64_v2_lemonldap-ng-handler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-handler-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-handler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-handler}"
SRC_URI[x86_64_v2_lemonldap-ng-handler.sha256sum] = "9101254cc4adfeef391de99753f85f4df3310738a7dd0767c07bb9eb1741deb2"

URI_x86_64_v2_lemonldap-ng-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-manager-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-manager}"
SRC_URI[x86_64_v2_lemonldap-ng-manager.sha256sum] = "6d7249e2b662135762e4b33d8a84afade560d59f4a1f3dd7e80bc6a3a9882377"
RPROVIDES:lemonldap-ng-manager:x86_64_v2 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_x86_64_v2_lemonldap-ng-portal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-portal-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-portal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-portal}"
SRC_URI[x86_64_v2_lemonldap-ng-portal.sha256sum] = "cf2061327842b48596b07cb17c51e25194170df69f108f6aa637b1bb77aec18d"

URI_x86_64_v2_lemonldap-ng-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-selinux-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-selinux}"
SRC_URI[x86_64_v2_lemonldap-ng-selinux.sha256sum] = "424f593df837763865bd85dac5b4121965a1bdc2e77d613aa16bd25de9fd001a"

URI_x86_64_v2_lemonldap-ng-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-test-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-test}"
SRC_URI[x86_64_v2_lemonldap-ng-test.sha256sum] = "bf0353c80a72de8929b16482da83b73ccc1a218c4596ba1f25fd5dc18729667a"

URI_x86_64_v2_lemonldap-ng-uwsgi-app = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lemonldap-ng-uwsgi-app-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lemonldap-ng-uwsgi-app}"
SRC_URI[x86_64_v2_lemonldap-ng-uwsgi-app.sha256sum] = "d97079bbe6074356419ad1b33df21af270ca50c8c19e5122524a49cab1061630"

URI_x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.22.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client}"
SRC_URI[x86_64_v2_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "815a2f21e97d4d39c485d20056b6d099b73505788d09cd0142c1fc147dc5e8ca"

URI_aarch64_lemonldap-ng = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng}"
SRC_URI[aarch64_lemonldap-ng.sha256sum] = "a0647fe153aa9c63c4391decf52d1532be639ccf6c13a18ebef1c17212f7a266"

URI_aarch64_lemonldap-ng-common = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-common-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-common}"
SRC_URI[aarch64_lemonldap-ng-common.sha256sum] = "71daa82c17a70496ca75012dc9e08b21910292452930dbf77b28875ac0fb8c0c"
RPROVIDES:lemonldap-ng-common:aarch64 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_aarch64_lemonldap-ng-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-doc-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-doc}"
SRC_URI[aarch64_lemonldap-ng-doc.sha256sum] = "cb9a8f9c5eb8d45504ccf68f182e5fafc337b27ba10c1d11606896a40745bc7c"

URI_aarch64_lemonldap-ng-fastcgi-server = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-fastcgi-server-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng-fastcgi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-fastcgi-server}"
SRC_URI[aarch64_lemonldap-ng-fastcgi-server.sha256sum] = "5ef6f78c98021b6215583debdd53b28f1ee7fbabb2818679d1b5ca42db6e8064"

URI_aarch64_lemonldap-ng-handler = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-handler-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng-handler;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-handler}"
SRC_URI[aarch64_lemonldap-ng-handler.sha256sum] = "19fac0498a07898b9e54c77e75b51d086651f6c7701ef4078c5c246f51ff0fe8"

URI_aarch64_lemonldap-ng-manager = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-manager-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-manager}"
SRC_URI[aarch64_lemonldap-ng-manager.sha256sum] = "b259b965179f290284cd65a6420dc358f1bfe2af003685783e0fd0ae5659e43d"
RPROVIDES:lemonldap-ng-manager:aarch64 = "virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

URI_aarch64_lemonldap-ng-portal = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-portal-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng-portal;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-portal}"
SRC_URI[aarch64_lemonldap-ng-portal.sha256sum] = "c41add2f704098773afa88da056d08aa862518acb84893002af06c18efdc6aec"

URI_aarch64_lemonldap-ng-selinux = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-selinux-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-selinux}"
SRC_URI[aarch64_lemonldap-ng-selinux.sha256sum] = "da2133abcd3b1d5a331c9ab3428547a29236d63c844a9eaee8ef68583b95f973"

URI_aarch64_lemonldap-ng-test = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-test-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-test}"
SRC_URI[aarch64_lemonldap-ng-test.sha256sum] = "f4dd0e095db512d7d8738d7564a02ddc13add4b2a38ce8b2b3aede0d52d5e2e6"

URI_aarch64_lemonldap-ng-uwsgi-app = "${EPEL_MIRROR}/aarch64/Packages/l/lemonldap-ng-uwsgi-app-2.22.3-1.el10_1.noarch.rpm;name=aarch64_lemonldap-ng-uwsgi-app;unpack=0"
SRC_URI:append = " ${URI_aarch64_lemonldap-ng-uwsgi-app}"
SRC_URI[aarch64_lemonldap-ng-uwsgi-app.sha256sum] = "9a1d363f7b900dd72bce8b10463d29d2340607d31bc3f11236a2bf956ad14164"

URI_aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Lemonldap-NG-SSOaaS-Apache-Client-2.22.3-1.el10_1.noarch.rpm;name=aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client}"
SRC_URI[aarch64_perl-Lemonldap-NG-SSOaaS-Apache-Client.sha256sum] = "745a8f016fd1197b22e5101ebd6f5a423e72ce8ab7d80c7ed92af7a22890b8ea"

RDEPENDS:lemonldap-ng = " \
 lemonldap-ng-common \
 lemonldap-ng-doc \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 lemonldap-ng-selinux \
 lemonldap-ng-test \
 "
RDEPENDS:lemonldap-ng-common = " \
 bash \
 httpd-filesystem \
 lemonldap-ng-common \
 mod_fcgid \
 mod_perl \
 nginx-filesystem \
 perl-Apache-Session \
 perl-Apache-Session-Browseable \
 perl-AutoLoader \
 perl-Cache-Cache \
 perl-Config-IniFiles \
 perl-Convert-Base32 \
 perl-Convert-PEM \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-Rijndael \
 perl-Crypt-URandom \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-HMAC \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-Getopt-Long \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-IO-String \
 perl-JSON \
 perl-JSON-XS \
 perl-LDAP \
 perl-Log-Log4perl \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Sentry-Raven \
 perl-String-Random \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-XML-LibXML \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 virtual/httpd_or_nginx \
 virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_ \
 "
RDEPENDS:lemonldap-ng-doc = " \
 lemonldap-ng-common \
 "
RDEPENDS:lemonldap-ng-fastcgi-server = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_fcgid \
 perl-FCGI-ProcManager \
 perl-Getopt-Long \
 perl-POSIX \
 perl-Plack \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-handler = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 mod_perl \
 perl-Apache-Session \
 perl-AutoLoader \
 perl-Cache-Memcached \
 perl-Digest-HMAC \
 perl-Digest-SHA \
 perl-Exporter \
 perl-Getopt-Std \
 perl-HTTP-Message \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-Plack \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-Time-HiRes \
 perl-URI \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-manager = " \
 lemonldap-ng-common \
 lemonldap-ng-handler \
 lemonldap-ng-manager \
 lemonldap-ng-portal \
 perl-Crypt-URandom \
 perl-Data-Dumper \
 perl-English \
 perl-Exporter \
 perl-File-Compare \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-Hash-Merge-Simple \
 perl-Hash-MultiValue \
 perl-IO-String \
 perl-JSON \
 perl-MIME-Base64 \
 perl-Mouse \
 perl-POSIX \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-Regexp-Common \
 perl-Safe \
 perl-URI \
 perl-constant \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:lemonldap-ng-portal = " \
 bash \
 lemonldap-ng-common \
 lemonldap-ng-portal \
 perl-Authen-PAM \
 perl-Authen-Radius \
 perl-Cache-Cache \
 perl-Carp \
 perl-Clone \
 perl-Crypt-JWT \
 perl-Crypt-OpenSSL-RSA \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-URandom \
 perl-DBI \
 perl-DateTime-Format-RFC3339 \
 perl-Digest-SHA \
 perl-Email-Date-Format \
 perl-Email-Sender \
 perl-Encode \
 perl-Exporter \
 perl-File-Temp \
 perl-GD-SecurityImage \
 perl-GSSAPI \
 perl-Getopt-Long \
 perl-HTML-FormatText-WithLinks \
 perl-HTML-Parser \
 perl-HTML-Template \
 perl-HTTP-Message \
 perl-Hash-MultiValue \
 perl-IO-Socket-Timeout \
 perl-IO-String \
 perl-IPC-Run \
 perl-JSON \
 perl-LDAP \
 perl-List-MoreUtils \
 perl-MIME-Base64 \
 perl-MIME-tools \
 perl-Mouse \
 perl-Net-CIDR \
 perl-Net-OpenID-Server \
 perl-Net-SSLeay \
 perl-POSIX \
 perl-Plack-Handler-FCGI \
 perl-Pod-Usage \
 perl-Regexp-Assemble \
 perl-SOAP-Lite \
 perl-Safe \
 perl-Scalar-List-Utils \
 perl-String-Random \
 perl-Text-Unidecode \
 perl-Time-Local \
 perl-TimeDate \
 perl-URI \
 perl-Web-ID \
 perl-XML-LibXML \
 perl-XML-LibXSLT \
 perl-base \
 perl-constant \
 perl-fields \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:lemonldap-ng-test = " \
 lemonldap-ng-common \
 perl-CGI \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-JSON \
 perl-MIME-Base64 \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:lemonldap-ng-uwsgi-app = " \
 uwsgi-plugin-psgi \
 "
RDEPENDS:perl-Lemonldap-NG-SSOaaS-Apache-Client = " \
 perl-FCGI-Client \
 perl-IO \
 perl-URI \
 perl-constant \
 perl-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"

PROVIDES:append:aarch64 = " rpm/virtual/perl_Lemonldap__NG__Common__Conf__DefaultValues_"
