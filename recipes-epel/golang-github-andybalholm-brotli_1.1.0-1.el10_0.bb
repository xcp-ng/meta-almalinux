# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-andybalholm-brotli"
PV = "1.1.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-andybalholm-brotli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-andybalholm-brotli-1.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2de9b43976e404ed1fa95540bc04b6f143cd1ff496549616621aac3196871801"

URI_x86_64_v2_golang-github-andybalholm-brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-andybalholm-brotli-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-andybalholm-brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-andybalholm-brotli-devel}"
SRC_URI[x86_64_v2_golang-github-andybalholm-brotli-devel.sha256sum] = "3c924c3bbd3d4fa67cdfa67ff428f48eba8a8461dd9e49df60f8e1ef428a7983"

URI_aarch64_golang-github-andybalholm-brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-andybalholm-brotli-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-andybalholm-brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-andybalholm-brotli-devel}"
SRC_URI[aarch64_golang-github-andybalholm-brotli-devel.sha256sum] = "a07c31db8dece2e38ef47a81561e2e7f35c525657999527e50932fe42582edb1"

RDEPENDS:golang-github-andybalholm-brotli-devel = " \
 go-filesystem \
 "
