# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-hi"
PE = "1"
PV = "0.7.0"
PR = "27.el10"
PACKAGES = " \
 hyphen-hi \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-hi-0.7.0-27.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e1fc4cbe33d1b7e74c1802a37eaab7e130d0c36d5889dc2de2097c5539272295"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-hi-0.7.0-27.el10.noarch.rpm;name=x86_64_v2_hyphen-hi;unpack=0"
SRC_URI[x86_64_v2_hyphen-hi.sha256sum] = "74fb3f440412a786f80897b99f6b468b32070ae2a772591a9023423dacb84265"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-hi-0.7.0-27.el10.noarch.rpm;name=aarch64_hyphen-hi;unpack=0"
SRC_URI[aarch64_hyphen-hi.sha256sum] = "74fb3f440412a786f80897b99f6b468b32070ae2a772591a9023423dacb84265"

RDEPENDS:hyphen-hi = " \
 hyphen \
 "
