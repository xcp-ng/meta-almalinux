# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-im-rc"
PV = "15.1.0"
PR = "9.el10_0"
PACKAGES = " \
 rust-im-rc+arbitrary-devel \
 rust-im-rc+debug-devel \
 rust-im-rc+default-devel \
 rust-im-rc+proptest-devel \
 rust-im-rc+quickcheck-devel \
 rust-im-rc+rayon-devel \
 rust-im-rc+serde-devel \
 rust-im-rc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-im-rc-15.1.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b96c0bc7ee8d588e7f9454b4dda74c8c7eb74dae755848992c6792f4393caa5b"

URI_x86_64_v2_rust-im-rc+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-im-rc+arbitrary-devel-15.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-im-rc+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-im-rc+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-im-rc+arbitrary-devel.sha256sum] = "abd1da1835a9661f8782b3bb98762a451d4281636e61336090d4d04a26d9609c"

URI_x86_64_v2_rust-im-rc+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-im-rc+debug-devel-15.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-im-rc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-im-rc+debug-devel}"
SRC_URI[x86_64_v2_rust-im-rc+debug-devel.sha256sum] = "1522a341331dbcb104ad794ff3b271d05fe9cbb5f57d7cab73a26e9fb16b2015"

URI_x86_64_v2_rust-im-rc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-im-rc+default-devel-15.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-im-rc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-im-rc+default-devel}"
SRC_URI[x86_64_v2_rust-im-rc+default-devel.sha256sum] = "f0ee017c72e9ffd7817fa94d3367ab19b45f1a981fcee5f5b0c69d441068cc01"

URI_x86_64_v2_rust-im-rc+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-im-rc+proptest-devel-15.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-im-rc+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-im-rc+proptest-devel}"
SRC_URI[x86_64_v2_rust-im-rc+proptest-devel.sha256sum] = "96b5da27bfd353eacae49935126e8a940171973fd8fe5dd7c0569f65980bc16f"

URI_x86_64_v2_rust-im-rc+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-im-rc+quickcheck-devel-15.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-im-rc+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-im-rc+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-im-rc+quickcheck-devel.sha256sum] = "4d601c940c288481b2b0ae569ccb3a4c95ee3b2a91b2aa8741433c7fba145aaf"

URI_x86_64_v2_rust-im-rc+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-im-rc+rayon-devel-15.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-im-rc+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-im-rc+rayon-devel}"
SRC_URI[x86_64_v2_rust-im-rc+rayon-devel.sha256sum] = "437cbc591410928a7016f99500aef076f28d9cc878c36eb7e65c302640e57b06"

URI_x86_64_v2_rust-im-rc+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-im-rc+serde-devel-15.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-im-rc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-im-rc+serde-devel}"
SRC_URI[x86_64_v2_rust-im-rc+serde-devel.sha256sum] = "5b6853dab0269f976b0f9377b43a238f704013fc5b0c47d87e94e250c6359a11"

URI_x86_64_v2_rust-im-rc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-im-rc-devel-15.1.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-im-rc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-im-rc-devel}"
SRC_URI[x86_64_v2_rust-im-rc-devel.sha256sum] = "660c30835bc0460a1dc1f8285c0ba5aa8641e496d4ceb6e929693021af7a8088"

URI_aarch64_rust-im-rc+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-im-rc+arbitrary-devel-15.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-im-rc+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-im-rc+arbitrary-devel}"
SRC_URI[aarch64_rust-im-rc+arbitrary-devel.sha256sum] = "95a875365f5108ac9525a82ae35669374feda184203076ec46360bc475b7d7e1"

URI_aarch64_rust-im-rc+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-im-rc+debug-devel-15.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-im-rc+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-im-rc+debug-devel}"
SRC_URI[aarch64_rust-im-rc+debug-devel.sha256sum] = "d3bcd4500568efa8083490b48cb5853b55ad27f7a79898ecc7deb6661457edbe"

URI_aarch64_rust-im-rc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-im-rc+default-devel-15.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-im-rc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-im-rc+default-devel}"
SRC_URI[aarch64_rust-im-rc+default-devel.sha256sum] = "9317005e2ca10e7f9f48076dd781cc47e4bd2f28049ad123ccce18fac786fed3"

URI_aarch64_rust-im-rc+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-im-rc+proptest-devel-15.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-im-rc+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-im-rc+proptest-devel}"
SRC_URI[aarch64_rust-im-rc+proptest-devel.sha256sum] = "0a4c7882ff46e2e999456eaec044e9b3b9ac55a1e14e6b91bfd0956141e70f24"

URI_aarch64_rust-im-rc+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-im-rc+quickcheck-devel-15.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-im-rc+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-im-rc+quickcheck-devel}"
SRC_URI[aarch64_rust-im-rc+quickcheck-devel.sha256sum] = "5731447f99a8441e54a2b850b187e390e9629e9676b2c34f349cbde992a71b09"

URI_aarch64_rust-im-rc+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-im-rc+rayon-devel-15.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-im-rc+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-im-rc+rayon-devel}"
SRC_URI[aarch64_rust-im-rc+rayon-devel.sha256sum] = "10c4ee41ffc8d60f993b97dd0fc0c7ccc9c7efd5af69e3178df48723b43d7bf3"

URI_aarch64_rust-im-rc+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-im-rc+serde-devel-15.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-im-rc+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-im-rc+serde-devel}"
SRC_URI[aarch64_rust-im-rc+serde-devel.sha256sum] = "a65ebf96bfa6fadee8d0c44bde74a6feeb0d1528f13910a19a12d5a84fe07bae"

URI_aarch64_rust-im-rc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-im-rc-devel-15.1.0-9.el10_0.noarch.rpm;name=aarch64_rust-im-rc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-im-rc-devel}"
SRC_URI[aarch64_rust-im-rc-devel.sha256sum] = "9722a2b7cc0f58daeaaa9e7b5ad1a1f4e078553fc7ac0bfb98d3216eb169129c"

RDEPENDS:rust-im-rc+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-im-rc-devel \
 "
RDEPENDS:rust-im-rc+debug-devel = " \
 cargo \
 rust-im-rc-devel \
 "
RDEPENDS:rust-im-rc+default-devel = " \
 cargo \
 rust-im-rc-devel \
 "
RDEPENDS:rust-im-rc+proptest-devel = " \
 cargo \
 rust-im-rc-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-im-rc+quickcheck-devel = " \
 cargo \
 rust-im-rc-devel \
 rust-quickcheck+default-devel \
 "
RDEPENDS:rust-im-rc+rayon-devel = " \
 cargo \
 rust-im-rc-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-im-rc+serde-devel = " \
 cargo \
 rust-im-rc-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-im-rc-devel = " \
 cargo \
 rust \
 rust-bitmaps+default-devel \
 rust-rand_core0.6+default-devel \
 rust-rand_xoshiro+default-devel \
 rust-sized-chunks+default-devel \
 rust-typenum+default-devel \
 rust-version_check+default-devel \
 "
