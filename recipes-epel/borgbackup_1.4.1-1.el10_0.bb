# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "borgbackup"
PV = "1.4.1"
PR = "1.el10_0"
PACKAGES = " \
 borgbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/borgbackup-1.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "380412d21cf5764eab3536b12a069f4a1011e0f5604b2884ce760d12b6a2d255"

URI_x86_64_v2_borgbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/borgbackup-1.4.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_borgbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_borgbackup}"
SRC_URI[x86_64_v2_borgbackup.sha256sum] = "ed339842ee851e9178a7e65d1bed1bfdfbcd430c1c2dab9cfb6c7ddb813e1f0a"

URI_aarch64_borgbackup = "${EPEL_MIRROR}/aarch64/Packages/b/borgbackup-1.4.1-1.el10_0.aarch64.rpm;name=aarch64_borgbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_borgbackup}"
SRC_URI[aarch64_borgbackup.sha256sum] = "0a4bae68e2be3e9a21f75e1aa1820c0df6f2ba28923b2f1e50563431bdc466f4"

RDEPENDS:borgbackup = " \
 fuse \
 glibc \
 libacl \
 libzstd \
 lz4-libs \
 openssl-libs \
 python3 \
 python3-llfuse \
 python3-msgpack \
 python3-packaging \
 xxhash-libs \
 "
