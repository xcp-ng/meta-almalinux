# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lzip"
PV = "1.24.1"
PR = "3.el10_0"
PACKAGES = " \
 lzip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lzip-1.24.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f5bb80ab5b620f88f114b5a74a12755641521bfef062837b31ffd9c654ae2ac"

URI_x86_64_v2_lzip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lzip-1.24.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lzip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lzip}"
SRC_URI[x86_64_v2_lzip.sha256sum] = "66dfd1d901d9606f24078f5f644a105285eeb85919ab657702b3fc403aa836f1"

URI_aarch64_lzip = "${EPEL_MIRROR}/aarch64/Packages/l/lzip-1.24.1-3.el10_0.aarch64.rpm;name=aarch64_lzip;unpack=0"
SRC_URI:append = " ${URI_aarch64_lzip}"
SRC_URI[aarch64_lzip.sha256sum] = "60fbba7fdff87af2d2ae3a1e4497298ce3b90009040d3dafdcadc2c71d677981"

RDEPENDS:lzip = " \
 glibc \
 libgcc \
 libstdc++ \
 "
