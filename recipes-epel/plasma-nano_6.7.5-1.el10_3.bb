# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-nano"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-nano \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-nano-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b0b4102408b38c6b16079f60a775d6455f74b754db0f5bce24e702fb274cdb3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-nano-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-nano;unpack=0"
SRC_URI[x86_64_v2_plasma-nano.sha256sum] = "8ce8489b6cc06761009262419ae4fa20132052ea484328272ed9166224f6fe50"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-nano-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-nano;unpack=0"
SRC_URI[aarch64_plasma-nano.sha256sum] = "091436ecf41fcaf5245666ac0ecfd05c474cec345b8d4b94a321991bdfc93116"

RDEPENDS:plasma-nano = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kpackage \
 kf6-kservice \
 kf6-kwindowsystem \
 kwayland \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
