# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-auth"
PE = "1"
PV = "2.56.2"
PR = "1.el10_3"
PACKAGES = " \
 python3-google-auth \
 python3-google-auth+aiohttp \
 python3-google-auth+enterprise_cert \
 python3-google-auth+pyjwt \
 python3-google-auth+pyopenssl \
 python3-google-auth+requests \
 python3-google-auth+urllib3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-auth-2.56.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "355c174d84f8e960060f15638e51958e2ade514fca0578c8bdaf6d72f6ec2f8a"

URI_x86_64_v2_python3-google-auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth-2.56.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth}"
SRC_URI[x86_64_v2_python3-google-auth.sha256sum] = "3697c9fe3134a687a85d86f0a8448e4686d7ef36e234eb6760142222fb086174"

URI_x86_64_v2_python3-google-auth+aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+aiohttp-2.56.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+aiohttp}"
SRC_URI[x86_64_v2_python3-google-auth+aiohttp.sha256sum] = "c70a90561dd7bd6b2636993e8f52b4fdbc868b6ad38e75ddd2dc9570c8e5c311"

URI_x86_64_v2_python3-google-auth+enterprise_cert = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+enterprise_cert-2.56.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+enterprise_cert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+enterprise_cert}"
SRC_URI[x86_64_v2_python3-google-auth+enterprise_cert.sha256sum] = "07f1c62bee84bb027f40282902e86f8c3e8d6a94799a00486cb9e2be0fa1a44b"

URI_x86_64_v2_python3-google-auth+pyjwt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+pyjwt-2.56.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+pyjwt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+pyjwt}"
SRC_URI[x86_64_v2_python3-google-auth+pyjwt.sha256sum] = "8001f34f70afafdaa1db0e179d4203aea48b34a19459bebc990140fefe91bd6c"

URI_x86_64_v2_python3-google-auth+pyopenssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+pyopenssl-2.56.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+pyopenssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+pyopenssl}"
SRC_URI[x86_64_v2_python3-google-auth+pyopenssl.sha256sum] = "c525086d0ea35351e9318b9a390cf51a17ba0146316bbbd920e3522b8a8b70e5"

URI_x86_64_v2_python3-google-auth+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+requests-2.56.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+requests}"
SRC_URI[x86_64_v2_python3-google-auth+requests.sha256sum] = "5daac6bdd744f50f33235a4f1ef5b6556c36b10cb560405bc38af47a6c90809d"

URI_x86_64_v2_python3-google-auth+urllib3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+urllib3-2.56.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+urllib3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+urllib3}"
SRC_URI[x86_64_v2_python3-google-auth+urllib3.sha256sum] = "607f4f1c902242e017716039ce6c7fd1f120ed32a84de258ab0e6c02c812ac31"

URI_aarch64_python3-google-auth = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth-2.56.2-1.el10_3.noarch.rpm;name=aarch64_python3-google-auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth}"
SRC_URI[aarch64_python3-google-auth.sha256sum] = "1a83d1d32c86755a512ad8eecdaf7686ae47c0454b4ec7bd456f55a2d83e484b"

URI_aarch64_python3-google-auth+aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+aiohttp-2.56.2-1.el10_3.noarch.rpm;name=aarch64_python3-google-auth+aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+aiohttp}"
SRC_URI[aarch64_python3-google-auth+aiohttp.sha256sum] = "92c74e9dc284bdaac647436a80733dcb32dbe1471f315c88e4906ab49bde30eb"

URI_aarch64_python3-google-auth+enterprise_cert = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+enterprise_cert-2.56.2-1.el10_3.noarch.rpm;name=aarch64_python3-google-auth+enterprise_cert;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+enterprise_cert}"
SRC_URI[aarch64_python3-google-auth+enterprise_cert.sha256sum] = "d7c16b7ac04d54f1d19ea681821696777ba2f71d172a9cd158a294dd965eaf6b"

URI_aarch64_python3-google-auth+pyjwt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+pyjwt-2.56.2-1.el10_3.noarch.rpm;name=aarch64_python3-google-auth+pyjwt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+pyjwt}"
SRC_URI[aarch64_python3-google-auth+pyjwt.sha256sum] = "02fcc1cecc39589c526e6d04fdaf30dc13388df60f722f51107c10909b4ee6ec"

URI_aarch64_python3-google-auth+pyopenssl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+pyopenssl-2.56.2-1.el10_3.noarch.rpm;name=aarch64_python3-google-auth+pyopenssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+pyopenssl}"
SRC_URI[aarch64_python3-google-auth+pyopenssl.sha256sum] = "61ca3ced8a153d46f7b0124ddb05ddaeda66d99ecc9f5bf0d211747bf5b9dbff"

URI_aarch64_python3-google-auth+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+requests-2.56.2-1.el10_3.noarch.rpm;name=aarch64_python3-google-auth+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+requests}"
SRC_URI[aarch64_python3-google-auth+requests.sha256sum] = "de7225b3375e3b9c31c2bf88ffb6c83430c1c34f32864a54eaae5a64942bc429"

URI_aarch64_python3-google-auth+urllib3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+urllib3-2.56.2-1.el10_3.noarch.rpm;name=aarch64_python3-google-auth+urllib3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+urllib3}"
SRC_URI[aarch64_python3-google-auth+urllib3.sha256sum] = "d6dad743cce446f67427aa9b28eff000c9ed9f13c8e632847b0a74db2915ee33"

RDEPENDS:python3-google-auth = " \
 python3 \
 python3-cryptography \
 python3-pyasn1-modules \
 "
RDEPENDS:python3-google-auth+aiohttp = " \
 python3 \
 python3-aiohttp \
 python3-google-auth \
 python3-requests \
 "
RDEPENDS:python3-google-auth+enterprise_cert = " \
 python3 \
 python3-cryptography \
 python3-google-auth \
 "
RDEPENDS:python3-google-auth+pyjwt = " \
 python3 \
 python3-google-auth \
 python3-jwt \
 "
RDEPENDS:python3-google-auth+pyopenssl = " \
 python3 \
 python3-cryptography \
 python3-google-auth \
 "
RDEPENDS:python3-google-auth+requests = " \
 python3 \
 python3-google-auth \
 python3-requests \
 "
RDEPENDS:python3-google-auth+urllib3 = " \
 python3 \
 python3-google-auth \
 python3-packaging \
 python3-urllib3 \
 "
