# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cairosvg"
PV = "2.9.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-cairosvg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cairosvg-2.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec86b81ce1f2b93bc2a45e4338e71e3bc278c01bf5420bcb054eb52a3a29afc1"

URI_x86_64_v2_python3-cairosvg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cairosvg-2.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cairosvg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cairosvg}"
SRC_URI[x86_64_v2_python3-cairosvg.sha256sum] = "17f452250b6713bd60ac7b3297a1105f53006d4136280862cba09121a078cf22"

URI_aarch64_python3-cairosvg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cairosvg-2.9.0-1.el10_3.noarch.rpm;name=aarch64_python3-cairosvg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cairosvg}"
SRC_URI[aarch64_python3-cairosvg.sha256sum] = "fa4ad8260a0d73a118d420741c07e9109888c1b66edab057c7a8e401ff7d0668"

RDEPENDS:python3-cairosvg = " \
 python3 \
 python3-cairocffi \
 python3-cssselect2 \
 python3-defusedxml \
 python3-pillow \
 python3-tinycss2 \
 "
