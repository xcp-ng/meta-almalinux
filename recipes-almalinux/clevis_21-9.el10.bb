# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "clevis"
PV = "21"
PR = "9.el10"
PACKAGES = " \
 clevis \
 clevis-dracut \
 clevis-luks \
 clevis-pin-pkcs11 \
 clevis-systemd \
 clevis-udisks2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/clevis-21-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b84ca89354193a78fa8f8b941b40bb814ad339aaecd78d8c135c59b160897b11"

URI_x86_64_v2_clevis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-21-9.el10.x86_64_v2.rpm;name=x86_64_v2_clevis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis}"
SRC_URI[x86_64_v2_clevis.sha256sum] = "92ee0668def9c3ff1bbde064b3f2aaaa9a18b3ddec357f66fcd8fb9234079896"

URI_x86_64_v2_clevis-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-dracut-21-9.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-dracut}"
SRC_URI[x86_64_v2_clevis-dracut.sha256sum] = "bcb0895e92446e670b61ffcdeda28ce7d74eb92fb4a818964a287ff768506b23"

URI_x86_64_v2_clevis-luks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-luks-21-9.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-luks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-luks}"
SRC_URI[x86_64_v2_clevis-luks.sha256sum] = "cb58c2c781a0afac8eb8d5c9c0b5e9630dd442efda68908d24207318d5828e5b"

URI_x86_64_v2_clevis-pin-pkcs11 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-pin-pkcs11-21-9.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-pin-pkcs11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-pin-pkcs11}"
SRC_URI[x86_64_v2_clevis-pin-pkcs11.sha256sum] = "9f158e39052a212bb590d96c4e55750167f1ef0f33010e303f23aa256b3f1764"

URI_x86_64_v2_clevis-systemd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-systemd-21-9.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-systemd}"
SRC_URI[x86_64_v2_clevis-systemd.sha256sum] = "6878a5cddf3d6fc010ad1c7e1db609b37df30538cd2d115c52b5954a58fca0e9"

URI_x86_64_v2_clevis-udisks2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/clevis-udisks2-21-9.el10.x86_64_v2.rpm;name=x86_64_v2_clevis-udisks2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clevis-udisks2}"
SRC_URI[x86_64_v2_clevis-udisks2.sha256sum] = "eab1ac71a30740553cbbbb3b595ffba925be6ddb84db6352d5f1fac679ab489d"

URI_aarch64_clevis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-21-9.el10.aarch64.rpm;name=aarch64_clevis;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis}"
SRC_URI[aarch64_clevis.sha256sum] = "2f7d1e715f7e3608362a94b16c7f300e1f5eae0932d3d6b476797809e6e26b0f"

URI_aarch64_clevis-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-dracut-21-9.el10.aarch64.rpm;name=aarch64_clevis-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-dracut}"
SRC_URI[aarch64_clevis-dracut.sha256sum] = "56835216da02f790c2f24fdcda2b735a63d7f4bf5bdd5c1bd01481a3b1e6445d"

URI_aarch64_clevis-luks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-luks-21-9.el10.aarch64.rpm;name=aarch64_clevis-luks;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-luks}"
SRC_URI[aarch64_clevis-luks.sha256sum] = "b8c0baa4f84fc5b59647fd50423f8848df782656fad6252f38f5f0a0f18e00c4"

URI_aarch64_clevis-pin-pkcs11 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-pin-pkcs11-21-9.el10.aarch64.rpm;name=aarch64_clevis-pin-pkcs11;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-pin-pkcs11}"
SRC_URI[aarch64_clevis-pin-pkcs11.sha256sum] = "55ffde445652a184d02f91c6f8a585f378123b86b8f9c5f0490333068f29bc32"

URI_aarch64_clevis-systemd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-systemd-21-9.el10.aarch64.rpm;name=aarch64_clevis-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-systemd}"
SRC_URI[aarch64_clevis-systemd.sha256sum] = "12f8a2e0f1f93278134d8bb3520e87a3fecba9134ae62b625fd69e7ea6920e85"

URI_aarch64_clevis-udisks2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/clevis-udisks2-21-9.el10.aarch64.rpm;name=aarch64_clevis-udisks2;unpack=0"
SRC_URI:append = " ${URI_aarch64_clevis-udisks2}"
SRC_URI[aarch64_clevis-udisks2.sha256sum] = "7b972d404af0ec4b71e1f84b592bc076d9b081d76bd8adfca69aeed7281b458d"

RDEPENDS:clevis = " \
 bash \
 clevis-pin-tpm2 \
 curl \
 glibc \
 jansson \
 jose \
 jq \
 libgcc \
 libjose \
 openssl-libs \
 shadow-utils \
 systemd \
 tpm2-tools \
 virtual/coreutils \
 "
RDEPENDS:clevis-dracut = " \
 bash \
 clevis-systemd \
 dracut-network \
 "
RDEPENDS:clevis-luks = " \
 bash \
 clevis \
 cryptsetup \
 luksmeta \
 "
RDEPENDS:clevis-pin-pkcs11 = " \
 bash \
 clevis-dracut \
 clevis-luks \
 clevis-systemd \
 glibc \
 opensc \
 openssl \
 pcsc-lite \
 socat \
 "
RDEPENDS:clevis-systemd = " \
 bash \
 clevis-luks \
 systemd \
 "
RDEPENDS:clevis-udisks2 = " \
 audit-libs \
 clevis-luks \
 cryptsetup-libs \
 glib2 \
 glibc \
 jansson \
 libgcc \
 libluksmeta \
 libudisks2 \
 "
