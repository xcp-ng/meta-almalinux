# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-aws"
PV = "0.24.1"
PR = "4.el10_0"
PACKAGES = " \
 ghc-aws \
 ghc-aws-devel \
 ghc-aws-doc \
 ghc-aws-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-aws-0.24.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26075a091097871cfd6acb693174ea83d60a9c3d2402a11d3c456a7c199df8ae"

URI_x86_64_v2_ghc-aws = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-aws-0.24.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-aws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-aws}"
SRC_URI[x86_64_v2_ghc-aws.sha256sum] = "42aa1c7e0d99bd3cb42ff41406834e5a15810943161b42ee36cc9bdbbcbeb4ca"

URI_x86_64_v2_ghc-aws-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-aws-devel-0.24.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-aws-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-aws-devel}"
SRC_URI[x86_64_v2_ghc-aws-devel.sha256sum] = "e42c48d2504f3d56a6b8046cfa2c5821a0a3c46544de88d150692981bfc85d79"

URI_x86_64_v2_ghc-aws-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-aws-doc-0.24.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-aws-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-aws-doc}"
SRC_URI[x86_64_v2_ghc-aws-doc.sha256sum] = "96c30f75091ab32fdf10b19522565aaeb59b2c8a87ae4511369e49dd12c82182"

URI_x86_64_v2_ghc-aws-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-aws-prof-0.24.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-aws-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-aws-prof}"
SRC_URI[x86_64_v2_ghc-aws-prof.sha256sum] = "8c6b96a9c7459a01dab30257fb4c52b0059c657361368bdd238b9c9a6e61eb74"

URI_aarch64_ghc-aws = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-aws-0.24.1-4.el10_0.aarch64.rpm;name=aarch64_ghc-aws;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-aws}"
SRC_URI[aarch64_ghc-aws.sha256sum] = "f27186e5a79b393b88d32033a610dfbe0839b06e6d73dd49b5fd1af46c48f3de"

URI_aarch64_ghc-aws-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-aws-devel-0.24.1-4.el10_0.aarch64.rpm;name=aarch64_ghc-aws-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-aws-devel}"
SRC_URI[aarch64_ghc-aws-devel.sha256sum] = "95d0dc91c49cdcfa018f3426eca134a4c555f098f2c250ded7b906863d3683c9"

URI_aarch64_ghc-aws-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-aws-doc-0.24.1-4.el10_0.noarch.rpm;name=aarch64_ghc-aws-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-aws-doc}"
SRC_URI[aarch64_ghc-aws-doc.sha256sum] = "e66699a9ed7a71cf3ca336e0a5c8dd7ab28751837e2ef4d255145dd72b7fe309"

URI_aarch64_ghc-aws-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-aws-prof-0.24.1-4.el10_0.aarch64.rpm;name=aarch64_ghc-aws-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-aws-prof}"
SRC_URI[aarch64_ghc-aws-prof.sha256sum] = "5d4d11d96a071e1c8a77eb08c15c5c7c93f4a971dadbf67c7530473e9654b7ba"

RDEPENDS:ghc-aws = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base16-bytestring \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-byteable \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-cryptonite \
 ghc-data-default \
 ghc-data-default-class \
 ghc-data-default-instances-containers \
 ghc-data-default-instances-dlist \
 ghc-data-default-instances-old-locale \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-lifted-base \
 ghc-memory \
 ghc-mime-types \
 ghc-monad-control \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-bsd \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-safe \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-aws-devel = " \
 ghc-aeson-devel \
 ghc-attoparsec-devel \
 ghc-aws \
 ghc-base-devel \
 ghc-base16-bytestring-devel \
 ghc-base64-bytestring-devel \
 ghc-blaze-builder-devel \
 ghc-byteable-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-cereal-devel \
 ghc-compiler \
 ghc-conduit-devel \
 ghc-conduit-extra-devel \
 ghc-containers-devel \
 ghc-cryptonite-devel \
 ghc-data-default-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-http-client-tls-devel \
 ghc-http-conduit-devel \
 ghc-http-types-devel \
 ghc-lifted-base-devel \
 ghc-memory-devel \
 ghc-monad-control-devel \
 ghc-mtl-devel \
 ghc-network-bsd-devel \
 ghc-network-devel \
 ghc-old-locale-devel \
 ghc-resourcet-devel \
 ghc-safe-devel \
 ghc-scientific-devel \
 ghc-tagged-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unordered-containers-devel \
 ghc-utf8-string-devel \
 ghc-vector-devel \
 ghc-xml-conduit-devel \
 "
RDEPENDS:ghc-aws-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-aws-prof = " \
 ghc-aeson-prof \
 ghc-attoparsec-prof \
 ghc-aws-devel \
 ghc-base-prof \
 ghc-base16-bytestring-prof \
 ghc-base64-bytestring-prof \
 ghc-blaze-builder-prof \
 ghc-byteable-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-cereal-prof \
 ghc-conduit-extra-prof \
 ghc-conduit-prof \
 ghc-containers-prof \
 ghc-cryptonite-prof \
 ghc-data-default-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-http-client-tls-prof \
 ghc-http-conduit-prof \
 ghc-http-types-prof \
 ghc-lifted-base-prof \
 ghc-memory-prof \
 ghc-monad-control-prof \
 ghc-mtl-prof \
 ghc-network-bsd-prof \
 ghc-network-prof \
 ghc-old-locale-prof \
 ghc-resourcet-prof \
 ghc-safe-prof \
 ghc-scientific-prof \
 ghc-tagged-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unordered-containers-prof \
 ghc-utf8-string-prof \
 ghc-vector-prof \
 ghc-xml-conduit-prof \
 "
