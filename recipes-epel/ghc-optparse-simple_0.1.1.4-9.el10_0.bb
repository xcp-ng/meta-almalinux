# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-optparse-simple"
PV = "0.1.1.4"
PR = "9.el10_0"
PACKAGES = " \
 ghc-githash \
 ghc-githash-devel \
 ghc-githash-doc \
 ghc-githash-prof \
 ghc-optparse-simple \
 ghc-optparse-simple-devel \
 ghc-optparse-simple-doc \
 ghc-optparse-simple-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-optparse-simple-0.1.1.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe7fbc9bf6b24d2bca421684025db58fb2614b83b5d924daeb48392d69ba892a"

URI_x86_64_v2_ghc-githash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-githash-0.1.7.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-githash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-githash}"
SRC_URI[x86_64_v2_ghc-githash.sha256sum] = "a07266b3a87f115f92a0220964a2c7343ccce74c4d9f3614e50358a8a71aa08b"

URI_x86_64_v2_ghc-githash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-githash-devel-0.1.7.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-githash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-githash-devel}"
SRC_URI[x86_64_v2_ghc-githash-devel.sha256sum] = "ae6125cbd4333af57e8d1604198806858d95918634d6ab76b0e9e8fae154b85d"

URI_x86_64_v2_ghc-githash-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-githash-doc-0.1.7.0-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-githash-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-githash-doc}"
SRC_URI[x86_64_v2_ghc-githash-doc.sha256sum] = "fc50bf10664e1fe4a56071e7e64c3b88e6bd92a3f7c91cd44b4e2f12253abb7a"

URI_x86_64_v2_ghc-githash-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-githash-prof-0.1.7.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-githash-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-githash-prof}"
SRC_URI[x86_64_v2_ghc-githash-prof.sha256sum] = "9dc9976c734f70ad0e017e32e42daa5ae8a4be48fedcc203c910b82ca626722a"

URI_x86_64_v2_ghc-optparse-simple = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optparse-simple-0.1.1.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-optparse-simple;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optparse-simple}"
SRC_URI[x86_64_v2_ghc-optparse-simple.sha256sum] = "12fbf5270168662b8b983187e80f37206cc1606c42c6bcb99ee5368f1bd8d043"

URI_x86_64_v2_ghc-optparse-simple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optparse-simple-devel-0.1.1.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-optparse-simple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optparse-simple-devel}"
SRC_URI[x86_64_v2_ghc-optparse-simple-devel.sha256sum] = "9243ffbef63b717ba3d43d6ffc2b7a97eb1a9bbd94d890bc7ed60c09e54f8a4f"

URI_x86_64_v2_ghc-optparse-simple-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optparse-simple-doc-0.1.1.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-optparse-simple-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optparse-simple-doc}"
SRC_URI[x86_64_v2_ghc-optparse-simple-doc.sha256sum] = "c9b9aadce6a0b0f29a157663376885ff93067f5a02bc6f929a39e13d308f17df"

URI_x86_64_v2_ghc-optparse-simple-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-optparse-simple-prof-0.1.1.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-optparse-simple-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-optparse-simple-prof}"
SRC_URI[x86_64_v2_ghc-optparse-simple-prof.sha256sum] = "46bb82fa14818f73ae978534604637c4730fdb9ac5b223d605c686edbe9b7653"

URI_aarch64_ghc-githash = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-githash-0.1.7.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-githash;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-githash}"
SRC_URI[aarch64_ghc-githash.sha256sum] = "7bf0bde502005d997097a76d323d045ae34efc458447915fa6c39d551029873a"

URI_aarch64_ghc-githash-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-githash-devel-0.1.7.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-githash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-githash-devel}"
SRC_URI[aarch64_ghc-githash-devel.sha256sum] = "200635ef842686edbd949d4fead70b0652b6dee060a735a1e65cf288bf7b9b8d"

URI_aarch64_ghc-githash-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-githash-doc-0.1.7.0-9.el10_0.noarch.rpm;name=aarch64_ghc-githash-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-githash-doc}"
SRC_URI[aarch64_ghc-githash-doc.sha256sum] = "13d42e06fac4b97ae3fdb17fc4594e5e8b3229888da8dd81a1641616ec7441a8"

URI_aarch64_ghc-githash-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-githash-prof-0.1.7.0-9.el10_0.aarch64.rpm;name=aarch64_ghc-githash-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-githash-prof}"
SRC_URI[aarch64_ghc-githash-prof.sha256sum] = "801310c882b5eaaefcffc4f637a3e78a00f87d15f861970930456cef8a6fffd1"

URI_aarch64_ghc-optparse-simple = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optparse-simple-0.1.1.4-9.el10_0.aarch64.rpm;name=aarch64_ghc-optparse-simple;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optparse-simple}"
SRC_URI[aarch64_ghc-optparse-simple.sha256sum] = "f25aa9809a59a960537d2b322c2a875fd715c2af2a390a87dc4047cea474511a"

URI_aarch64_ghc-optparse-simple-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optparse-simple-devel-0.1.1.4-9.el10_0.aarch64.rpm;name=aarch64_ghc-optparse-simple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optparse-simple-devel}"
SRC_URI[aarch64_ghc-optparse-simple-devel.sha256sum] = "a392a9d34a81b33587eece31e8f5b3c2a7611a315f5b4684a6db90662e595558"

URI_aarch64_ghc-optparse-simple-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optparse-simple-doc-0.1.1.4-9.el10_0.noarch.rpm;name=aarch64_ghc-optparse-simple-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optparse-simple-doc}"
SRC_URI[aarch64_ghc-optparse-simple-doc.sha256sum] = "2e7587d6149570c6e30a5c66bf305fceb0c443edb1846bb851580a7c9eb0ba0d"

URI_aarch64_ghc-optparse-simple-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-optparse-simple-prof-0.1.1.4-9.el10_0.aarch64.rpm;name=aarch64_ghc-optparse-simple-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-optparse-simple-prof}"
SRC_URI[aarch64_ghc-optparse-simple-prof.sha256sum] = "2eee56305ed70d90f066f695abdedb58d4617ca31f537d05c714bfc40d7d3886"

RDEPENDS:ghc-githash = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-th-compat \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-githash-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-githash \
 ghc-process-devel \
 ghc-template-haskell-devel \
 ghc-th-compat-devel \
 "
RDEPENDS:ghc-githash-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-githash-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-githash-devel \
 ghc-process-prof \
 ghc-template-haskell-prof \
 ghc-th-compat-prof \
 "
RDEPENDS:ghc-optparse-simple = " \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-githash \
 ghc-mtl \
 ghc-optparse-applicative \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-th-compat \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-optparse-simple-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-githash-devel \
 ghc-optparse-applicative-devel \
 ghc-optparse-simple \
 ghc-template-haskell-devel \
 ghc-th-compat-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-optparse-simple-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-optparse-simple-prof = " \
 ghc-base-prof \
 ghc-githash-prof \
 ghc-optparse-applicative-prof \
 ghc-optparse-simple-devel \
 ghc-template-haskell-prof \
 ghc-th-compat-prof \
 ghc-transformers-prof \
 "
