# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-text-editor"
PV = "47.4"
PR = "2.el10"
PACKAGES = " \
 gnome-text-editor \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-text-editor-47.4-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96fc22fe19cfd93b0586d8ecf09907d43e0bab77f78b80895209bfeac2263a26"

URI_x86_64_v2_gnome-text-editor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-text-editor-47.4-2.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-text-editor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-text-editor}"
SRC_URI[x86_64_v2_gnome-text-editor.sha256sum] = "dc61b427e6b7644100bb520c85238cc79777dc6b63b2a34e6cdeab1e40a9195c"

URI_aarch64_gnome-text-editor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-text-editor-47.4-2.el10.aarch64.rpm;name=aarch64_gnome-text-editor;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-text-editor}"
SRC_URI[aarch64_gnome-text-editor.sha256sum] = "08bd47801dc25091f9a45ec747f1f4a61ae3e8713331d4b0e58f5c36e3929ca7"

RDEPENDS:gnome-text-editor = " \
 cairo \
 editorconfig-libs \
 enchant2 \
 glib2 \
 glibc \
 gtk4 \
 gtksourceview5 \
 libadwaita \
 libgcc \
 libspelling \
 pango \
 "
