# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsecret"
PV = "0.21.2"
PR = "7.el10"
PACKAGES = " \
 libsecret \
 libsecret-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libsecret-0.21.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2efe58af14c4f4268c43cd8121cc6ffa1ef788df996198eda4c4f0db9c73f974"

URI_x86_64_v2_libsecret = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsecret-0.21.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_libsecret;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsecret}"
SRC_URI[x86_64_v2_libsecret.sha256sum] = "c677d1f5469ed229591faa61d9300f303781790a9cd3135cd357542697324c9b"

URI_x86_64_v2_libsecret-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsecret-devel-0.21.2-7.el10.x86_64_v2.rpm;name=x86_64_v2_libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsecret-devel}"
SRC_URI[x86_64_v2_libsecret-devel.sha256sum] = "00225e065d13c6ef5aab1b67620400e465fcdd3fec4fe823d368c44cc69fd7b9"

URI_aarch64_libsecret = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsecret-0.21.2-7.el10.aarch64.rpm;name=aarch64_libsecret;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsecret}"
SRC_URI[aarch64_libsecret.sha256sum] = "9ad93887dbde3a2890757885189fb9ab9c043fe590b88d9504a27ae549794d72"

URI_aarch64_libsecret-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsecret-devel-0.21.2-7.el10.aarch64.rpm;name=aarch64_libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsecret-devel}"
SRC_URI[aarch64_libsecret-devel.sha256sum] = "72b3ca05a337f900f52892a066ad5962f6e55f206000250c0807fb2713d215e5"

RDEPENDS:libsecret = " \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 "
RDEPENDS:libsecret-devel = " \
 glib2-devel \
 gnutls-devel \
 libsecret \
 libsecret-devel \
 pkgconf-pkg-config \
 "
