# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kitinerary"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kitinerary \
 kitinerary-devel \
 kitinerary-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kitinerary-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c225bce18e327267db6df49ef95828be3ef5b0edd88a13d29bad802822ae6d37"

URI_x86_64_v2_kitinerary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary}"
SRC_URI[x86_64_v2_kitinerary.sha256sum] = "88f18cc7566e88bcaf0d54dbb26c44aa1d01cf097dbcd8326bcf0f3932c5895a"

URI_x86_64_v2_kitinerary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary-devel}"
SRC_URI[x86_64_v2_kitinerary-devel.sha256sum] = "202ba584c094ecd0f961f31d20949346f8a47af11a128c1231f3db7818a09896"

URI_x86_64_v2_kitinerary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kitinerary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitinerary-doc}"
SRC_URI[x86_64_v2_kitinerary-doc.sha256sum] = "5b70258e4d23a4ee86cebf00aba11f35675221ac8d4d20765f9173e52e2aa1be"

URI_aarch64_kitinerary = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kitinerary;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary}"
SRC_URI[aarch64_kitinerary.sha256sum] = "bf0ac8b1ac4e5bf3593e94cb23e6f1f48867e0e6a3af44096ca88dca9cb4ef94"

URI_aarch64_kitinerary-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kitinerary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary-devel}"
SRC_URI[aarch64_kitinerary-devel.sha256sum] = "a283c94f688dea9ab42a75f32ce255f4cadc82255d2f10f5cd65f9d7aa6314d1"

URI_aarch64_kitinerary-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kitinerary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitinerary-doc}"
SRC_URI[aarch64_kitinerary-doc.sha256sum] = "744785463a0ec32d50c7c07e5c35909da908bec752e118e9fd0229ce79b921c0"

RDEPENDS:kitinerary = " \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcontacts \
 kf6-ki18n \
 kmime \
 kpkpass \
 libgcc \
 libstdc++ \
 libxml2 \
 openssl-libs \
 poppler \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 zxing-cpp \
 "
RDEPENDS:kitinerary-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kitinerary \
 kmime-devel \
 kpkpass-devel \
 "
RDEPENDS:kitinerary-doc = " \
 "
