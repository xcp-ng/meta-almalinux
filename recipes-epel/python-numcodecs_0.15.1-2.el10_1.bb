# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-numcodecs"
PV = "0.15.1"
PR = "2.el10_1"
PACKAGES = " \
 python-numcodecs-doc \
 python3-numcodecs \
 python3-numcodecs+crc32c \
 python3-numcodecs+msgpack \
 python3-numcodecs+zfpy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-numcodecs-0.15.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a31d440390a662240be6aa76afeccdc5ed7e37349fd98b772e1c6719cff42181"

URI_x86_64_v2_python-numcodecs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-numcodecs-doc-0.15.1-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-numcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-numcodecs-doc}"
SRC_URI[x86_64_v2_python-numcodecs-doc.sha256sum] = "25951caaff39f4bc9dce35961c4c6a12548565f6938e75d47d66d7b5201e0b91"

URI_x86_64_v2_python3-numcodecs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-numcodecs-0.15.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-numcodecs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numcodecs}"
SRC_URI[x86_64_v2_python3-numcodecs.sha256sum] = "1f82894658f9ec2be541f6d23eca1c8813baa77ee38202012d63eccbc85aebb4"

URI_x86_64_v2_python3-numcodecs+crc32c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-numcodecs+crc32c-0.15.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-numcodecs+crc32c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numcodecs+crc32c}"
SRC_URI[x86_64_v2_python3-numcodecs+crc32c.sha256sum] = "166ca3946b525e5db4d34f286da327bc672fb518609f43fa07e15cb0e7d8528a"

URI_x86_64_v2_python3-numcodecs+msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-numcodecs+msgpack-0.15.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-numcodecs+msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numcodecs+msgpack}"
SRC_URI[x86_64_v2_python3-numcodecs+msgpack.sha256sum] = "b2241d5c81812c48e87da37b8c1a2b3264ba2c0b076a42cee3aefb970b5dd0d9"

URI_x86_64_v2_python3-numcodecs+zfpy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-numcodecs+zfpy-0.15.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-numcodecs+zfpy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-numcodecs+zfpy}"
SRC_URI[x86_64_v2_python3-numcodecs+zfpy.sha256sum] = "d3660a54da5b7123cbd5f1b677a81d4f59d0dbe7d12eebd3af7cc69eef01880b"

URI_aarch64_python-numcodecs-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-numcodecs-doc-0.15.1-2.el10_1.noarch.rpm;name=aarch64_python-numcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-numcodecs-doc}"
SRC_URI[aarch64_python-numcodecs-doc.sha256sum] = "26c27620a6cd34ec3264107170706cef3ea3647b2e619bd3e2885c73cc6dddc4"

URI_aarch64_python3-numcodecs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-numcodecs-0.15.1-2.el10_1.aarch64.rpm;name=aarch64_python3-numcodecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numcodecs}"
SRC_URI[aarch64_python3-numcodecs.sha256sum] = "34d64c06ccfb87868df0c73ffb39cfb28dcec99d5fe665ee445df8deb79c4bd7"

URI_aarch64_python3-numcodecs+crc32c = "${EPEL_MIRROR}/aarch64/Packages/p/python3-numcodecs+crc32c-0.15.1-2.el10_1.aarch64.rpm;name=aarch64_python3-numcodecs+crc32c;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numcodecs+crc32c}"
SRC_URI[aarch64_python3-numcodecs+crc32c.sha256sum] = "0fbbcb6ab9de3638dbc2a2b9a9ab6cebc8dce8770e6e2a50c9c90aaedcc0f702"

URI_aarch64_python3-numcodecs+msgpack = "${EPEL_MIRROR}/aarch64/Packages/p/python3-numcodecs+msgpack-0.15.1-2.el10_1.aarch64.rpm;name=aarch64_python3-numcodecs+msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numcodecs+msgpack}"
SRC_URI[aarch64_python3-numcodecs+msgpack.sha256sum] = "a7ff66fd37c3cb75e1d9adbc8a47e8a7b4ff10f607e05ea8176a6cde0daa6c9b"

URI_aarch64_python3-numcodecs+zfpy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-numcodecs+zfpy-0.15.1-2.el10_1.aarch64.rpm;name=aarch64_python3-numcodecs+zfpy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-numcodecs+zfpy}"
SRC_URI[aarch64_python3-numcodecs+zfpy.sha256sum] = "d87f0db4421bfcf77c10ca6a44d69de1c29db98d8b88525e3cfde35ca6321fa1"

RDEPENDS:python-numcodecs-doc = " \
 "
RDEPENDS:python3-numcodecs = " \
 blosc \
 glibc \
 libzstd \
 lz4-libs \
 python3 \
 python3-deprecated \
 python3-numpy \
 "
RDEPENDS:python3-numcodecs+crc32c = " \
 python3 \
 python3-crc32c \
 python3-numcodecs \
 "
RDEPENDS:python3-numcodecs+msgpack = " \
 python3 \
 python3-msgpack \
 python3-numcodecs \
 "
RDEPENDS:python3-numcodecs+zfpy = " \
 python3 \
 python3-numcodecs \
 python3-zfpy \
 "
