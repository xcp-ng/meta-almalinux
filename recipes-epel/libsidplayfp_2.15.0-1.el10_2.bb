# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsidplayfp"
PV = "2.15.0"
PR = "1.el10_2"
PACKAGES = " \
 libsidplayfp \
 libsidplayfp-devel \
 libsidplayfp-devel-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libsidplayfp-2.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a447296155371377f99bdf060fd75c9bdf208937e909a080b2fb922d9411b1a5"

URI_x86_64_v2_libsidplayfp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsidplayfp-2.15.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsidplayfp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsidplayfp}"
SRC_URI[x86_64_v2_libsidplayfp.sha256sum] = "f1a3571baf9f2be656635d317b708ab693c1ef1faf1ab9309e97e91dac14e330"

URI_x86_64_v2_libsidplayfp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsidplayfp-devel-2.15.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsidplayfp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsidplayfp-devel}"
SRC_URI[x86_64_v2_libsidplayfp-devel.sha256sum] = "5d2bb03c95c07aa1e40d47e7fa4a70d0a908e3962eea64c737cc610c81a9934d"

URI_x86_64_v2_libsidplayfp-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsidplayfp-devel-doc-2.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libsidplayfp-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsidplayfp-devel-doc}"
SRC_URI[x86_64_v2_libsidplayfp-devel-doc.sha256sum] = "ce191c771400db21d4d2dc85fbbc1d9112aaf5476c688ddc6dd6205d51c29e6c"

URI_aarch64_libsidplayfp = "${EPEL_MIRROR}/aarch64/Packages/l/libsidplayfp-2.15.0-1.el10_2.aarch64.rpm;name=aarch64_libsidplayfp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsidplayfp}"
SRC_URI[aarch64_libsidplayfp.sha256sum] = "8f64db667017526d91efd25263f020378d6871da5c2e9d116b23bdef560d4ab4"

URI_aarch64_libsidplayfp-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsidplayfp-devel-2.15.0-1.el10_2.aarch64.rpm;name=aarch64_libsidplayfp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsidplayfp-devel}"
SRC_URI[aarch64_libsidplayfp-devel.sha256sum] = "149e38b789e3d287ce1526b83ec0f38358f83fc2fa8246af74a26a863f88a721"

URI_aarch64_libsidplayfp-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libsidplayfp-devel-doc-2.15.0-1.el10_2.noarch.rpm;name=aarch64_libsidplayfp-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsidplayfp-devel-doc}"
SRC_URI[aarch64_libsidplayfp-devel-doc.sha256sum] = "cab46a325b953e1b87645cc9408d038a987aeb296f26bd7cfdb4fe7193f32c8f"

RDEPENDS:libsidplayfp = " \
 glibc \
 libgcc \
 libgcrypt \
 libstdc++ \
 "
RDEPENDS:libsidplayfp-devel = " \
 libsidplayfp \
 pkgconf-pkg-config \
 "
RDEPENDS:libsidplayfp-devel-doc = " \
 "
