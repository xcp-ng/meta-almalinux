# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpeople"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kpeople \
 kf6-kpeople-devel \
 kf6-kpeople-doc \
 kf6-kpeople-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kpeople-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e3635aaae1ba84a0d8631dc71aa71a5eea5a360f88d0a191db1f77d40b60179"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople;unpack=0"
SRC_URI[x86_64_v2_kf6-kpeople.sha256sum] = "1e3defe3a796e983a93b4246e84ff59885b4325b3b6f1460d118fd3fc7350f67"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpeople-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kpeople-devel.sha256sum] = "fb24aded5141cd73039b2d87216d4f6ed6b30861e01ab6e956c5d07cf68d6bc4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpeople-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kpeople-doc.sha256sum] = "b66d1307b2c976ea3e5c0453db3deae93dfe6a29a6d6b6d35696f02c9a6b32a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpeople-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpeople-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kpeople-html.sha256sum] = "6100c89b67f85ff3c45684f589cf17d4c04026cfba6cbf6e8db33c8ea3586fc6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpeople;unpack=0"
SRC_URI[aarch64_kf6-kpeople.sha256sum] = "480eb5f9e87673a621688860e2a48a1255286d5992ae84d7866ae442baeeaac6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kpeople-devel;unpack=0"
SRC_URI[aarch64_kf6-kpeople-devel.sha256sum] = "457664817c41a10804fbf9afae240fa0170f4af8b90bc45735741480615bc634"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpeople-doc;unpack=0"
SRC_URI[aarch64_kf6-kpeople-doc.sha256sum] = "563917c253d6a0f9bf1bca62ea088d25420250b7c85d190181bc78da35297977"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpeople-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kpeople-html;unpack=0"
SRC_URI[aarch64_kf6-kpeople-html.sha256sum] = "13443d73735cec228efd53876e18cc964d7d0721ba8c1dc9c19fd5455ac0a65c"

RDEPENDS:kf6-kpeople = " \
 glibc \
 kf6-filesystem \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kpeople-devel = " \
 cmake-filesystem \
 kf6-kpeople \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kpeople-doc = " \
 "
RDEPENDS:kf6-kpeople-html = " \
 "
