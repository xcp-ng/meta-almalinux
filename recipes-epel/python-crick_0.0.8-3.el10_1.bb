# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-crick"
PV = "0.0.8"
PR = "3.el10_1"
PACKAGES = " \
 python3-crick \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-crick-0.0.8-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "915c614a4112d199ec1e98365857fd9bcd68599f03c261aac9e9396f40782408"

URI_x86_64_v2_python3-crick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-crick-0.0.8-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-crick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-crick}"
SRC_URI[x86_64_v2_python3-crick.sha256sum] = "c866780a96581ef38f8ecf0dfec5cb2adc508f91ef9acace761fe62a624d8170"

URI_aarch64_python3-crick = "${EPEL_MIRROR}/aarch64/Packages/p/python3-crick-0.0.8-3.el10_1.aarch64.rpm;name=aarch64_python3-crick;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-crick}"
SRC_URI[aarch64_python3-crick.sha256sum] = "86746dc573422272da3fb79d08337f3f0c8ea048ecd349f4d58562bfdb8654a0"

RDEPENDS:python3-crick = " \
 glibc \
 python3 \
 "
