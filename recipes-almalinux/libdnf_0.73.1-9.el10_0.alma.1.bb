# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdnf"
PV = "0.73.1"
PR = "9.el10_0.alma.1"
PACKAGES = " \
 libdnf \
 libdnf-devel \
 python3-hawkey \
 python3-libdnf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libdnf-0.73.1-9.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49ff76e950a2fef7167cafcfb99431ed780fddb6292e5846d5548f58f6d25cab"

URI_x86_64_v2_libdnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdnf-0.73.1-9.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf}"
SRC_URI[x86_64_v2_libdnf.sha256sum] = "6891d6fb87a237e37dd26727aad7df14a67fe7a9dd98299e1d65d463355e7800"

URI_x86_64_v2_libdnf-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdnf-devel-0.73.1-9.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf-devel}"
SRC_URI[x86_64_v2_libdnf-devel.sha256sum] = "64cc24911ab60ea01d04985a15822b226733c070cef3f89b5b2c1c2a67e21bbc"

URI_x86_64_v2_python3-hawkey = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-hawkey-0.73.1-9.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-hawkey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-hawkey}"
SRC_URI[x86_64_v2_python3-hawkey.sha256sum] = "de84af8adf2be1179f8ddaee63f4994a75500ee1a7482b5dc439500ca7f3b683"

URI_x86_64_v2_python3-libdnf = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libdnf-0.73.1-9.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-libdnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libdnf}"
SRC_URI[x86_64_v2_python3-libdnf.sha256sum] = "835708a3c0ff9fd41ab15a1be0a3ece979f935e4a07d0f94311be9040987e3a4"

URI_aarch64_libdnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdnf-0.73.1-9.el10_0.alma.1.aarch64.rpm;name=aarch64_libdnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf}"
SRC_URI[aarch64_libdnf.sha256sum] = "39618b4a712780fdb8ab4e3213418922e1e0fe8391cbb014f171c3904f8987db"

URI_aarch64_libdnf-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdnf-devel-0.73.1-9.el10_0.alma.1.aarch64.rpm;name=aarch64_libdnf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf-devel}"
SRC_URI[aarch64_libdnf-devel.sha256sum] = "6862c868833fdecd6fe4a7cdcdca9e80d6704e23a2c8d4a29028528db0d5d305"

URI_aarch64_python3-hawkey = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-hawkey-0.73.1-9.el10_0.alma.1.aarch64.rpm;name=aarch64_python3-hawkey;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-hawkey}"
SRC_URI[aarch64_python3-hawkey.sha256sum] = "28a400ded5ce04e7b36a2ef1f140430e94576a857d0791491e71460370257ee7"

URI_aarch64_python3-libdnf = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libdnf-0.73.1-9.el10_0.alma.1.aarch64.rpm;name=aarch64_python3-libdnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libdnf}"
SRC_URI[aarch64_python3-libdnf.sha256sum] = "061bf074aab950985857b00ca21fc7901624418d4dc541560e2acc5031626459"

RDEPENDS:libdnf = " \
 glib2 \
 glibc \
 json-c \
 libgcc \
 libmodulemd \
 librepo \
 libsmartcols \
 libsolv \
 libstdc++ \
 rpm-libs \
 sqlite-libs \
 "
RDEPENDS:libdnf-devel = " \
 glib2-devel \
 libdnf \
 librepo-devel \
 libsolv-devel \
 pkgconf-pkg-config \
 rpm-devel \
 sqlite-devel \
 "
RDEPENDS:python3-hawkey = " \
 glib2 \
 glibc \
 libdnf \
 libgcc \
 libsolv \
 libstdc++ \
 python3 \
 python3-libdnf \
 python3-libs \
 "
RDEPENDS:python3-libdnf = " \
 glibc \
 libdnf \
 libgcc \
 libsmartcols \
 libstdc++ \
 python3 \
 python3-libs \
 "
