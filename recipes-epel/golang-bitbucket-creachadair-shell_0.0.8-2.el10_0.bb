# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-bitbucket-creachadair-shell"
PV = "0.0.8"
PR = "2.el10_0"
PACKAGES = " \
 golang-bitbucket-creachadair-shell-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-bitbucket-creachadair-shell-0.0.8-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ae8f1e0c91f949c5942f60cc3acb58365a197279d712661fef6b5189b27323f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-bitbucket-creachadair-shell-devel-0.0.8-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-bitbucket-creachadair-shell-devel;unpack=0"
SRC_URI[x86_64_v2_golang-bitbucket-creachadair-shell-devel.sha256sum] = "6c2d5e86e0c12a2ad71d8b09ecda78cdc2ca4d4b0cb73af58d601fe50d01c6f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-bitbucket-creachadair-shell-devel-0.0.8-2.el10_0.noarch.rpm;name=aarch64_golang-bitbucket-creachadair-shell-devel;unpack=0"
SRC_URI[aarch64_golang-bitbucket-creachadair-shell-devel.sha256sum] = "715142722f2e265a055c738f883d15ab38f9defb5796884b86ce64185f986ece"

RDEPENDS:golang-bitbucket-creachadair-shell-devel = " \
 go-filesystem \
 "
