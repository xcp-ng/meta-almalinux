# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-furo"
PV = "2024.08.06"
PR = "1.el10_0"
PACKAGES = " \
 python-furo-doc \
 python3-furo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-furo-2024.08.06-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74223397dce802238abc1e7009dd444a4e3a85d8de9aad3d350f3c00459252b8"

URI_x86_64_v2_python-furo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-furo-doc-2024.08.06-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-furo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-furo-doc}"
SRC_URI[x86_64_v2_python-furo-doc.sha256sum] = "d52c89ec1f0250dba57c1396c4d3e130b8a92fd0f481e6b0fb98a03a1f411fde"

URI_x86_64_v2_python3-furo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-furo-2024.08.06-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-furo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-furo}"
SRC_URI[x86_64_v2_python3-furo.sha256sum] = "e5ef43cd94bef51c1b83357b6445263263d5974dd8b77b8c8770888a287cc079"

URI_aarch64_python-furo-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-furo-doc-2024.08.06-1.el10_0.noarch.rpm;name=aarch64_python-furo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-furo-doc}"
SRC_URI[aarch64_python-furo-doc.sha256sum] = "5c0f9687f1e58646b051575e5af35dbab5f4f0c7cb45ca3c0dbb68af09d4632e"

URI_aarch64_python3-furo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-furo-2024.08.06-1.el10_0.noarch.rpm;name=aarch64_python3-furo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-furo}"
SRC_URI[aarch64_python3-furo.sha256sum] = "6ebd47498a1cde486febc78d3fcbd5557b1f80c07557f3d044f702ea3a6448aa"

RDEPENDS:python-furo-doc = " \
 "
RDEPENDS:python3-furo = " \
 python3 \
 python3-beautifulsoup4 \
 python3-pygments \
 python3-sphinx \
 python3-sphinx-basic-ng \
 "
