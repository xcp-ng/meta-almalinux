# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MooseX-Types-Common"
PV = "0.001014"
PR = "27.el10_0"
PACKAGES = " \
 perl-MooseX-Types-Common \
 perl-MooseX-Types-Common-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-MooseX-Types-Common-0.001014-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "873b71054016c888e80c871ad5874a21eae22f177741d011ca17b10edc6abb14"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooseX-Types-Common-0.001014-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooseX-Types-Common;unpack=0"
SRC_URI[x86_64_v2_perl-MooseX-Types-Common.sha256sum] = "0406569d55c519ceeae4b8766700fb2053a25a74097c47fe6dbc229784588c07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MooseX-Types-Common-tests-0.001014-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MooseX-Types-Common-tests;unpack=0"
SRC_URI[x86_64_v2_perl-MooseX-Types-Common-tests.sha256sum] = "eb49f4a403f015ec10fef12fbe7b07ac69e962808a519ff7d5e56681e97a7e6f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-MooseX-Types-Common-0.001014-27.el10_0.noarch.rpm;name=aarch64_perl-MooseX-Types-Common;unpack=0"
SRC_URI[aarch64_perl-MooseX-Types-Common.sha256sum] = "4775cf03d45749d42504c143605e5ff668e8193559f5a61b93b149c2696fcd5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-MooseX-Types-Common-tests-0.001014-27.el10_0.noarch.rpm;name=aarch64_perl-MooseX-Types-Common-tests;unpack=0"
SRC_URI[aarch64_perl-MooseX-Types-Common-tests.sha256sum] = "57892536730ea07e61c8ca19b5682cd6e71625c4d62da71af6d7274387fb90c7"

RDEPENDS:perl-MooseX-Types-Common = " \
 perl-Carp \
 perl-MooseX-Types \
 perl-if \
 perl-libs \
 perl-namespace-autoclean \
 "
RDEPENDS:perl-MooseX-Types-Common-tests = " \
 bash \
 perl-Module-Metadata \
 perl-MooseX-Types-Common \
 perl-PathTools \
 perl-Test-Deep \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Test-Warnings \
 perl-URI \
 perl-if \
 perl-interpreter \
 perl-libs \
 perl-open \
 "
