# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-googleapis-common-protos"
PV = "1.63.0"
PR = "7.el10_0~bootstrap"
PACKAGES = " \
 python3-googleapis-common-protos \
 python3-googleapis-common-protos+grpc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-googleapis-common-protos-1.63.0-7.el10_0~bootstrap.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3276411095bbc34bfb78113712fadac369792704785d9283edd4055326a919f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-googleapis-common-protos-1.63.0-7.el10_0~bootstrap.alma_altarch.noarch.rpm;name=x86_64_v2_python3-googleapis-common-protos;unpack=0"
SRC_URI[x86_64_v2_python3-googleapis-common-protos.sha256sum] = "22cf5d4c6f71a76bd0ff0d4a08e25aeaf1c7aa4a0981628dac8ea3efb7bc417a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-googleapis-common-protos+grpc-1.63.0-7.el10_0~bootstrap.alma_altarch.noarch.rpm;name=x86_64_v2_python3-googleapis-common-protos+grpc;unpack=0"
SRC_URI[x86_64_v2_python3-googleapis-common-protos+grpc.sha256sum] = "542ecfe23a12f73b67d83c82c618f390f4a02d39d88b326ad4d6e03490003f14"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-googleapis-common-protos-1.63.0-7.el10_0~bootstrap.noarch.rpm;name=aarch64_python3-googleapis-common-protos;unpack=0"
SRC_URI[aarch64_python3-googleapis-common-protos.sha256sum] = "4ea2afb7a61028b5b5e5d74c5275f961229e9472b7e6f507a88e521476bd8e8e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-googleapis-common-protos+grpc-1.63.0-7.el10_0~bootstrap.noarch.rpm;name=aarch64_python3-googleapis-common-protos+grpc;unpack=0"
SRC_URI[aarch64_python3-googleapis-common-protos+grpc.sha256sum] = "7b49fc34705f1335516d8e5b1137f19260a727b6835a93939f7eebcb269e64d6"

RDEPENDS:python3-googleapis-common-protos = " \
 python3 \
 python3-protobuf \
 "
RDEPENDS:python3-googleapis-common-protos+grpc = " \
 python3 \
 python3-googleapis-common-protos \
 python3-grpcio \
 "
