# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "objfw"
PV = "1.2.3"
PR = "1.el10_0"
PACKAGES = " \
 libobjfw \
 libobjfw-devel \
 libobjfwhid \
 libobjfwhid-devel \
 libobjfwrt \
 libobjfwrt-devel \
 libobjfwtls \
 libobjfwtls-devel \
 objfw \
 objfw-doc \
 ofarc \
 ofdns \
 ofhash \
 ofhttp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/objfw-1.2.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a31ea475f56ae7ed17b7b75f02b47eb5e88784efcf09bdfd37a9baf3793548b"

URI_x86_64_v2_libobjfw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfw-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfw}"
SRC_URI[x86_64_v2_libobjfw.sha256sum] = "89602468c72978437f6c9bad4056336cc92a07c681c39f68fae29b278becd86c"

URI_x86_64_v2_libobjfw-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfw-devel-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfw-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfw-devel}"
SRC_URI[x86_64_v2_libobjfw-devel.sha256sum] = "4a606906e71826b28268545c60a805b6418800e31e6c6b7e5dadd74c7b9207ab"

URI_x86_64_v2_libobjfwhid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwhid-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwhid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwhid}"
SRC_URI[x86_64_v2_libobjfwhid.sha256sum] = "1f421b6b7588c2299f7c589b887afdfb303f4f8b93deb35cfa1b522f4e7c7b6b"

URI_x86_64_v2_libobjfwhid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwhid-devel-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwhid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwhid-devel}"
SRC_URI[x86_64_v2_libobjfwhid-devel.sha256sum] = "b46ab613f9cef60a1fe019b219aca9ef1e0808ab155801f6aa5e4c0ca5b71676"

URI_x86_64_v2_libobjfwrt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwrt-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwrt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwrt}"
SRC_URI[x86_64_v2_libobjfwrt.sha256sum] = "bbecfc16614aa62a27bd0a95dffa45ebc6785dfaf029ead5377e5227a1bb344c"

URI_x86_64_v2_libobjfwrt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwrt-devel-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwrt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwrt-devel}"
SRC_URI[x86_64_v2_libobjfwrt-devel.sha256sum] = "74e9adc5e27a3fad57d420136459687f788e5c49a7dee9080ebcd6afed9ef089"

URI_x86_64_v2_libobjfwtls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwtls-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwtls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwtls}"
SRC_URI[x86_64_v2_libobjfwtls.sha256sum] = "82ce4dff8ffe3691828489b1d16407eeae668fc8450f6fd2073d2fe8a378bba6"

URI_x86_64_v2_libobjfwtls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libobjfwtls-devel-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libobjfwtls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libobjfwtls-devel}"
SRC_URI[x86_64_v2_libobjfwtls-devel.sha256sum] = "60dc350e98b6cd1e03e7820c2bd5b8cc3272a0e7aba12cc00eed1dd04aa53739"

URI_x86_64_v2_objfw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/objfw-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_objfw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objfw}"
SRC_URI[x86_64_v2_objfw.sha256sum] = "4d0fbf2c4d54977de7f02b9ef013de893b87ae8c578a199cd3cb6dd7507174cb"

URI_x86_64_v2_objfw-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/objfw-doc-1.2.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_objfw-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_objfw-doc}"
SRC_URI[x86_64_v2_objfw-doc.sha256sum] = "4078255fdf14c8351eca1cac87ab033e4677c6a664734ab6de267dc2c7f02eb3"

URI_x86_64_v2_ofarc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofarc-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofarc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofarc}"
SRC_URI[x86_64_v2_ofarc.sha256sum] = "a7834c00af082fcbac57c6810701361d75221bb8046e4419dbdbc4e3efe86739"

URI_x86_64_v2_ofdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofdns-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofdns}"
SRC_URI[x86_64_v2_ofdns.sha256sum] = "0e7db22f700376af60251701385f274c7631c0c02988b010e173c463347247c3"

URI_x86_64_v2_ofhash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofhash-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofhash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofhash}"
SRC_URI[x86_64_v2_ofhash.sha256sum] = "a4730621cec74ce6d73011ade2e1e7c034c6a8110cf5220f1cc08d118ed20e5c"

URI_x86_64_v2_ofhttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ofhttp-1.2.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ofhttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ofhttp}"
SRC_URI[x86_64_v2_ofhttp.sha256sum] = "df118f923ec8d1493a3b3b2cac1b9100fb0616232f16a1776e2b284279a4f17a"

URI_aarch64_libobjfw = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfw-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_libobjfw;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfw}"
SRC_URI[aarch64_libobjfw.sha256sum] = "01889624f3536e7a0edfe70fc70a21b9114328c7af6d4078d06545930cca3bef"

URI_aarch64_libobjfw-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfw-devel-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_libobjfw-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfw-devel}"
SRC_URI[aarch64_libobjfw-devel.sha256sum] = "68f99f01b2fd02f222ee41b1d0aec9ed3cb1c41c8f05ee442d4efa2c19c295c8"

URI_aarch64_libobjfwhid = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwhid-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_libobjfwhid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwhid}"
SRC_URI[aarch64_libobjfwhid.sha256sum] = "2701eeb5320a52b20cc5631023acca71e583657676021508f6602c8a96676710"

URI_aarch64_libobjfwhid-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwhid-devel-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_libobjfwhid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwhid-devel}"
SRC_URI[aarch64_libobjfwhid-devel.sha256sum] = "61a5713d36877d334553b05de62a31224fe25a88f190e616d45f5e7026b414f7"

URI_aarch64_libobjfwrt = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwrt-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_libobjfwrt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwrt}"
SRC_URI[aarch64_libobjfwrt.sha256sum] = "b66c7c7551f6a0c150c7f644e6126439269c909f34cc0170af2c565c5d7a7196"

URI_aarch64_libobjfwrt-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwrt-devel-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_libobjfwrt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwrt-devel}"
SRC_URI[aarch64_libobjfwrt-devel.sha256sum] = "3c58ff67be35c18512f8cbaaf04e85b710a765be4236810f766981b025492c7d"

URI_aarch64_libobjfwtls = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwtls-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_libobjfwtls;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwtls}"
SRC_URI[aarch64_libobjfwtls.sha256sum] = "ecd7561ddc59a9375711bd090961041eafb6c8bde3876a21dcf155d72cc4bb85"

URI_aarch64_libobjfwtls-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libobjfwtls-devel-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_libobjfwtls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libobjfwtls-devel}"
SRC_URI[aarch64_libobjfwtls-devel.sha256sum] = "e02761851fa76d95fe3280fe3eeee44054a72a600e489ce57d9a4f03ac655511"

URI_aarch64_objfw = "${EPEL_MIRROR}/aarch64/Packages/o/objfw-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_objfw;unpack=0"
SRC_URI:append = " ${URI_aarch64_objfw}"
SRC_URI[aarch64_objfw.sha256sum] = "b9be8510139995dfe1e5ad15f74cab094d11213a4373cd1bfa7aab43550b527b"

URI_aarch64_objfw-doc = "${EPEL_MIRROR}/aarch64/Packages/o/objfw-doc-1.2.3-1.el10_0.noarch.rpm;name=aarch64_objfw-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_objfw-doc}"
SRC_URI[aarch64_objfw-doc.sha256sum] = "203be82f48dfe496cccf76de78a427b523b8f7937831547b5f1e6b6ee1b8b54c"

URI_aarch64_ofarc = "${EPEL_MIRROR}/aarch64/Packages/o/ofarc-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_ofarc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofarc}"
SRC_URI[aarch64_ofarc.sha256sum] = "0d4a801399735e805a363cab0613d72c0a82cfecf289e3617287b8e10b19caec"

URI_aarch64_ofdns = "${EPEL_MIRROR}/aarch64/Packages/o/ofdns-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_ofdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofdns}"
SRC_URI[aarch64_ofdns.sha256sum] = "414a2771a671e729d1161aee332ffb8532bb10ec7ee9db7067d5a8c1fe169f3a"

URI_aarch64_ofhash = "${EPEL_MIRROR}/aarch64/Packages/o/ofhash-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_ofhash;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofhash}"
SRC_URI[aarch64_ofhash.sha256sum] = "f6b584b5869efd20123efb4a81f9b05e6d0c65d6de42ee92e57ed89eb193f24d"

URI_aarch64_ofhttp = "${EPEL_MIRROR}/aarch64/Packages/o/ofhttp-1.2.3-1.el10_0.aarch64.rpm;name=aarch64_ofhttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ofhttp}"
SRC_URI[aarch64_ofhttp.sha256sum] = "b31f7ab3e383ba21d6ccff794e0d56de51f7076c353ee358ea450bcb0b349a61"

RDEPENDS:libobjfw = " \
 glibc \
 libgcc \
 libobjfwrt \
 "
RDEPENDS:libobjfw-devel = " \
 bash \
 glibc \
 libgcc \
 libobjfw \
 libobjfwhid-devel \
 libobjfwrt \
 libobjfwrt-devel \
 "
RDEPENDS:libobjfwhid = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:libobjfwhid-devel = " \
 libobjfw-devel \
 libobjfwhid \
 libobjfwrt-devel \
 "
RDEPENDS:libobjfwrt = " \
 glibc \
 libgcc \
 "
RDEPENDS:libobjfwrt-devel = " \
 libobjfwrt \
 "
RDEPENDS:libobjfwtls = " \
 glibc \
 gnutls \
 libgcc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:libobjfwtls-devel = " \
 libobjfw-devel \
 libobjfwrt-devel \
 libobjfwtls \
 "
RDEPENDS:objfw = " \
 libobjfw \
 libobjfw-devel \
 libobjfwrt \
 libobjfwrt-devel \
 libobjfwtls \
 libobjfwtls-devel \
 ofarc \
 ofdns \
 ofhash \
 ofhttp \
 "
RDEPENDS:objfw-doc = " \
 "
RDEPENDS:ofarc = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
RDEPENDS:ofdns = " \
 glibc \
 libobjfw \
 libobjfwrt \
 "
RDEPENDS:ofhash = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
RDEPENDS:ofhttp = " \
 glibc \
 libgcc \
 libobjfw \
 libobjfwrt \
 libobjfwtls \
 "
