# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ti"
PV = "0.20090911"
PR = "30.el10"
PACKAGES = " \
 hunspell-ti \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ti-0.20090911-30.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe3d5fade20972ac64bd833455fab566ec0509fd6ac35f3c47d34a5dd79d8795"

URI_x86_64_v2_hunspell-ti = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ti-0.20090911-30.el10.noarch.rpm;name=x86_64_v2_hunspell-ti;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ti}"
SRC_URI[x86_64_v2_hunspell-ti.sha256sum] = "98ce4cec63641bedda59a54831ca7eefa814627a2fe22a8bbced2b42e9988446"

URI_aarch64_hunspell-ti = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ti-0.20090911-30.el10.noarch.rpm;name=aarch64_hunspell-ti;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ti}"
SRC_URI[aarch64_hunspell-ti.sha256sum] = "98ce4cec63641bedda59a54831ca7eefa814627a2fe22a8bbced2b42e9988446"

RDEPENDS:hunspell-ti = " \
 hunspell-filesystem \
 "
