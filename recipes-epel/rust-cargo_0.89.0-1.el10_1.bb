# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo"
PV = "0.89.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-cargo+default-devel \
 rust-cargo+openssl-devel \
 rust-cargo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-0.89.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2928cd559bbb00057d99195c842ca058f777642277c44b853b6414ed17ed5775"

URI_x86_64_v2_rust-cargo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+default-devel-0.89.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+default-devel}"
SRC_URI[x86_64_v2_rust-cargo+default-devel.sha256sum] = "104162df62e944e0e6deb86c1bfbe02c8ef0f35ef0d81bad578a8a79662f684d"

URI_x86_64_v2_rust-cargo+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo+openssl-devel-0.89.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo+openssl-devel}"
SRC_URI[x86_64_v2_rust-cargo+openssl-devel.sha256sum] = "8e2ea347fb4fd7cb0de69db2ec5d089d90559fd106fd1ddde07038af4c4ae65a"

URI_x86_64_v2_rust-cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-devel-0.89.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-devel}"
SRC_URI[x86_64_v2_rust-cargo-devel.sha256sum] = "056601a20dd0a2f20c2fe4fbf381dc91f78f67e41c87624c8c63eb5344b16348"

URI_aarch64_rust-cargo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+default-devel-0.89.0-1.el10_1.noarch.rpm;name=aarch64_rust-cargo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+default-devel}"
SRC_URI[aarch64_rust-cargo+default-devel.sha256sum] = "8d5b9266f8d9deb386f41d69c9d18dcb3314ffff7045a3335f33b3febd4ecf16"

URI_aarch64_rust-cargo+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo+openssl-devel-0.89.0-1.el10_1.noarch.rpm;name=aarch64_rust-cargo+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo+openssl-devel}"
SRC_URI[aarch64_rust-cargo+openssl-devel.sha256sum] = "d63c9f9f4710d9629739976f4c813c0561a427f324684a76b9e75f377b46b432"

URI_aarch64_rust-cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-devel-0.89.0-1.el10_1.noarch.rpm;name=aarch64_rust-cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-devel}"
SRC_URI[aarch64_rust-cargo-devel.sha256sum] = "a03739a7f1f281554ab1780a286333489986ea86bab6ef56b470500a72dc12c3"

RDEPENDS:rust-cargo+default-devel = " \
 cargo \
 rust-cargo-devel \
 "
RDEPENDS:rust-cargo+openssl-devel = " \
 cargo \
 rust-cargo-devel \
 rust-openssl+default-devel \
 "
RDEPENDS:rust-cargo-devel = " \
 cargo \
 rust \
 rust-annotate-snippets+default-devel \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-anyhow+default-devel \
 rust-base64+default-devel \
 rust-blake3+default-devel \
 rust-cargo-credential+default-devel \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-platform+default-devel \
 rust-cargo-util+default-devel \
 rust-cargo-util-schemas+default-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete+unstable-dynamic-devel \
 rust-color-print+default-devel \
 rust-crates-io+default-devel \
 rust-curl+default-devel \
 rust-curl+http2-devel \
 rust-curl-sys+default-devel \
 rust-filetime+default-devel \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-git2+default-devel \
 rust-git2-curl+default-devel \
 rust-gix+blocking-http-transport-curl-devel \
 rust-gix+dirwalk-devel \
 rust-gix+parallel-devel \
 rust-gix+progress-tree-devel \
 rust-gix-devel \
 rust-glob+default-devel \
 rust-hex+default-devel \
 rust-hmac+default-devel \
 rust-home+default-devel \
 rust-http-auth-devel \
 rust-ignore+default-devel \
 rust-im-rc+default-devel \
 rust-indexmap+default-devel \
 rust-itertools+default-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 rust-jobserver+default-devel \
 rust-lazycell+default-devel \
 rust-libc+default-devel \
 rust-libgit2-sys+default-devel \
 rust-memchr+default-devel \
 rust-opener+default-devel \
 rust-os_info-devel \
 rust-pasetors+default-devel \
 rust-pasetors+paserk-devel \
 rust-pasetors+serde-devel \
 rust-pasetors+std-devel \
 rust-pasetors+v3-devel \
 rust-pathdiff+default-devel \
 rust-rand+default-devel \
 rust-regex+default-devel \
 rust-rusqlite+default-devel \
 rust-rustc-hash+default-devel \
 rust-rustc-stable-hash+default-devel \
 rust-rustfix+default-devel \
 rust-same-file+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde-untagged+default-devel \
 rust-serde_ignored+default-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-sha1+default-devel \
 rust-shell-escape+default-devel \
 rust-supports-hyperlinks+default-devel \
 rust-supports-unicode+default-devel \
 rust-tar-devel \
 rust-tempfile+default-devel \
 rust-thiserror+default-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-toml0.8+default-devel \
 rust-toml_edit0.22+default-devel \
 rust-toml_edit0.22+serde-devel \
 rust-tracing+attributes-devel \
 rust-tracing+std-devel \
 rust-tracing-chrome+default-devel \
 rust-tracing-devel \
 rust-tracing-subscriber+default-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-unicase+default-devel \
 rust-unicode-width+default-devel \
 rust-url+default-devel \
 rust-walkdir+default-devel \
 "
