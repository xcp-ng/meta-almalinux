# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ron"
PV = "0.12.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-ron+default-devel \
 rust-ron+indexmap-devel \
 rust-ron+integer128-devel \
 rust-ron+std-devel \
 rust-ron+unicode-segmentation-devel \
 rust-ron-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ron-0.12.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "86e87e003e85d6c380d974a64a278a73cb93c1ccfc1fde525f2b7607f054edc9"

URI_x86_64_v2_rust-ron+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+default-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+default-devel}"
SRC_URI[x86_64_v2_rust-ron+default-devel.sha256sum] = "e56c55191d97ec3d2dbc20bf01ccf49b695957dcb3d1f32657263346b7568736"

URI_x86_64_v2_rust-ron+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+indexmap-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+indexmap-devel}"
SRC_URI[x86_64_v2_rust-ron+indexmap-devel.sha256sum] = "47c98bc33ebf841ab8f18fd8f40d86e358e723171daad698d706bf183ec465f9"

URI_x86_64_v2_rust-ron+integer128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+integer128-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+integer128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+integer128-devel}"
SRC_URI[x86_64_v2_rust-ron+integer128-devel.sha256sum] = "88cfc7eff4382ace9cc541ffe9e0c5b922d89d8d8d21eea809a0a6353b90a511"

URI_x86_64_v2_rust-ron+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+std-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+std-devel}"
SRC_URI[x86_64_v2_rust-ron+std-devel.sha256sum] = "f8a73560947debdc1a84787718b2bf0cba484e2a4012b76254f5ccc5c6f089df"

URI_x86_64_v2_rust-ron+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron+unicode-segmentation-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-ron+unicode-segmentation-devel.sha256sum] = "0aa595e955b4ec070bafa4e76d94740db382b82d8aa4620828ec3d35716e4166"

URI_x86_64_v2_rust-ron-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ron-devel-0.12.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ron-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ron-devel}"
SRC_URI[x86_64_v2_rust-ron-devel.sha256sum] = "87b86f6c6081c409a65ea46a3b524579b697f216e2e7f31d9465bbe234de4fa3"

URI_aarch64_rust-ron+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+default-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ron+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+default-devel}"
SRC_URI[aarch64_rust-ron+default-devel.sha256sum] = "e31e84071236358a3ebee812a888bc9156f55db944ccc9ba3c585fc633488ee5"

URI_aarch64_rust-ron+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+indexmap-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ron+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+indexmap-devel}"
SRC_URI[aarch64_rust-ron+indexmap-devel.sha256sum] = "7c8fb0576db14ac006f26a20f6cb8e279f35df76722f3ce0686dab1066c8ba5b"

URI_aarch64_rust-ron+integer128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+integer128-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ron+integer128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+integer128-devel}"
SRC_URI[aarch64_rust-ron+integer128-devel.sha256sum] = "f1aedaa415c2dfac18f9be1d7045f83991f068b6720e27ce2f68cead00924d79"

URI_aarch64_rust-ron+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+std-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ron+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+std-devel}"
SRC_URI[aarch64_rust-ron+std-devel.sha256sum] = "e2ca398f1216d9eaf8f3e03eb6e09570ec1d24c965f562c120eb93517394c771"

URI_aarch64_rust-ron+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron+unicode-segmentation-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ron+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-ron+unicode-segmentation-devel.sha256sum] = "ce5a6d625873e52a9c16012777e2bd14929102373ed0b91ed8bd7de8ed3f719d"

URI_aarch64_rust-ron-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ron-devel-0.12.2-1.el10_3.noarch.rpm;name=aarch64_rust-ron-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ron-devel}"
SRC_URI[aarch64_rust-ron-devel.sha256sum] = "e89c1610623078519e78114778b749db7fb72832c3c10d97b6c8e8a47f3be176"

RDEPENDS:rust-ron+default-devel = " \
 cargo \
 rust-ron+std-devel \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+indexmap-devel = " \
 cargo \
 rust-indexmap+serde-devel \
 rust-indexmap-devel \
 rust-ron+std-devel \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+integer128-devel = " \
 cargo \
 rust-ron-devel \
 "
RDEPENDS:rust-ron+std-devel = " \
 cargo \
 rust-ron-devel \
 rust-serde+std-devel \
 "
RDEPENDS:rust-ron+unicode-segmentation-devel = " \
 cargo \
 rust-ron-devel \
 rust-unicode-segmentation-devel \
 "
RDEPENDS:rust-ron-devel = " \
 cargo \
 rust \
 rust-bitflags+serde-devel \
 rust-bitflags-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell+race-devel \
 rust-once_cell-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-serde_derive-devel \
 rust-typeid-devel \
 rust-unicode-ident-devel \
 "
