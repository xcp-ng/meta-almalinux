# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkg-config"
PV = "0.3.34"
PR = "1.el10_3"
PACKAGES = " \
 rust-pkg-config+default-devel \
 rust-pkg-config-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pkg-config-0.3.34-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1f8a5e3dfebc4c2a8b6b1dc3895d6463a4e7122942e76018a18e860380fa3d86"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config+default-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pkg-config+default-devel.sha256sum] = "f2a6cdeb315b2339a79f016f72ed28b02087446da4005bf0454af54387a0acd2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config-devel-0.3.34-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pkg-config-devel.sha256sum] = "3683810daa71cd35395130c6bd01d8e9093bd30d0cf660bcf283a35f25ebae4e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config+default-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-pkg-config+default-devel;unpack=0"
SRC_URI[aarch64_rust-pkg-config+default-devel.sha256sum] = "86d6512b02f316e255c9f6b71ee4a53457c018ac96c9d4d420275e9d1fe48728"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config-devel-0.3.34-1.el10_3.noarch.rpm;name=aarch64_rust-pkg-config-devel;unpack=0"
SRC_URI[aarch64_rust-pkg-config-devel.sha256sum] = "cecc6d0544838e18c06729e573ba0a781c74c13fbbc92d3abdeb1d7438b2af1e"

RDEPENDS:rust-pkg-config+default-devel = " \
 cargo \
 rust-pkg-config-devel \
 "
RDEPENDS:rust-pkg-config-devel = " \
 cargo \
 pkgconf-pkg-config \
 rust \
 "
