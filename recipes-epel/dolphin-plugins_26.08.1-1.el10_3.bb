# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dolphin-plugins"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 dolphin-plugins \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dolphin-plugins-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ea8ef03857d602826ef1114c0777cfba9205fdf0cab72224c063316304cc952c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dolphin-plugins-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dolphin-plugins;unpack=0"
SRC_URI[x86_64_v2_dolphin-plugins.sha256sum] = "37d6b91b2641643180123ff5c3b287d5145e1c054878424e6929f2552acf4606"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dolphin-plugins-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_dolphin-plugins;unpack=0"
SRC_URI[aarch64_dolphin-plugins.sha256sum] = "a54f66b194b3789e72867083af5b0370fa9004ece4ff9ff0d6620520e88d6c7c"

RDEPENDS:dolphin-plugins = " \
 dolphin \
 dolphin-libs \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
