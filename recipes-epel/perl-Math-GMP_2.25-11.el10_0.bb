# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Math-GMP"
PV = "2.25"
PR = "11.el10_0"
PACKAGES = " \
 perl-Math-GMP \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Math-GMP-2.25-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e61e3a5a74e673d6223b28ed91fb8cfd82c801305df630e9a59a0b5b63f5953c"

URI_x86_64_v2_perl-Math-GMP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-GMP-2.25-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Math-GMP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-GMP}"
SRC_URI[x86_64_v2_perl-Math-GMP.sha256sum] = "2628968e9e37c17b83c554d66bc743c8d197e7b8311865a9ea6429161b86f846"

URI_aarch64_perl-Math-GMP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-GMP-2.25-11.el10_0.aarch64.rpm;name=aarch64_perl-Math-GMP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-GMP}"
SRC_URI[aarch64_perl-Math-GMP.sha256sum] = "ee84e1e7beadcc74c9ec3822712e1af6fe1b03c07b30be500f8aff7ed933a04f"

RDEPENDS:perl-Math-GMP = " \
 glibc \
 gmp \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
