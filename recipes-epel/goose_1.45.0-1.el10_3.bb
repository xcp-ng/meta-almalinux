# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "goose"
PV = "1.45.0"
PR = "1.el10_3"
PACKAGES = " \
 goose \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/goose-1.45.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c9908d4ea9f430d56de5cea6fb0f9bfc2fe0a3e08a8887258aab143c49f7adc0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/goose-1.45.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_goose;unpack=0"
SRC_URI[x86_64_v2_goose.sha256sum] = "3c43c4a535777901fe9b64513c003a96f878ed91d74267809e02c5f6a1c8dbd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/goose-1.45.0-1.el10_3.aarch64.rpm;name=aarch64_goose;unpack=0"
SRC_URI[aarch64_goose.sha256sum] = "0154cbef2de8da42b76fb8d455dbea95cac7ed4104b500213107abf56da6d102"

RDEPENDS:goose = " \
 dbus-libs \
 glibc \
 libgcc \
 libzstd \
 oniguruma \
 openssl-libs \
 sqlite-libs \
 "
