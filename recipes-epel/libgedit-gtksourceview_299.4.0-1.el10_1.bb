# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgedit-gtksourceview"
PV = "299.4.0"
PR = "1.el10_1"
PACKAGES = " \
 libgedit-gtksourceview \
 libgedit-gtksourceview-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgedit-gtksourceview-299.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0471ba0067a4c0c78a7a573184f7b8d93b1f1ff3697890b800623e7515f3edb6"

URI_x86_64_v2_libgedit-gtksourceview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-gtksourceview-299.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-gtksourceview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-gtksourceview}"
SRC_URI[x86_64_v2_libgedit-gtksourceview.sha256sum] = "2e6e6d2d374d850bcbc8b298319f1f5f35859a3ec155d68069b2f94733dca4e1"

URI_x86_64_v2_libgedit-gtksourceview-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgedit-gtksourceview-devel-299.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgedit-gtksourceview-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgedit-gtksourceview-devel}"
SRC_URI[x86_64_v2_libgedit-gtksourceview-devel.sha256sum] = "e3591ec057023ab45c2a3db0158c75f5e39e506a69f77921b53ed0dc812f8383"

URI_aarch64_libgedit-gtksourceview = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-gtksourceview-299.4.0-1.el10_1.aarch64.rpm;name=aarch64_libgedit-gtksourceview;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-gtksourceview}"
SRC_URI[aarch64_libgedit-gtksourceview.sha256sum] = "db194fa3123025fac3e13c47531c3ae7dec3a91d2b7071c814d4767df7c1363f"

URI_aarch64_libgedit-gtksourceview-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgedit-gtksourceview-devel-299.4.0-1.el10_1.aarch64.rpm;name=aarch64_libgedit-gtksourceview-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgedit-gtksourceview-devel}"
SRC_URI[aarch64_libgedit-gtksourceview-devel.sha256sum] = "5c001c1ef7443372a8894fc8876311a3abc157b660a74ec9d6fb17aa61d33998"

RDEPENDS:libgedit-gtksourceview = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 libxml2 \
 pango \
 "
RDEPENDS:libgedit-gtksourceview-devel = " \
 glib2-devel \
 gtk3-devel \
 libgedit-gtksourceview \
 libxml2-devel \
 pkgconf-pkg-config \
 "
