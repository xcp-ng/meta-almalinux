# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Math-Base36"
PV = "0.14"
PR = "32.el10_3"
PACKAGES = " \
 perl-Math-Base36 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Math-Base36-0.14-32.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b95958d7ac0f319993fc284e4b1f221f9c1ae03aa1d39fd9b05e76d356ae1bc"

URI_x86_64_v2_perl-Math-Base36 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-Base36-0.14-32.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Math-Base36;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-Base36}"
SRC_URI[x86_64_v2_perl-Math-Base36.sha256sum] = "245c064b29d35eef8ecb1ec98f1e72da91d286a40bafb121589357cff8b1a3d5"

URI_aarch64_perl-Math-Base36 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-Base36-0.14-32.el10_3.noarch.rpm;name=aarch64_perl-Math-Base36;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-Base36}"
SRC_URI[aarch64_perl-Math-Base36.sha256sum] = "425c2a7cb4401da6f7a1e58d40b519a5c8a3a82fe31db866f89a3b98ff314e1e"

RDEPENDS:perl-Math-Base36 = " \
 perl-Carp \
 perl-Exporter \
 perl-Math-BigInt \
 perl-base \
 perl-libs \
 "
