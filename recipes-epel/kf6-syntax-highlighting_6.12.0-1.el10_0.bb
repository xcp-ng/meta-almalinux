# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syntax-highlighting"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-syntax-highlighting \
 kf6-syntax-highlighting-devel \
 kf6-syntax-highlighting-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-syntax-highlighting-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "959c40145b89a630db3f8aa5eeba2bce07c91bf24036730e23570bf48240cdaf"

URI_x86_64_v2_kf6-syntax-highlighting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting.sha256sum] = "60b7cf5fa1f60c0c4bca1dba9e19f9a5c3edaae5055459047a330a3da81fdcb4"

URI_x86_64_v2_kf6-syntax-highlighting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-devel}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-devel.sha256sum] = "d96f7147f2bb05ef92c179bcffcad9b66f34aca6e0a289f5d6dd05ab16b4c7ce"

URI_x86_64_v2_kf6-syntax-highlighting-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-doc}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-doc.sha256sum] = "40fbabc3c06ae5c3f699b0db6caed35d1ea1a7336804dcb01197f940ee77e4c4"

URI_aarch64_kf6-syntax-highlighting = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-syntax-highlighting;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting}"
SRC_URI[aarch64_kf6-syntax-highlighting.sha256sum] = "b767190a0bfd865e740fc40703033af71f9b62d61fe2fc86c718fcc15c64d9d0"

URI_aarch64_kf6-syntax-highlighting-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-devel}"
SRC_URI[aarch64_kf6-syntax-highlighting-devel.sha256sum] = "d3cc43ad4d6673385f6f2baee7a98d7a5600fb672d7debcc432b8354e03373b3"

URI_aarch64_kf6-syntax-highlighting-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-doc}"
SRC_URI[aarch64_kf6-syntax-highlighting-doc.sha256sum] = "dfab7bcf04cafc5c55107a2290a2140b467654613174f84bacfef2b6392de20c"

RDEPENDS:kf6-syntax-highlighting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-syntax-highlighting-devel = " \
 cmake-filesystem \
 kf6-syntax-highlighting \
 "
RDEPENDS:kf6-syntax-highlighting-doc = " \
 "
