# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keylime"
PV = "7.12.1"
PR = "2.el10"
PACKAGES = " \
 keylime \
 keylime-base \
 keylime-registrar \
 keylime-selinux \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keylime-7.12.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ace03484c740abdc4d0992083aa91fe29ee2c8194fd6fc05f5505c97eb61c5d7"

URI_x86_64_v2_keylime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-7.12.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime}"
SRC_URI[x86_64_v2_keylime.sha256sum] = "32be177d5d4811f4328f1a040e489d864ee84c70a22f6ad7a60f87840fed827b"

URI_x86_64_v2_keylime-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-base-7.12.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-base}"
SRC_URI[x86_64_v2_keylime-base.sha256sum] = "ef9026ef9f82dbc2269113073dd435e48e44cb0d6fef19916216ff3da73c0012"

URI_x86_64_v2_keylime-registrar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-registrar-7.12.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-registrar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-registrar}"
SRC_URI[x86_64_v2_keylime-registrar.sha256sum] = "6e90c7f34bb7a304ced608f11f9eb8f732f4a878fb26952838618b5886eb7cff"

URI_x86_64_v2_keylime-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-selinux-7.12.1-2.el10.noarch.rpm;name=x86_64_v2_keylime-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-selinux}"
SRC_URI[x86_64_v2_keylime-selinux.sha256sum] = "fa72358fa34e614f561e9b1f6e1cb488625bb0ac8ac8fde438338199aeacec55"

URI_x86_64_v2_keylime-tenant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tenant-7.12.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-tenant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-tenant}"
SRC_URI[x86_64_v2_keylime-tenant.sha256sum] = "9fefac826fc2bf1f2ce6a4a867caa8efcb0b7c984ff77b41207ad8b5ef8d0680"

URI_x86_64_v2_keylime-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-tools-7.12.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-tools}"
SRC_URI[x86_64_v2_keylime-tools.sha256sum] = "4793d8df8107e86cae1cfe5b8d729c97ae165acc6e77a43de2af0509312e1cfc"

URI_x86_64_v2_keylime-verifier = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-verifier-7.12.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_keylime-verifier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-verifier}"
SRC_URI[x86_64_v2_keylime-verifier.sha256sum] = "de30da60beec0b7a879b71b72a7c3552f144987a3537abe561a04c7177562803"

URI_x86_64_v2_python3-keylime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-keylime-7.12.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3-keylime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-keylime}"
SRC_URI[x86_64_v2_python3-keylime.sha256sum] = "3226b64b88ea40265e5e326c10063e6650d5d27233297663d03fd18f7c72dc2d"

URI_aarch64_keylime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-7.12.1-2.el10.aarch64.rpm;name=aarch64_keylime;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime}"
SRC_URI[aarch64_keylime.sha256sum] = "c9205ad684052072dea132cfabaf57ca7e7544f3fecbd1e5b05d014dd4882f96"

URI_aarch64_keylime-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-base-7.12.1-2.el10.aarch64.rpm;name=aarch64_keylime-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-base}"
SRC_URI[aarch64_keylime-base.sha256sum] = "ea221abfd80f0b5884571c145d03d5076ca5c4366b4ea59cc57d554b304c64e0"

URI_aarch64_keylime-registrar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-registrar-7.12.1-2.el10.aarch64.rpm;name=aarch64_keylime-registrar;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-registrar}"
SRC_URI[aarch64_keylime-registrar.sha256sum] = "25d6c060007d193e3342b4f54c79649bf6bbaea11f86b370c48eded7c94acb3d"

URI_aarch64_keylime-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-selinux-7.12.1-2.el10.noarch.rpm;name=aarch64_keylime-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-selinux}"
SRC_URI[aarch64_keylime-selinux.sha256sum] = "fa72358fa34e614f561e9b1f6e1cb488625bb0ac8ac8fde438338199aeacec55"

URI_aarch64_keylime-tenant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tenant-7.12.1-2.el10.aarch64.rpm;name=aarch64_keylime-tenant;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-tenant}"
SRC_URI[aarch64_keylime-tenant.sha256sum] = "a152f425c732727998596063c3b7bdbbf5f1e4b8188c8356ada1700d0b615d65"

URI_aarch64_keylime-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-tools-7.12.1-2.el10.aarch64.rpm;name=aarch64_keylime-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-tools}"
SRC_URI[aarch64_keylime-tools.sha256sum] = "04cbfd3eb8a5e64fef27ad24dab5e2a4311759a604e4ebea598979ae5fed7776"

URI_aarch64_keylime-verifier = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-verifier-7.12.1-2.el10.aarch64.rpm;name=aarch64_keylime-verifier;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-verifier}"
SRC_URI[aarch64_keylime-verifier.sha256sum] = "fd23e0f3cfaeacb68f3cd6c13664d581c06480abf396eda6ef7a7921408e0955"

URI_aarch64_python3-keylime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-keylime-7.12.1-2.el10.aarch64.rpm;name=aarch64_python3-keylime;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-keylime}"
SRC_URI[aarch64_python3-keylime.sha256sum] = "19cfb4f47a5633adde7f505201826c33760505264fd7cc0f099569dd10938e6c"

RDEPENDS:keylime = " \
 keylime-agent-rust \
 keylime-base \
 keylime-registrar \
 keylime-tenant \
 keylime-tools \
 keylime-verifier \
 python3-keylime \
 "
RDEPENDS:keylime-base = " \
 bash \
 efivar-libs \
 openssl \
 procps-ng \
 python3 \
 python3-jinja2 \
 shadow-utils \
 tpm2-tss \
 "
RDEPENDS:keylime-registrar = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:keylime-tenant = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-tools = " \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:keylime-verifier = " \
 bash \
 keylime-base \
 python3 \
 python3-keylime \
 "
RDEPENDS:python3-keylime = " \
 keylime-base \
 python3 \
 python3-alembic \
 python3-cryptography \
 python3-gpg \
 python3-jsonschema \
 python3-lark \
 python3-packaging \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyyaml \
 python3-requests \
 python3-sqlalchemy \
 python3-tornado \
 python3-typing-extensions \
 tpm2-tools \
 "
