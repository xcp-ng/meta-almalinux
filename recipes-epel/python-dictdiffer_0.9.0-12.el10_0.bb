# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dictdiffer"
PV = "0.9.0"
PR = "12.el10_0"
PACKAGES = " \
 python3-dictdiffer \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-dictdiffer-0.9.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7eff9553ca6edca08860a095cff44fbc37260babb5dfa407cf619961233e422c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dictdiffer-0.9.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dictdiffer;unpack=0"
SRC_URI[x86_64_v2_python3-dictdiffer.sha256sum] = "33397e15cf5582c35ece1853cd5c1b81e2ee59b49663d8f212a345ea4ef9bbd3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-dictdiffer-0.9.0-12.el10_0.noarch.rpm;name=aarch64_python3-dictdiffer;unpack=0"
SRC_URI[aarch64_python3-dictdiffer.sha256sum] = "53ff966159cdd98dfff35c4a1a84933e0380047a1c4fd50b07d750d5e8f46ad7"

RDEPENDS:python3-dictdiffer = " \
 python3 \
 "
