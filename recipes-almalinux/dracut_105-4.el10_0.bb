# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dracut"
PV = "105"
PR = "4.el10_0"
PACKAGES = " \
 dracut \
 dracut-caps \
 dracut-config-generic \
 dracut-config-rescue \
 dracut-live \
 dracut-network \
 dracut-squash \
 dracut-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dracut-105-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0ea781467194453227afca99969ae5ca7a309a3e4ddac57c92f14b432ec5c26"

URI_x86_64_v2_dracut = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-105-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut}"
SRC_URI[x86_64_v2_dracut.sha256sum] = "a4157e5e445f04bb46b7609afbf2c824051d7c75cd41332d1f86c9293cc734e3"

URI_x86_64_v2_dracut-caps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-caps-105-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_dracut-caps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-caps}"
SRC_URI[x86_64_v2_dracut-caps.sha256sum] = "21b5d001d505bc79e06cfca69a41b45b03179ef9f72073e58864660e1c99b370"

URI_x86_64_v2_dracut-config-generic = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-generic-105-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_dracut-config-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-config-generic}"
SRC_URI[x86_64_v2_dracut-config-generic.sha256sum] = "2c2396d980569ebf1dcb9a30b99d89a1322f079e1f4422c0f972caf12613be14"

URI_x86_64_v2_dracut-config-rescue = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-config-rescue-105-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_dracut-config-rescue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-config-rescue}"
SRC_URI[x86_64_v2_dracut-config-rescue.sha256sum] = "0e5ef4f35c83c8ec2450c665f009344bb8fe9caa9a8ee5f8692d410ec8419fbf"

URI_x86_64_v2_dracut-live = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dracut-live-105-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_dracut-live;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-live}"
SRC_URI[x86_64_v2_dracut-live.sha256sum] = "0629f98dd285ff48d4616ae7e4064608d6dcfeb3d37e31cb8a12a115dbb59667"

URI_x86_64_v2_dracut-network = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-network-105-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_dracut-network;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-network}"
SRC_URI[x86_64_v2_dracut-network.sha256sum] = "9747c9cca4dbfe52b6640940afe61aa630a17313b8ec56f148c9402a95f37450"

URI_x86_64_v2_dracut-squash = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-squash-105-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_dracut-squash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-squash}"
SRC_URI[x86_64_v2_dracut-squash.sha256sum] = "0bcec9bc04d8d733003e3607df354a5a6223c7bec5910e503afaa362e75377ef"

URI_x86_64_v2_dracut-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dracut-tools-105-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_dracut-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-tools}"
SRC_URI[x86_64_v2_dracut-tools.sha256sum] = "c031fd26822e708ae760bc4e50011f0624d8de822f7ca2c861387bdcd36c2de9"

URI_aarch64_dracut = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-105-4.el10_0.aarch64.rpm;name=aarch64_dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut}"
SRC_URI[aarch64_dracut.sha256sum] = "facb1d72d8f9fe26c012849480c5e955f332383f27a79a28569d31be41ec2068"

URI_aarch64_dracut-caps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-caps-105-4.el10_0.aarch64.rpm;name=aarch64_dracut-caps;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-caps}"
SRC_URI[aarch64_dracut-caps.sha256sum] = "51389bc096296cf7173545d1f4af3d39242b6b22e47b8daacbbc26100058485a"

URI_aarch64_dracut-config-generic = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-generic-105-4.el10_0.aarch64.rpm;name=aarch64_dracut-config-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-config-generic}"
SRC_URI[aarch64_dracut-config-generic.sha256sum] = "5c6c346d1c8410e75e49bf0fd77bfab18f274be9614a0c9d13927ff5d424868c"

URI_aarch64_dracut-config-rescue = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-config-rescue-105-4.el10_0.aarch64.rpm;name=aarch64_dracut-config-rescue;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-config-rescue}"
SRC_URI[aarch64_dracut-config-rescue.sha256sum] = "2442d03554adc73148c1cd818cc93ff6269111c8d3e124b2cbae0c74a14debcd"

URI_aarch64_dracut-live = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dracut-live-105-4.el10_0.aarch64.rpm;name=aarch64_dracut-live;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-live}"
SRC_URI[aarch64_dracut-live.sha256sum] = "f7abd434feba96ac3a0fa4d3e7cb62f7d5fea42dae157bdc0937d449ee561913"

URI_aarch64_dracut-network = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-network-105-4.el10_0.aarch64.rpm;name=aarch64_dracut-network;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-network}"
SRC_URI[aarch64_dracut-network.sha256sum] = "2d73d684c10e4d6fe0a04bcb5a6213aa1a3903478e052f26e2f148ebc0a07c1c"

URI_aarch64_dracut-squash = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-squash-105-4.el10_0.aarch64.rpm;name=aarch64_dracut-squash;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-squash}"
SRC_URI[aarch64_dracut-squash.sha256sum] = "bec8eaca9af3ce1c3dff4d51dfc413e572e67193c46a5422d8b75d41d35cef7d"

URI_aarch64_dracut-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dracut-tools-105-4.el10_0.aarch64.rpm;name=aarch64_dracut-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-tools}"
SRC_URI[aarch64_dracut-tools.sha256sum] = "0fe8413511abb7bfa9207486321f6e4e0e2f78f584d15e414bb3c4ff6aa4520b"

RDEPENDS:dracut = " \
 bash \
 cpio \
 filesystem \
 findutils \
 glibc \
 grep \
 gzip \
 kmod \
 kmod-libs \
 libgcc \
 libkcapi-hmaccalc \
 openssl-libs \
 procps-ng \
 sed \
 systemd \
 systemd-udev \
 util-linux \
 virtual/coreutils \
 xz \
 "
RDEPENDS:dracut-caps = " \
 bash \
 dracut \
 libcap \
 "
RDEPENDS:dracut-config-generic = " \
 dracut \
 "
RDEPENDS:dracut-config-rescue = " \
 bash \
 dracut \
 "
RDEPENDS:dracut-live = " \
 bash \
 curl \
 device-mapper \
 dracut \
 dracut-network \
 gzip \
 parted \
 tar \
 virtual/coreutils \
 "
RDEPENDS:dracut-network = " \
 NetworkManager \
 bash \
 dracut \
 iproute \
 iputils \
 jq \
 "
RDEPENDS:dracut-squash = " \
 bash \
 dracut \
 erofs-utils \
 "
RDEPENDS:dracut-tools = " \
 bash \
 dracut \
 "
