# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-duct"
PV = "0.13.7"
PR = "2.el10_0"
PACKAGES = " \
 rust-duct+default-devel \
 rust-duct-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-duct-0.13.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab67d042cd49cc6fb4cd9fffb98642640fd406f544b494d0b7f9c68d3e1f6e0a"

URI_x86_64_v2_rust-duct+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-duct+default-devel-0.13.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-duct+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-duct+default-devel}"
SRC_URI[x86_64_v2_rust-duct+default-devel.sha256sum] = "8681a1751d383c3d90c619fe87d5df39c0f5c1ee9fc55451aaa1b2343db75dc8"

URI_x86_64_v2_rust-duct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-duct-devel-0.13.7-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-duct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-duct-devel}"
SRC_URI[x86_64_v2_rust-duct-devel.sha256sum] = "9530b00792cb7b06915902946283ed8eaaf66fbcfe8dc076a37c210d914cb718"

URI_aarch64_rust-duct+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-duct+default-devel-0.13.7-2.el10_0.noarch.rpm;name=aarch64_rust-duct+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-duct+default-devel}"
SRC_URI[aarch64_rust-duct+default-devel.sha256sum] = "cf57d602e01a4f32b1ab869cc08a9133718e1ba1153f5418a0a5351609cf2cdb"

URI_aarch64_rust-duct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-duct-devel-0.13.7-2.el10_0.noarch.rpm;name=aarch64_rust-duct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-duct-devel}"
SRC_URI[aarch64_rust-duct-devel.sha256sum] = "8d488549944e717c46ca0be77032b4dec393e04be752a0b61e3ee587877c7dc7"

RDEPENDS:rust-duct+default-devel = " \
 cargo \
 rust-duct-devel \
 "
RDEPENDS:rust-duct-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-os_pipe+default-devel \
 rust-shared_child+default-devel \
 "
