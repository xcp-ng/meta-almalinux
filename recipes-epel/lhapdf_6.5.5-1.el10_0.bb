# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lhapdf"
PV = "6.5.5"
PR = "1.el10_0"
PACKAGES = " \
 lhapdf \
 lhapdf-devel \
 lhapdf-doc \
 python3-lhapdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lhapdf-6.5.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef53bfd03b984d0d2462cf72d6bcdb14be98619d239e6335ff8986ca2f593b26"

URI_x86_64_v2_lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-6.5.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf}"
SRC_URI[x86_64_v2_lhapdf.sha256sum] = "e397194b4abd333d31d329bc9eccfecca47225a9ba2bed155bd15bd56366129c"

URI_x86_64_v2_lhapdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-devel-6.5.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lhapdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf-devel}"
SRC_URI[x86_64_v2_lhapdf-devel.sha256sum] = "e940a048270e6e32e1bfe8c112bba93b257f0a7184523b4bb4a1afbc45473a91"

URI_x86_64_v2_lhapdf-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lhapdf-doc-6.5.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lhapdf-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lhapdf-doc}"
SRC_URI[x86_64_v2_lhapdf-doc.sha256sum] = "3bfc9b2808d3f4da92adabc250d5dff6e1da096ec50e0547acf65a5d09a3ce37"

URI_x86_64_v2_python3-lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lhapdf-6.5.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lhapdf}"
SRC_URI[x86_64_v2_python3-lhapdf.sha256sum] = "321b504fe5b219503030f626dded53a6ceb49930bf00cb67025fecfae8852f67"

URI_aarch64_lhapdf = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-6.5.5-1.el10_0.aarch64.rpm;name=aarch64_lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf}"
SRC_URI[aarch64_lhapdf.sha256sum] = "f0aeae36084795fb9b29189d8eaea19ab99d61424a5f976392bcb1f2b710a022"

URI_aarch64_lhapdf-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-devel-6.5.5-1.el10_0.aarch64.rpm;name=aarch64_lhapdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf-devel}"
SRC_URI[aarch64_lhapdf-devel.sha256sum] = "9a598b8c1ee123f173764f21406c0afc1dabee429ea609c854bdb5a87b46c221"

URI_aarch64_lhapdf-doc = "${EPEL_MIRROR}/aarch64/Packages/l/lhapdf-doc-6.5.5-1.el10_0.noarch.rpm;name=aarch64_lhapdf-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_lhapdf-doc}"
SRC_URI[aarch64_lhapdf-doc.sha256sum] = "9706f49eff26319349184a6a42beea183b27c6003efb1ca3eb80635d6603eccb"

URI_aarch64_python3-lhapdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lhapdf-6.5.5-1.el10_0.aarch64.rpm;name=aarch64_python3-lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lhapdf}"
SRC_URI[aarch64_python3-lhapdf.sha256sum] = "4d88666d697b2577869b4ec97f26846e843878a802d74a9b16ac41f6d2426919"

RDEPENDS:lhapdf = " \
 glibc \
 libgcc \
 libstdc++ \
 yaml-cpp \
 "
RDEPENDS:lhapdf-devel = " \
 bash \
 lhapdf \
 pkgconf-pkg-config \
 "
RDEPENDS:lhapdf-doc = " \
 "
RDEPENDS:python3-lhapdf = " \
 glibc \
 lhapdf \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
