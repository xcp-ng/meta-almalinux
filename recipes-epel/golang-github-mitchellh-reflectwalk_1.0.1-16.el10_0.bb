# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mitchellh-reflectwalk"
PV = "1.0.1"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-mitchellh-reflectwalk-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mitchellh-reflectwalk-1.0.1-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35614a6f302a5c3e79557bb560d0af38a6d45d550586ddfd7c3c428c389df4df"

URI_x86_64_v2_golang-github-mitchellh-reflectwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mitchellh-reflectwalk-devel-1.0.1-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mitchellh-reflectwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mitchellh-reflectwalk-devel}"
SRC_URI[x86_64_v2_golang-github-mitchellh-reflectwalk-devel.sha256sum] = "670e44ab54bf02ab00d050648df5da2493f8ac720cf963f71cab1aa414cfdd39"

URI_aarch64_golang-github-mitchellh-reflectwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mitchellh-reflectwalk-devel-1.0.1-16.el10_0.noarch.rpm;name=aarch64_golang-github-mitchellh-reflectwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mitchellh-reflectwalk-devel}"
SRC_URI[aarch64_golang-github-mitchellh-reflectwalk-devel.sha256sum] = "66ead5497407b7efa4f54f4576e576a66ab8d4a53caee4cbfe993b5ab41e7af6"

RDEPENDS:golang-github-mitchellh-reflectwalk-devel = " \
 go-filesystem \
 "
