# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgee"
PV = "0.20.6"
PR = "8.el10"
PACKAGES = " \
 libgee \
 libgee-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libgee-0.20.6-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0799ef9e721be633854d8ecb6783c350f414748cf782a6cf08b898820279b739"

URI_x86_64_v2_libgee = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libgee-0.20.6-8.el10.x86_64_v2.rpm;name=x86_64_v2_libgee;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgee}"
SRC_URI[x86_64_v2_libgee.sha256sum] = "686f2f9c809434cf34a6109858542cac284f79df576b9625f852d7753a34f37c"

URI_x86_64_v2_libgee-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libgee-devel-0.20.6-8.el10.x86_64_v2.rpm;name=x86_64_v2_libgee-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgee-devel}"
SRC_URI[x86_64_v2_libgee-devel.sha256sum] = "c3dac7e3c466f0cc8caa7db0351bd004c5281645800192efebb3a1ef48171b46"

URI_aarch64_libgee = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libgee-0.20.6-8.el10.aarch64.rpm;name=aarch64_libgee;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgee}"
SRC_URI[aarch64_libgee.sha256sum] = "ef77c398dfd24c50dd9c967f5466f7004eed1f321d44ee71ca1c6bedc7c6b6d8"

URI_aarch64_libgee-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libgee-devel-0.20.6-8.el10.aarch64.rpm;name=aarch64_libgee-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgee-devel}"
SRC_URI[aarch64_libgee-devel.sha256sum] = "01a2b0be96e9977f5d90512c9f5c8696d14d06f99a068fdf31babd5bd9e37a4b"

RDEPENDS:libgee = " \
 glib2 \
 glibc \
 "
RDEPENDS:libgee-devel = " \
 glib2-devel \
 libgee \
 pkgconf-pkg-config \
 "
