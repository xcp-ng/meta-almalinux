# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcompletion"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kcompletion \
 kf6-kcompletion-devel \
 kf6-kcompletion-doc \
 kf6-kcompletion-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcompletion-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b694c9c75342718bcf58b02595fe8bd1eec37876381fc11fe90847f8dd345d47"

URI_x86_64_v2_kf6-kcompletion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion}"
SRC_URI[x86_64_v2_kf6-kcompletion.sha256sum] = "5e3b6b9f41ff20e065dee1a2eff819578ccaa1ea8ba472b9384d3d6159f1d683"

URI_x86_64_v2_kf6-kcompletion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcompletion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-devel}"
SRC_URI[x86_64_v2_kf6-kcompletion-devel.sha256sum] = "ca22e65d3b7cf832ab424b50a81ab8b2bf2a9825768f379c478c38688c66d447"

URI_x86_64_v2_kf6-kcompletion-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcompletion-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-doc}"
SRC_URI[x86_64_v2_kf6-kcompletion-doc.sha256sum] = "01cad89f2161ee5e53b2a42802c4924017c838caf93385edde50b627c1fa589a"

URI_x86_64_v2_kf6-kcompletion-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcompletion-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcompletion-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcompletion-html}"
SRC_URI[x86_64_v2_kf6-kcompletion-html.sha256sum] = "b7395e00f6c2a897b2815aa98537ec8e4de2a2989229c9b51515c3b88d30b19d"

URI_aarch64_kf6-kcompletion = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcompletion;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion}"
SRC_URI[aarch64_kf6-kcompletion.sha256sum] = "2f1c38f64906774e268169ab1d8910cca5831712395d2d781dac05cce60fcc02"

URI_aarch64_kf6-kcompletion-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcompletion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-devel}"
SRC_URI[aarch64_kf6-kcompletion-devel.sha256sum] = "cec3a60577df82ddbd542b6a38a1ea0b95df88ce777b7ebfba6447ca6f161564"

URI_aarch64_kf6-kcompletion-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcompletion-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-doc}"
SRC_URI[aarch64_kf6-kcompletion-doc.sha256sum] = "80623492b7df10dcb5303e66d3bd93c223caf31afccf9405a590ee540937eed5"

URI_aarch64_kf6-kcompletion-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcompletion-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcompletion-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcompletion-html}"
SRC_URI[aarch64_kf6-kcompletion-html.sha256sum] = "a29544bbaa690c0e21bc8df35730539d00712eb2d3d65e7452a03414c94d02b2"

RDEPENDS:kf6-kcompletion = " \
 glibc \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcompletion \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcompletion-doc = " \
 "
RDEPENDS:kf6-kcompletion-html = " \
 "
