# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pptp"
PV = "1.10.0"
PR = "22.el10"
PACKAGES = " \
 pptp \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pptp-1.10.0-22.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bb5d22179000e2821185445f4efd896d5d9b5a98432b44b4db3d40d9c821e44f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pptp-1.10.0-22.el10.x86_64_v2.rpm;name=x86_64_v2_pptp;unpack=0"
SRC_URI[x86_64_v2_pptp.sha256sum] = "9c39bc1a02cae4ec2701c44e2e522f518c5010f575f4c59724b777ae04e44608"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pptp-1.10.0-22.el10.aarch64.rpm;name=aarch64_pptp;unpack=0"
SRC_URI[aarch64_pptp.sha256sum] = "c75ff22a5ed0f2d5e3510b134ab57e9ba1db37287e5e20fa62f04536b6c23d7a"

RDEPENDS:pptp = " \
 glibc \
 iproute \
 ppp \
 systemd \
 "
