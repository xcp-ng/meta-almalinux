# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpmreaper"
PV = "0.2.0"
PR = "34.el10_0"
PACKAGES = " \
 rpmreaper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpmreaper-0.2.0-34.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6483f56ac8c3cf815b69cec6870adf871ba7beb838496c5f4e33eb5d6a13d7ee"

URI_x86_64_v2_rpmreaper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmreaper-0.2.0-34.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpmreaper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmreaper}"
SRC_URI[x86_64_v2_rpmreaper.sha256sum] = "82b7496994c1503140bedfbe2e7a3a28f4b2c765b49efa1dff3adb1e57d2f764"

URI_aarch64_rpmreaper = "${EPEL_MIRROR}/aarch64/Packages/r/rpmreaper-0.2.0-34.el10_0.aarch64.rpm;name=aarch64_rpmreaper;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmreaper}"
SRC_URI[aarch64_rpmreaper.sha256sum] = "c4d2b2464f9e7cad13b939bb956af7d5e6a4d80b24a29ce80ec70422aedddbb0"

RDEPENDS:rpmreaper = " \
 glibc \
 less \
 ncurses-libs \
 popt \
 rpm \
 rpm-libs \
 "
