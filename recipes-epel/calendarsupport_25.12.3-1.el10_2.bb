# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calendarsupport"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 calendarsupport \
 calendarsupport-devel \
 calendarsupport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/calendarsupport-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13f8e9ec79c9433212184c957d4b76b65cc28f77c1c59d36920010db5ad6260e"

URI_x86_64_v2_calendarsupport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport}"
SRC_URI[x86_64_v2_calendarsupport.sha256sum] = "e558c5ec0d1c158f125249d501b050aadb7684533a316b269ffe8fa812ee24e4"

URI_x86_64_v2_calendarsupport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calendarsupport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport-devel}"
SRC_URI[x86_64_v2_calendarsupport-devel.sha256sum] = "176af3dbb3891ba9ad3bfac9bcf7c7771d44f7fe23df133fda89777f265efabd"

URI_x86_64_v2_calendarsupport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calendarsupport-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_calendarsupport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calendarsupport-doc}"
SRC_URI[x86_64_v2_calendarsupport-doc.sha256sum] = "34058be14c87f03bc4ee9232a7470344947b7d2da83d661494537a3d30bb43a5"

URI_aarch64_calendarsupport = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_calendarsupport;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport}"
SRC_URI[aarch64_calendarsupport.sha256sum] = "152e23c004e353a39365f4c90d0766aa12c12137a9b267b7295d579c69b0622e"

URI_aarch64_calendarsupport-devel = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_calendarsupport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport-devel}"
SRC_URI[aarch64_calendarsupport-devel.sha256sum] = "a3bf1af9ec81b4d00cedf24097e538e0a0a5011034c9af9387081921acc40320"

URI_aarch64_calendarsupport-doc = "${EPEL_MIRROR}/aarch64/Packages/c/calendarsupport-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_calendarsupport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_calendarsupport-doc}"
SRC_URI[aarch64_calendarsupport-doc.sha256sum] = "49237afd86c43048b41c8db53bd1196643280821adbbcf909ea4f558f3798d74"

RDEPENDS:calendarsupport = " \
 akonadi-calendar \
 akonadi-server \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kidentitymanagement \
 kmime \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:calendarsupport-devel = " \
 akonadi-calendar-devel \
 calendarsupport \
 cmake-filesystem \
 kidentitymanagement-devel \
 kmime-devel \
 "
RDEPENDS:calendarsupport-doc = " \
 "
