# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cookie"
PV = "0.18.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-cookie+aes-gcm-devel \
 rust-cookie+base64-devel \
 rust-cookie+default-devel \
 rust-cookie+hkdf-devel \
 rust-cookie+hmac-devel \
 rust-cookie+key-expansion-devel \
 rust-cookie+percent-encode-devel \
 rust-cookie+percent-encoding-devel \
 rust-cookie+private-devel \
 rust-cookie+rand-devel \
 rust-cookie+secure-devel \
 rust-cookie+sha2-devel \
 rust-cookie+signed-devel \
 rust-cookie+subtle-devel \
 rust-cookie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cookie-0.18.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18b60cdf1661a4ad140adcbcfbe0209ed3c198c594313929c6021cd9f26dbbf7"

URI_x86_64_v2_rust-cookie+aes-gcm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+aes-gcm-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+aes-gcm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+aes-gcm-devel}"
SRC_URI[x86_64_v2_rust-cookie+aes-gcm-devel.sha256sum] = "87582053567fe6fbf73d96b26eedcb0129089a957a69e5aa4ec3f5bd9a818b74"

URI_x86_64_v2_rust-cookie+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+base64-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+base64-devel}"
SRC_URI[x86_64_v2_rust-cookie+base64-devel.sha256sum] = "7a62d7e19942b8d30190d261626a79c5d06be972a10dd82cc725278dbc61856e"

URI_x86_64_v2_rust-cookie+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+default-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+default-devel}"
SRC_URI[x86_64_v2_rust-cookie+default-devel.sha256sum] = "77f36fe018e20088b91567d906e0d9b9ef588196ebbe31376df49600abaca7c8"

URI_x86_64_v2_rust-cookie+hkdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+hkdf-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+hkdf-devel}"
SRC_URI[x86_64_v2_rust-cookie+hkdf-devel.sha256sum] = "190d38a26e32bf9d0b4bc758fd60df6a4811203dd29269dccb225b0332e39b7a"

URI_x86_64_v2_rust-cookie+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+hmac-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+hmac-devel}"
SRC_URI[x86_64_v2_rust-cookie+hmac-devel.sha256sum] = "1f3169a80bdf8d5f07eebe574b9aad7bb8c84d0bac777e657d2234c4a75e3c05"

URI_x86_64_v2_rust-cookie+key-expansion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+key-expansion-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+key-expansion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+key-expansion-devel}"
SRC_URI[x86_64_v2_rust-cookie+key-expansion-devel.sha256sum] = "a4436b910bb089c9266e0ff5dc990dcbb65f7fd0ce2005f69b62783d588dba9d"

URI_x86_64_v2_rust-cookie+percent-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+percent-encode-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+percent-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+percent-encode-devel}"
SRC_URI[x86_64_v2_rust-cookie+percent-encode-devel.sha256sum] = "476720b2e64306e948539a2fd1c40e74596dbb599893d3d94eee235d26810628"

URI_x86_64_v2_rust-cookie+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+percent-encoding-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-cookie+percent-encoding-devel.sha256sum] = "1bc877fc530e57a5f87a0346943d4ac4dfcc24f6a710ffd447b99716d40c5a7e"

URI_x86_64_v2_rust-cookie+private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+private-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+private-devel}"
SRC_URI[x86_64_v2_rust-cookie+private-devel.sha256sum] = "b3edb7e9f61cd20671ac9123f7cb04d74a70b81147defd5e3617afec3ed0a146"

URI_x86_64_v2_rust-cookie+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+rand-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+rand-devel}"
SRC_URI[x86_64_v2_rust-cookie+rand-devel.sha256sum] = "a1c6c5cfdaf6e971ad7f01a9efe15853c954e3769338c191a530a6181f45bbee"

URI_x86_64_v2_rust-cookie+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+secure-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+secure-devel}"
SRC_URI[x86_64_v2_rust-cookie+secure-devel.sha256sum] = "d91ea918f81226201fcae99b6680f5076633daba1be14ec80704a38312839ffa"

URI_x86_64_v2_rust-cookie+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+sha2-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+sha2-devel}"
SRC_URI[x86_64_v2_rust-cookie+sha2-devel.sha256sum] = "6e9fd80852fc43ec36aa53ebc3eda08619d36f25cc1f5c902f2975c132b7e110"

URI_x86_64_v2_rust-cookie+signed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+signed-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+signed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+signed-devel}"
SRC_URI[x86_64_v2_rust-cookie+signed-devel.sha256sum] = "eec944b0ab2e88fa570e1c7cc94276089301cf14fa3a9532f2cd004daaa09545"

URI_x86_64_v2_rust-cookie+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+subtle-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+subtle-devel}"
SRC_URI[x86_64_v2_rust-cookie+subtle-devel.sha256sum] = "f1f9eacc53d88299257438f1a6bd5ad00af1b950861cf96099f7747c84659caf"

URI_x86_64_v2_rust-cookie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-devel-0.18.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-devel}"
SRC_URI[x86_64_v2_rust-cookie-devel.sha256sum] = "acbeaa6b4bd28c091ff672b704df875b019a91087423fffc6bfac5e679176f3b"

URI_aarch64_rust-cookie+aes-gcm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+aes-gcm-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+aes-gcm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+aes-gcm-devel}"
SRC_URI[aarch64_rust-cookie+aes-gcm-devel.sha256sum] = "f00e3f1db0db50964b26b6dd85931d9425fd234a32815ee26b5db7b00f69c7bf"

URI_aarch64_rust-cookie+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+base64-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+base64-devel}"
SRC_URI[aarch64_rust-cookie+base64-devel.sha256sum] = "9894b76bd1618fea027f1455b6cd9919d713e2c2518ed60df99cc6656a8bc92c"

URI_aarch64_rust-cookie+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+default-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+default-devel}"
SRC_URI[aarch64_rust-cookie+default-devel.sha256sum] = "935e21b91bcfc75d65a06e4fd10979978c0aea12d9d63a88d06b35e521426448"

URI_aarch64_rust-cookie+hkdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+hkdf-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+hkdf-devel}"
SRC_URI[aarch64_rust-cookie+hkdf-devel.sha256sum] = "a05de855756e022e9d220db64c0b39971bde450fc00e1e6ccf8660fb6fc5afb9"

URI_aarch64_rust-cookie+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+hmac-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+hmac-devel}"
SRC_URI[aarch64_rust-cookie+hmac-devel.sha256sum] = "6262ce82efa31eafe5aed98deca9bf72d59b893435a26b66d1f73a53e63e66e2"

URI_aarch64_rust-cookie+key-expansion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+key-expansion-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+key-expansion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+key-expansion-devel}"
SRC_URI[aarch64_rust-cookie+key-expansion-devel.sha256sum] = "0c8c4df23028b952dd1132c2071bf7abcc0d1818a8c4073117071de3a4e6d3dc"

URI_aarch64_rust-cookie+percent-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+percent-encode-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+percent-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+percent-encode-devel}"
SRC_URI[aarch64_rust-cookie+percent-encode-devel.sha256sum] = "a3b2bd6ced59664f4ffa14c79634e7e04ba31fa505814c83aaa06b86b21a71ff"

URI_aarch64_rust-cookie+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+percent-encoding-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+percent-encoding-devel}"
SRC_URI[aarch64_rust-cookie+percent-encoding-devel.sha256sum] = "2d8da6bbb438b6b97a34022e54afa52b85f5cde2d7769f0643a3b35057c77dcc"

URI_aarch64_rust-cookie+private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+private-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+private-devel}"
SRC_URI[aarch64_rust-cookie+private-devel.sha256sum] = "0429f0fb44bdcc7d9a7e40fb02f86d07d81ba12bb9936577cc4c4f16ed536679"

URI_aarch64_rust-cookie+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+rand-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+rand-devel}"
SRC_URI[aarch64_rust-cookie+rand-devel.sha256sum] = "1dc65cd643bb26c07354efcc53db79360a169c593b8fe017b83b87bf10de2d6b"

URI_aarch64_rust-cookie+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+secure-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+secure-devel}"
SRC_URI[aarch64_rust-cookie+secure-devel.sha256sum] = "128929e4e47a4165d3a152fb03b356b569e086de0b3fdb32b3746cef492a373e"

URI_aarch64_rust-cookie+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+sha2-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+sha2-devel}"
SRC_URI[aarch64_rust-cookie+sha2-devel.sha256sum] = "6439f8673efb66705471a90e6c79629d4af41821f414ac1b40ff5d41e480fd9c"

URI_aarch64_rust-cookie+signed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+signed-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+signed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+signed-devel}"
SRC_URI[aarch64_rust-cookie+signed-devel.sha256sum] = "2a6eef1f8edf8071cde8c9d84e85e8855a6a6f8044428b8ab6c0902ecf4d947a"

URI_aarch64_rust-cookie+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+subtle-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+subtle-devel}"
SRC_URI[aarch64_rust-cookie+subtle-devel.sha256sum] = "fa1d25214170b8c099d9bbf6b1086b1936b67129d47bde5ecf43e2a462be522c"

URI_aarch64_rust-cookie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-devel-0.18.2-1.el10_3.noarch.rpm;name=aarch64_rust-cookie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-devel}"
SRC_URI[aarch64_rust-cookie-devel.sha256sum] = "f215bd10fb716cc1e1cae2d9acd349108ebca1cbc1dbb757b6535eddb9564949"

RDEPENDS:rust-cookie+aes-gcm-devel = " \
 cargo \
 rust-aes-gcm+default-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+base64-devel = " \
 cargo \
 rust-base64_0.22+default-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+default-devel = " \
 cargo \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+hkdf-devel = " \
 cargo \
 rust-cookie-devel \
 rust-hkdf0.12+default-devel \
 "
RDEPENDS:rust-cookie+hmac-devel = " \
 cargo \
 rust-cookie-devel \
 rust-hmac0.12+default-devel \
 "
RDEPENDS:rust-cookie+key-expansion-devel = " \
 cargo \
 rust-cookie+hkdf-devel \
 rust-cookie+sha2-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+percent-encode-devel = " \
 cargo \
 rust-cookie+percent-encoding-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+percent-encoding-devel = " \
 cargo \
 rust-cookie-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-cookie+private-devel = " \
 cargo \
 rust-cookie+aes-gcm-devel \
 rust-cookie+base64-devel \
 rust-cookie+rand-devel \
 rust-cookie+subtle-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+rand-devel = " \
 cargo \
 rust-cookie-devel \
 rust-rand0.8+default-devel \
 "
RDEPENDS:rust-cookie+secure-devel = " \
 cargo \
 rust-cookie+key-expansion-devel \
 rust-cookie+private-devel \
 rust-cookie+signed-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+sha2-devel = " \
 cargo \
 rust-cookie-devel \
 rust-sha2_0.10+default-devel \
 "
RDEPENDS:rust-cookie+signed-devel = " \
 cargo \
 rust-cookie+base64-devel \
 rust-cookie+hmac-devel \
 rust-cookie+rand-devel \
 rust-cookie+sha2-devel \
 rust-cookie+subtle-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+subtle-devel = " \
 cargo \
 rust-cookie-devel \
 rust-subtle+default-devel \
 "
RDEPENDS:rust-cookie-devel = " \
 bash \
 cargo \
 rust \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 rust-time+std-devel \
 rust-time-devel \
 rust-version_check+default-devel \
 "
