# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-API"
PV = "0.010"
PR = "17.el10_0"
PACKAGES = " \
 perl-Test-API \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Test-API-0.010-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "372501427db6b250ca4c3fecbbb5976a9a09a02d7bd1adfd6f2415a0bf121a39"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-API-0.010-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-API;unpack=0"
SRC_URI[x86_64_v2_perl-Test-API.sha256sum] = "49ed8b980c33d2b22c038b566084ce75b22f7ebc37978ac34a1e0e81d5408f81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-API-0.010-17.el10_0.noarch.rpm;name=aarch64_perl-Test-API;unpack=0"
SRC_URI[aarch64_perl-Test-API.sha256sum] = "1239860a14af574de944cf0ece7bc006078e8e59a62dbaeca8cd9bbcc21dc3ac"

RDEPENDS:perl-Test-API = " \
 perl-Symbol \
 perl-Test-Simple \
 perl-libs \
 "
