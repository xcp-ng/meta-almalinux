# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmime"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmime \
 kmime-devel \
 kmime-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmime-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b6ef4db319e1c59b2a6deca671fc56a1f222d2ec122004711f08ff3a667793f"

URI_x86_64_v2_kmime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime}"
SRC_URI[x86_64_v2_kmime.sha256sum] = "3e8687e2864b9abc7dd0a3bde4e453da7a7d96a9080059c7a0d1cd1579113842"

URI_x86_64_v2_kmime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime-devel}"
SRC_URI[x86_64_v2_kmime-devel.sha256sum] = "f4333aa8fa840ee81f1c0a705dc71197fa93e95058679ac32af0ef2d1495d750"

URI_x86_64_v2_kmime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-doc-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kmime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime-doc}"
SRC_URI[x86_64_v2_kmime-doc.sha256sum] = "735a2ca0dd53da73138a2c0bed522f2591de44583d6e630580a8351dbf534bad"

URI_aarch64_kmime = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime}"
SRC_URI[aarch64_kmime.sha256sum] = "677d16fc4bec6acea1c5110c18c30b593c74cbe6d8c74855f45610c4e20d7ca4"

URI_aarch64_kmime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime-devel}"
SRC_URI[aarch64_kmime-devel.sha256sum] = "3cf564c559f3d582e93cc7d44fab0acbde8bf5dabb0546dd1748de307217f6bd"

URI_aarch64_kmime-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-doc-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kmime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime-doc}"
SRC_URI[aarch64_kmime-doc.sha256sum] = "f223cff33400668b9f2b97b044e0f293df63e23b65b8e485c9d40496babf54c4"

RDEPENDS:kmime = " \
 glibc \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kmime-devel = " \
 boost-devel \
 cmake-filesystem \
 kf6-kcodecs-devel \
 kmime \
 "
RDEPENDS:kmime-doc = " \
 "
