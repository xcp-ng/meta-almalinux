# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Perl-Critic-Pulp"
PV = "99"
PR = "7.el10_0"
PACKAGES = " \
 perl-Perl-Critic-Pulp \
 perl-Perl-Critic-Pulp-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Perl-Critic-Pulp-99-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0a5a47c59ecabd594b46f2742ac93b1ed78a3e78838babfc46f1ec1e3889708"

URI_x86_64_v2_perl-Perl-Critic-Pulp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl-Critic-Pulp-99-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Perl-Critic-Pulp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl-Critic-Pulp}"
SRC_URI[x86_64_v2_perl-Perl-Critic-Pulp.sha256sum] = "e26283c24aca3ab3b5cf37927a5909cf2e8047e3f35f8463af6341f047ae3898"

URI_x86_64_v2_perl-Perl-Critic-Pulp-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Perl-Critic-Pulp-tests-99-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Perl-Critic-Pulp-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Perl-Critic-Pulp-tests}"
SRC_URI[x86_64_v2_perl-Perl-Critic-Pulp-tests.sha256sum] = "6bd800cd88660485a4bd8255aea15971bb580acf95b96287989f2401d430c654"

URI_aarch64_perl-Perl-Critic-Pulp = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl-Critic-Pulp-99-7.el10_0.noarch.rpm;name=aarch64_perl-Perl-Critic-Pulp;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl-Critic-Pulp}"
SRC_URI[aarch64_perl-Perl-Critic-Pulp.sha256sum] = "ef835a1a3ed3bb7260a157e67359c0ea18aabbb32353c96ae7bbb7dbf11a451c"

URI_aarch64_perl-Perl-Critic-Pulp-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Perl-Critic-Pulp-tests-99-7.el10_0.noarch.rpm;name=aarch64_perl-Perl-Critic-Pulp-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Perl-Critic-Pulp-tests}"
SRC_URI[aarch64_perl-Perl-Critic-Pulp-tests.sha256sum] = "c7ab2c339b42c0affa519cc714ac826ad222bb4c597c33d1e41a76cd6e871796"

RDEPENDS:perl-Perl-Critic-Pulp = " \
 perl-Exporter \
 perl-IO-String \
 perl-List-MoreUtils \
 perl-POSIX \
 perl-PPI \
 perl-Perl-Critic \
 perl-Perl-Critic-Pulp \
 perl-Pod-Escapes \
 perl-Pod-MinimumVersion \
 perl-Pod-Parser \
 perl-Scalar-List-Utils \
 perl-Test-Simple \
 perl-base \
 perl-constant \
 perl-libs \
 perl-podlators \
 perl-vars \
 perl-version \
 "
RDEPENDS:perl-Perl-Critic-Pulp-tests = " \
 bash \
 perl-Data-Dumper \
 perl-PPI \
 perl-Perl-Critic \
 perl-Perl-Critic-Pulp \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-version \
 "
