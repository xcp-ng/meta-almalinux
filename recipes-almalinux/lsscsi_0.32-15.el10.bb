# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lsscsi"
PV = "0.32"
PR = "15.el10"
PACKAGES = " \
 lsscsi \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lsscsi-0.32-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fc16eb5a1ad48c82e5c73cf072455a9a585fffa31d0a538afc89801706fde57"

URI_x86_64_v2_lsscsi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lsscsi-0.32-15.el10.x86_64_v2.rpm;name=x86_64_v2_lsscsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsscsi}"
SRC_URI[x86_64_v2_lsscsi.sha256sum] = "74d2c9f23cd9fe224636a071f1fe33c985ff28e25f51652600a4673b73cc2fee"

URI_aarch64_lsscsi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lsscsi-0.32-15.el10.aarch64.rpm;name=aarch64_lsscsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsscsi}"
SRC_URI[aarch64_lsscsi.sha256sum] = "98281ad5a5ed4dadc2b90a1b25843588377f182916931fe5dc1782e368603c35"

RDEPENDS:lsscsi = " \
 glibc \
 "
