# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-document-features"
PV = "0.2.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-document-features+default-devel \
 rust-document-features+self-test-devel \
 rust-document-features-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-document-features-0.2.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94a86817c12c11d295eb010224d4ab29b875cd12474d1b7eb38ac235b574cc6a"

URI_x86_64_v2_rust-document-features+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-document-features+default-devel-0.2.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-document-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-document-features+default-devel}"
SRC_URI[x86_64_v2_rust-document-features+default-devel.sha256sum] = "cf64015dcdddd7eabc0f9b1b06aa462096982c6afbcbb7a6202d8819107949e6"

URI_x86_64_v2_rust-document-features+self-test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-document-features+self-test-devel-0.2.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-document-features+self-test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-document-features+self-test-devel}"
SRC_URI[x86_64_v2_rust-document-features+self-test-devel.sha256sum] = "8694fee4700a4030058a2324974e2ab510166aaa1fe9a7cfd800cf1c97f69869"

URI_x86_64_v2_rust-document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-document-features-devel-0.2.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-document-features-devel}"
SRC_URI[x86_64_v2_rust-document-features-devel.sha256sum] = "071b350161ab72b5b2af2cc6dfede1e7c16ba0bed33dea866a0781ba2270dccd"

URI_aarch64_rust-document-features+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-document-features+default-devel-0.2.11-1.el10_1.noarch.rpm;name=aarch64_rust-document-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-document-features+default-devel}"
SRC_URI[aarch64_rust-document-features+default-devel.sha256sum] = "3d72c9424777d174b7a89426e33c5dbdfe0ea15338cb35a022e2f0fabe7ba3a4"

URI_aarch64_rust-document-features+self-test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-document-features+self-test-devel-0.2.11-1.el10_1.noarch.rpm;name=aarch64_rust-document-features+self-test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-document-features+self-test-devel}"
SRC_URI[aarch64_rust-document-features+self-test-devel.sha256sum] = "e54c6e051dd820035765a550fbad667ca7b30569d8360a02ec47fd9c9630ef93"

URI_aarch64_rust-document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-document-features-devel-0.2.11-1.el10_1.noarch.rpm;name=aarch64_rust-document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-document-features-devel}"
SRC_URI[aarch64_rust-document-features-devel.sha256sum] = "6a50fe2370594a8cdaad244b41be1c94ca24829c58fc9df9c0bcab3a54a059c1"

RDEPENDS:rust-document-features+default-devel = " \
 cargo \
 rust-document-features-devel \
 "
RDEPENDS:rust-document-features+self-test-devel = " \
 cargo \
 rust-document-features-devel \
 "
RDEPENDS:rust-document-features-devel = " \
 cargo \
 rust-litrs-devel \
 "
