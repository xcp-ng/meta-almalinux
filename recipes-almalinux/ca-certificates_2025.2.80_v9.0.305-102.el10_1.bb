# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ca-certificates"
PV = "2025.2.80_v9.0.305"
PR = "102.el10_1"
PACKAGES = " \
 ca-certificates \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac36c829b0c2ab56a29f54903f38a84527b002d2efc38c08ba58f074145a17ed"

URI_x86_64_v2_ca-certificates = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10_1.noarch.rpm;name=x86_64_v2_ca-certificates;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ca-certificates}"
SRC_URI[x86_64_v2_ca-certificates.sha256sum] = "6b4b153b35901ac27e57d41b1ec98f7754c0642d361e782dde5f9ba6765fda2d"

URI_aarch64_ca-certificates = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ca-certificates-2025.2.80_v9.0.305-102.el10_1.noarch.rpm;name=aarch64_ca-certificates;unpack=0"
SRC_URI:append = " ${URI_aarch64_ca-certificates}"
SRC_URI[aarch64_ca-certificates.sha256sum] = "6b4b153b35901ac27e57d41b1ec98f7754c0642d361e782dde5f9ba6765fda2d"

RDEPENDS:ca-certificates = " \
 bash \
 findutils \
 grep \
 libffi \
 p11-kit-trust \
 sed \
 virtual/coreutils \
 "
