# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdk-pixbuf2-modules-extra"
PV = "2.42.12"
PR = "2.el10_0"
PACKAGES = " \
 gdk-pixbuf2-modules-extra \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gdk-pixbuf2-modules-extra-2.42.12-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8cf15a0f60843a28c319fd09702a1ba5d190c15b6108ab5c2cfb6923f1737b4"

URI_x86_64_v2_gdk-pixbuf2-modules-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gdk-pixbuf2-modules-extra-2.42.12-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-modules-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2-modules-extra}"
SRC_URI[x86_64_v2_gdk-pixbuf2-modules-extra.sha256sum] = "9ee82b9ce243da79f5cc0a9511cb143861d94ab9fdd33b8010eaf2105acdc553"

URI_aarch64_gdk-pixbuf2-modules-extra = "${EPEL_MIRROR}/aarch64/Packages/g/gdk-pixbuf2-modules-extra-2.42.12-2.el10_0.aarch64.rpm;name=aarch64_gdk-pixbuf2-modules-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2-modules-extra}"
SRC_URI[aarch64_gdk-pixbuf2-modules-extra.sha256sum] = "d24c105b68a674558a7f0eb1ca92e0fdec12b24567e283063ff1e5d2677c2028"

RDEPENDS:gdk-pixbuf2-modules-extra = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 "
