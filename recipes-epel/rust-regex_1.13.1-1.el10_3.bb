# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-regex"
PV = "1.13.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-regex+default-devel \
 rust-regex+logging-devel \
 rust-regex+pattern-devel \
 rust-regex+perf-backtrack-devel \
 rust-regex+perf-cache-devel \
 rust-regex+perf-devel \
 rust-regex+perf-dfa-devel \
 rust-regex+perf-dfa-full-devel \
 rust-regex+perf-inline-devel \
 rust-regex+perf-literal-devel \
 rust-regex+perf-onepass-devel \
 rust-regex+std-devel \
 rust-regex+unicode-age-devel \
 rust-regex+unicode-bool-devel \
 rust-regex+unicode-case-devel \
 rust-regex+unicode-devel \
 rust-regex+unicode-gencat-devel \
 rust-regex+unicode-perl-devel \
 rust-regex+unicode-script-devel \
 rust-regex+unicode-segment-devel \
 rust-regex+unstable-devel \
 rust-regex+use_std-devel \
 rust-regex-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-regex-1.13.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba51ad411547a2c314be138dd93cf74419b8c0bd85efe981dff46d86e32fc911"

URI_x86_64_v2_rust-regex+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+default-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+default-devel}"
SRC_URI[x86_64_v2_rust-regex+default-devel.sha256sum] = "5b60a7a3e57aeaa4dad0517dd423857029d96f8b1e037a23774bcf464bea0409"

URI_x86_64_v2_rust-regex+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+logging-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+logging-devel}"
SRC_URI[x86_64_v2_rust-regex+logging-devel.sha256sum] = "f76f4ed67f8f0b83526c4f12fe4d2609e5acb0a17bbd4bdfd2beebef0d179053"

URI_x86_64_v2_rust-regex+pattern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+pattern-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+pattern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+pattern-devel}"
SRC_URI[x86_64_v2_rust-regex+pattern-devel.sha256sum] = "8aecd9976b3b025f9de7d02a803cac2d6f9f500e34ede38f2623f984c35bd244"

URI_x86_64_v2_rust-regex+perf-backtrack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-backtrack-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-backtrack-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-backtrack-devel.sha256sum] = "730bbaec93b6329404c2f3b8ca6547d38f72f8a05668316296164aa5a1b6a2b9"

URI_x86_64_v2_rust-regex+perf-cache-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-cache-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-cache-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-cache-devel.sha256sum] = "2a0378341cd5e9648babb9a58d0576dc595c032aad7fa6c484fa6e632cd2f4e6"

URI_x86_64_v2_rust-regex+perf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-devel.sha256sum] = "9279849ef928489d0ec6826c0168079b17a4e9a964c05a090e8d10097cf20274"

URI_x86_64_v2_rust-regex+perf-dfa-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-dfa-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-dfa-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-dfa-devel.sha256sum] = "348e9dd13a4d0b223ee17a09f9b35b457006b582e6d0509e853bad2e336d9aa9"

URI_x86_64_v2_rust-regex+perf-dfa-full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-dfa-full-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-dfa-full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-dfa-full-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-dfa-full-devel.sha256sum] = "24cd99371ed22a0c47c0a0fe047122e707388c9581d742d2fa9989ea0bbbbfa9"

URI_x86_64_v2_rust-regex+perf-inline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-inline-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-inline-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-inline-devel.sha256sum] = "89586d4f522ac7c9a6aa4d9b7c00de59361950e647959435479907a3bc581831"

URI_x86_64_v2_rust-regex+perf-literal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-literal-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-literal-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-literal-devel.sha256sum] = "e04dcb5fdf26c35a3ef87c945bb626fb4a12f5a8d8b9deaaff25c48ec3400323"

URI_x86_64_v2_rust-regex+perf-onepass-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+perf-onepass-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+perf-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+perf-onepass-devel}"
SRC_URI[x86_64_v2_rust-regex+perf-onepass-devel.sha256sum] = "c9755684e025ad94be6c12d1c67e5d8a366a43d5bbbf2e886ef80cdc55eae400"

URI_x86_64_v2_rust-regex+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+std-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+std-devel}"
SRC_URI[x86_64_v2_rust-regex+std-devel.sha256sum] = "38bc747c2b0f3eda6a79fa1e20f2942eaadaa2058cbbdbb61fe3e3790be9297c"

URI_x86_64_v2_rust-regex+unicode-age-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-age-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-age-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-age-devel.sha256sum] = "a59e7b4929f9d43a28e92fb3fa85eacd1f33436322df42599ed319f8135381b2"

URI_x86_64_v2_rust-regex+unicode-bool-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-bool-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-bool-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-bool-devel.sha256sum] = "6357fbc3a47540ca9a3fc2ba73e91fd1e98ebc1c1be308320f3e7c481eeb703f"

URI_x86_64_v2_rust-regex+unicode-case-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-case-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-case-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-case-devel.sha256sum] = "5048b335ad3d3280a7bb91a73439e04d130cbbe63bfc6c18a315d1a48ad68694"

URI_x86_64_v2_rust-regex+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-devel.sha256sum] = "36f605c13558dbb76436cb79ad3b4f698cba6342cde1bf4e14f476ec7dadb1ca"

URI_x86_64_v2_rust-regex+unicode-gencat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-gencat-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-gencat-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-gencat-devel.sha256sum] = "23568da5500f5e71f5e215197b75c55e35c6bb6fd3137212a41969754c116bf6"

URI_x86_64_v2_rust-regex+unicode-perl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-perl-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-perl-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-perl-devel.sha256sum] = "b8377734b1757dcf119628c8545f2aa828c8a458e6ca687433c2aa2babfa43b5"

URI_x86_64_v2_rust-regex+unicode-script-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-script-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-script-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-script-devel.sha256sum] = "b6790308a1c80687ad692208e9207598091a4ae1b04ca06ed77bdd0568919e7e"

URI_x86_64_v2_rust-regex+unicode-segment-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unicode-segment-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unicode-segment-devel}"
SRC_URI[x86_64_v2_rust-regex+unicode-segment-devel.sha256sum] = "3859b927d3569aab908427e094e40f2662cfc9570c7ced68c793b70305d6a8ae"

URI_x86_64_v2_rust-regex+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+unstable-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+unstable-devel}"
SRC_URI[x86_64_v2_rust-regex+unstable-devel.sha256sum] = "294eb75ed4e4325ae535d2ee987959dbf6470bbc97889a687d458477bd762183"

URI_x86_64_v2_rust-regex+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex+use_std-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex+use_std-devel}"
SRC_URI[x86_64_v2_rust-regex+use_std-devel.sha256sum] = "38efab4f4018f1ab07c0860aa6c89edd8b838408f914f5d1283fd67dd020cc7d"

URI_x86_64_v2_rust-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-regex-devel-1.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-regex-devel}"
SRC_URI[x86_64_v2_rust-regex-devel.sha256sum] = "76c52bfc7a047f4176c00d431d87735c47a6a416720acff3988d1afc76a3e227"

URI_aarch64_rust-regex+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+default-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+default-devel}"
SRC_URI[aarch64_rust-regex+default-devel.sha256sum] = "e217a9a8973eaf619f483718710d0da32c056dc2ac0482a0163597f236c5a43e"

URI_aarch64_rust-regex+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+logging-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+logging-devel}"
SRC_URI[aarch64_rust-regex+logging-devel.sha256sum] = "3ed08cb3cba936cd97dda2ff1a8baa99d02881a69911d5473f2dea7fdfcdbdcf"

URI_aarch64_rust-regex+pattern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+pattern-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+pattern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+pattern-devel}"
SRC_URI[aarch64_rust-regex+pattern-devel.sha256sum] = "88f478f208b229d284b54e37ba0f466143cfa7f81369fc73b65aad0b78301404"

URI_aarch64_rust-regex+perf-backtrack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-backtrack-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+perf-backtrack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-backtrack-devel}"
SRC_URI[aarch64_rust-regex+perf-backtrack-devel.sha256sum] = "fb95e82640fbc0a52131349f2174e8cceeed7a6e1192dbd3a01d11bba12092e9"

URI_aarch64_rust-regex+perf-cache-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-cache-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+perf-cache-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-cache-devel}"
SRC_URI[aarch64_rust-regex+perf-cache-devel.sha256sum] = "524d8511f3ebf3ba50a2d958e64a0f892421819b977345911f82708ef55968f8"

URI_aarch64_rust-regex+perf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+perf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-devel}"
SRC_URI[aarch64_rust-regex+perf-devel.sha256sum] = "43c964c5ec9f4caa4ce6f50b5e473451f99bf8516515b5e63acff1d3f0a7c083"

URI_aarch64_rust-regex+perf-dfa-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-dfa-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+perf-dfa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-dfa-devel}"
SRC_URI[aarch64_rust-regex+perf-dfa-devel.sha256sum] = "2e11c41613cec7488c70c4e67c024eb34150cda44aa9a16d25670c4ccba59da6"

URI_aarch64_rust-regex+perf-dfa-full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-dfa-full-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+perf-dfa-full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-dfa-full-devel}"
SRC_URI[aarch64_rust-regex+perf-dfa-full-devel.sha256sum] = "14bb532f14ac2478143b3b25b522ba34e7cb7f7238323b2befa65053a024a5e6"

URI_aarch64_rust-regex+perf-inline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-inline-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+perf-inline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-inline-devel}"
SRC_URI[aarch64_rust-regex+perf-inline-devel.sha256sum] = "7c722790bffeb4d6794a91543e8293812b52efc9ccccb98b7b29bff72e15ca41"

URI_aarch64_rust-regex+perf-literal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-literal-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+perf-literal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-literal-devel}"
SRC_URI[aarch64_rust-regex+perf-literal-devel.sha256sum] = "f1e7cfa1ff61da4b7a163634786b2eed8efd40feaef6b0fdd632f9076bbd7e2a"

URI_aarch64_rust-regex+perf-onepass-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+perf-onepass-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+perf-onepass-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+perf-onepass-devel}"
SRC_URI[aarch64_rust-regex+perf-onepass-devel.sha256sum] = "ca45436305053fb2a300671bca6bb8af1234b35f3e6faf0d9fe0863e719af867"

URI_aarch64_rust-regex+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+std-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+std-devel}"
SRC_URI[aarch64_rust-regex+std-devel.sha256sum] = "a8235ea71245000b0816be4a8f59465208d209b120e33ea872baf1b6e5a22efb"

URI_aarch64_rust-regex+unicode-age-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-age-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+unicode-age-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-age-devel}"
SRC_URI[aarch64_rust-regex+unicode-age-devel.sha256sum] = "e08710e434b27025555956c2db23b179c70cf5d8bff8c0a13431dc201afffc54"

URI_aarch64_rust-regex+unicode-bool-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-bool-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+unicode-bool-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-bool-devel}"
SRC_URI[aarch64_rust-regex+unicode-bool-devel.sha256sum] = "90a38f3ead90262322ac0f8b0d321a5c2fbc10538bd5a982f79557693d90d2e7"

URI_aarch64_rust-regex+unicode-case-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-case-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+unicode-case-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-case-devel}"
SRC_URI[aarch64_rust-regex+unicode-case-devel.sha256sum] = "43667abfde46481f76f190c8ae0cca1056472fc513a7516f9a8555ce8a8182ce"

URI_aarch64_rust-regex+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-devel}"
SRC_URI[aarch64_rust-regex+unicode-devel.sha256sum] = "223a94394f8cd3d53cede62db946a65edd73985e7dd230bf9c662c5d54ac9c85"

URI_aarch64_rust-regex+unicode-gencat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-gencat-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+unicode-gencat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-gencat-devel}"
SRC_URI[aarch64_rust-regex+unicode-gencat-devel.sha256sum] = "1185318b73fbf6d527ebeaa9040fbfca1a6cf1d25d950b4f6c694ec9000c1af0"

URI_aarch64_rust-regex+unicode-perl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-perl-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+unicode-perl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-perl-devel}"
SRC_URI[aarch64_rust-regex+unicode-perl-devel.sha256sum] = "4cc8108ce4ef2447a2041a748a8e5e3bd21de07237f00ac8db0fa324e4bf793c"

URI_aarch64_rust-regex+unicode-script-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-script-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+unicode-script-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-script-devel}"
SRC_URI[aarch64_rust-regex+unicode-script-devel.sha256sum] = "8ec88765d344dbe55d97cc5f6bc4a6c1302748dbba3ebeed9f88916138630b6b"

URI_aarch64_rust-regex+unicode-segment-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unicode-segment-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+unicode-segment-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unicode-segment-devel}"
SRC_URI[aarch64_rust-regex+unicode-segment-devel.sha256sum] = "7e8ec1c2bafecb4890fc025e4fad980c7c02a7bb518e9b5fc3b3b04782564cb6"

URI_aarch64_rust-regex+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+unstable-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+unstable-devel}"
SRC_URI[aarch64_rust-regex+unstable-devel.sha256sum] = "e53b909b095a59f24bb234cb6ceb235fd6a41bbf862bba0180b0f7f1f169a0a6"

URI_aarch64_rust-regex+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex+use_std-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex+use_std-devel}"
SRC_URI[aarch64_rust-regex+use_std-devel.sha256sum] = "b563d2600e90f85709b47c9e63af60c48cc6d839cc2574c6935f7ed68b938f2a"

URI_aarch64_rust-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-regex-devel-1.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-regex-devel}"
SRC_URI[aarch64_rust-regex-devel.sha256sum] = "165e7591f49f742ac0f2b33ef3c94bd18dcc2fe3fec3f0d0e3251fe8eb45c82e"

RDEPENDS:rust-regex+default-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax+default-devel \
 "
RDEPENDS:rust-regex+logging-devel = " \
 cargo \
 rust-aho-corasick+logging-devel \
 rust-aho-corasick-devel \
 rust-memchr+logging-devel \
 rust-memchr-devel \
 rust-regex-automata+logging-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+pattern-devel = " \
 cargo \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-backtrack-devel = " \
 cargo \
 rust-regex-automata+nfa-backtrack-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-cache-devel = " \
 cargo \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-devel = " \
 cargo \
 rust-regex+perf-backtrack-devel \
 rust-regex+perf-cache-devel \
 rust-regex+perf-dfa-devel \
 rust-regex+perf-inline-devel \
 rust-regex+perf-literal-devel \
 rust-regex+perf-onepass-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-dfa-devel = " \
 cargo \
 rust-regex-automata+hybrid-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-dfa-full-devel = " \
 cargo \
 rust-regex-automata+dfa-build-devel \
 rust-regex-automata+dfa-search-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-inline-devel = " \
 cargo \
 rust-regex-automata+perf-inline-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-literal-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-memchr-devel \
 rust-regex-automata+perf-literal-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+perf-onepass-devel = " \
 cargo \
 rust-regex-automata+dfa-onepass-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+std-devel = " \
 cargo \
 rust-aho-corasick+std-devel \
 rust-aho-corasick-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-regex-automata+std-devel \
 rust-regex-devel \
 rust-regex-syntax+std-devel \
 "
RDEPENDS:rust-regex+unicode-age-devel = " \
 cargo \
 rust-regex-automata+unicode-age-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-age-devel \
 "
RDEPENDS:rust-regex+unicode-bool-devel = " \
 cargo \
 rust-regex-automata+unicode-bool-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-bool-devel \
 "
RDEPENDS:rust-regex+unicode-case-devel = " \
 cargo \
 rust-regex-automata+unicode-case-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-case-devel \
 "
RDEPENDS:rust-regex+unicode-devel = " \
 cargo \
 rust-regex+unicode-age-devel \
 rust-regex+unicode-bool-devel \
 rust-regex+unicode-case-devel \
 rust-regex+unicode-gencat-devel \
 rust-regex+unicode-perl-devel \
 rust-regex+unicode-script-devel \
 rust-regex+unicode-segment-devel \
 rust-regex-automata+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-devel \
 "
RDEPENDS:rust-regex+unicode-gencat-devel = " \
 cargo \
 rust-regex-automata+unicode-gencat-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-gencat-devel \
 "
RDEPENDS:rust-regex+unicode-perl-devel = " \
 cargo \
 rust-regex-automata+unicode-perl-devel \
 rust-regex-automata+unicode-word-boundary-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-perl-devel \
 "
RDEPENDS:rust-regex+unicode-script-devel = " \
 cargo \
 rust-regex-automata+unicode-script-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-script-devel \
 "
RDEPENDS:rust-regex+unicode-segment-devel = " \
 cargo \
 rust-regex-automata+unicode-segment-devel \
 rust-regex-devel \
 rust-regex-syntax+unicode-segment-devel \
 "
RDEPENDS:rust-regex+unstable-devel = " \
 cargo \
 rust-regex+pattern-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex+use_std-devel = " \
 cargo \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-regex-devel = " \
 cargo \
 rust \
 rust-regex-automata+alloc-devel \
 rust-regex-automata+meta-devel \
 rust-regex-automata+nfa-pikevm-devel \
 rust-regex-automata+syntax-devel \
 rust-regex-automata-devel \
 rust-regex-syntax-devel \
 "
