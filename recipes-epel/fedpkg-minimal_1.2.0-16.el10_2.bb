# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedpkg-minimal"
PV = "1.2.0"
PR = "16.el10_2"
PACKAGES = " \
 fedpkg-minimal \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedpkg-minimal-1.2.0-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff0e05a341946df8fc57a3ce4a4177d12ee1cf8e1390bffe36b37125564930fb"

URI_x86_64_v2_fedpkg-minimal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedpkg-minimal-1.2.0-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_fedpkg-minimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedpkg-minimal}"
SRC_URI[x86_64_v2_fedpkg-minimal.sha256sum] = "eae7a374d2ead48a6c060eec2271e80c935ec3983301b06f1a1f816c75e7cc20"

URI_aarch64_fedpkg-minimal = "${EPEL_MIRROR}/aarch64/Packages/f/fedpkg-minimal-1.2.0-16.el10_2.noarch.rpm;name=aarch64_fedpkg-minimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedpkg-minimal}"
SRC_URI[aarch64_fedpkg-minimal.sha256sum] = "baf6e231873650bb9e616542dfd175f029b27b267cf41b1c367be55bbed0427d"

RDEPENDS:fedpkg-minimal = " \
 bash \
 curl \
 "
