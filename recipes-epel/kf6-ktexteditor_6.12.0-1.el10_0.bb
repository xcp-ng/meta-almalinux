# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexteditor"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-ktexteditor \
 kf6-ktexteditor-devel \
 kf6-ktexteditor-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexteditor-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f3fa9ae5b49febc5774d1136ebd237833fcac5baa5af9789e636f16d329e9049"

URI_x86_64_v2_kf6-ktexteditor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor}"
SRC_URI[x86_64_v2_kf6-ktexteditor.sha256sum] = "265804ce54dc128e1269773894fe6093655c15b644b02fe1b60532452bac56e9"

URI_x86_64_v2_kf6-ktexteditor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor-devel}"
SRC_URI[x86_64_v2_kf6-ktexteditor-devel.sha256sum] = "a29bc47ede4c4659259740d2b6b7e72d87afd997e492ef1f1df0be4d8302be34"

URI_x86_64_v2_kf6-ktexteditor-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexteditor-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexteditor-doc}"
SRC_URI[x86_64_v2_kf6-ktexteditor-doc.sha256sum] = "280b8721c038055f9e23afcb0927c96ee78fd2d0dd40b5c6974353428ec3a1f0"

URI_aarch64_kf6-ktexteditor = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ktexteditor;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor}"
SRC_URI[aarch64_kf6-ktexteditor.sha256sum] = "c800be6a71450b4981f7c221fb347dc0c96758b0e555d6c9475a56bac1f83558"

URI_aarch64_kf6-ktexteditor-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-ktexteditor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor-devel}"
SRC_URI[aarch64_kf6-ktexteditor-devel.sha256sum] = "172b0396ae69bf11d93c3effb6569b241e07f52eeb3f3f6218311bf92d02084d"

URI_aarch64_kf6-ktexteditor-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-ktexteditor-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexteditor-doc}"
SRC_URI[aarch64_kf6-ktexteditor-doc.sha256sum] = "b0d8b77ad949015e032a3cb4490baefdc93930fb52fe20d873603adbaf2bc2ff"

RDEPENDS:kf6-ktexteditor = " \
 editorconfig-libs \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kauth \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
RDEPENDS:kf6-ktexteditor-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kf6-ktexteditor \
 kf6-syntax-highlighting-devel \
 "
RDEPENDS:kf6-ktexteditor-doc = " \
 "
