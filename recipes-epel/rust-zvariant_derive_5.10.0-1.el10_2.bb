# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zvariant_derive"
PV = "5.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-zvariant_derive+default-devel \
 rust-zvariant_derive+gvariant-devel \
 rust-zvariant_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zvariant_derive-5.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "526de48d8bc3ddde37e11b2d04cf65e8c5d72dc3f33e8602d30c0a6d4b8b2e45"

URI_x86_64_v2_rust-zvariant_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_derive+default-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_derive+default-devel}"
SRC_URI[x86_64_v2_rust-zvariant_derive+default-devel.sha256sum] = "ace4bc2bd96baf1cd89c296d2f82a433863069d1a5fa2c9fbaa72d2f92f4a77e"

URI_x86_64_v2_rust-zvariant_derive+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_derive+gvariant-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_derive+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_derive+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant_derive+gvariant-devel.sha256sum] = "6d8e393aeda55d8e3be2db09d34863cfe51aac954bdb4622fe13c22e8190f3cb"

URI_x86_64_v2_rust-zvariant_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_derive-devel-5.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_derive-devel}"
SRC_URI[x86_64_v2_rust-zvariant_derive-devel.sha256sum] = "2d6f91453bbb13ff12a3c5b8eaca5cb16c0503a286951eb676a75b224a2b247b"

URI_aarch64_rust-zvariant_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_derive+default-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_derive+default-devel}"
SRC_URI[aarch64_rust-zvariant_derive+default-devel.sha256sum] = "7eeb58c1361c5344dd6d6eb8ca876fb5a933266115ffdc819a42da96d902c8ab"

URI_aarch64_rust-zvariant_derive+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_derive+gvariant-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant_derive+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_derive+gvariant-devel}"
SRC_URI[aarch64_rust-zvariant_derive+gvariant-devel.sha256sum] = "a6b6fb47cd9d09c27350a50fb867a7bb9e411a81b4fd1890a938b4d9c7b33222"

URI_aarch64_rust-zvariant_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_derive-devel-5.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-zvariant_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_derive-devel}"
SRC_URI[aarch64_rust-zvariant_derive-devel.sha256sum] = "dc4bb9d7ed8351df3be30fe2f08b6cd919f0e004d72f661f90a1efe4626ea43d"

RDEPENDS:rust-zvariant_derive+default-devel = " \
 cargo \
 rust-zvariant_derive-devel \
 "
RDEPENDS:rust-zvariant_derive+gvariant-devel = " \
 cargo \
 rust-zvariant_derive-devel \
 rust-zvariant_utils+gvariant-devel \
 "
RDEPENDS:rust-zvariant_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-zvariant_utils+default-devel \
 "
