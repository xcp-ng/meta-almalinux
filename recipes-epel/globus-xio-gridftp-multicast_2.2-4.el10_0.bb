# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xio-gridftp-multicast"
PV = "2.2"
PR = "4.el10_0"
PACKAGES = " \
 globus-xio-gridftp-multicast \
 globus-xio-gridftp-multicast-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/globus-xio-gridftp-multicast-2.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "314c16a8ea1ab6ed7e4905b93eb58980795dbe2eb1ce47bfd495fb4ac665929d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-gridftp-multicast-2.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-gridftp-multicast;unpack=0"
SRC_URI[x86_64_v2_globus-xio-gridftp-multicast.sha256sum] = "1bd8e039663d639f6a701e636f403c5564ea10ae59c42da96ea43680b9d88ede"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-gridftp-multicast-devel-2.2-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-gridftp-multicast-devel;unpack=0"
SRC_URI[x86_64_v2_globus-xio-gridftp-multicast-devel.sha256sum] = "edf87c0ad2abdd4ad7b3f56ddaf76f70e3331394ba5cd39d3ded19d89754dca0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-gridftp-multicast-2.2-4.el10_0.aarch64.rpm;name=aarch64_globus-xio-gridftp-multicast;unpack=0"
SRC_URI[aarch64_globus-xio-gridftp-multicast.sha256sum] = "50db417b793c6b5c22aa663880df75d5f1d76876254895f47eb3c856dee656d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-gridftp-multicast-devel-2.2-4.el10_0.aarch64.rpm;name=aarch64_globus-xio-gridftp-multicast-devel;unpack=0"
SRC_URI[aarch64_globus-xio-gridftp-multicast-devel.sha256sum] = "5aa42af6a6090b7a8332c0b5c8b3264c152431177afd73598ce00bb03695f50c"

RDEPENDS:globus-xio-gridftp-multicast = " \
 glibc \
 globus-common \
 globus-ftp-client \
 globus-xio \
 "
RDEPENDS:globus-xio-gridftp-multicast-devel = " \
 globus-common-devel \
 globus-ftp-client-devel \
 globus-xio-devel \
 globus-xio-gridftp-multicast \
 pkgconf-pkg-config \
 "
