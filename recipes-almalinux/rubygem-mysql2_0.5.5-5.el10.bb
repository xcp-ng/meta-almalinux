# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-mysql2"
PV = "0.5.5"
PR = "5.el10"
PACKAGES = " \
 rubygem-mysql2 \
 rubygem-mysql2-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rubygem-mysql2-0.5.5-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d187ac825b7da01b347a869c9903ebd6aa1b797922a4bc2ec4c0e72699673b7a"

URI_x86_64_v2_rubygem-mysql2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rubygem-mysql2-0.5.5-5.el10.x86_64_v2.rpm;name=x86_64_v2_rubygem-mysql2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mysql2}"
SRC_URI[x86_64_v2_rubygem-mysql2.sha256sum] = "b998f80f2b88e54ba15bc4f8e43cb63f86ec099464f52c29fca05d621281c02d"

URI_x86_64_v2_rubygem-mysql2-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rubygem-mysql2-doc-0.5.5-5.el10.noarch.rpm;name=x86_64_v2_rubygem-mysql2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-mysql2-doc}"
SRC_URI[x86_64_v2_rubygem-mysql2-doc.sha256sum] = "03164cecbc99e1d97ec68e56f160a33871b2c6af6bd88ffef9d57a9b9c0ac364"

URI_aarch64_rubygem-mysql2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rubygem-mysql2-0.5.5-5.el10.aarch64.rpm;name=aarch64_rubygem-mysql2;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mysql2}"
SRC_URI[aarch64_rubygem-mysql2.sha256sum] = "f3fc287d4434bf55c7917366e3d230ab7d7956dfb79c84875db671477a23dcfa"

URI_aarch64_rubygem-mysql2-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rubygem-mysql2-doc-0.5.5-5.el10.noarch.rpm;name=aarch64_rubygem-mysql2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-mysql2-doc}"
SRC_URI[aarch64_rubygem-mysql2-doc.sha256sum] = "03164cecbc99e1d97ec68e56f160a33871b2c6af6bd88ffef9d57a9b9c0ac364"

RDEPENDS:rubygem-mysql2 = " \
 glibc \
 mariadb-connector-c \
 ruby-libs \
 rubygem-bigdecimal \
 rubygems \
 "
RDEPENDS:rubygem-mysql2-doc = " \
 rubygem-mysql2 \
 "
