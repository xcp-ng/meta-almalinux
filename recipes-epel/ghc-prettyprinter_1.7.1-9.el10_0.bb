# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-prettyprinter"
PV = "1.7.1"
PR = "9.el10_0"
PACKAGES = " \
 ghc-prettyprinter \
 ghc-prettyprinter-devel \
 ghc-prettyprinter-doc \
 ghc-prettyprinter-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-prettyprinter-1.7.1-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6c3e626f35e1855ec8df55e06fc39685bb32311f9add6235f0521137d146b77"

URI_x86_64_v2_ghc-prettyprinter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-prettyprinter-1.7.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-prettyprinter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-prettyprinter}"
SRC_URI[x86_64_v2_ghc-prettyprinter.sha256sum] = "d6bc3a6b57c217265721759d5b53abddd3e8d2d3e578af02daf17eabaefa7a2e"

URI_x86_64_v2_ghc-prettyprinter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-prettyprinter-devel-1.7.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-prettyprinter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-prettyprinter-devel}"
SRC_URI[x86_64_v2_ghc-prettyprinter-devel.sha256sum] = "f87977fdd126f40b1feabd85501161452ea02f5d29eed69510e41085dfb0ed3f"

URI_x86_64_v2_ghc-prettyprinter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-prettyprinter-doc-1.7.1-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-prettyprinter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-prettyprinter-doc}"
SRC_URI[x86_64_v2_ghc-prettyprinter-doc.sha256sum] = "2d9ec20f5798cb721b8dc7c956ab412240161d9e2bc246075db97f278cf3086f"

URI_x86_64_v2_ghc-prettyprinter-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-prettyprinter-prof-1.7.1-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-prettyprinter-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-prettyprinter-prof}"
SRC_URI[x86_64_v2_ghc-prettyprinter-prof.sha256sum] = "b7298279cbd0f41ac83215fcae6c2b10ee5f0c797c2321a946db6e883df5a759"

URI_aarch64_ghc-prettyprinter = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-prettyprinter-1.7.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-prettyprinter;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-prettyprinter}"
SRC_URI[aarch64_ghc-prettyprinter.sha256sum] = "a4f32c52e980f943574af51c69b95fafd4495b6cf6672a65843237a0665a4d41"

URI_aarch64_ghc-prettyprinter-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-prettyprinter-devel-1.7.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-prettyprinter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-prettyprinter-devel}"
SRC_URI[aarch64_ghc-prettyprinter-devel.sha256sum] = "6b693208e7628c5f5001ddcb1a37ddac8b7ae6b0c69e509d7fe785e062e62c3b"

URI_aarch64_ghc-prettyprinter-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-prettyprinter-doc-1.7.1-9.el10_0.noarch.rpm;name=aarch64_ghc-prettyprinter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-prettyprinter-doc}"
SRC_URI[aarch64_ghc-prettyprinter-doc.sha256sum] = "71e78a2c81492da4cc2bb598314221c127800eabef7067d68b732bcdee82b543"

URI_aarch64_ghc-prettyprinter-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-prettyprinter-prof-1.7.1-9.el10_0.aarch64.rpm;name=aarch64_ghc-prettyprinter-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-prettyprinter-prof}"
SRC_URI[aarch64_ghc-prettyprinter-prof.sha256sum] = "5a754f4397715b80f456fe91ad49d193ebe1f8777ca3205487ed0908c6c5538c"

RDEPENDS:ghc-prettyprinter = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-prettyprinter-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-prettyprinter \
 ghc-text-devel \
 "
RDEPENDS:ghc-prettyprinter-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-prettyprinter-prof = " \
 ghc-base-prof \
 ghc-prettyprinter-devel \
 ghc-text-prof \
 "
