# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-racket"
PV = "0.24.7"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-racket+default-devel \
 rust-tree-sitter-racket-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-racket-0.24.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81375326d66844dbafd2e0d07f19ea315bcd06ba41a0f969090b81a8ae29d4a4"

URI_x86_64_v2_rust-tree-sitter-racket+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-racket+default-devel-0.24.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-racket+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-racket+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-racket+default-devel.sha256sum] = "49fd8945832e08c6e5706dd237b4ec625d0795ba6becfbfdef96c3af6e66af08"

URI_x86_64_v2_rust-tree-sitter-racket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-racket-devel-0.24.7-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-racket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-racket-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-racket-devel.sha256sum] = "d9095da68ee108b210e8588a7597abb3bf52652473a29d7d738d7daa0c45dd83"

URI_aarch64_rust-tree-sitter-racket+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-racket+default-devel-0.24.7-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-racket+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-racket+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-racket+default-devel.sha256sum] = "f3d520cb2795434096e225a6d703527aed1f935a6d0cd2ffefe9c1b7465e9fa2"

URI_aarch64_rust-tree-sitter-racket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-racket-devel-0.24.7-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-racket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-racket-devel}"
SRC_URI[aarch64_rust-tree-sitter-racket-devel.sha256sum] = "7a20749bc79ae3106aa318ca075f4419f43313984420abd2a6ebead4ac966752"

RDEPENDS:rust-tree-sitter-racket+default-devel = " \
 cargo \
 rust-tree-sitter-racket-devel \
 "
RDEPENDS:rust-tree-sitter-racket-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
