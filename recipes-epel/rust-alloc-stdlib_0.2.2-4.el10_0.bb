# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-alloc-stdlib"
PV = "0.2.2"
PR = "4.el10_0"
PACKAGES = " \
 rust-alloc-stdlib+default-devel \
 rust-alloc-stdlib+unsafe-devel \
 rust-alloc-stdlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-alloc-stdlib-0.2.2-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8ea68bea9d943271a0f6707103b72e02a6c294825d59732b53eadfa0bf5d3a8"

URI_x86_64_v2_rust-alloc-stdlib+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-stdlib+default-devel-0.2.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-stdlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alloc-stdlib+default-devel}"
SRC_URI[x86_64_v2_rust-alloc-stdlib+default-devel.sha256sum] = "9a5f1149555cbc8e1bb29df76e94cef5ae9d61a9ba2282044935067dc45f8044"

URI_x86_64_v2_rust-alloc-stdlib+unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-stdlib+unsafe-devel-0.2.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-stdlib+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alloc-stdlib+unsafe-devel}"
SRC_URI[x86_64_v2_rust-alloc-stdlib+unsafe-devel.sha256sum] = "1a266cc6d1ac91141e3ea6b907c2ab50d77180cfc228a60f9217acf0688ecc3d"

URI_x86_64_v2_rust-alloc-stdlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-alloc-stdlib-devel-0.2.2-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-alloc-stdlib-devel}"
SRC_URI[x86_64_v2_rust-alloc-stdlib-devel.sha256sum] = "b6203e3ea5eef83344a56f374c4c2f6f574d13612bd16dd1b8f86a23d37f8084"

URI_aarch64_rust-alloc-stdlib+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-stdlib+default-devel-0.2.2-4.el10_0.noarch.rpm;name=aarch64_rust-alloc-stdlib+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alloc-stdlib+default-devel}"
SRC_URI[aarch64_rust-alloc-stdlib+default-devel.sha256sum] = "728d4a92b657759f927776380ba47c6b817bf0203e99a1117901223719320519"

URI_aarch64_rust-alloc-stdlib+unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-stdlib+unsafe-devel-0.2.2-4.el10_0.noarch.rpm;name=aarch64_rust-alloc-stdlib+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alloc-stdlib+unsafe-devel}"
SRC_URI[aarch64_rust-alloc-stdlib+unsafe-devel.sha256sum] = "3dc2b18a666cb16a9001aa51338ac4ce72f62fa83eb5c7813bcefd6f121ec4d5"

URI_aarch64_rust-alloc-stdlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-alloc-stdlib-devel-0.2.2-4.el10_0.noarch.rpm;name=aarch64_rust-alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-alloc-stdlib-devel}"
SRC_URI[aarch64_rust-alloc-stdlib-devel.sha256sum] = "2c8e48b5a9142aeb1b02a391e2ba9c3ec541e547f0a183f2635a7873530057c0"

RDEPENDS:rust-alloc-stdlib+default-devel = " \
 cargo \
 rust-alloc-stdlib-devel \
 "
RDEPENDS:rust-alloc-stdlib+unsafe-devel = " \
 cargo \
 rust-alloc-stdlib-devel \
 "
RDEPENDS:rust-alloc-stdlib-devel = " \
 cargo \
 rust-alloc-no-stdlib+default-devel \
 "
