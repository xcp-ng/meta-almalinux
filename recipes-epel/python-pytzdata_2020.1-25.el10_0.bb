# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytzdata"
PV = "2020.1"
PR = "25.el10_0"
PACKAGES = " \
 python3-pytzdata \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytzdata-2020.1-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bca5c6d8a29fb999b1dfc26ed58186022f1e48abba0f8e19287f92da209b4730"

URI_x86_64_v2_python3-pytzdata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytzdata-2020.1-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytzdata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytzdata}"
SRC_URI[x86_64_v2_python3-pytzdata.sha256sum] = "fbb6e3b9e54e475730e5e9584ed473ed2d8376e3dcf0e6630d32c9025c167104"

URI_aarch64_python3-pytzdata = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytzdata-2020.1-25.el10_0.noarch.rpm;name=aarch64_python3-pytzdata;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytzdata}"
SRC_URI[aarch64_python3-pytzdata.sha256sum] = "bc3d0b4ce107a39c73cb25354bf07c24da8c4e2ae4446724e96789f6d3e80495"

RDEPENDS:python3-pytzdata = " \
 python3 \
 tzdata \
 "
