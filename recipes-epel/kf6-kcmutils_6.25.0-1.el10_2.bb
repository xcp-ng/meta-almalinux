# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcmutils"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kcmutils \
 kf6-kcmutils-devel \
 kf6-kcmutils-doc \
 kf6-kcmutils-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcmutils-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8d636ad732c8c5cf988270bd1779c73bdee226b6ec2b559b2286e9154b6a856"

URI_x86_64_v2_kf6-kcmutils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils}"
SRC_URI[x86_64_v2_kf6-kcmutils.sha256sum] = "bff3915b28960d88b0a8fbb57e754fe72d73d6c34d8f35c17c92b3db6bb3b184"

URI_x86_64_v2_kf6-kcmutils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcmutils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-devel}"
SRC_URI[x86_64_v2_kf6-kcmutils-devel.sha256sum] = "d5733816c5de75e10994cc56878fc021f78ea74cc41158456682d3e0559ef016"

URI_x86_64_v2_kf6-kcmutils-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcmutils-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-doc}"
SRC_URI[x86_64_v2_kf6-kcmutils-doc.sha256sum] = "254f8a09389984f372a06414d0a164b109cef31c7e3250319f6fe0a0df55dfc9"

URI_x86_64_v2_kf6-kcmutils-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcmutils-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcmutils-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcmutils-html}"
SRC_URI[x86_64_v2_kf6-kcmutils-html.sha256sum] = "359697865ed0fc0c595084e9df758f6e977ae6c7436e9af781f3615dcf56b8fd"

URI_aarch64_kf6-kcmutils = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcmutils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils}"
SRC_URI[aarch64_kf6-kcmutils.sha256sum] = "34118c45d783c66a2c14159c58473f9d3cece7658fc1a0a90b3ac3d6a99ac83d"

URI_aarch64_kf6-kcmutils-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kcmutils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-devel}"
SRC_URI[aarch64_kf6-kcmutils-devel.sha256sum] = "fffdd59482bcb4c90e0b040b9864f486440808d8fb013b206c598a4f823c9136"

URI_aarch64_kf6-kcmutils-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcmutils-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-doc}"
SRC_URI[aarch64_kf6-kcmutils-doc.sha256sum] = "5949f29ea1098594fcc038d2d1f88f683cf5686659169664592b185fce3c8c2b"

URI_aarch64_kf6-kcmutils-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcmutils-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kcmutils-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcmutils-html}"
SRC_URI[aarch64_kf6-kcmutils-html.sha256sum] = "5c436da0d0096a9a0eb6eff0535161e3149396a4d3fb14ad5a713a99e1168321"

RDEPENDS:kf6-kcmutils = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kitemviews \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcmutils-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kcmutils \
 kf6-kconfigwidgets-devel \
 kf6-kservice-devel \
 qt6-qtbase \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:kf6-kcmutils-doc = " \
 "
RDEPENDS:kf6-kcmutils-html = " \
 "
