# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-brotli-decompressor"
PV = "4.0.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor+default-devel \
 rust-brotli-decompressor+disable-timer-devel \
 rust-brotli-decompressor+ffi-api-devel \
 rust-brotli-decompressor+pass-through-ffi-panics-devel \
 rust-brotli-decompressor+seccomp-devel \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor+unsafe-devel \
 rust-brotli-decompressor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-brotli-decompressor-4.0.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15a2a8b6e30cf7db8381303ea274dd9832454d7016e7bcd9a615be3f2f6ad476"

URI_x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+alloc-stdlib-devel-4.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "331278ca55f7bfb4557dcaf01eac3b33fc6dcd587ca0a2395d843803f69850c8"

URI_x86_64_v2_rust-brotli-decompressor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+default-devel-4.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+default-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+default-devel.sha256sum] = "d1a9722e8629357d4ac1653602fd1f955c08f0e57fd901e5d292069b43cda2b2"

URI_x86_64_v2_rust-brotli-decompressor+disable-timer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+disable-timer-devel-4.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+disable-timer-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "def8bffd3d89d0540869f2b12c7d361bffd7c5cc7ac5c1bcc211cc4dafc2121f"

URI_x86_64_v2_rust-brotli-decompressor+ffi-api-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+ffi-api-devel-4.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+ffi-api-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "1df363b4143a7b9fec98c351d95188672bb2ddb971e294ee69b94ec75df6b0db"

URI_x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+pass-through-ffi-panics-devel-4.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "d4d95cfc1530946795acc5ddea98dd868a4f30e99d3f82239c62a69632a86b93"

URI_x86_64_v2_rust-brotli-decompressor+seccomp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+seccomp-devel-4.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+seccomp-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+seccomp-devel.sha256sum] = "b4500f1606a205e5adcf0a690a6bdff1323991271ec4da783a00b82fa24beb29"

URI_x86_64_v2_rust-brotli-decompressor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+std-devel-4.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+std-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+std-devel.sha256sum] = "b84f712f890c60178a257bbe82c59ebd2762221d04d80993048ed669fe7ced61"

URI_x86_64_v2_rust-brotli-decompressor+unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor+unsafe-devel-4.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor+unsafe-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor+unsafe-devel.sha256sum] = "b572d4a16d0c4a87843dd5aeaea31c5fa6567f223de1a5ad67e6fc2266494ac4"

URI_x86_64_v2_rust-brotli-decompressor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-brotli-decompressor-devel-4.0.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-brotli-decompressor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-brotli-decompressor-devel}"
SRC_URI[x86_64_v2_rust-brotli-decompressor-devel.sha256sum] = "5c632abe2abc0e2fe3215e9b30f98e7dbcbf26e76232dd45cec053f29acc6a5f"

URI_aarch64_rust-brotli-decompressor+alloc-stdlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+alloc-stdlib-devel-4.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-brotli-decompressor+alloc-stdlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+alloc-stdlib-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+alloc-stdlib-devel.sha256sum] = "350ca7229a04f5fc0f44e960f048bc899e0304abbdec03622f231f0ca872d7a1"

URI_aarch64_rust-brotli-decompressor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+default-devel-4.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-brotli-decompressor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+default-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+default-devel.sha256sum] = "717a32b1d11fe197ea1e4df6958f1d5a9316bfbe83ab69d3b3e9a072d764c23c"

URI_aarch64_rust-brotli-decompressor+disable-timer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+disable-timer-devel-4.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-brotli-decompressor+disable-timer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+disable-timer-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+disable-timer-devel.sha256sum] = "bdd933d028e00bce025697abffe948e26817ecbd07e765d8681cdf2968a30d10"

URI_aarch64_rust-brotli-decompressor+ffi-api-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+ffi-api-devel-4.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-brotli-decompressor+ffi-api-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+ffi-api-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+ffi-api-devel.sha256sum] = "32f0a2849a6be917f8d6c3c1d8e6d4f0daeef2f72ce3f58a9d908f3a6efe948f"

URI_aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+pass-through-ffi-panics-devel-4.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+pass-through-ffi-panics-devel.sha256sum] = "cbc3c31d1dc4e17bfdce12ae46b29d1e74091937153bfe92ad9a8325d186a6df"

URI_aarch64_rust-brotli-decompressor+seccomp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+seccomp-devel-4.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-brotli-decompressor+seccomp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+seccomp-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+seccomp-devel.sha256sum] = "f0f9906a959294a3c0115c6bec5a74854ad0714849bf8316439f1a7037e7bee2"

URI_aarch64_rust-brotli-decompressor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+std-devel-4.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-brotli-decompressor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+std-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+std-devel.sha256sum] = "da07385b4d745db85cef6ec5b087ed4d85c7769240aa0ac51e3f2f3ff29286f0"

URI_aarch64_rust-brotli-decompressor+unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor+unsafe-devel-4.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-brotli-decompressor+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor+unsafe-devel}"
SRC_URI[aarch64_rust-brotli-decompressor+unsafe-devel.sha256sum] = "15addbb8677a8539db66f317c76c7b06364a0ccbcf0a7c88b4dfb35f8fd978fe"

URI_aarch64_rust-brotli-decompressor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-brotli-decompressor-devel-4.0.3-1.el10_1.noarch.rpm;name=aarch64_rust-brotli-decompressor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-brotli-decompressor-devel}"
SRC_URI[aarch64_rust-brotli-decompressor-devel.sha256sum] = "10c2d84e27e17d8809836eb02a1cb46a31fbedc1031538018cc17a8f3f02236e"

RDEPENDS:rust-brotli-decompressor+alloc-stdlib-devel = " \
 cargo \
 rust-alloc-stdlib+default-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+default-devel = " \
 cargo \
 rust-brotli-decompressor+std-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+disable-timer-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+ffi-api-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+pass-through-ffi-panics-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+seccomp-devel = " \
 cargo \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+std-devel = " \
 cargo \
 rust-brotli-decompressor+alloc-stdlib-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor+unsafe-devel = " \
 cargo \
 rust-alloc-no-stdlib+unsafe-devel \
 rust-alloc-stdlib+default-devel \
 rust-alloc-stdlib+unsafe-devel \
 rust-brotli-decompressor-devel \
 "
RDEPENDS:rust-brotli-decompressor-devel = " \
 cargo \
 rust-alloc-no-stdlib+default-devel \
 "
