# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-lt"
PV = "1.2.1"
PR = "35.el10"
PACKAGES = " \
 hunspell-lt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-lt-1.2.1-35.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd94b4c6e4a84110978cc3bc2b6a5b36778266b7d775eac7c3399de34e86bc83"

URI_x86_64_v2_hunspell-lt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-lt-1.2.1-35.el10.noarch.rpm;name=x86_64_v2_hunspell-lt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-lt}"
SRC_URI[x86_64_v2_hunspell-lt.sha256sum] = "84edb0ca3ffdabaed4cae90cbc226c0349aaf2e7f681dc506abc08ae75479469"

URI_aarch64_hunspell-lt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-lt-1.2.1-35.el10.noarch.rpm;name=aarch64_hunspell-lt;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-lt}"
SRC_URI[aarch64_hunspell-lt.sha256sum] = "84edb0ca3ffdabaed4cae90cbc226c0349aaf2e7f681dc506abc08ae75479469"

RDEPENDS:hunspell-lt = " \
 hunspell-filesystem \
 "
