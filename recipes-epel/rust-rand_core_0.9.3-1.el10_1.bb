# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_core"
PV = "0.9.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-rand_core+default-devel \
 rust-rand_core+os_rng-devel \
 rust-rand_core+serde-devel \
 rust-rand_core+std-devel \
 rust-rand_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_core-0.9.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cca7c079b34839c1b4bc121dfc2347da6d0366325b4e1387b2f9ab147b4ca0cb"

URI_x86_64_v2_rust-rand_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+default-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+default-devel}"
SRC_URI[x86_64_v2_rust-rand_core+default-devel.sha256sum] = "1cea8b9f3e447b452879ca71bbb63a7fb7f917349ec760c9431e7de71afec432"

URI_x86_64_v2_rust-rand_core+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+os_rng-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand_core+os_rng-devel.sha256sum] = "7c01ad26ea8135e41b529ce00eebde96d7426c8fa82496e1c0b8f80a366ecfcc"

URI_x86_64_v2_rust-rand_core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+serde-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_core+serde-devel.sha256sum] = "a97c5aa845a914c53a6b72ab1cf756623f4d8e509f0285184b6b6247f808958e"

URI_x86_64_v2_rust-rand_core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+std-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+std-devel}"
SRC_URI[x86_64_v2_rust-rand_core+std-devel.sha256sum] = "026e023303fbb989e975a1d5423eec4816842cb49bfcbfba26b8df865d1c1968"

URI_x86_64_v2_rust-rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core-devel-0.9.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core-devel}"
SRC_URI[x86_64_v2_rust-rand_core-devel.sha256sum] = "c8f7cbfc4de124526b688fcc7586bd2f85f11788181e26f3b7a9289e23684be4"

URI_aarch64_rust-rand_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+default-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-rand_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+default-devel}"
SRC_URI[aarch64_rust-rand_core+default-devel.sha256sum] = "3aea104ca87d939ea42b9399e6ec11cc0e151068960ae1cebc867e359d480f7d"

URI_aarch64_rust-rand_core+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+os_rng-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-rand_core+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+os_rng-devel}"
SRC_URI[aarch64_rust-rand_core+os_rng-devel.sha256sum] = "9b92ae1a3069d3867db9956a3a414827aeab7a28c145ccf66a489c8e8cad7820"

URI_aarch64_rust-rand_core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+serde-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-rand_core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+serde-devel}"
SRC_URI[aarch64_rust-rand_core+serde-devel.sha256sum] = "5f5938b38895b5ff031f3717bd5f08faaf0d2570c209809aa3f003d8b2b1b088"

URI_aarch64_rust-rand_core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+std-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-rand_core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+std-devel}"
SRC_URI[aarch64_rust-rand_core+std-devel.sha256sum] = "9a5dfcc7a6c791c8275affd6fb98928dc7817406c9f89d34d05e70df8ccc7152"

URI_aarch64_rust-rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core-devel-0.9.3-1.el10_1.noarch.rpm;name=aarch64_rust-rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core-devel}"
SRC_URI[aarch64_rust-rand_core-devel.sha256sum] = "29de7d1ad630c3972079f5167d099083df074e7ebba88d10829d66314bbdd225"

RDEPENDS:rust-rand_core+default-devel = " \
 cargo \
 rust-rand_core-devel \
 "
RDEPENDS:rust-rand_core+os_rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-rand_core+serde-devel = " \
 cargo \
 rust-rand_core-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_core+std-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-rand_core-devel \
 "
RDEPENDS:rust-rand_core-devel = " \
 cargo \
 rust \
 "
