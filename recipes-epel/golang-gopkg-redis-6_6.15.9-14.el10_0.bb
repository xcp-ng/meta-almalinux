# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-redis-6"
PV = "6.15.9"
PR = "14.el10_0"
PACKAGES = " \
 compat-golang-github-redis-devel \
 golang-gopkg-redis-6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-redis-6-6.15.9-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a6d27ecfb4dee15a732041a38f67d9487e887f3a3b0e21f6e1619afe6f3c810"

URI_x86_64_v2_compat-golang-github-redis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-redis-devel-6.15.9-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-redis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-redis-devel}"
SRC_URI[x86_64_v2_compat-golang-github-redis-devel.sha256sum] = "834476b0a833eee587177821acd8ab4aba019749c1273c064d8a2b80a238b6d7"

URI_x86_64_v2_golang-gopkg-redis-6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-gopkg-redis-6-devel-6.15.9-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-gopkg-redis-6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-gopkg-redis-6-devel}"
SRC_URI[x86_64_v2_golang-gopkg-redis-6-devel.sha256sum] = "4828f66644346061856e6553fc4ed5a085eff76370ad8521e492b3fc4fb455ae"

URI_aarch64_compat-golang-github-redis-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-redis-devel-6.15.9-14.el10_0.noarch.rpm;name=aarch64_compat-golang-github-redis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-redis-devel}"
SRC_URI[aarch64_compat-golang-github-redis-devel.sha256sum] = "18d5900aab9fee05f4616d36655fa299b3885117d074ef9749af48269fba566d"

URI_aarch64_golang-gopkg-redis-6-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-redis-6-devel-6.15.9-14.el10_0.noarch.rpm;name=aarch64_golang-gopkg-redis-6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-redis-6-devel}"
SRC_URI[aarch64_golang-gopkg-redis-6-devel.sha256sum] = "95834eec04ad88b390b05c84a2f3c5f364f98fc983e12a2fb2533d54caf5e61f"

RDEPENDS:compat-golang-github-redis-devel = " \
 go-filesystem \
 golang-gopkg-redis-6-devel \
 "
RDEPENDS:golang-gopkg-redis-6-devel = " \
 go-filesystem \
 "
