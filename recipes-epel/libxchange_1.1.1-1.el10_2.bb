# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxchange"
PV = "1.1.1"
PR = "1.el10_2"
PACKAGES = " \
 libxchange \
 libxchange-devel \
 libxchange-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libxchange-1.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ea9d03053e0b703456a6d7454c8690a38d8f44fb09a21f4c29ee4deeb44acdb7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxchange-1.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxchange;unpack=0"
SRC_URI[x86_64_v2_libxchange.sha256sum] = "fa450f30ab48396311393f194dfe831cf53185d63bc2e2de135bf03273f7a56a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxchange-devel-1.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxchange-devel;unpack=0"
SRC_URI[x86_64_v2_libxchange-devel.sha256sum] = "6a89366856d46d31e5692088257f283093067e9a114118a5f06a2263309f2e26"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxchange-doc-1.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libxchange-doc;unpack=0"
SRC_URI[x86_64_v2_libxchange-doc.sha256sum] = "128838d9273c974661889e1f7bc449fc9016dadd2b5f458ecf100138496d5c04"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxchange-1.1.1-1.el10_2.aarch64.rpm;name=aarch64_libxchange;unpack=0"
SRC_URI[aarch64_libxchange.sha256sum] = "752a3129e823f1f0552a684276c0c57b35f539f5e75cb984b043c6603e4308b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxchange-devel-1.1.1-1.el10_2.aarch64.rpm;name=aarch64_libxchange-devel;unpack=0"
SRC_URI[aarch64_libxchange-devel.sha256sum] = "ea7202a1fa4850c2b5f2f2c04085cc54709f4670be5672b9adb95c0a0b9450b3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxchange-doc-1.1.1-1.el10_2.noarch.rpm;name=aarch64_libxchange-doc;unpack=0"
SRC_URI[aarch64_libxchange-doc.sha256sum] = "988b14f800db0cbc4d8b8604c39eed7416a8b53c0006ec1a5baf08de9ca09d72"

RDEPENDS:libxchange = " \
 glibc \
 "
RDEPENDS:libxchange-devel = " \
 libxchange \
 "
RDEPENDS:libxchange-doc = " \
 "
