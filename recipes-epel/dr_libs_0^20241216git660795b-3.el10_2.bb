# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dr_libs"
PV = "0^20241216git660795b"
PR = "3.el10_2"
PACKAGES = " \
 dr_flac-devel \
 dr_libs-devel \
 dr_libs-doc \
 dr_mp3-devel \
 dr_wav-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dr_libs-0^20241216git660795b-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cd08a3c7409302c6af715da2531f1f8138c3e82457a330fb94b91d82010d9fb"

URI_x86_64_v2_dr_flac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_flac-devel-0.12.43^20241216git660795b-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dr_flac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_flac-devel}"
SRC_URI[x86_64_v2_dr_flac-devel.sha256sum] = "a61fc161d522065d4c690c5b1d6e2520a31da9bf64f751220346a1adc8a566de"

URI_x86_64_v2_dr_libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_libs-devel-0^20241216git660795b-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dr_libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_libs-devel}"
SRC_URI[x86_64_v2_dr_libs-devel.sha256sum] = "600ba4dd7daacc037ca1e9fb7781d383b2952aaf067b870ff34c5a71c00d3bb6"

URI_x86_64_v2_dr_libs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_libs-doc-0^20241216git660795b-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dr_libs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_libs-doc}"
SRC_URI[x86_64_v2_dr_libs-doc.sha256sum] = "af9b4739e8030bb45f9e3b17f51d60377526246e9ace229666c1b32aee58b0ea"

URI_x86_64_v2_dr_mp3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_mp3-devel-0.6.40^20241216git660795b-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dr_mp3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_mp3-devel}"
SRC_URI[x86_64_v2_dr_mp3-devel.sha256sum] = "bd8cb6ace900e5146e54c8be7e5de0138656ced7a3e90eeff88133923d7167f6"

URI_x86_64_v2_dr_wav-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dr_wav-devel-0.13.17^20241216git660795b-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_dr_wav-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dr_wav-devel}"
SRC_URI[x86_64_v2_dr_wav-devel.sha256sum] = "d4cba13cac8212d5eae2d1cb250748141733473ef09b7a80c123d149a07b1fbd"

URI_aarch64_dr_flac-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_flac-devel-0.12.43^20241216git660795b-3.el10_2.noarch.rpm;name=aarch64_dr_flac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_flac-devel}"
SRC_URI[aarch64_dr_flac-devel.sha256sum] = "959964d913774c4445fac83016ef5af6c8f8cedbe2baf0f5249c55d86cd7964e"

URI_aarch64_dr_libs-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_libs-devel-0^20241216git660795b-3.el10_2.noarch.rpm;name=aarch64_dr_libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_libs-devel}"
SRC_URI[aarch64_dr_libs-devel.sha256sum] = "869296d901e6fb22497c7b778648a1baaf35abe346c4b3a5549afa8b84c16f61"

URI_aarch64_dr_libs-doc = "${EPEL_MIRROR}/aarch64/Packages/d/dr_libs-doc-0^20241216git660795b-3.el10_2.noarch.rpm;name=aarch64_dr_libs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_libs-doc}"
SRC_URI[aarch64_dr_libs-doc.sha256sum] = "549d78d62c34e5e1b8883defb081b2d28daeedc4ec2c2f624ef7dd327526c7ee"

URI_aarch64_dr_mp3-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_mp3-devel-0.6.40^20241216git660795b-3.el10_2.noarch.rpm;name=aarch64_dr_mp3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_mp3-devel}"
SRC_URI[aarch64_dr_mp3-devel.sha256sum] = "fc013a31eeb12b8b6bf64b8f569e99377758a1a7507f3b68f4e8f28dd2f72603"

URI_aarch64_dr_wav-devel = "${EPEL_MIRROR}/aarch64/Packages/d/dr_wav-devel-0.13.17^20241216git660795b-3.el10_2.noarch.rpm;name=aarch64_dr_wav-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dr_wav-devel}"
SRC_URI[aarch64_dr_wav-devel.sha256sum] = "d19bf789d70c0466d6cf74c5538f770bd5f90427e005cddd52b1930d0d56e6db"

RDEPENDS:dr_flac-devel = " \
 "
RDEPENDS:dr_libs-devel = " \
 dr_flac-devel \
 dr_mp3-devel \
 dr_wav-devel \
 "
RDEPENDS:dr_libs-doc = " \
 "
RDEPENDS:dr_mp3-devel = " \
 "
RDEPENDS:dr_wav-devel = " \
 "
