# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-util"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-util+alloc-devel \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+bilock-devel \
 rust-futures-util+cfg-target-has-atomic-devel \
 rust-futures-util+channel-devel \
 rust-futures-util+default-devel \
 rust-futures-util+futures-channel-devel \
 rust-futures-util+futures-io-devel \
 rust-futures-util+futures-macro-devel \
 rust-futures-util+futures-sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+libc-devel \
 rust-futures-util+memchr-devel \
 rust-futures-util+portable-atomic-alloc-devel \
 rust-futures-util+portable-atomic-devel \
 rust-futures-util+portable-atomic-util-devel \
 rust-futures-util+portable_atomic_crate-devel \
 rust-futures-util+sink-devel \
 rust-futures-util+slab-devel \
 rust-futures-util+spin-devel \
 rust-futures-util+std-devel \
 rust-futures-util+unstable-devel \
 rust-futures-util+write-all-vectored-devel \
 rust-futures-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-util-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df8a5a8b7a923879eafeab79b0276116484b8fd9729dba4dde335b275b90a4a1"

URI_x86_64_v2_rust-futures-util+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+alloc-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-util+alloc-devel.sha256sum] = "c55803f403c63d9ad563a2fc7ca9ffb5dfa2160293026540e63a13157523c7c5"

URI_x86_64_v2_rust-futures-util+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+async-await-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+async-await-devel}"
SRC_URI[x86_64_v2_rust-futures-util+async-await-devel.sha256sum] = "bb719a99f7c47b09a49016cccf3a45ee4d2403caadc7552700e9d33f1f4cf4a3"

URI_x86_64_v2_rust-futures-util+async-await-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+async-await-macro-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+async-await-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+async-await-macro-devel}"
SRC_URI[x86_64_v2_rust-futures-util+async-await-macro-devel.sha256sum] = "1abaeb60b70509001bb4591ad2bb4f986ce6e08c99419996a408d847ed2d24f4"

URI_x86_64_v2_rust-futures-util+bilock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+bilock-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+bilock-devel}"
SRC_URI[x86_64_v2_rust-futures-util+bilock-devel.sha256sum] = "fd94efc0b28c749bb5b9617c393e09ff665b6ed8cb43dc387954fe29b2fcd44f"

URI_x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+cfg-target-has-atomic-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-util+cfg-target-has-atomic-devel.sha256sum] = "0b67f4764a6e4e0293b4fd93f4bbe535e2cd894532c99a978bb81662a7ae609a"

URI_x86_64_v2_rust-futures-util+channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+channel-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+channel-devel}"
SRC_URI[x86_64_v2_rust-futures-util+channel-devel.sha256sum] = "70a5bc203b5efa93e6475f944616e2ff3fd44847bf27c7e625301abda80c0a90"

URI_x86_64_v2_rust-futures-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+default-devel}"
SRC_URI[x86_64_v2_rust-futures-util+default-devel.sha256sum] = "eee2a2f2ab87a596dc02ea104acaf29977e67a0177d3838ffb0a6757317eb520"

URI_x86_64_v2_rust-futures-util+futures-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-channel-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-channel-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-channel-devel.sha256sum] = "51e67e9f3f9908d3728cdd055d2effac1a9d2c3869f0975d6357bb521639e2f6"

URI_x86_64_v2_rust-futures-util+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-io-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-io-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-io-devel.sha256sum] = "fc8fd2f929db1e8f1a5f1c8a42c9ceeb59c869f8e41e3711f41970af461470bc"

URI_x86_64_v2_rust-futures-util+futures-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-macro-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-macro-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-macro-devel.sha256sum] = "593de4524775bce2e098a328c28e5444a78ef8ba1c231e4bd602097b936264d3"

URI_x86_64_v2_rust-futures-util+futures-sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+futures-sink-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+futures-sink-devel}"
SRC_URI[x86_64_v2_rust-futures-util+futures-sink-devel.sha256sum] = "13cc71d733bc4f832edfdd5aca1279ee00c15a8bb259790b39c194342a3f4ea8"

URI_x86_64_v2_rust-futures-util+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+io-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+io-devel}"
SRC_URI[x86_64_v2_rust-futures-util+io-devel.sha256sum] = "07c86828b842e5169e013471b1f155fae7a373f0ed3bf16078d9a6f997c43763"

URI_x86_64_v2_rust-futures-util+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+libc-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+libc-devel}"
SRC_URI[x86_64_v2_rust-futures-util+libc-devel.sha256sum] = "c6e8946cf947743f203cfed791f8703c18159645c75dde77b01a80f3988b0559"

URI_x86_64_v2_rust-futures-util+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+memchr-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+memchr-devel}"
SRC_URI[x86_64_v2_rust-futures-util+memchr-devel.sha256sum] = "b7dce4e838f2bed0b5e1459a135e331788f0d420ad22b1e989a7fd7d2faedbbf"

URI_x86_64_v2_rust-futures-util+portable-atomic-alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable-atomic-alloc-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable-atomic-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+portable-atomic-alloc-devel}"
SRC_URI[x86_64_v2_rust-futures-util+portable-atomic-alloc-devel.sha256sum] = "c1ec77daec7c708ae3281865a0b442589d2f1d10a14f2cbea2b77574b021018a"

URI_x86_64_v2_rust-futures-util+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable-atomic-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-futures-util+portable-atomic-devel.sha256sum] = "3f6c5b748dee9ca36d533df07f58c91dfe80b1ed53a0eb51834f24e1ef3129a3"

URI_x86_64_v2_rust-futures-util+portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable-atomic-util-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-futures-util+portable-atomic-util-devel.sha256sum] = "b1fafff18a3bf04cbe210d8aabc60d62aa3963f520e4245df28a685748e90b3c"

URI_x86_64_v2_rust-futures-util+portable_atomic_crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+portable_atomic_crate-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+portable_atomic_crate-devel}"
SRC_URI[x86_64_v2_rust-futures-util+portable_atomic_crate-devel.sha256sum] = "1d8eaf654fee55aeced2d31ab25b91318a44f34415aaa1e191a6a2d295c082d6"

URI_x86_64_v2_rust-futures-util+sink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+sink-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+sink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+sink-devel}"
SRC_URI[x86_64_v2_rust-futures-util+sink-devel.sha256sum] = "dfbda7ac1de016828f3765161d23d9bd8c4beec8250ca35b38f9818fcedbf736"

URI_x86_64_v2_rust-futures-util+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+slab-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+slab-devel}"
SRC_URI[x86_64_v2_rust-futures-util+slab-devel.sha256sum] = "89c6e5268b01088333263005afc8075f998b1f4c74639be9f7aa3280cb142d6f"

URI_x86_64_v2_rust-futures-util+spin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+spin-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+spin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+spin-devel}"
SRC_URI[x86_64_v2_rust-futures-util+spin-devel.sha256sum] = "6ca1305d0fe123357e27a1d6da7756efd41ba93b72318519c5a88f9367d70d3e"

URI_x86_64_v2_rust-futures-util+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+std-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+std-devel}"
SRC_URI[x86_64_v2_rust-futures-util+std-devel.sha256sum] = "f6762d781c4cda1dca116378df7c49ed16aadae6b9bd5d476d92311687ef587b"

URI_x86_64_v2_rust-futures-util+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+unstable-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+unstable-devel}"
SRC_URI[x86_64_v2_rust-futures-util+unstable-devel.sha256sum] = "81ffdfbec5c19fa5fb5a3fd500452d25a810c85423b207573f93977ffb46a3cd"

URI_x86_64_v2_rust-futures-util+write-all-vectored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util+write-all-vectored-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util+write-all-vectored-devel}"
SRC_URI[x86_64_v2_rust-futures-util+write-all-vectored-devel.sha256sum] = "ab9d34fd4e8a5b931dc676ffaea075a1ee47921a3bb44dbc2bf26526b5d49389"

URI_x86_64_v2_rust-futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-util-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-util-devel}"
SRC_URI[x86_64_v2_rust-futures-util-devel.sha256sum] = "fba8774ba1992866c349e92528abb92e9510e84e53b21eb8b336b83d1d01c979"

URI_aarch64_rust-futures-util+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+alloc-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+alloc-devel}"
SRC_URI[aarch64_rust-futures-util+alloc-devel.sha256sum] = "852d5c1e56f465c08e5ad4763da1708686df581520def6769514be1fe50ea4d9"

URI_aarch64_rust-futures-util+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+async-await-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+async-await-devel}"
SRC_URI[aarch64_rust-futures-util+async-await-devel.sha256sum] = "5da6c34ad520a4f943e93e064aa0644335034f02a68b2ef9c24dac2df79c6a4b"

URI_aarch64_rust-futures-util+async-await-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+async-await-macro-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+async-await-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+async-await-macro-devel}"
SRC_URI[aarch64_rust-futures-util+async-await-macro-devel.sha256sum] = "975a17efa51e449cb2d673a9618112d368132fe71c80b0f85f57458330fb1a3f"

URI_aarch64_rust-futures-util+bilock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+bilock-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+bilock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+bilock-devel}"
SRC_URI[aarch64_rust-futures-util+bilock-devel.sha256sum] = "584d5404b6d7ffb329852239a3c17460ff7ef230ff5a02b2264c7a1b1a0c5a38"

URI_aarch64_rust-futures-util+cfg-target-has-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+cfg-target-has-atomic-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+cfg-target-has-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+cfg-target-has-atomic-devel}"
SRC_URI[aarch64_rust-futures-util+cfg-target-has-atomic-devel.sha256sum] = "24aadb189a20f24acda39b2b6bbb0ca28e844a740533a6a71636194a7ec593bb"

URI_aarch64_rust-futures-util+channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+channel-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+channel-devel}"
SRC_URI[aarch64_rust-futures-util+channel-devel.sha256sum] = "a1621f1013ec13f5349f7537a5c75672e89a3bfdd6d47193f1d20af4d7839ddc"

URI_aarch64_rust-futures-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+default-devel}"
SRC_URI[aarch64_rust-futures-util+default-devel.sha256sum] = "dac3ae50ba0ac0c36c82540447d825461c57d020ed5985a3cf307dbdfd72a797"

URI_aarch64_rust-futures-util+futures-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-channel-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+futures-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-channel-devel}"
SRC_URI[aarch64_rust-futures-util+futures-channel-devel.sha256sum] = "69335aaa26ae72a4b8e182b6d444daa005f9923b671dab9404b33a3a37dbc064"

URI_aarch64_rust-futures-util+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-io-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-io-devel}"
SRC_URI[aarch64_rust-futures-util+futures-io-devel.sha256sum] = "43cda25f68038d88be63150bccaa18eba0fa5df5896dab306c18bb400bd6d768"

URI_aarch64_rust-futures-util+futures-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-macro-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-macro-devel}"
SRC_URI[aarch64_rust-futures-util+futures-macro-devel.sha256sum] = "0e3129f4834aa6ff4370dfc5f0ddfd470a9ba818673f5ae652474e459e9c952f"

URI_aarch64_rust-futures-util+futures-sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+futures-sink-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+futures-sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+futures-sink-devel}"
SRC_URI[aarch64_rust-futures-util+futures-sink-devel.sha256sum] = "8f3c7210f2cad71f23aae2dd97946266ef15bcd480b8c23df5d270e6ac0def82"

URI_aarch64_rust-futures-util+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+io-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+io-devel}"
SRC_URI[aarch64_rust-futures-util+io-devel.sha256sum] = "95e1031d4985923fd26cb42546924024b1d0cbf7326f1dfd5d69fdf75dd1cf6a"

URI_aarch64_rust-futures-util+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+libc-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+libc-devel}"
SRC_URI[aarch64_rust-futures-util+libc-devel.sha256sum] = "66b4fa577a110dcada92713593e8b1607e519f5915d3868c604420236a25dc88"

URI_aarch64_rust-futures-util+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+memchr-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+memchr-devel}"
SRC_URI[aarch64_rust-futures-util+memchr-devel.sha256sum] = "2342102acbe06179b7b99bc03ee5a624fc7c56bfde03b6aa81741c18b378795a"

URI_aarch64_rust-futures-util+portable-atomic-alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable-atomic-alloc-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+portable-atomic-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+portable-atomic-alloc-devel}"
SRC_URI[aarch64_rust-futures-util+portable-atomic-alloc-devel.sha256sum] = "4c50abc8981ee1def54dd3e94aea7efb782b1f534a1feb10705a57062c883efa"

URI_aarch64_rust-futures-util+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable-atomic-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+portable-atomic-devel}"
SRC_URI[aarch64_rust-futures-util+portable-atomic-devel.sha256sum] = "aa11caccd20dea3673eb2cf25bf4387cb862d4215c3ee39496b9babb016b7ed1"

URI_aarch64_rust-futures-util+portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable-atomic-util-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+portable-atomic-util-devel}"
SRC_URI[aarch64_rust-futures-util+portable-atomic-util-devel.sha256sum] = "7d94dbd7e086d1fb79ecb30ac3c2a744b7602c938939b395b5781ef7a30134f3"

URI_aarch64_rust-futures-util+portable_atomic_crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+portable_atomic_crate-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+portable_atomic_crate-devel}"
SRC_URI[aarch64_rust-futures-util+portable_atomic_crate-devel.sha256sum] = "3b23ef614170cc9bcf1fae8571bd7657d4c594e674fc5f5edaaf11845306d786"

URI_aarch64_rust-futures-util+sink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+sink-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+sink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+sink-devel}"
SRC_URI[aarch64_rust-futures-util+sink-devel.sha256sum] = "8a3459c066d42e6a6053427c489de2b7d84058a2788baff8b94106a62382b23a"

URI_aarch64_rust-futures-util+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+slab-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+slab-devel}"
SRC_URI[aarch64_rust-futures-util+slab-devel.sha256sum] = "2fd674605f973a096dd6acc1f2da312d0383ce0de309ba15da6b8eb54f43a534"

URI_aarch64_rust-futures-util+spin-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+spin-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+spin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+spin-devel}"
SRC_URI[aarch64_rust-futures-util+spin-devel.sha256sum] = "e3ea3d5b0c793cc5fa4ba8366998328d1e2c91c5c89b8c0b1d7be1088fbceffb"

URI_aarch64_rust-futures-util+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+std-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+std-devel}"
SRC_URI[aarch64_rust-futures-util+std-devel.sha256sum] = "ff320753cd6d95e34832f0dce492a24f564e6621ead05d4f823bb33623cbd63a"

URI_aarch64_rust-futures-util+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+unstable-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+unstable-devel}"
SRC_URI[aarch64_rust-futures-util+unstable-devel.sha256sum] = "e7742ef0254a47cf1ee37d5515d4c3e20af7686a07b80460433e177dabe10e44"

URI_aarch64_rust-futures-util+write-all-vectored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util+write-all-vectored-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util+write-all-vectored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util+write-all-vectored-devel}"
SRC_URI[aarch64_rust-futures-util+write-all-vectored-devel.sha256sum] = "bd2c6418ae3140366e8ecac03a0595a6b116a36a5f991a6a2a54a695e1ff90bf"

URI_aarch64_rust-futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-util-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-util-devel}"
SRC_URI[aarch64_rust-futures-util-devel.sha256sum] = "d53798512cf12830f576aebf613d3358f95fdfe37edfff4f1136d12dd353cc03"

RDEPENDS:rust-futures-util+alloc-devel = " \
 cargo \
 rust-futures-core+alloc-devel \
 rust-futures-task+alloc-devel \
 rust-futures-util+slab-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+async-await-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+async-await-macro-devel = " \
 cargo \
 rust-futures-util+async-await-devel \
 rust-futures-util+futures-macro-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+bilock-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+cfg-target-has-atomic-devel = " \
 cargo \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+channel-devel = " \
 cargo \
 rust-futures-util+futures-channel-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+default-devel = " \
 cargo \
 rust-futures-util+async-await-devel \
 rust-futures-util+async-await-macro-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-channel-devel = " \
 cargo \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-io-devel = " \
 cargo \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-macro-devel = " \
 cargo \
 rust-futures-macro-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+futures-sink-devel = " \
 cargo \
 rust-futures-sink-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+io-devel = " \
 cargo \
 rust-futures-util+futures-io-devel \
 rust-futures-util+memchr-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+libc-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-futures-util+memchr-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-memchr+default-devel \
 "
RDEPENDS:rust-futures-util+portable-atomic-alloc-devel = " \
 cargo \
 rust-futures-util+portable-atomic-devel \
 rust-futures-util-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-futures-util+portable-atomic-devel = " \
 cargo \
 rust-futures-core+portable-atomic-devel \
 rust-futures-util+portable_atomic_crate-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+portable-atomic-util-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-futures-util+portable_atomic_crate-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-futures-util+sink-devel = " \
 cargo \
 rust-futures-util+futures-sink-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+slab-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-futures-util+spin-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-spin+default-devel \
 "
RDEPENDS:rust-futures-util+std-devel = " \
 cargo \
 rust-futures-core+std-devel \
 rust-futures-task+std-devel \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-slab+std-devel \
 rust-slab-devel \
 "
RDEPENDS:rust-futures-util+unstable-devel = " \
 cargo \
 rust-futures-core+unstable-devel \
 rust-futures-task+unstable-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util+write-all-vectored-devel = " \
 cargo \
 rust-futures-util+io-devel \
 rust-futures-util-devel \
 "
RDEPENDS:rust-futures-util-devel = " \
 cargo \
 rust \
 rust-futures-core-devel \
 rust-futures-task-devel \
 rust-pin-project-lite+default-devel \
 "
