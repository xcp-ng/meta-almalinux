# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glib2"
PV = "2.80.4"
PR = "22.el10"
PACKAGES = " \
 glib2 \
 glib2-devel \
 glib2-doc \
 glib2-static \
 glib2-tests \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glib2-2.80.4-22.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "21c7ae0014df1babe4e0815d00be9df5e79f362dd204e9a033522f7dc36a4140"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glib2-2.80.4-22.el10.x86_64_v2.rpm;name=x86_64_v2_glib2;unpack=0"
SRC_URI[x86_64_v2_glib2.sha256sum] = "e9d8ff66bbb3534d778f3f80696f19f18d05d0fe3601abcc24da986ff2114c09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-devel-2.80.4-22.el10.x86_64_v2.rpm;name=x86_64_v2_glib2-devel;unpack=0"
SRC_URI[x86_64_v2_glib2-devel.sha256sum] = "3c9695cc3a8c33391df517fe2ff4d1c802618a2845a8e889c2c563ab417b54f7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-doc-2.80.4-22.el10.x86_64_v2.rpm;name=x86_64_v2_glib2-doc;unpack=0"
SRC_URI[x86_64_v2_glib2-doc.sha256sum] = "5aa0d2fe8dbcb9517b20a370aa71e67ba767d393f0f3feddab5208ed2c6b0014"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glib2-static-2.80.4-22.el10.x86_64_v2.rpm;name=x86_64_v2_glib2-static;unpack=0"
SRC_URI[x86_64_v2_glib2-static.sha256sum] = "695054eb4e83b508c09efdf6d28431a3850b688502c6ef9ffaf014693575c538"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glib2-tests-2.80.4-22.el10.x86_64_v2.rpm;name=x86_64_v2_glib2-tests;unpack=0"
SRC_URI[x86_64_v2_glib2-tests.sha256sum] = "540c4edd685827a07cce0dc6c643c0692acb6970acc02d9d9a79c407b89141ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glib2-2.80.4-22.el10.aarch64.rpm;name=aarch64_glib2;unpack=0"
SRC_URI[aarch64_glib2.sha256sum] = "25c06d3f72371e11411953cdabd2b74b601909db3fde9e02e25591e62959db5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-devel-2.80.4-22.el10.aarch64.rpm;name=aarch64_glib2-devel;unpack=0"
SRC_URI[aarch64_glib2-devel.sha256sum] = "0f2ddcda2a3f91127b93c9e001c7e1364bb8791159f71e743168162996289142"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-doc-2.80.4-22.el10.aarch64.rpm;name=aarch64_glib2-doc;unpack=0"
SRC_URI[aarch64_glib2-doc.sha256sum] = "528aa8d5f0d4507e48672ae989c89bddfcbaa044222ba397850ae9ef4a4a43a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glib2-static-2.80.4-22.el10.aarch64.rpm;name=aarch64_glib2-static;unpack=0"
SRC_URI[aarch64_glib2-static.sha256sum] = "55a55a362fdfa3bc577113a3870240f68da0bcba714719ab2e7173ed11436e24"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glib2-tests-2.80.4-22.el10.aarch64.rpm;name=aarch64_glib2-tests;unpack=0"
SRC_URI[aarch64_glib2-tests.sha256sum] = "280b55495ed363e5111ceb937856d4624c921781f982c3bd519e1e4af61f6b66"

RDEPENDS:glib2 = " \
 bash \
 glibc \
 gnutls \
 libffi \
 libmount \
 libselinux \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:glib2-devel = " \
 bash \
 elfutils-libelf \
 glib2 \
 glib2-devel \
 glibc \
 libffi \
 libffi-devel \
 libmount-devel \
 libselinux-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 python3 \
 python3-packaging \
 sysprof-capture-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:glib2-doc = " \
 glib2 \
 "
RDEPENDS:glib2-static = " \
 glib2-devel \
 pcre2-static \
 sysprof-capture-devel \
 "
RDEPENDS:glib2-tests = " \
 bash \
 glib2 \
 glibc \
 libgcc \
 pcre2 \
 python3 \
 "
