# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-lxc"
PV = "5.0.0"
PR = "14.el10_1"
PACKAGES = " \
 python3-lxc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-lxc-5.0.0-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdd4fada04f0bb63ea11a16c488153bb8ecf5d299bcdda9c0f451acfa7e2cf58"

URI_x86_64_v2_python3-lxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-lxc-5.0.0-14.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-lxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lxc}"
SRC_URI[x86_64_v2_python3-lxc.sha256sum] = "041973948ff6acc603728dae1e43d230a3a536e9427962e2884d6a26b487ad40"

URI_aarch64_python3-lxc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-lxc-5.0.0-14.el10_1.aarch64.rpm;name=aarch64_python3-lxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lxc}"
SRC_URI[aarch64_python3-lxc.sha256sum] = "32336f5cb9b3f27cf242e8d1977e57a99587bb4d31a87f3b027295d5584d586c"

RDEPENDS:python3-lxc = " \
 glibc \
 lxc-libs \
 python3 \
 "
