# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fsspec-xrootd"
PV = "0.5.5"
PR = "1.el10_3"
PACKAGES = " \
 python3-fsspec-xrootd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-fsspec-xrootd-0.5.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b4f48ec731c42fe9dbb29d9e41df1f22b89e7a44a43ba163f0cc01eaae21df1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fsspec-xrootd-0.5.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fsspec-xrootd;unpack=0"
SRC_URI[x86_64_v2_python3-fsspec-xrootd.sha256sum] = "bf41a63adb42384db0b8723a4bfcb284c488e57e862e507ffcd7d482eed917b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-fsspec-xrootd-0.5.5-1.el10_3.noarch.rpm;name=aarch64_python3-fsspec-xrootd;unpack=0"
SRC_URI[aarch64_python3-fsspec-xrootd.sha256sum] = "1678fbb846e8c8815a6520f413ecfe7c6650304a52722271ace157d8664fe2fc"

RDEPENDS:python3-fsspec-xrootd = " \
 python3 \
 python3-fsspec \
 python3-xrootd \
 "
