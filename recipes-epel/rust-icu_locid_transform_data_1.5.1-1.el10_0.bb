# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locid_transform_data"
PV = "1.5.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-icu_locid_transform_data+default-devel \
 rust-icu_locid_transform_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locid_transform_data-1.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4bf0cccc0c704a5d3e2e3b6ad47ead614ef208c348e9833db525014ad0764ca6"

URI_x86_64_v2_rust-icu_locid_transform_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid_transform_data+default-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid_transform_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid_transform_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locid_transform_data+default-devel.sha256sum] = "15f0ccd57f4d49ea6d2f484a0cdfa9cddece3d9a01dffaa093313ff7c644afe2"

URI_x86_64_v2_rust-icu_locid_transform_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locid_transform_data-devel-1.5.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locid_transform_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locid_transform_data-devel}"
SRC_URI[x86_64_v2_rust-icu_locid_transform_data-devel.sha256sum] = "3bd356039d9dd1bac58f12192e5fb0e5def34ca054bf42cf91f5b67ab2f14b53"

URI_aarch64_rust-icu_locid_transform_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid_transform_data+default-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_locid_transform_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid_transform_data+default-devel}"
SRC_URI[aarch64_rust-icu_locid_transform_data+default-devel.sha256sum] = "c413de775186fad3d0a8088fd132dca569d53aa3ed7f426a05666d74edb8249b"

URI_aarch64_rust-icu_locid_transform_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locid_transform_data-devel-1.5.1-1.el10_0.noarch.rpm;name=aarch64_rust-icu_locid_transform_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locid_transform_data-devel}"
SRC_URI[aarch64_rust-icu_locid_transform_data-devel.sha256sum] = "7fac4862d00f53a9bed405cb79cfef022b0fd03ad1fda3e36cca4c2294aac030"

RDEPENDS:rust-icu_locid_transform_data+default-devel = " \
 cargo \
 rust-icu_locid_transform_data-devel \
 "
RDEPENDS:rust-icu_locid_transform_data-devel = " \
 cargo \
 rust \
 "
