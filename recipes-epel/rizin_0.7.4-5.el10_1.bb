# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rizin"
PV = "0.7.4"
PR = "5.el10_1"
PACKAGES = " \
 rizin \
 rizin-common \
 rizin-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rizin-0.7.4-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "66af3377e6a8056ab5760a2a6e7af48d246acf0bf49713d058a0cc787c7e43f7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rizin-0.7.4-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rizin;unpack=0"
SRC_URI[x86_64_v2_rizin.sha256sum] = "2788789bdc9f01c2a035472e63698f2ca81a904248c9418d4e01d3aac9bfecd2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rizin-common-0.7.4-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rizin-common;unpack=0"
SRC_URI[x86_64_v2_rizin-common.sha256sum] = "14f5757f9a9c6503ca59a54af540f98c2e6ab54a1cd01280c310e2c1d73f0168"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rizin-devel-0.7.4-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rizin-devel;unpack=0"
SRC_URI[x86_64_v2_rizin-devel.sha256sum] = "01248467091464f1480d907bf9005425e6411fc7818ac8ce57add24a6ed411b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rizin-0.7.4-5.el10_1.aarch64.rpm;name=aarch64_rizin;unpack=0"
SRC_URI[aarch64_rizin.sha256sum] = "b3668fffe1243dd79942fe52220792ffc7911d1d11267a7b8a902f914ab8fffb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rizin-common-0.7.4-5.el10_1.noarch.rpm;name=aarch64_rizin-common;unpack=0"
SRC_URI[aarch64_rizin-common.sha256sum] = "4c2514d80cbcc7d2ac656dc837da6e237d61965623131aaacf437662ca4bd432"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rizin-devel-0.7.4-5.el10_1.aarch64.rpm;name=aarch64_rizin-devel;unpack=0"
SRC_URI[aarch64_rizin-devel.sha256sum] = "4a4f79aa64c38e0c36ec11c44e52c0056165664159bfdac787d4dcb87d6d3f70"

RDEPENDS:rizin = " \
 capstone \
 file-libs \
 glibc \
 libmspack \
 libtree-sitter \
 libzip \
 libzstd \
 lz4-libs \
 openssl-libs \
 rizin-common \
 xxhash-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:rizin-common = " \
 rizin \
 "
RDEPENDS:rizin-devel = " \
 capstone-devel \
 file-devel \
 libmspack-devel \
 libtree-sitter-devel \
 libzip-devel \
 libzstd-devel \
 lz4-devel \
 openssl-devel \
 pkgconf-pkg-config \
 rizin \
 rizin-devel \
 xxhash-devel \
 xz-devel \
 zlib-ng-compat-devel \
 "
