# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-baloo"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-baloo \
 kf6-baloo-devel \
 kf6-baloo-doc \
 kf6-baloo-file \
 kf6-baloo-html \
 kf6-baloo-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-baloo-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b221db314e92ebf920e051c76cef64cb03a66cb729fdb46dc06405fcd618111"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo;unpack=0"
SRC_URI[x86_64_v2_kf6-baloo.sha256sum] = "7f8c6f0407b22bef1d196ebe851350301135831c01eba36519e86242a948005e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-baloo-devel.sha256sum] = "77f2ddc94558b5ead23e11d9ffbb01c0c7bfe51ee1a582225ff6e4deb7b25658"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-baloo-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-baloo-doc.sha256sum] = "4ebb9f71ede722231a6ba6aec36b88b68f6a0dffd48973c105168e89b56f3c49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-file-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-file;unpack=0"
SRC_URI[x86_64_v2_kf6-baloo-file.sha256sum] = "e2138fb328ffeca2e19cf5320e369500fa4341dedeec929356f152928ded6c9b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-baloo-html;unpack=0"
SRC_URI[x86_64_v2_kf6-baloo-html.sha256sum] = "835f23342104804e0218229e6410a29b089e826ad5cb1672b7b4999f9a6db018"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-libs-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-libs;unpack=0"
SRC_URI[x86_64_v2_kf6-baloo-libs.sha256sum] = "5af5bf36ee03d39497ea0dbcb1cfe624a13aa236d4661a1851fb3efdc2106a0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-baloo;unpack=0"
SRC_URI[aarch64_kf6-baloo.sha256sum] = "c07051f224ac08f69e8983d1522b033c297b1c97a6571363659720e7e4596f41"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-baloo-devel;unpack=0"
SRC_URI[aarch64_kf6-baloo-devel.sha256sum] = "97d01a10313ea43b8caa013139cd0380b8efc59137c45c6e8d3ee5d8db3d795e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-baloo-doc;unpack=0"
SRC_URI[aarch64_kf6-baloo-doc.sha256sum] = "a36290776864e89559767ba0e4b3785b39a5fb21edf6355a944efc5679328fcf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-file-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-baloo-file;unpack=0"
SRC_URI[aarch64_kf6-baloo-file.sha256sum] = "348fcb30f0799d850981fd3991e13484f6ed560cc432f20bb34b03ec61336552"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-baloo-html;unpack=0"
SRC_URI[aarch64_kf6-baloo-html.sha256sum] = "c27f7fe6b80dfe9ec72b90ae36c9824eb855696ece1b74c7b53b4a2ada47ed8b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-libs-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-baloo-libs;unpack=0"
SRC_URI[aarch64_kf6-baloo-libs.sha256sum] = "9ad41ab6f69a74ece8d82b90f8264636a0659b8ec902e882a6c4b418f2d9704e"

RDEPENDS:kf6-baloo = " \
 glibc \
 kf6-baloo-libs \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-baloo-devel = " \
 cmake-filesystem \
 kf6-baloo-libs \
 kf6-kcoreaddons-devel \
 kf6-kfilemetadata-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-baloo-doc = " \
 "
RDEPENDS:kf6-baloo-file = " \
 glibc \
 kf6-baloo-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kidletime \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-baloo-html = " \
 "
RDEPENDS:kf6-baloo-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-solid \
 libstdc++ \
 lmdb-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
