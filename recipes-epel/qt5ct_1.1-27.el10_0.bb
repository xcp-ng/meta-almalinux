# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5ct"
PV = "1.1"
PR = "27.el10_0"
PACKAGES = " \
 qt5ct \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5ct-1.1-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "119f6f0f80ffe8646d7896cccd3ab6ddee778959a9b689bd562cd4ed9355d267"

URI_x86_64_v2_qt5ct = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5ct-1.1-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5ct;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5ct}"
SRC_URI[x86_64_v2_qt5ct.sha256sum] = "dd069b6b20e88c85347ae951ccb6efb30d365629fbfa8a16f669e51cc29d7fe9"

URI_aarch64_qt5ct = "${EPEL_MIRROR}/aarch64/Packages/q/qt5ct-1.1-27.el10_0.aarch64.rpm;name=aarch64_qt5ct;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5ct}"
SRC_URI[aarch64_qt5ct.sha256sum] = "2a3ee9f220a190db5f3af3b0a394cd8acd2b644e9bec7a5f30e2dbacce270611"

RDEPENDS:qt5ct = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
