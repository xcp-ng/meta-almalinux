# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Gtk3"
PV = "0.038"
PR = "18.el10_1"
PACKAGES = " \
 perl-Gtk3 \
 perl-Gtk3-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Gtk3-0.038-18.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d04940f0d51b802af084290ce0c7a87e77262487b4a946c1830ce51f49e8ae9c"

URI_x86_64_v2_perl-Gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-0.038-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3}"
SRC_URI[x86_64_v2_perl-Gtk3.sha256sum] = "fe050ef2818f7a95495418119807dbf00b1fba88ca5e4ec498f309b6c3c41146"

URI_x86_64_v2_perl-Gtk3-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-tests-0.038-18.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-tests}"
SRC_URI[x86_64_v2_perl-Gtk3-tests.sha256sum] = "9dc3764837462ec132b53a1622344541b42849e39c830a0808ff9b0f19ee0ffc"

URI_aarch64_perl-Gtk3 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-0.038-18.el10_1.noarch.rpm;name=aarch64_perl-Gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3}"
SRC_URI[aarch64_perl-Gtk3.sha256sum] = "0ed24d7d1876b3095798257b7454d718d68561607d4d4a869502e64385df9cff"

URI_aarch64_perl-Gtk3-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-tests-0.038-18.el10_1.noarch.rpm;name=aarch64_perl-Gtk3-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-tests}"
SRC_URI[aarch64_perl-Gtk3-tests.sha256sum] = "9381bc45de8e7b34ae9732fcc557fa834807ff6b0c0b5c94fbb6da57708e170b"

RDEPENDS:perl-Gtk3 = " \
 gtk3 \
 perl-Cairo-GObject \
 perl-Carp \
 perl-Exporter \
 perl-Glib-Object-Introspection \
 perl-POSIX \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Gtk3-tests = " \
 bash \
 gdk-pixbuf2-modules-extra \
 mutter \
 perl-Encode \
 perl-File-Temp \
 perl-Glib \
 perl-Gtk3 \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-constant \
 perl-interpreter \
 perl-libs \
 xwayland-run \
 "
