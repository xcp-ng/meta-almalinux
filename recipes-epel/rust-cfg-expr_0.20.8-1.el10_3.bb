# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cfg-expr"
PV = "0.20.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-cfg-expr+default-devel \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr+targets-devel \
 rust-cfg-expr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cfg-expr-0.20.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3fb941cd6a543cc5ebdd2e3fa734fe381966782683b951328dd775747d8ba53"

URI_x86_64_v2_rust-cfg-expr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+default-devel-0.20.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr+default-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr+default-devel.sha256sum] = "5f475c71f25ef37f32ef4be7fa6822c429d44cad0a622cb936f8e4fde3fd4088"
RPROVIDES:rust-cfg-expr+default-devel:x86_64_v2 = "virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

URI_x86_64_v2_rust-cfg-expr+target-lexicon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+target-lexicon-devel-0.20.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr+target-lexicon-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr+target-lexicon-devel.sha256sum] = "821779cb720c6d032a7f11ec31de6e4f1969c6c95d1c16c24478d09b1211705b"

URI_x86_64_v2_rust-cfg-expr+targets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr+targets-devel-0.20.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr+targets-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr+targets-devel.sha256sum] = "39585ed03925858703765a68bfb915ce6a05860af8467d1f1d5a4d7ca6bc13d0"
RPROVIDES:rust-cfg-expr+targets-devel:x86_64_v2 = "virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

URI_x86_64_v2_rust-cfg-expr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cfg-expr-devel-0.20.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cfg-expr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cfg-expr-devel}"
SRC_URI[x86_64_v2_rust-cfg-expr-devel.sha256sum] = "f18b1ac1c513c54f89739e0ffe943f14b6a394c31089befe0db66d0675857f0a"

URI_aarch64_rust-cfg-expr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+default-devel-0.20.8-1.el10_3.noarch.rpm;name=aarch64_rust-cfg-expr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr+default-devel}"
SRC_URI[aarch64_rust-cfg-expr+default-devel.sha256sum] = "e18db80ae049b8437380c8df162e5c13218714952559ee211705837a8dc2285e"
RPROVIDES:rust-cfg-expr+default-devel:aarch64 = "virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~"

URI_aarch64_rust-cfg-expr+target-lexicon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+target-lexicon-devel-0.20.8-1.el10_3.noarch.rpm;name=aarch64_rust-cfg-expr+target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr+target-lexicon-devel}"
SRC_URI[aarch64_rust-cfg-expr+target-lexicon-devel.sha256sum] = "cecbca582558ebdaf80c576a2d96ba66e2e78b180f147daed33a7ca9a6801bc5"

URI_aarch64_rust-cfg-expr+targets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr+targets-devel-0.20.8-1.el10_3.noarch.rpm;name=aarch64_rust-cfg-expr+targets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr+targets-devel}"
SRC_URI[aarch64_rust-cfg-expr+targets-devel.sha256sum] = "6d0941ac3b8008ea7b431ff4757be4aede706683efa7d984d2edf2b48e951f93"
RPROVIDES:rust-cfg-expr+targets-devel:aarch64 = "virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

URI_aarch64_rust-cfg-expr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cfg-expr-devel-0.20.8-1.el10_3.noarch.rpm;name=aarch64_rust-cfg-expr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cfg-expr-devel}"
SRC_URI[aarch64_rust-cfg-expr-devel.sha256sum] = "25163a2ca66a521cede485057fff13178620863470f9e69dd5acf00805b62f08"

RDEPENDS:rust-cfg-expr+default-devel = " \
 cargo \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr+target-lexicon-devel = " \
 cargo \
 rust-cfg-expr-devel \
 rust-target-lexicon+default-devel \
 "
RDEPENDS:rust-cfg-expr+targets-devel = " \
 cargo \
 rust-cfg-expr+target-lexicon-devel \
 rust-cfg-expr-devel \
 "
RDEPENDS:rust-cfg-expr-devel = " \
 cargo \
 rust \
 rust-smallvec+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~ rpm/virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~ rpm/virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~"
