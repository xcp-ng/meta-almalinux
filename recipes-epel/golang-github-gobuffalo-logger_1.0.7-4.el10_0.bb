# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gobuffalo-logger"
PV = "1.0.7"
PR = "4.el10_0"
PACKAGES = " \
 golang-github-gobuffalo-logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gobuffalo-logger-1.0.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "402adc1089ff41c6f172f47dac1ffa958044e7e4165b2654917527c7e5c9b6f1"

URI_x86_64_v2_golang-github-gobuffalo-logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gobuffalo-logger-devel-1.0.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gobuffalo-logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gobuffalo-logger-devel}"
SRC_URI[x86_64_v2_golang-github-gobuffalo-logger-devel.sha256sum] = "d59715836bcd4a913d9e66557ac5efd2854a0ae5aab595557d476c27d9fa8ff9"

URI_aarch64_golang-github-gobuffalo-logger-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gobuffalo-logger-devel-1.0.7-4.el10_0.noarch.rpm;name=aarch64_golang-github-gobuffalo-logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gobuffalo-logger-devel}"
SRC_URI[aarch64_golang-github-gobuffalo-logger-devel.sha256sum] = "c6ded15d7ceb3587030b8c6ff1fed775bfe9469b38f154af6fff549fe01c4f44"

RDEPENDS:golang-github-gobuffalo-logger-devel = " \
 go-filesystem \
 golang-github-sirupsen-logrus-devel \
 golang-x-term-devel \
 "
