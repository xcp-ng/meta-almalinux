# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sympa"
PV = "6.2.78"
PR = "3.el10_3"
PACKAGES = " \
 sympa \
 sympa-devel-doc \
 sympa-httpd \
 sympa-lighttpd \
 sympa-nginx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sympa-6.2.78-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d793f4360751fa70d1f1dac8d4b4943543a4e5a638048e4b4f1917424055ede2"

URI_x86_64_v2_sympa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-6.2.78-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sympa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa}"
SRC_URI[x86_64_v2_sympa.sha256sum] = "2f90d32b0203304fe5a1c8692e6f899ce33a7e5aca5c14414c3d1d65c1c27192"

URI_x86_64_v2_sympa-devel-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-devel-doc-6.2.78-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-devel-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-devel-doc}"
SRC_URI[x86_64_v2_sympa-devel-doc.sha256sum] = "357e7c1b5045258649bd40c20ddf5f9bc028efad9b222f261445618d7bb4e6bc"

URI_x86_64_v2_sympa-httpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-httpd-6.2.78-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-httpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-httpd}"
SRC_URI[x86_64_v2_sympa-httpd.sha256sum] = "c058d3703ecd9b13662bd8154f85df5da2263474c79c637eb93f6ba5d15a70b3"

URI_x86_64_v2_sympa-lighttpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-lighttpd-6.2.78-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-lighttpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-lighttpd}"
SRC_URI[x86_64_v2_sympa-lighttpd.sha256sum] = "5a36b6191b20694e6d856aa137cd6d06b2424cd1cfd06bc8728b8535afea57dd"

URI_x86_64_v2_sympa-nginx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sympa-nginx-6.2.78-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_sympa-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sympa-nginx}"
SRC_URI[x86_64_v2_sympa-nginx.sha256sum] = "191f5c82f3bb9db3e5a7bd95a8e2bca4a8ee821eb2c84ec50ad85005f0b608bd"

URI_aarch64_sympa = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-6.2.78-3.el10_3.aarch64.rpm;name=aarch64_sympa;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa}"
SRC_URI[aarch64_sympa.sha256sum] = "345ee911943854ccbbc232054565832b150627fca4f8b8669e8c2b016b01b794"

URI_aarch64_sympa-devel-doc = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-devel-doc-6.2.78-3.el10_3.noarch.rpm;name=aarch64_sympa-devel-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-devel-doc}"
SRC_URI[aarch64_sympa-devel-doc.sha256sum] = "72911f7674e035811cee7d1a5f0f7c5d97d8f31c56ef20ba5016d684a7775d53"

URI_aarch64_sympa-httpd = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-httpd-6.2.78-3.el10_3.noarch.rpm;name=aarch64_sympa-httpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-httpd}"
SRC_URI[aarch64_sympa-httpd.sha256sum] = "6a2ef71efc60eeb626c97806c9f852f9f9c44544706edab17eadf771edf970bc"

URI_aarch64_sympa-lighttpd = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-lighttpd-6.2.78-3.el10_3.noarch.rpm;name=aarch64_sympa-lighttpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-lighttpd}"
SRC_URI[aarch64_sympa-lighttpd.sha256sum] = "64b0703f2ae259a47ad10539bebd1480b331e0b43b2917689e6db3df0977cb4d"

URI_aarch64_sympa-nginx = "${EPEL_MIRROR}/aarch64/Packages/s/sympa-nginx-6.2.78-3.el10_3.noarch.rpm;name=aarch64_sympa-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_sympa-nginx}"
SRC_URI[aarch64_sympa-nginx.sha256sum] = "b0382ca75d0df15d6a5f26eb477bca3df12c77153f9b4ef0bd25b76df9d896ef"

RDEPENDS:sympa = " \
 bash \
 glibc \
 js-jquery \
 js-jquery-ui \
 logrotate \
 mhonarc \
 perl-Archive-Zip-SimpleZip \
 perl-AuthCAS \
 perl-CGI \
 perl-CGI-Fast \
 perl-Carp \
 perl-Class-Singleton \
 perl-Clone \
 perl-Crypt-CipherSaber \
 perl-Crypt-Eksblowfish \
 perl-Crypt-OpenSSL-X509 \
 perl-Crypt-SMIME \
 perl-DBD-CSV \
 perl-DBD-MySQL \
 perl-DBI \
 perl-Data-Dumper \
 perl-Data-Password \
 perl-DateTime \
 perl-DateTime-Format-Mail \
 perl-DateTime-TimeZone \
 perl-Digest-MD5 \
 perl-Encode \
 perl-Encode-EUCJPASCII \
 perl-Encode-HanExtra \
 perl-Encode-Locale \
 perl-English \
 perl-FCGI \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Copy-Recursive \
 perl-File-Find \
 perl-File-NFSLock \
 perl-File-Path \
 perl-Getopt-Long \
 perl-HTML-Formatter \
 perl-HTML-Parser \
 perl-HTML-StripScripts-Parser \
 perl-HTML-Tree \
 perl-HTTP-Cookies \
 perl-HTTP-Message \
 perl-IO \
 perl-IO-Socket-IP \
 perl-IO-Socket-SSL \
 perl-IO-stringy \
 perl-LDAP \
 perl-LWP-Protocol-https \
 perl-MIME-Base64 \
 perl-MIME-Charset \
 perl-MIME-EncWords \
 perl-MIME-Lite-HTML \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-MailTools \
 perl-Net-CIDR \
 perl-Net-DNS \
 perl-POSIX \
 perl-PathTools \
 perl-Pod-Usage \
 perl-SOAP-Lite \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Sys-Syslog \
 perl-Template-Toolkit \
 perl-Term-ProgressBar \
 perl-Time-HiRes \
 perl-Time-Local \
 perl-URI \
 perl-URI-Find \
 perl-Unicode-LineBreak \
 perl-Unicode-Normalize \
 perl-Unicode-UTF8 \
 perl-XML-LibXML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libintl-perl \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 perl-parent \
 shadow-utils \
 sympa \
 systemd \
 virtual/smtpdaemon \
 "
RDEPENDS:sympa-devel-doc = " \
 sympa \
 "
RDEPENDS:sympa-httpd = " \
 bash \
 httpd \
 multiwatch \
 sympa \
 "
RDEPENDS:sympa-lighttpd = " \
 lighttpd \
 lighttpd-fastcgi \
 sympa \
 "
RDEPENDS:sympa-nginx = " \
 bash \
 multiwatch \
 nginx \
 sympa \
 "
