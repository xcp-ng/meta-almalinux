# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-setuptools-git-versioning"
PV = "2.1.0"
PR = "16.el10_1"
PACKAGES = " \
 python3-setuptools-git-versioning \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-setuptools-git-versioning-2.1.0-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f21a42fb94cdbaa79bca247ffa478c92129102d274f7e5a29708007372a8fd8d"

URI_x86_64_v2_python3-setuptools-git-versioning = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-setuptools-git-versioning-2.1.0-16.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-setuptools-git-versioning;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setuptools-git-versioning}"
SRC_URI[x86_64_v2_python3-setuptools-git-versioning.sha256sum] = "b7c72b87915b49c962dd09867c708d23aaf685e34019e9af18e0a85a45509fa8"

URI_aarch64_python3-setuptools-git-versioning = "${EPEL_MIRROR}/aarch64/Packages/p/python3-setuptools-git-versioning-2.1.0-16.el10_1.noarch.rpm;name=aarch64_python3-setuptools-git-versioning;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setuptools-git-versioning}"
SRC_URI[aarch64_python3-setuptools-git-versioning.sha256sum] = "11ef4ec675117cf6858007a8a2ccf2a4a696b582c9172e35d39fb73c10b0d91f"

RDEPENDS:python3-setuptools-git-versioning = " \
 python3 \
 python3-packaging \
 python3-setuptools \
 "
