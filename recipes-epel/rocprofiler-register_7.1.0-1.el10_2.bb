# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocprofiler-register"
PV = "7.1.0"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 rocprofiler-register \
 rocprofiler-register-devel \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rocprofiler-register-7.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "200b1827bdbcd43c9a9a4bf64c31f455005824a5ad5b6894b4abdf080b7743a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocprofiler-register-7.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocprofiler-register;unpack=0"
SRC_URI[x86_64_v2_rocprofiler-register.sha256sum] = "e19513ce1749048d07f9e08c6b11c56b121a3075e5205a6eadd9064494038489"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocprofiler-register-devel-7.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocprofiler-register-devel;unpack=0"
SRC_URI[x86_64_v2_rocprofiler-register-devel.sha256sum] = "408a6b324dc5255de69a830b8781662f0a43851d36cdda9287473cfa200b0e7a"

RDEPENDS:rocprofiler-register = " \
 fmt \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:rocprofiler-register-devel = " \
 cmake-filesystem \
 rocprofiler-register \
 "
