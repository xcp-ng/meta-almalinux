# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-bugzilla-redhat"
PV = "1.0.1.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-bugzilla-redhat \
 ghc-bugzilla-redhat-devel \
 ghc-bugzilla-redhat-doc \
 ghc-bugzilla-redhat-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-bugzilla-redhat-1.0.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2058ec19b16fec4b8792fb5ea51c4f98de03bc6b64b82269bd9e6f69672f806a"

URI_x86_64_v2_ghc-bugzilla-redhat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bugzilla-redhat-1.0.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bugzilla-redhat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bugzilla-redhat}"
SRC_URI[x86_64_v2_ghc-bugzilla-redhat.sha256sum] = "5aaea3b18e5bc76934fbc68df3d6a6419ef1b2a367eb9305948dd4d1b86af073"

URI_x86_64_v2_ghc-bugzilla-redhat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bugzilla-redhat-devel-1.0.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bugzilla-redhat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bugzilla-redhat-devel}"
SRC_URI[x86_64_v2_ghc-bugzilla-redhat-devel.sha256sum] = "b2e5fc36b0a556ade6063efc75bef5dda692718a54ae4ff4a83dbfe7ea565a5d"

URI_x86_64_v2_ghc-bugzilla-redhat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bugzilla-redhat-doc-1.0.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-bugzilla-redhat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bugzilla-redhat-doc}"
SRC_URI[x86_64_v2_ghc-bugzilla-redhat-doc.sha256sum] = "ed50592edf2881a6f5510a44507678587f883adb370820ac768b5e9c737fa417"

URI_x86_64_v2_ghc-bugzilla-redhat-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-bugzilla-redhat-prof-1.0.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-bugzilla-redhat-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-bugzilla-redhat-prof}"
SRC_URI[x86_64_v2_ghc-bugzilla-redhat-prof.sha256sum] = "dbafa57c12c2878d0035d20c5ca391bee5527d5dd6644b8d81c59483e63369b9"

URI_aarch64_ghc-bugzilla-redhat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bugzilla-redhat-1.0.1.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-bugzilla-redhat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bugzilla-redhat}"
SRC_URI[aarch64_ghc-bugzilla-redhat.sha256sum] = "78d70f1865daffd388a64636897e34d512bfcf5f91c1be61dfe3388bec0436e9"

URI_aarch64_ghc-bugzilla-redhat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bugzilla-redhat-devel-1.0.1.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-bugzilla-redhat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bugzilla-redhat-devel}"
SRC_URI[aarch64_ghc-bugzilla-redhat-devel.sha256sum] = "332a6633abe1bcb9a19ba116b9aa9bedb23fc38b52c64cc9841ab338100bf851"

URI_aarch64_ghc-bugzilla-redhat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bugzilla-redhat-doc-1.0.1.1-1.el10_0.noarch.rpm;name=aarch64_ghc-bugzilla-redhat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bugzilla-redhat-doc}"
SRC_URI[aarch64_ghc-bugzilla-redhat-doc.sha256sum] = "8c9610b70d992e0c92e61aed5c95d7cb2284c59e97b32d9c8ea490dad8fc94af"

URI_aarch64_ghc-bugzilla-redhat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-bugzilla-redhat-prof-1.0.1.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-bugzilla-redhat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-bugzilla-redhat-prof}"
SRC_URI[aarch64_ghc-bugzilla-redhat-prof.sha256sum] = "9ec88f3b4e448b3e50cc73104d2b77819a84bbd4dc33f9bb063b771914522753"

RDEPENDS:ghc-bugzilla-redhat = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-iso8601-time \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-bugzilla-redhat-devel = " \
 ghc-aeson-devel \
 ghc-base-devel \
 ghc-blaze-builder-devel \
 ghc-bugzilla-redhat \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-http-conduit-devel \
 ghc-http-types-devel \
 ghc-iso8601-time-devel \
 ghc-resourcet-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-unordered-containers-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-bugzilla-redhat-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-bugzilla-redhat-prof = " \
 ghc-aeson-prof \
 ghc-base-prof \
 ghc-blaze-builder-prof \
 ghc-bugzilla-redhat-devel \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-http-conduit-prof \
 ghc-http-types-prof \
 ghc-iso8601-time-prof \
 ghc-resourcet-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-unordered-containers-prof \
 ghc-vector-prof \
 "
