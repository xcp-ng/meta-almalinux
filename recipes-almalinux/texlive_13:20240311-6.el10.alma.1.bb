# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "texlive"
PE = "13"
PV = "20240311"
PR = "6.el10.alma.1"
PACKAGES = " \
 texlive \
 texlive-acronym \
 texlive-adjustbox \
 texlive-ae \
 texlive-algorithms \
 texlive-alphalph \
 texlive-amscls \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-anyfontsize \
 texlive-anysize \
 texlive-appendix \
 texlive-arphic \
 texlive-atbegshi \
 texlive-attachfile \
 texlive-attachfile2 \
 texlive-atveryend \
 texlive-auxhook \
 texlive-avantgar \
 texlive-awesomebox \
 texlive-babel \
 texlive-babel-english \
 texlive-babelbib \
 texlive-base \
 texlive-beamer \
 texlive-bera \
 texlive-beton \
 texlive-bibtex \
 texlive-bibtopic \
 texlive-bidi \
 texlive-bigfoot \
 texlive-bigintcalc \
 texlive-bitset \
 texlive-bookman \
 texlive-bookmark \
 texlive-booktabs \
 texlive-breakurl \
 texlive-breqn \
 texlive-capt-of \
 texlive-caption \
 texlive-carlisle \
 texlive-catchfile \
 texlive-changebar \
 texlive-changepage \
 texlive-charter \
 texlive-chngcntr \
 texlive-cite \
 texlive-classpack \
 texlive-cm \
 texlive-cm-lgc \
 texlive-cm-super \
 texlive-cmap \
 texlive-cmextra \
 texlive-cns \
 texlive-collectbox \
 texlive-collection-basic \
 texlive-collection-fontsrecommended \
 texlive-collection-htmlxml \
 texlive-collection-latex \
 texlive-collection-latexrecommended \
 texlive-collection-xetex \
 texlive-colorprofiles \
 texlive-colortbl \
 texlive-context \
 texlive-count1to \
 texlive-courier \
 texlive-crop \
 texlive-csquotes \
 texlive-ctable \
 texlive-ctablestack \
 texlive-currfile \
 texlive-datetime \
 texlive-dehyph \
 texlive-dvipdfmx \
 texlive-dvipng \
 texlive-dvips \
 texlive-dvisvgm \
 texlive-ec \
 texlive-eepic \
 texlive-enctex \
 texlive-enumitem \
 texlive-environ \
 texlive-epsf \
 texlive-epstopdf \
 texlive-epstopdf-pkg \
 texlive-eqparbox \
 texlive-eso-pic \
 texlive-etex \
 texlive-etex-pkg \
 texlive-etexcmds \
 texlive-etoc \
 texlive-etoolbox \
 texlive-euenc \
 texlive-euler \
 texlive-euro \
 texlive-eurosym \
 texlive-everysel \
 texlive-everyshi \
 texlive-extsizes \
 texlive-fancybox \
 texlive-fancyhdr \
 texlive-fancyref \
 texlive-fancyvrb \
 texlive-filecontents \
 texlive-filehook \
 texlive-finstrut \
 texlive-firstaid \
 texlive-fix2col \
 texlive-fixlatvian \
 texlive-float \
 texlive-fmtcount \
 texlive-fncychap \
 texlive-fontawesome \
 texlive-fontbook \
 texlive-fonts-tlwg \
 texlive-fontspec \
 texlive-fontware \
 texlive-fontwrap \
 texlive-footmisc \
 texlive-footnotehyper \
 texlive-fp \
 texlive-fpl \
 texlive-framed \
 texlive-garuda-c90 \
 texlive-geometry \
 texlive-gettitlestring \
 texlive-glyphlist \
 texlive-gnu-freefont \
 texlive-graphics \
 texlive-graphics-cfg \
 texlive-graphics-def \
 texlive-grfext \
 texlive-grffile \
 texlive-gsftopk \
 texlive-hanging \
 texlive-helvetic \
 texlive-hobsub \
 texlive-hologo \
 texlive-hopatch \
 texlive-hycolor \
 texlive-hypcap \
 texlive-hypdoc \
 texlive-hyperref \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-hyphenat \
 texlive-hyphenex \
 texlive-ifmtarg \
 texlive-ifoddpage \
 texlive-ifplatform \
 texlive-iftex \
 texlive-import \
 texlive-index \
 texlive-infwarerr \
 texlive-intcalc \
 texlive-jadetex \
 texlive-jknapltx \
 texlive-kastrup \
 texlive-kerkis \
 texlive-knuth-lib \
 texlive-knuth-local \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-kvdefinekeys \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-l3backend \
 texlive-l3experimental \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lastpage \
 texlive-latex \
 texlive-latex-fonts \
 texlive-latex2man \
 texlive-latexbug \
 texlive-latexconfig \
 texlive-letltxmacro \
 texlive-lettrine \
 texlive-lib \
 texlive-lib-devel \
 texlive-linegoal \
 texlive-lineno \
 texlive-listings \
 texlive-listofitems \
 texlive-lm \
 texlive-lm-math \
 texlive-ltabptch \
 texlive-ltxcmds \
 texlive-ltxmisc \
 texlive-lua-alt-getopt \
 texlive-lua-uni-algos \
 texlive-luahbtex \
 texlive-lualatex-math \
 texlive-lualibs \
 texlive-luaotfload \
 texlive-luatex \
 texlive-luatex85 \
 texlive-luatexbase \
 texlive-lwarp \
 texlive-makecmds \
 texlive-makeindex \
 texlive-manfnt-font \
 texlive-marginnote \
 texlive-marvosym \
 texlive-mathpazo \
 texlive-mathspec \
 texlive-mathtools \
 texlive-mdwtools \
 texlive-memoir \
 texlive-metafont \
 texlive-metalogo \
 texlive-metapost \
 texlive-mflogo \
 texlive-mflogo-font \
 texlive-mfnfss \
 texlive-mfware \
 texlive-microtype \
 texlive-minitoc \
 texlive-mnsymbol \
 texlive-modes \
 texlive-mparhack \
 texlive-mptopdf \
 texlive-multido \
 texlive-multirow \
 texlive-multitoc \
 texlive-natbib \
 texlive-ncctools \
 texlive-ncntrsbk \
 texlive-needspace \
 texlive-newfloat \
 texlive-newunicodechar \
 texlive-norasi-c90 \
 texlive-notoccite \
 texlive-ntgclass \
 texlive-oberdiek \
 texlive-overpic \
 texlive-palatino \
 texlive-paralist \
 texlive-parallel \
 texlive-parskip \
 texlive-passivetex \
 texlive-pdfcol \
 texlive-pdfcolfoot \
 texlive-pdfcolmk \
 texlive-pdfescape \
 texlive-pdflscape \
 texlive-pdfmanagement-testphase \
 texlive-pdfpages \
 texlive-pdftex \
 texlive-pdftexcmds \
 texlive-pgf \
 texlive-philokalia \
 texlive-placeins \
 texlive-plain \
 texlive-polyglossia \
 texlive-powerdot \
 texlive-preprint \
 texlive-psfrag \
 texlive-pslatex \
 texlive-psnfss \
 texlive-pspicture \
 texlive-pst-3d \
 texlive-pst-arrow \
 texlive-pst-blur \
 texlive-pst-coil \
 texlive-pst-eps \
 texlive-pst-fill \
 texlive-pst-grad \
 texlive-pst-math \
 texlive-pst-node \
 texlive-pst-plot \
 texlive-pst-slpe \
 texlive-pst-text \
 texlive-pst-tools \
 texlive-pst-tree \
 texlive-pstricks \
 texlive-pstricks-add \
 texlive-ptext \
 texlive-pxfonts \
 texlive-qstest \
 texlive-ragged2e \
 texlive-rcs \
 texlive-realscripts \
 texlive-refcount \
 texlive-relsize \
 texlive-rerunfilecheck \
 texlive-rsfs \
 texlive-sansmath \
 texlive-sansmathaccent \
 texlive-sauerj \
 texlive-scheme-basic \
 texlive-section \
 texlive-sectsty \
 texlive-seminar \
 texlive-sepnum \
 texlive-setspace \
 texlive-sfmath \
 texlive-showexpl \
 texlive-soul \
 texlive-stackengine \
 texlive-stmaryrd \
 texlive-stringenc \
 texlive-subfig \
 texlive-subfigure \
 texlive-svn-prov \
 texlive-symbol \
 texlive-t2 \
 texlive-tabu \
 texlive-tabulary \
 texlive-tex \
 texlive-tex-gyre \
 texlive-tex-gyre-math \
 texlive-tex-ini-files \
 texlive-tex4ht \
 texlive-texlive-common-doc \
 texlive-texlive-en \
 texlive-texlive-msg-translations \
 texlive-texlive-scripts \
 texlive-texlive-scripts-extra \
 texlive-texlive.infra \
 texlive-textcase \
 texlive-textpos \
 texlive-threeparttable \
 texlive-thumbpdf \
 texlive-times \
 texlive-tipa \
 texlive-titlesec \
 texlive-titling \
 texlive-tocloft \
 texlive-tools \
 texlive-translator \
 texlive-trimspaces \
 texlive-txfonts \
 texlive-type1cm \
 texlive-typehtml \
 texlive-ucharcat \
 texlive-ucharclasses \
 texlive-ucs \
 texlive-uhc \
 texlive-ulem \
 texlive-underscore \
 texlive-unicode-data \
 texlive-unicode-math \
 texlive-uniquecounter \
 texlive-unisugar \
 texlive-upquote \
 texlive-url \
 texlive-utopia \
 texlive-varwidth \
 texlive-wadalab \
 texlive-was \
 texlive-wasy \
 texlive-wasy-type1 \
 texlive-wasysym \
 texlive-wrapfig \
 texlive-xcolor \
 texlive-xecolor \
 texlive-xecyr \
 texlive-xeindex \
 texlive-xepersian \
 texlive-xesearch \
 texlive-xetex \
 texlive-xetex-itrans \
 texlive-xetex-pstricks \
 texlive-xetexconfig \
 texlive-xetexfontinfo \
 texlive-xfrac \
 texlive-xifthen \
 texlive-xkeyval \
 texlive-xltxtra \
 texlive-xmltex \
 texlive-xpatch \
 texlive-xstring \
 texlive-xtab \
 texlive-xunicode \
 texlive-zapfchan \
 texlive-zapfding \
 texlive-zref \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/texlive-20240311-6.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a2e0235cafc93176548a455df23e714d1bdd419981a981b15549e3ceb3054f7"

URI_x86_64_v2_texlive = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive}"
SRC_URI[x86_64_v2_texlive.sha256sum] = "3f0cd979a4702f73d9c296d74c78ec93b4f1221ebc78e3ccaad6f5676796f933"

URI_x86_64_v2_texlive-acronym = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-acronym-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-acronym;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-acronym}"
SRC_URI[x86_64_v2_texlive-acronym.sha256sum] = "80384fa1f2d7bdfcd6852338d08ad68c054362a4f2b1c7e8d37005d3ea53c3a1"

URI_x86_64_v2_texlive-adjustbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-adjustbox-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-adjustbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-adjustbox}"
SRC_URI[x86_64_v2_texlive-adjustbox.sha256sum] = "c09b968f9dd02437a34f774ed6e8ea134c7e9af928e100e471f141955c126d9f"

URI_x86_64_v2_texlive-ae = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ae-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ae}"
SRC_URI[x86_64_v2_texlive-ae.sha256sum] = "0fb257653f1d6898c62f1929190af40c0068640eefc4f7c7e92ac4a2b48773f6"

URI_x86_64_v2_texlive-algorithms = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-algorithms-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-algorithms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-algorithms}"
SRC_URI[x86_64_v2_texlive-algorithms.sha256sum] = "5f76937e2aec9cdb7507c15b30edfb181f41fb39b7224c11e0d9872a7e3cb379"

URI_x86_64_v2_texlive-alphalph = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-alphalph-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-alphalph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-alphalph}"
SRC_URI[x86_64_v2_texlive-alphalph.sha256sum] = "573b93d9032e6580a4862a21001f05addccf91fa70e5dbf0bd0b10c9a8745eaf"

URI_x86_64_v2_texlive-amscls = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-amscls-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-amscls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-amscls}"
SRC_URI[x86_64_v2_texlive-amscls.sha256sum] = "6a73433e635f068fe038c7f52a0ca5644312c514c5fc82b1410614cbb6dfb1a0"

URI_x86_64_v2_texlive-amsfonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-amsfonts-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-amsfonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-amsfonts}"
SRC_URI[x86_64_v2_texlive-amsfonts.sha256sum] = "f107712e65d0d874157dd5fc51b89efe7850173926ff7debc908c4f62de3cac8"

URI_x86_64_v2_texlive-amsmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-amsmath-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-amsmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-amsmath}"
SRC_URI[x86_64_v2_texlive-amsmath.sha256sum] = "17a2219a95182aa7507cdad5d1740dc0d39182a1af07a74a16f27034bbad00d9"

URI_x86_64_v2_texlive-anyfontsize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-anyfontsize-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-anyfontsize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-anyfontsize}"
SRC_URI[x86_64_v2_texlive-anyfontsize.sha256sum] = "381c13e8c59ee286de95db119fb4a695eda324ef3a785d94a564a9763647480f"

URI_x86_64_v2_texlive-anysize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-anysize-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-anysize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-anysize}"
SRC_URI[x86_64_v2_texlive-anysize.sha256sum] = "2ca1d2a41d4c6137cb5083a6e6b6d531c5b04a9c09f52063d8d5a6d23f69d538"

URI_x86_64_v2_texlive-appendix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-appendix-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-appendix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-appendix}"
SRC_URI[x86_64_v2_texlive-appendix.sha256sum] = "f375389870a91b3a22df20b51664961db638db3cbab6264eeded8d10934bd077"

URI_x86_64_v2_texlive-arphic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-arphic-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-arphic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-arphic}"
SRC_URI[x86_64_v2_texlive-arphic.sha256sum] = "11d02081cde3e4b0ed0622059a55946aa86916e697ae15564e435c686e15d0e8"

URI_x86_64_v2_texlive-atbegshi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-atbegshi-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-atbegshi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-atbegshi}"
SRC_URI[x86_64_v2_texlive-atbegshi.sha256sum] = "295d86b25bfa1e5f95412c206b5aee476f01ddcf9b279e684f3e73e3178d7de2"

URI_x86_64_v2_texlive-attachfile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-attachfile-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-attachfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-attachfile}"
SRC_URI[x86_64_v2_texlive-attachfile.sha256sum] = "080259fa58dace76b0092833c318eb796627caa1165bbb6539ae285abcf2b172"

URI_x86_64_v2_texlive-attachfile2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-attachfile2-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-attachfile2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-attachfile2}"
SRC_URI[x86_64_v2_texlive-attachfile2.sha256sum] = "676ad3b7bac5ff7f9196d220398f701a49f77cf0450afdba78fd0d94d536a571"

URI_x86_64_v2_texlive-atveryend = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-atveryend-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-atveryend;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-atveryend}"
SRC_URI[x86_64_v2_texlive-atveryend.sha256sum] = "2eca624c348f5721e0b1e5865b048de9372b71d48d564f98ac4b41d05059042b"

URI_x86_64_v2_texlive-auxhook = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-auxhook-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-auxhook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-auxhook}"
SRC_URI[x86_64_v2_texlive-auxhook.sha256sum] = "b72c4c7de62a90983b656c2e7de2d7ee102b580235970ddc4bc79beb40b5704e"

URI_x86_64_v2_texlive-avantgar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-avantgar-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-avantgar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-avantgar}"
SRC_URI[x86_64_v2_texlive-avantgar.sha256sum] = "a19df22647aca95f88007b08f826a22c1c965b2f6f74c945af6e9ec461487680"

URI_x86_64_v2_texlive-awesomebox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-awesomebox-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-awesomebox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-awesomebox}"
SRC_URI[x86_64_v2_texlive-awesomebox.sha256sum] = "c4584aee759c5558273ce0d79244e0dbde853348935dcfbddf18f3a169b12f91"

URI_x86_64_v2_texlive-babel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-babel-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-babel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel}"
SRC_URI[x86_64_v2_texlive-babel.sha256sum] = "1dcc02dc4e984ef44ad7c5a9b1e0d4d38a70078f8cd957c84cfdc21dcc605fe7"

URI_x86_64_v2_texlive-babel-english = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-babel-english-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-babel-english;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babel-english}"
SRC_URI[x86_64_v2_texlive-babel-english.sha256sum] = "d9326890402a3c878c67cd6ce2f254d7b93d7429d214f9f0723e40bd0815fd73"

URI_x86_64_v2_texlive-babelbib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-babelbib-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-babelbib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-babelbib}"
SRC_URI[x86_64_v2_texlive-babelbib.sha256sum] = "54c2db77beb2b3a8c7279771e721ce9b5b49f49aac5d58a2b3a0a68644e45aee"

URI_x86_64_v2_texlive-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-base-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-base}"
SRC_URI[x86_64_v2_texlive-base.sha256sum] = "f30f92141d89fd3f1e4151f7e547ad6123df18f21e7737a453a06ba90826ed8c"

URI_x86_64_v2_texlive-beamer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-beamer-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-beamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-beamer}"
SRC_URI[x86_64_v2_texlive-beamer.sha256sum] = "eeba85d2946f2dd18aed02b741c87b187f2a733f40ed43b97edc46878b0baef1"

URI_x86_64_v2_texlive-bera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bera-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-bera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bera}"
SRC_URI[x86_64_v2_texlive-bera.sha256sum] = "637e2ff791a2454dec51c6b3a2f942011477e66e0763ff906a912a8883854879"

URI_x86_64_v2_texlive-beton = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-beton-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-beton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-beton}"
SRC_URI[x86_64_v2_texlive-beton.sha256sum] = "56e05d1de31dcda54bb1c744618e1e54cf39bd47f0b691a22b624dbc4f5c1612"

URI_x86_64_v2_texlive-bibtex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bibtex-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-bibtex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bibtex}"
SRC_URI[x86_64_v2_texlive-bibtex.sha256sum] = "b6c0f82d89ae03a9d27cd9e3362d3f87af769daec3628f3858306c3163df4ec6"

URI_x86_64_v2_texlive-bibtopic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bibtopic-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-bibtopic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bibtopic}"
SRC_URI[x86_64_v2_texlive-bibtopic.sha256sum] = "8d0d6a1d3d4dc7c1f8f2beebac2fb2aeb6fe6f9a0db3757e7332f184330d34a3"

URI_x86_64_v2_texlive-bidi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bidi-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-bidi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bidi}"
SRC_URI[x86_64_v2_texlive-bidi.sha256sum] = "224b77c121c697427a7d612ca5182e37af42b0b35fc3878b0a1dd1f76be3479e"

URI_x86_64_v2_texlive-bigfoot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bigfoot-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-bigfoot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bigfoot}"
SRC_URI[x86_64_v2_texlive-bigfoot.sha256sum] = "13ebf6960a6f75dcafbb17d12513b5637f0ae02c61d135d2e6923356704f9314"

URI_x86_64_v2_texlive-bigintcalc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bigintcalc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-bigintcalc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bigintcalc}"
SRC_URI[x86_64_v2_texlive-bigintcalc.sha256sum] = "0bcfc2c881f5244642e20f31e9ffc8e6a90813a67066321a829542a9985090ba"

URI_x86_64_v2_texlive-bitset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bitset-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-bitset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bitset}"
SRC_URI[x86_64_v2_texlive-bitset.sha256sum] = "7f06d43a6a9bf0a6743e2ee306f1cb47e2fbf41e068558940e31b76841bab028"

URI_x86_64_v2_texlive-bookman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bookman-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-bookman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bookman}"
SRC_URI[x86_64_v2_texlive-bookman.sha256sum] = "f9a4bf36c66a10af3f37b65daaf33754d252422a9728ca11b3f933fc98dc5109"

URI_x86_64_v2_texlive-bookmark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-bookmark-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-bookmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-bookmark}"
SRC_URI[x86_64_v2_texlive-bookmark.sha256sum] = "c8c4dc21be42820ebbcc200ce2ac84e18179770ed662f072da82e8caf9f7f843"

URI_x86_64_v2_texlive-booktabs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-booktabs-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-booktabs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-booktabs}"
SRC_URI[x86_64_v2_texlive-booktabs.sha256sum] = "418c9be694074f0e04c5092bf41aee762f245bad3a3cfd81b7f7cefc114c2a6f"

URI_x86_64_v2_texlive-breakurl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-breakurl-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-breakurl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-breakurl}"
SRC_URI[x86_64_v2_texlive-breakurl.sha256sum] = "3c988e45436192d600d95b0a9e95340a3fc49442c247563a169b1b1c0ecb33f9"

URI_x86_64_v2_texlive-breqn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-breqn-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-breqn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-breqn}"
SRC_URI[x86_64_v2_texlive-breqn.sha256sum] = "d00c452fb7580fbd82b3772555c0b77fe3d4e48fa5467ed8c932c5171dcff8f2"

URI_x86_64_v2_texlive-capt-of = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-capt-of-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-capt-of;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-capt-of}"
SRC_URI[x86_64_v2_texlive-capt-of.sha256sum] = "62e95360f73e03c47ad3ae7d9c6fbce0252ff366e6e1960bf01d4c6428868b2c"

URI_x86_64_v2_texlive-caption = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-caption-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-caption;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-caption}"
SRC_URI[x86_64_v2_texlive-caption.sha256sum] = "40cc219930f99223116aa4617ed66adea917a763443a19cb837aca2465fb3020"

URI_x86_64_v2_texlive-carlisle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-carlisle-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-carlisle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-carlisle}"
SRC_URI[x86_64_v2_texlive-carlisle.sha256sum] = "959d0d66160e6168bb19e686a2afa16cdba7c3e0867ee1afeac66373f66f70dd"

URI_x86_64_v2_texlive-catchfile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-catchfile-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-catchfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-catchfile}"
SRC_URI[x86_64_v2_texlive-catchfile.sha256sum] = "4b3c5c55d12082d5478f5634da483bb306223f4a01680c6598909fc30c6e84d4"

URI_x86_64_v2_texlive-changebar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-changebar-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-changebar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-changebar}"
SRC_URI[x86_64_v2_texlive-changebar.sha256sum] = "0ca4815d28c5b989d9c1b8ac1cf1886c88bfc046265dd866f468ecfc4713d5de"

URI_x86_64_v2_texlive-changepage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-changepage-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-changepage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-changepage}"
SRC_URI[x86_64_v2_texlive-changepage.sha256sum] = "f4c6ea88a24837d3782cfdedcf1eecaceb7b4c7a8822d75b345e976952b9da7e"

URI_x86_64_v2_texlive-charter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-charter-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-charter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-charter}"
SRC_URI[x86_64_v2_texlive-charter.sha256sum] = "6394a86a98403238affec0041f71a678b28dd421031856160901e5692a401629"

URI_x86_64_v2_texlive-chngcntr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-chngcntr-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-chngcntr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-chngcntr}"
SRC_URI[x86_64_v2_texlive-chngcntr.sha256sum] = "31a94a228c39165845d067f533563ebd2db4da05ec6b0678aafee198945e2451"

URI_x86_64_v2_texlive-cite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cite-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-cite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cite}"
SRC_URI[x86_64_v2_texlive-cite.sha256sum] = "b73557625108444c13d74bbf737b5fb5abd565da9cf4b5698c7e22a3a9e20ad8"

URI_x86_64_v2_texlive-classpack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-classpack-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-classpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-classpack}"
SRC_URI[x86_64_v2_texlive-classpack.sha256sum] = "51ca8bfe2a9e3314a1bf36ec91aae11a9c22045aa8fa06efbdb19f72726e57a7"

URI_x86_64_v2_texlive-cm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cm-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-cm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cm}"
SRC_URI[x86_64_v2_texlive-cm.sha256sum] = "ae49f8db4e695a6a7d80493ba6c59172b3074c870a7707ef04bfbcfe34cfce2b"

URI_x86_64_v2_texlive-cm-lgc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cm-lgc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-cm-lgc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cm-lgc}"
SRC_URI[x86_64_v2_texlive-cm-lgc.sha256sum] = "b87d86d71b9a9344e2bcd0d513427a2f5013a951ac7d8e67f9e1d065c1372c59"

URI_x86_64_v2_texlive-cm-super = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cm-super-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-cm-super;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cm-super}"
SRC_URI[x86_64_v2_texlive-cm-super.sha256sum] = "76e64407c06fa64af32e6fbc6ac75f1755ed037eba20aa94b9ebaf28c45ff1b7"

URI_x86_64_v2_texlive-cmap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cmap-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-cmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cmap}"
SRC_URI[x86_64_v2_texlive-cmap.sha256sum] = "6c2ef512b04a3362483cc106eac8496d674ec4af66bad72cdb6549ee81610bb6"

URI_x86_64_v2_texlive-cmextra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cmextra-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-cmextra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cmextra}"
SRC_URI[x86_64_v2_texlive-cmextra.sha256sum] = "c401dd194f10ac87536ed4ad5d4df74afd6d85ebc9c16291bc65fd751f7f01d1"

URI_x86_64_v2_texlive-cns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-cns-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-cns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-cns}"
SRC_URI[x86_64_v2_texlive-cns.sha256sum] = "2eb9a8438901bc5e1a63a953316241274960ffc009bf89de4442da0f82a7b71c"

URI_x86_64_v2_texlive-collectbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collectbox-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-collectbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collectbox}"
SRC_URI[x86_64_v2_texlive-collectbox.sha256sum] = "c242eaf525b3cb3b052e8ef5ed0c720f0b8e70fd189a089514c8144720e8d8c6"

URI_x86_64_v2_texlive-collection-basic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-basic-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-collection-basic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-basic}"
SRC_URI[x86_64_v2_texlive-collection-basic.sha256sum] = "f7b794fe0ef684eacc79233c8020636c3cff4ba5d8da629cd005aecad77bf68c"

URI_x86_64_v2_texlive-collection-fontsrecommended = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-fontsrecommended-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-collection-fontsrecommended;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-fontsrecommended}"
SRC_URI[x86_64_v2_texlive-collection-fontsrecommended.sha256sum] = "3add18de434f20d376fd6a40bd4bd9d9da4d9d799b9915c15a8abf7e125cedbd"

URI_x86_64_v2_texlive-collection-htmlxml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-htmlxml-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-collection-htmlxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-htmlxml}"
SRC_URI[x86_64_v2_texlive-collection-htmlxml.sha256sum] = "464ad91a3670ed1cbae454515311b1f30297a3db205f54705185ae9bbf45f64f"

URI_x86_64_v2_texlive-collection-latex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-latex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-collection-latex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-latex}"
SRC_URI[x86_64_v2_texlive-collection-latex.sha256sum] = "dc69f2e5672cb81527261433883b599c742d496c7071fd905644451a0513ff00"

URI_x86_64_v2_texlive-collection-latexrecommended = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-latexrecommended-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-collection-latexrecommended;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-latexrecommended}"
SRC_URI[x86_64_v2_texlive-collection-latexrecommended.sha256sum] = "6930bb95cc8de7b139cd1ba4b697a714506c08d015b7ed096fae97691253d63b"
RPROVIDES:texlive-collection-latexrecommended:x86_64_v2 = "virtual/texlive-latex"

URI_x86_64_v2_texlive-collection-xetex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-collection-xetex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-collection-xetex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-collection-xetex}"
SRC_URI[x86_64_v2_texlive-collection-xetex.sha256sum] = "110697017a3459301a4fb12912af10bed839f4f131ffcfec31d184b1d1b8d6ae"

URI_x86_64_v2_texlive-colorprofiles = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-colorprofiles-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-colorprofiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-colorprofiles}"
SRC_URI[x86_64_v2_texlive-colorprofiles.sha256sum] = "746d6e79468a06f281edb374034b308b11f90866faa29ff002902d99e9b6e25f"

URI_x86_64_v2_texlive-colortbl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-colortbl-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-colortbl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-colortbl}"
SRC_URI[x86_64_v2_texlive-colortbl.sha256sum] = "2f566676c3e4b2efc1790365130a0b62b4fbb376d3d27d8b1c7e94a63eac5918"

URI_x86_64_v2_texlive-context = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-context-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-context;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-context}"
SRC_URI[x86_64_v2_texlive-context.sha256sum] = "56f78fb17e73d38a3f80920e9a459ed0e2e353ca4f6b3b66f3b29c5ab41d147e"

URI_x86_64_v2_texlive-count1to = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-count1to-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-count1to;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-count1to}"
SRC_URI[x86_64_v2_texlive-count1to.sha256sum] = "ac90587180e366b7ad6e83d7ecb295cf5b036840bb7eb06fe0edf337920fec07"

URI_x86_64_v2_texlive-courier = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-courier-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-courier;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-courier}"
SRC_URI[x86_64_v2_texlive-courier.sha256sum] = "bb5a61c3b3bda61e260abefaa387abadc04701381783f9d2edb169d1c1c6665f"

URI_x86_64_v2_texlive-crop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-crop-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-crop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-crop}"
SRC_URI[x86_64_v2_texlive-crop.sha256sum] = "18bede7196d41e4bdf4b432592a5a513a94722a4f03b7ea0a0510239f3a331f6"

URI_x86_64_v2_texlive-csquotes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-csquotes-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-csquotes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-csquotes}"
SRC_URI[x86_64_v2_texlive-csquotes.sha256sum] = "7ce14f7931974b92af2e5345c64845ecc9f4e24ba1693219de990e4fcb29c8ba"

URI_x86_64_v2_texlive-ctable = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ctable-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ctable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctable}"
SRC_URI[x86_64_v2_texlive-ctable.sha256sum] = "45d2cbfd38c2eec8d564c3804fc538bb72f397e3cf1cb8d4093d0014de695ea6"

URI_x86_64_v2_texlive-ctablestack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ctablestack-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ctablestack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ctablestack}"
SRC_URI[x86_64_v2_texlive-ctablestack.sha256sum] = "26bec7a1ac7920b5a01d1ee7727b6ad1ca7df0399b9c137c4e1d6ff48be044f6"

URI_x86_64_v2_texlive-currfile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-currfile-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-currfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-currfile}"
SRC_URI[x86_64_v2_texlive-currfile.sha256sum] = "acbc23e0e445025166bf9e43f8f2fda47e2acb9e28513019a57072f9879db676"

URI_x86_64_v2_texlive-datetime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-datetime-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-datetime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-datetime}"
SRC_URI[x86_64_v2_texlive-datetime.sha256sum] = "e1e309bcd8f3510cbdc3102b2ff342603aa69ecdc94db8c64038499a882737b9"

URI_x86_64_v2_texlive-dehyph = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dehyph-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-dehyph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dehyph}"
SRC_URI[x86_64_v2_texlive-dehyph.sha256sum] = "403f6dd37ca093acbe1c27173a382fac646be4a4c121f41de1cad03f4cc7aae1"

URI_x86_64_v2_texlive-dvipdfmx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dvipdfmx-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-dvipdfmx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dvipdfmx}"
SRC_URI[x86_64_v2_texlive-dvipdfmx.sha256sum] = "79ef4854b50d4cbd9d813c8aba94fcf198f8ffa6d2cc332e87e8727acec3885d"

URI_x86_64_v2_texlive-dvipng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dvipng-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-dvipng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dvipng}"
SRC_URI[x86_64_v2_texlive-dvipng.sha256sum] = "f243b1de7b9dd35a102f179e2174b144901e7eea96e0590a1f6c0d34e40d6e49"

URI_x86_64_v2_texlive-dvips = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dvips-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-dvips;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dvips}"
SRC_URI[x86_64_v2_texlive-dvips.sha256sum] = "8215ad4f23a4d84a190bf5edf56f9c84af5f6334caadc0fd0712fd4c6d0608ea"

URI_x86_64_v2_texlive-dvisvgm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-dvisvgm-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-dvisvgm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-dvisvgm}"
SRC_URI[x86_64_v2_texlive-dvisvgm.sha256sum] = "2ea480a77b97efe797959527c1be02654d057b0d67a02b976facf1507f649dd1"

URI_x86_64_v2_texlive-ec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ec-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ec}"
SRC_URI[x86_64_v2_texlive-ec.sha256sum] = "48ac3abc9c5450c15b8b1e0de9497b9a00d27d1b6685f5db4667183a1b969db3"

URI_x86_64_v2_texlive-eepic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-eepic-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-eepic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-eepic}"
SRC_URI[x86_64_v2_texlive-eepic.sha256sum] = "d5e3a165eb897d0bb04c072acf8ad4b1bf52629431ec71a765db410de986fd21"

URI_x86_64_v2_texlive-enctex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-enctex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-enctex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-enctex}"
SRC_URI[x86_64_v2_texlive-enctex.sha256sum] = "b02a1bfad6c86befc855166562d9a3abd68d15177cea4435d04502c5f9528d06"

URI_x86_64_v2_texlive-enumitem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-enumitem-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-enumitem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-enumitem}"
SRC_URI[x86_64_v2_texlive-enumitem.sha256sum] = "2e5967cdffbc9912713d859c193cecd125544ee9a48453ea82ae50eae45534bb"

URI_x86_64_v2_texlive-environ = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-environ-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-environ;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-environ}"
SRC_URI[x86_64_v2_texlive-environ.sha256sum] = "19c2781efa855af00ef9c765a149f7d35a08aba6b93caa77733ba94939b329fc"

URI_x86_64_v2_texlive-epsf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-epsf-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-epsf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-epsf}"
SRC_URI[x86_64_v2_texlive-epsf.sha256sum] = "7fc3387d069cf6ba7cf14a9ab1a2d320361fac81c3e9ff89cd990c64a8136c02"

URI_x86_64_v2_texlive-epstopdf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-epstopdf-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-epstopdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-epstopdf}"
SRC_URI[x86_64_v2_texlive-epstopdf.sha256sum] = "f0683f2637e6d4fd717bef50780908026df1e0de85cd72f77ebc1eaa535ac9d6"

URI_x86_64_v2_texlive-epstopdf-pkg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-epstopdf-pkg-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-epstopdf-pkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-epstopdf-pkg}"
SRC_URI[x86_64_v2_texlive-epstopdf-pkg.sha256sum] = "ec7784f996193554258a228eec8b5450d03d657ba86f22f9c7a38510079f1810"

URI_x86_64_v2_texlive-eqparbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-eqparbox-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-eqparbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-eqparbox}"
SRC_URI[x86_64_v2_texlive-eqparbox.sha256sum] = "4011bc6cf3cf2809396e3f6bc5d71f8cf524bf91ca5dd4ba7871eb067352c093"

URI_x86_64_v2_texlive-eso-pic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-eso-pic-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-eso-pic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-eso-pic}"
SRC_URI[x86_64_v2_texlive-eso-pic.sha256sum] = "3db7a50dda6f558da4c38a9a87d0a55d07ffb1b60932b87b7c6a2a4078aacc3d"

URI_x86_64_v2_texlive-etex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-etex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etex}"
SRC_URI[x86_64_v2_texlive-etex.sha256sum] = "014b1d983e4bd39ce7a68727d2b204e2d88967feb5e0c60ef555b234099708b8"

URI_x86_64_v2_texlive-etex-pkg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etex-pkg-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-etex-pkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etex-pkg}"
SRC_URI[x86_64_v2_texlive-etex-pkg.sha256sum] = "bd34dc7dc0c6ab1c722c375b1db2bd898efd1d7e8c0e2d20d8edb539f29a7e0a"

URI_x86_64_v2_texlive-etexcmds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etexcmds-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-etexcmds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etexcmds}"
SRC_URI[x86_64_v2_texlive-etexcmds.sha256sum] = "47e104e48120e1f09051b53535598948386743d88489ace87474f3b653c5ae12"

URI_x86_64_v2_texlive-etoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etoc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-etoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etoc}"
SRC_URI[x86_64_v2_texlive-etoc.sha256sum] = "61121845a5bb93eab230f944d9ccbe47f6861a192693647d4ccef6f22441c01d"

URI_x86_64_v2_texlive-etoolbox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-etoolbox-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-etoolbox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-etoolbox}"
SRC_URI[x86_64_v2_texlive-etoolbox.sha256sum] = "39a9ce6182c981cb2e82cea6732f837c9209226deff45ae05594cc0cc8b074be"

URI_x86_64_v2_texlive-euenc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-euenc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-euenc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-euenc}"
SRC_URI[x86_64_v2_texlive-euenc.sha256sum] = "d148dc37ba667695e25e24155633df9d8bf2081b35959ad03d25cd72f43b0779"

URI_x86_64_v2_texlive-euler = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-euler-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-euler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-euler}"
SRC_URI[x86_64_v2_texlive-euler.sha256sum] = "0201c692753b163541a99c5d0acf4e786305b8c096fb809b9ab31b1b0ec04636"

URI_x86_64_v2_texlive-euro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-euro-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-euro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-euro}"
SRC_URI[x86_64_v2_texlive-euro.sha256sum] = "07e9108f56c4005cd9094ca674c9e2577812eb09e734563936f24923ff194e9b"

URI_x86_64_v2_texlive-eurosym = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-eurosym-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-eurosym;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-eurosym}"
SRC_URI[x86_64_v2_texlive-eurosym.sha256sum] = "2a1fc9c0701a153ace2fe7c6e2d670afa6e5345ef5b91e9bb2b9b26db38adf07"

URI_x86_64_v2_texlive-everysel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-everysel-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-everysel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-everysel}"
SRC_URI[x86_64_v2_texlive-everysel.sha256sum] = "61c62b6c5ed0d5dfda8d4882e4a10e785e786a5e8bb4622dfd3eb2f70e73c0ad"

URI_x86_64_v2_texlive-everyshi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-everyshi-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-everyshi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-everyshi}"
SRC_URI[x86_64_v2_texlive-everyshi.sha256sum] = "2a9786006c369c36d607e1af84b20f9660e236da63af50d08d2f629fc952f82b"

URI_x86_64_v2_texlive-extsizes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-extsizes-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-extsizes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-extsizes}"
SRC_URI[x86_64_v2_texlive-extsizes.sha256sum] = "e79240055ee15e9a2caeaac5d34c7d8586234c4d982860ff558bc69f4d3b18e7"

URI_x86_64_v2_texlive-fancybox = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fancybox-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fancybox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fancybox}"
SRC_URI[x86_64_v2_texlive-fancybox.sha256sum] = "c6069fc0aecbbd84ca16cc82cb77276e2d304c522282c8d7ef2062d47bf8f1d0"

URI_x86_64_v2_texlive-fancyhdr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fancyhdr-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fancyhdr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fancyhdr}"
SRC_URI[x86_64_v2_texlive-fancyhdr.sha256sum] = "b0f7c77fc844716845af8251c936532cf28014e892abd1c8f116723f1ca99fa7"

URI_x86_64_v2_texlive-fancyref = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fancyref-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fancyref;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fancyref}"
SRC_URI[x86_64_v2_texlive-fancyref.sha256sum] = "569aa8a0cec469248af09667521c459134d1da507afb84b305c794a4ed7179cd"

URI_x86_64_v2_texlive-fancyvrb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fancyvrb-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fancyvrb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fancyvrb}"
SRC_URI[x86_64_v2_texlive-fancyvrb.sha256sum] = "7d19c675b3cbdeab8170a0394073e38c61b601c426d93b1bfdd0a31158738c3a"

URI_x86_64_v2_texlive-filecontents = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-filecontents-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-filecontents;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-filecontents}"
SRC_URI[x86_64_v2_texlive-filecontents.sha256sum] = "2948f80cea5f02cf43db56041dfb8f8afc4b69fb8f86e559060745ddfdc24efe"

URI_x86_64_v2_texlive-filehook = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-filehook-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-filehook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-filehook}"
SRC_URI[x86_64_v2_texlive-filehook.sha256sum] = "50dc59da4a488e658f4fe3d8391b98fc2783ac70d6e23f99746b602dcb264766"

URI_x86_64_v2_texlive-finstrut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-finstrut-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-finstrut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-finstrut}"
SRC_URI[x86_64_v2_texlive-finstrut.sha256sum] = "c350133983f8cd563b9c442cd7d32a3f6c0e179e459167b234084ab2258c4348"

URI_x86_64_v2_texlive-firstaid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-firstaid-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-firstaid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-firstaid}"
SRC_URI[x86_64_v2_texlive-firstaid.sha256sum] = "0fdcb66b075c624f6e9d9db272615749d9256d758b9573db72592f4513275373"

URI_x86_64_v2_texlive-fix2col = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fix2col-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fix2col;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fix2col}"
SRC_URI[x86_64_v2_texlive-fix2col.sha256sum] = "393bcfd7f164afde626ec7d911ec2a630190b6157756758f3a7a4e876a8d5655"

URI_x86_64_v2_texlive-fixlatvian = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fixlatvian-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fixlatvian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fixlatvian}"
SRC_URI[x86_64_v2_texlive-fixlatvian.sha256sum] = "135b71abbc41b7f524ebe61bde08f4ee5c8e2cfd6813a0e74d04aa3206b4edfa"

URI_x86_64_v2_texlive-float = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-float-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-float;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-float}"
SRC_URI[x86_64_v2_texlive-float.sha256sum] = "f402162aa2a442ea203d4be65def559dfb00685ea0bcdc13241fe9b68116b6fd"

URI_x86_64_v2_texlive-fmtcount = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fmtcount-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fmtcount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fmtcount}"
SRC_URI[x86_64_v2_texlive-fmtcount.sha256sum] = "77844632d37d6fc29d414d6c547727632b055f165287754b0b24f1983d92251a"

URI_x86_64_v2_texlive-fncychap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fncychap-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fncychap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fncychap}"
SRC_URI[x86_64_v2_texlive-fncychap.sha256sum] = "c9f32eb74c0257cf90f8ca93686ee91166432292b8ad6b67f6415a758d1e3a66"

URI_x86_64_v2_texlive-fontawesome = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontawesome-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fontawesome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontawesome}"
SRC_URI[x86_64_v2_texlive-fontawesome.sha256sum] = "e03f881fa6dc91cda715bffe6cdaf3891fd551acca2e5f539dd6f091feea7e29"

URI_x86_64_v2_texlive-fontbook = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontbook-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fontbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontbook}"
SRC_URI[x86_64_v2_texlive-fontbook.sha256sum] = "1863d5298e25dc1a802dfd51923e83f375e919afbe66df911788f60bcb3dc61a"

URI_x86_64_v2_texlive-fonts-tlwg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fonts-tlwg-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fonts-tlwg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fonts-tlwg}"
SRC_URI[x86_64_v2_texlive-fonts-tlwg.sha256sum] = "05f2b8083ba82e9977f8d5a870be4f4dbef115ddffddbff64b654a0b425e4da9"

URI_x86_64_v2_texlive-fontspec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontspec-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fontspec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontspec}"
SRC_URI[x86_64_v2_texlive-fontspec.sha256sum] = "cffbbacae4ae0f75bcc8b504e5e4e58e09515afafe476ae0eff1b0bc92218e9f"

URI_x86_64_v2_texlive-fontware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontware-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-fontware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontware}"
SRC_URI[x86_64_v2_texlive-fontware.sha256sum] = "0ab7000bdcc6b1b4268a2724b86bbad2b9209e7d53b774aea2f249cb6ebb6cc0"

URI_x86_64_v2_texlive-fontwrap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fontwrap-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fontwrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fontwrap}"
SRC_URI[x86_64_v2_texlive-fontwrap.sha256sum] = "0086949aed1024998faa0172cbc2731d7f470d79a09524ff1748f0952d638605"

URI_x86_64_v2_texlive-footmisc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-footmisc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-footmisc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-footmisc}"
SRC_URI[x86_64_v2_texlive-footmisc.sha256sum] = "ee14f50683fc41462b05b6a6a2f27e4c2226ad0d2d2c170714eaa8a47f6e11b6"

URI_x86_64_v2_texlive-footnotehyper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-footnotehyper-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-footnotehyper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-footnotehyper}"
SRC_URI[x86_64_v2_texlive-footnotehyper.sha256sum] = "7a927d53a7c02f69ff59b937f4cd64ba8e7d8afb7e4d7cc266bdcd6d3ecf30fe"

URI_x86_64_v2_texlive-fp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fp-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fp}"
SRC_URI[x86_64_v2_texlive-fp.sha256sum] = "84e34a32773e66354a3ab4f8bb1bc4d7020622af2e62098dc1a6aa4ca4107de2"

URI_x86_64_v2_texlive-fpl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-fpl-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-fpl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-fpl}"
SRC_URI[x86_64_v2_texlive-fpl.sha256sum] = "e7238cd1394edf7340233f2ffa87087e4e03672c3c98fa393dac090cd56f94d3"

URI_x86_64_v2_texlive-framed = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-framed-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-framed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-framed}"
SRC_URI[x86_64_v2_texlive-framed.sha256sum] = "b658553d759319888e9dda915535e52f679b4370f4b5863fd53925cc36f0d92f"

URI_x86_64_v2_texlive-garuda-c90 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-garuda-c90-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-garuda-c90;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-garuda-c90}"
SRC_URI[x86_64_v2_texlive-garuda-c90.sha256sum] = "56a724141ff9c4df2be59599737acf15dc38865ba0e1f8c20b1b4243039130e8"

URI_x86_64_v2_texlive-geometry = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-geometry-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-geometry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-geometry}"
SRC_URI[x86_64_v2_texlive-geometry.sha256sum] = "2768e7de33a65a85831672c02dd30a1957fc907b97a094ae93aa8022ead9d88f"

URI_x86_64_v2_texlive-gettitlestring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-gettitlestring-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-gettitlestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gettitlestring}"
SRC_URI[x86_64_v2_texlive-gettitlestring.sha256sum] = "f6ff748bfeb73d8de7f779ccab9c30e79aa4f1bdd6711abeef142d8d7bec2ecb"

URI_x86_64_v2_texlive-glyphlist = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-glyphlist-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-glyphlist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-glyphlist}"
SRC_URI[x86_64_v2_texlive-glyphlist.sha256sum] = "e212f021a29a3ab52a275f5ecf2544d2abd9881a8172bcb0013ec1667d9bdd48"

URI_x86_64_v2_texlive-gnu-freefont = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/texlive-gnu-freefont-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-gnu-freefont;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gnu-freefont}"
SRC_URI[x86_64_v2_texlive-gnu-freefont.sha256sum] = "c296e6088139fa10aaf3ae8f0c93857cb0ebb2836f15a90ab2264c190616c938"

URI_x86_64_v2_texlive-graphics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-graphics-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-graphics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-graphics}"
SRC_URI[x86_64_v2_texlive-graphics.sha256sum] = "01faaea46589ef98503bf28bbffc1d494b3583fabdd621955deeff7a44cda524"

URI_x86_64_v2_texlive-graphics-cfg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-graphics-cfg-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-graphics-cfg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-graphics-cfg}"
SRC_URI[x86_64_v2_texlive-graphics-cfg.sha256sum] = "64c0bd4c2c34dc6320cfb05dd7142eafe8ce486e4969200b7a2f5f764ee59a34"

URI_x86_64_v2_texlive-graphics-def = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-graphics-def-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-graphics-def;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-graphics-def}"
SRC_URI[x86_64_v2_texlive-graphics-def.sha256sum] = "a32f33d499e66e3253fecea682accfc20e85e3f6765530e240dd9ccb0a6de98f"

URI_x86_64_v2_texlive-grfext = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-grfext-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-grfext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-grfext}"
SRC_URI[x86_64_v2_texlive-grfext.sha256sum] = "e5f603f7c0ad6871edd1fa5d14ea649a2ab54603556cbe3d466346b684925f7e"

URI_x86_64_v2_texlive-grffile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-grffile-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-grffile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-grffile}"
SRC_URI[x86_64_v2_texlive-grffile.sha256sum] = "7a55cc789709a475f28213d85d2e02f4bab8969dcb8cee2618a3973f909804f3"

URI_x86_64_v2_texlive-gsftopk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-gsftopk-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-gsftopk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-gsftopk}"
SRC_URI[x86_64_v2_texlive-gsftopk.sha256sum] = "b9d35d520ecafcfd203500b1d50aea6a1efdb21eeccb9b0299180910e1d3dd5d"

URI_x86_64_v2_texlive-hanging = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hanging-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hanging;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hanging}"
SRC_URI[x86_64_v2_texlive-hanging.sha256sum] = "a594aad0f2c1914918251969b83c39af74e558d5f4e73cf9e055ad340a58ccf5"

URI_x86_64_v2_texlive-helvetic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-helvetic-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-helvetic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-helvetic}"
SRC_URI[x86_64_v2_texlive-helvetic.sha256sum] = "87cd8d4c47303cc331e11d6c720ea7aaa5cc12409784fa1a2d394a4339b389a5"

URI_x86_64_v2_texlive-hobsub = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hobsub-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hobsub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hobsub}"
SRC_URI[x86_64_v2_texlive-hobsub.sha256sum] = "40289846013334eff7bb5f349284a80291aa73c4e051924bf2052be8762bdf09"

URI_x86_64_v2_texlive-hologo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hologo-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hologo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hologo}"
SRC_URI[x86_64_v2_texlive-hologo.sha256sum] = "e0092f4756bf3dd780997a1cb920bd1c28e17cd1a53862f92a0c754690404ebc"

URI_x86_64_v2_texlive-hopatch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hopatch-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hopatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hopatch}"
SRC_URI[x86_64_v2_texlive-hopatch.sha256sum] = "20a4586b8a54083397c38016c3fff8f77dd151bb9bd89d66fcc2340f6f5cfa52"

URI_x86_64_v2_texlive-hycolor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hycolor-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hycolor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hycolor}"
SRC_URI[x86_64_v2_texlive-hycolor.sha256sum] = "79ed570c4b50f5041833e2cdf76d77e2dcc1c93397d08f126ce9b521781e54f5"

URI_x86_64_v2_texlive-hypcap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hypcap-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hypcap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hypcap}"
SRC_URI[x86_64_v2_texlive-hypcap.sha256sum] = "e73f2655c8eaa42d168c656f03887cd75ab8b1b35ec6c29b0d4b983abddaad26"

URI_x86_64_v2_texlive-hypdoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hypdoc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hypdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hypdoc}"
SRC_URI[x86_64_v2_texlive-hypdoc.sha256sum] = "05eb7c042e90994b8954fbfe65542e6750dcc463250ace80a34eccd618055367"

URI_x86_64_v2_texlive-hyperref = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyperref-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hyperref;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyperref}"
SRC_URI[x86_64_v2_texlive-hyperref.sha256sum] = "0891e994f73b69beca1271ad32f3b8e2b643767912d1a318404e55f0d988d007"

URI_x86_64_v2_texlive-hyph-utf8 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyph-utf8-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hyph-utf8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyph-utf8}"
SRC_URI[x86_64_v2_texlive-hyph-utf8.sha256sum] = "bfe5bc6b04f7efe86304f570db5d5b469262f38a10a510d4eaaadca9404338a3"

URI_x86_64_v2_texlive-hyphen-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyphen-base-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hyphen-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphen-base}"
SRC_URI[x86_64_v2_texlive-hyphen-base.sha256sum] = "b1a976656d19ab7106bbd0f6cf7cfa884ec9e037bf82b8d6b5039fe894c19b59"

URI_x86_64_v2_texlive-hyphenat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyphenat-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hyphenat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphenat}"
SRC_URI[x86_64_v2_texlive-hyphenat.sha256sum] = "82cf85f17d8c3ef681fdbbec71a04d237fce1a2388c7c70f9085b4bb89a47154"

URI_x86_64_v2_texlive-hyphenex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-hyphenex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-hyphenex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-hyphenex}"
SRC_URI[x86_64_v2_texlive-hyphenex.sha256sum] = "49ea954cc7947840498c9930a3fbbeddadc449f549d100ef435e7d0ede500ce1"

URI_x86_64_v2_texlive-ifmtarg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ifmtarg-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ifmtarg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ifmtarg}"
SRC_URI[x86_64_v2_texlive-ifmtarg.sha256sum] = "7859a6849ab01becec00bf43be6e6e55beed3448088434a06bc0c6667651d9cd"

URI_x86_64_v2_texlive-ifoddpage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ifoddpage-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ifoddpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ifoddpage}"
SRC_URI[x86_64_v2_texlive-ifoddpage.sha256sum] = "8df5bc691d3b764cba406d3171ebe55f402059183dd566ff00c7b3483c5946c2"

URI_x86_64_v2_texlive-ifplatform = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ifplatform-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ifplatform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ifplatform}"
SRC_URI[x86_64_v2_texlive-ifplatform.sha256sum] = "3236800a65a081cca0df47bac6f266bb7bad73ba29f690442e3b5d2f0bbe9040"

URI_x86_64_v2_texlive-iftex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-iftex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-iftex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-iftex}"
SRC_URI[x86_64_v2_texlive-iftex.sha256sum] = "113e73cd99da13331f58d85641afa6563cab2824dc7c3336083bc39fb6537821"

URI_x86_64_v2_texlive-import = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-import-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-import;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-import}"
SRC_URI[x86_64_v2_texlive-import.sha256sum] = "cca9ed88d3f7c44ff9d956d3390962219e0874750c9d024b7418c8e9aa27b8a0"

URI_x86_64_v2_texlive-index = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-index-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-index}"
SRC_URI[x86_64_v2_texlive-index.sha256sum] = "c439e4aebfba5682408baeca0f5a92a966f2136e8b1699a74b699c79f784dd9a"

URI_x86_64_v2_texlive-infwarerr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-infwarerr-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-infwarerr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-infwarerr}"
SRC_URI[x86_64_v2_texlive-infwarerr.sha256sum] = "fba458b303a6a43ddeb80da45ce1feb69aa6788907c83c98c801620f4475a9de"

URI_x86_64_v2_texlive-intcalc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-intcalc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-intcalc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-intcalc}"
SRC_URI[x86_64_v2_texlive-intcalc.sha256sum] = "ef6520a190e4061250975b90c360d280ada0a2349dd92edc9d18cbafdeb940e6"

URI_x86_64_v2_texlive-jadetex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-jadetex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-jadetex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-jadetex}"
SRC_URI[x86_64_v2_texlive-jadetex.sha256sum] = "6ed140f416faf992726f339bb42da18f9983fd0a48d1b5a7677fc5e9def22dc1"

URI_x86_64_v2_texlive-jknapltx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-jknapltx-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-jknapltx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-jknapltx}"
SRC_URI[x86_64_v2_texlive-jknapltx.sha256sum] = "8526833d8344fa4b8e4244b4cf6445791a30c287809081e4609df0c06472a72c"

URI_x86_64_v2_texlive-kastrup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kastrup-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-kastrup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kastrup}"
SRC_URI[x86_64_v2_texlive-kastrup.sha256sum] = "f3109bc708c4d0a25f3f472e7287d43b81ef16baff7e8b0ec61fd58d42ccd593"

URI_x86_64_v2_texlive-kerkis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kerkis-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-kerkis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kerkis}"
SRC_URI[x86_64_v2_texlive-kerkis.sha256sum] = "8ae85530dbb1e35869277fd4c9b8b8d835ea158a9d91f14f80c4184899ea9033"

URI_x86_64_v2_texlive-knuth-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-knuth-lib-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-knuth-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-knuth-lib}"
SRC_URI[x86_64_v2_texlive-knuth-lib.sha256sum] = "d04bc812dc39655db8a301483a58a254a7f31a3f30de411937291a2679090682"

URI_x86_64_v2_texlive-knuth-local = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-knuth-local-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-knuth-local;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-knuth-local}"
SRC_URI[x86_64_v2_texlive-knuth-local.sha256sum] = "296134cc7ec32374b65ce8c92595754c7fe0085603fa16e53885b170971cae26"

URI_x86_64_v2_texlive-koma-script = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-koma-script-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-koma-script;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-koma-script}"
SRC_URI[x86_64_v2_texlive-koma-script.sha256sum] = "5bbb3b43ba18de53d44081ef46f06a91c4645ef01ebbc6a2d52f85fe939e6522"

URI_x86_64_v2_texlive-kpathsea = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kpathsea-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-kpathsea;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kpathsea}"
SRC_URI[x86_64_v2_texlive-kpathsea.sha256sum] = "0db45d862af99801dec821aaf332daeb14789a77b4eab25ceb1059042bf36406"

URI_x86_64_v2_texlive-kvdefinekeys = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kvdefinekeys-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-kvdefinekeys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kvdefinekeys}"
SRC_URI[x86_64_v2_texlive-kvdefinekeys.sha256sum] = "4a455b5e9aefb328c5b6525c642f48b6bea31e8b82708c2306d3d14e0a2b3ef4"

URI_x86_64_v2_texlive-kvoptions = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kvoptions-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-kvoptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kvoptions}"
SRC_URI[x86_64_v2_texlive-kvoptions.sha256sum] = "77d437a37ea29a33ac360cb2f1417b03c495db05f92ed0e23a8eec6dd466235e"

URI_x86_64_v2_texlive-kvsetkeys = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-kvsetkeys-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-kvsetkeys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-kvsetkeys}"
SRC_URI[x86_64_v2_texlive-kvsetkeys.sha256sum] = "d2b0dafa7d530d748923ad9c18be15b759ce25b2e11fa5ddb794b9d1c9fb68ba"

URI_x86_64_v2_texlive-l3backend = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-l3backend-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-l3backend;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-l3backend}"
SRC_URI[x86_64_v2_texlive-l3backend.sha256sum] = "e3a97e0241e90fe3228344d82c04fdbfa008ffe0335917cdc1059d106eef6b2e"

URI_x86_64_v2_texlive-l3experimental = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-l3experimental-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-l3experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-l3experimental}"
SRC_URI[x86_64_v2_texlive-l3experimental.sha256sum] = "c1784848004a561b79aed23993f6178240e2328827783bb2dc9af6cf5d29f774"

URI_x86_64_v2_texlive-l3kernel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-l3kernel-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-l3kernel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-l3kernel}"
SRC_URI[x86_64_v2_texlive-l3kernel.sha256sum] = "3f50c482d0919eb03d3717be656211c3fc74fa649f23edafe5ec1f766041d7c8"

URI_x86_64_v2_texlive-l3packages = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-l3packages-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-l3packages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-l3packages}"
SRC_URI[x86_64_v2_texlive-l3packages.sha256sum] = "7455fdbe2b063bbfded616cf37d01e551b00d6cb94c681f806d64768c561af09"

URI_x86_64_v2_texlive-lastpage = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lastpage-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lastpage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lastpage}"
SRC_URI[x86_64_v2_texlive-lastpage.sha256sum] = "67ecf5884734c7231bbcb13bd949c8cb7f8ee48627bc17b287f9c499c7e0a95c"

URI_x86_64_v2_texlive-latex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-latex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex}"
SRC_URI[x86_64_v2_texlive-latex.sha256sum] = "196828451e412f49361c0d45becdaf7c24c6daecbdba08a2ddf62657596c7e3c"
RPROVIDES:texlive-latex:x86_64_v2 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_ virtual/texlive-latex"

URI_x86_64_v2_texlive-latex-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latex-fonts-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-latex-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex-fonts}"
SRC_URI[x86_64_v2_texlive-latex-fonts.sha256sum] = "842e3474fdd0712ff119471bf4021632e2138c9ef8c2f682c9aaafe55b67f672"

URI_x86_64_v2_texlive-latex2man = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latex2man-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-latex2man;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latex2man}"
SRC_URI[x86_64_v2_texlive-latex2man.sha256sum] = "a93b36bd4e050624ce36e7d72f346582e5fbf7bcfb80de791467248d1d8a9ae0"

URI_x86_64_v2_texlive-latexbug = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latexbug-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-latexbug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latexbug}"
SRC_URI[x86_64_v2_texlive-latexbug.sha256sum] = "0c33e76c7f143207b91f005736a7add709c5de3b2f803701892459fac4ae035a"

URI_x86_64_v2_texlive-latexconfig = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-latexconfig-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-latexconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-latexconfig}"
SRC_URI[x86_64_v2_texlive-latexconfig.sha256sum] = "9e736904162a3c6308d12735315c448036d4b42a4ac2cf6720244c1572eee353"

URI_x86_64_v2_texlive-letltxmacro = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-letltxmacro-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-letltxmacro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-letltxmacro}"
SRC_URI[x86_64_v2_texlive-letltxmacro.sha256sum] = "60edd39a2c3360d43c563f38262cc71e3946fa94df52e69d3eb83706736435a9"

URI_x86_64_v2_texlive-lettrine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lettrine-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lettrine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lettrine}"
SRC_URI[x86_64_v2_texlive-lettrine.sha256sum] = "90f0a7973f5d279605449d6c99dd4bb22a848d14310905c2fe2889d8b1ffd78b"

URI_x86_64_v2_texlive-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lib-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lib}"
SRC_URI[x86_64_v2_texlive-lib.sha256sum] = "3c9790d7de9b7bebabef0f82d868e430280d33eaa9a8d67872bef7eecf10ba3b"

URI_x86_64_v2_texlive-lib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/texlive-lib-devel-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-lib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lib-devel}"
SRC_URI[x86_64_v2_texlive-lib-devel.sha256sum] = "cee44c869f533d458c6539ce44fc5d0548429f98cde3b627cb8f21dd42289b16"

URI_x86_64_v2_texlive-linegoal = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-linegoal-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-linegoal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-linegoal}"
SRC_URI[x86_64_v2_texlive-linegoal.sha256sum] = "3cd16f6ed480459ad397f90694d33ef44ba86294f24f5e9246e3d9a3af7ef800"

URI_x86_64_v2_texlive-lineno = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lineno-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lineno;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lineno}"
SRC_URI[x86_64_v2_texlive-lineno.sha256sum] = "2530af73b80c534944a3ced8f15d66327846c6e8900fb5a56b6b810dc1789a97"

URI_x86_64_v2_texlive-listings = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-listings-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-listings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-listings}"
SRC_URI[x86_64_v2_texlive-listings.sha256sum] = "82bf3cab6361cd60cc203d3597ed47f0dc7d419400371349508c3d004bce04b2"

URI_x86_64_v2_texlive-listofitems = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-listofitems-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-listofitems;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-listofitems}"
SRC_URI[x86_64_v2_texlive-listofitems.sha256sum] = "76e3a64236c2c36014198b078450077dd09d13f8ae8c83bef4175fb42112466b"

URI_x86_64_v2_texlive-lm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lm-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lm}"
SRC_URI[x86_64_v2_texlive-lm.sha256sum] = "023a9f5cae2326a5f5766af0be9136c62710fb6e5ea400d8633eac4ab367f2a3"

URI_x86_64_v2_texlive-lm-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lm-math-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lm-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lm-math}"
SRC_URI[x86_64_v2_texlive-lm-math.sha256sum] = "ccdfea596e47a14ed61288e3cbd77eb1e2cc6b7a6a25814608ef0e72dded91de"

URI_x86_64_v2_texlive-ltabptch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ltabptch-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ltabptch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ltabptch}"
SRC_URI[x86_64_v2_texlive-ltabptch.sha256sum] = "b84a81a204db471532282f3a0e8177c642b8376e32c378d4dc31aa8eaa1c37bb"

URI_x86_64_v2_texlive-ltxcmds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ltxcmds-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ltxcmds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ltxcmds}"
SRC_URI[x86_64_v2_texlive-ltxcmds.sha256sum] = "d9f231abfcfa07b45de491655d684528259821242715b8c902800e688dee0e92"

URI_x86_64_v2_texlive-ltxmisc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ltxmisc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ltxmisc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ltxmisc}"
SRC_URI[x86_64_v2_texlive-ltxmisc.sha256sum] = "64bb1d4ab0b04b75138543c229894b8d71b3f6961827766f7c250e2541f2cfcc"

URI_x86_64_v2_texlive-lua-alt-getopt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lua-alt-getopt-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lua-alt-getopt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lua-alt-getopt}"
SRC_URI[x86_64_v2_texlive-lua-alt-getopt.sha256sum] = "fd3c063f7febf3ba5f0dd6ef40eb73ffb0fde2648911fe49f4ef6530695b737d"

URI_x86_64_v2_texlive-lua-uni-algos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lua-uni-algos-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lua-uni-algos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lua-uni-algos}"
SRC_URI[x86_64_v2_texlive-lua-uni-algos.sha256sum] = "569d07855b42dc5ede6eee97290c5e400a13d318cccb3f0cd4c95cada8319a3f"

URI_x86_64_v2_texlive-luahbtex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luahbtex-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-luahbtex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luahbtex}"
SRC_URI[x86_64_v2_texlive-luahbtex.sha256sum] = "6d28438200e847186fb11533bd3b44225468de6b61d58d6e5f092aa804fcb61e"

URI_x86_64_v2_texlive-lualatex-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lualatex-math-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lualatex-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lualatex-math}"
SRC_URI[x86_64_v2_texlive-lualatex-math.sha256sum] = "d3130cd75a23497a0f3ffe201aa65917abc0955bc1ea558ea27c548acb0c6b4a"

URI_x86_64_v2_texlive-lualibs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lualibs-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lualibs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lualibs}"
SRC_URI[x86_64_v2_texlive-lualibs.sha256sum] = "60f187d1e2f17ddac08e36b152e4773e3cb30403430bfdddbfbbb6f0607db913"

URI_x86_64_v2_texlive-luaotfload = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luaotfload-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-luaotfload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luaotfload}"
SRC_URI[x86_64_v2_texlive-luaotfload.sha256sum] = "b5395e55e600822395fecfdf2e78fce6ff3d723ec72d9328360634fd297c07eb"

URI_x86_64_v2_texlive-luatex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luatex-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-luatex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatex}"
SRC_URI[x86_64_v2_texlive-luatex.sha256sum] = "2ecd426e59c88b736837bc0fb0e373cf0d8f6c8ab219fd7ed5935c2dce3d565a"

URI_x86_64_v2_texlive-luatex85 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luatex85-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-luatex85;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatex85}"
SRC_URI[x86_64_v2_texlive-luatex85.sha256sum] = "e3945ad747d36d07b4acb3059f689e3c54254d987796df61db5bf2954a93fb15"

URI_x86_64_v2_texlive-luatexbase = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-luatexbase-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-luatexbase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-luatexbase}"
SRC_URI[x86_64_v2_texlive-luatexbase.sha256sum] = "e25f399a5ceb45521d6a3c0ff26fac61d431cd145abfbfd6052677754e00261d"

URI_x86_64_v2_texlive-lwarp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-lwarp-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-lwarp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-lwarp}"
SRC_URI[x86_64_v2_texlive-lwarp.sha256sum] = "baf0871a050235fa4e68564a0e3789edcdefa151f722ab07f11a4bd8475e3d81"

URI_x86_64_v2_texlive-makecmds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-makecmds-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-makecmds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-makecmds}"
SRC_URI[x86_64_v2_texlive-makecmds.sha256sum] = "c2cdb39afcb413e6b2bf124244f2996eb37131796b62e9d246cc1cd1b064b10e"

URI_x86_64_v2_texlive-makeindex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-makeindex-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-makeindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-makeindex}"
SRC_URI[x86_64_v2_texlive-makeindex.sha256sum] = "0f7a707d7fe342aa2048c4659751f4a050c93be75d087ba393dee7e5ba6b816f"

URI_x86_64_v2_texlive-manfnt-font = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-manfnt-font-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-manfnt-font;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-manfnt-font}"
SRC_URI[x86_64_v2_texlive-manfnt-font.sha256sum] = "f3d39aa21674853bf5f7137728357072f5b471329067146594a33808d00e752b"

URI_x86_64_v2_texlive-marginnote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-marginnote-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-marginnote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-marginnote}"
SRC_URI[x86_64_v2_texlive-marginnote.sha256sum] = "da03c01579f019f5ca28a51793f15c00fe171b3d744fa10340d395b0b22fef46"

URI_x86_64_v2_texlive-marvosym = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-marvosym-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-marvosym;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-marvosym}"
SRC_URI[x86_64_v2_texlive-marvosym.sha256sum] = "4c636a9ba8c9a29b824ac7d7e7f3ab339e0fa6909a69ea7fbb844d882b9ac88e"

URI_x86_64_v2_texlive-mathpazo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mathpazo-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mathpazo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mathpazo}"
SRC_URI[x86_64_v2_texlive-mathpazo.sha256sum] = "4b6bfaee1cd48101850a23c8f8a24e7b4659446fcd58a0059d3125e163568ca9"

URI_x86_64_v2_texlive-mathspec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mathspec-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mathspec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mathspec}"
SRC_URI[x86_64_v2_texlive-mathspec.sha256sum] = "cc6ffcd6f90b8cb18578baaf33a27f90e5b9ccef1567ef881275ec43cfbef163"

URI_x86_64_v2_texlive-mathtools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mathtools-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mathtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mathtools}"
SRC_URI[x86_64_v2_texlive-mathtools.sha256sum] = "a11610473afc8599c5bdb6b06a69a3701c9b290c8f1367794d1c28edcc5607cf"

URI_x86_64_v2_texlive-mdwtools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mdwtools-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mdwtools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mdwtools}"
SRC_URI[x86_64_v2_texlive-mdwtools.sha256sum] = "14f3decbf84afac279c2b306246595ab15c7853f0d3b5d2610980a78ca5ff13d"

URI_x86_64_v2_texlive-memoir = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-memoir-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-memoir;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-memoir}"
SRC_URI[x86_64_v2_texlive-memoir.sha256sum] = "fed013c39b371e4067bd2e6a5db23d234bf54a4bd2117c025acd00426b5236ac"

URI_x86_64_v2_texlive-metafont = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-metafont-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-metafont;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-metafont}"
SRC_URI[x86_64_v2_texlive-metafont.sha256sum] = "f735e009638b76a29ed3d1e5886616892275b181956a16bf9d843f0dda8a8947"

URI_x86_64_v2_texlive-metalogo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-metalogo-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-metalogo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-metalogo}"
SRC_URI[x86_64_v2_texlive-metalogo.sha256sum] = "7dea5ffa7ef54f30db2b9ac940eec33bb9a484c967634ea4f0b5ccea924ea78c"

URI_x86_64_v2_texlive-metapost = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-metapost-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-metapost;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-metapost}"
SRC_URI[x86_64_v2_texlive-metapost.sha256sum] = "353f9ebf19deeac4a0e8a5fa032a55edea6cae558958e293ed36655290771c40"

URI_x86_64_v2_texlive-mflogo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mflogo-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mflogo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mflogo}"
SRC_URI[x86_64_v2_texlive-mflogo.sha256sum] = "1fb2ed54edb6e36f1fa39781279f0da42a882f997eb4ed62866d2ce190606d33"

URI_x86_64_v2_texlive-mflogo-font = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mflogo-font-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mflogo-font;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mflogo-font}"
SRC_URI[x86_64_v2_texlive-mflogo-font.sha256sum] = "53a93e050229d495559f753d92b4820f51ab5009add8b7a35d69672244958a7f"

URI_x86_64_v2_texlive-mfnfss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mfnfss-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mfnfss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mfnfss}"
SRC_URI[x86_64_v2_texlive-mfnfss.sha256sum] = "5fb8665b1d3c4ba968e279b6cac3c7af056743f9c8bb7f7cbd2045bbaf09c33d"

URI_x86_64_v2_texlive-mfware = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mfware-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-mfware;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mfware}"
SRC_URI[x86_64_v2_texlive-mfware.sha256sum] = "79a35f6551b49d32c8c8eaa8337a74313e0144b8e792df831dad132db51c2ea4"

URI_x86_64_v2_texlive-microtype = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-microtype-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-microtype;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-microtype}"
SRC_URI[x86_64_v2_texlive-microtype.sha256sum] = "4d6f2a835327b3b1161fda23ed3309889a8716bed2fa40dcdbd869bc48432886"

URI_x86_64_v2_texlive-minitoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-minitoc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-minitoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-minitoc}"
SRC_URI[x86_64_v2_texlive-minitoc.sha256sum] = "c138a00447dfd3bcf1b0f10177f25e54e7ac98f1cb764ec4915d45d5378ce748"

URI_x86_64_v2_texlive-mnsymbol = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mnsymbol-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mnsymbol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mnsymbol}"
SRC_URI[x86_64_v2_texlive-mnsymbol.sha256sum] = "57d0cef8c5bca9439577578a1be3aab23c57d72b49c3b7ac6e1921ada078e920"

URI_x86_64_v2_texlive-modes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-modes-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-modes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-modes}"
SRC_URI[x86_64_v2_texlive-modes.sha256sum] = "509e15cab7a15eb00eb97de059ce0efde17b1e568b59ae594ced5f931f5d4305"

URI_x86_64_v2_texlive-mparhack = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mparhack-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mparhack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mparhack}"
SRC_URI[x86_64_v2_texlive-mparhack.sha256sum] = "c9e7dcc0b149c84e899d259235951baa832a9543ce55a2107d44cf897c147ca8"

URI_x86_64_v2_texlive-mptopdf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-mptopdf-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-mptopdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-mptopdf}"
SRC_URI[x86_64_v2_texlive-mptopdf.sha256sum] = "d8e6d477015a80c3432399d6c1190004757b15deefe86975df55c373bf58df2d"

URI_x86_64_v2_texlive-multido = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-multido-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-multido;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-multido}"
SRC_URI[x86_64_v2_texlive-multido.sha256sum] = "a5f914229f58455b5eb022bc69c5e7c9ff035b1fe0c76b38e9ad31d10b1e8152"

URI_x86_64_v2_texlive-multirow = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-multirow-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-multirow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-multirow}"
SRC_URI[x86_64_v2_texlive-multirow.sha256sum] = "faabdd2c319163d313d3c35d0c4369b73fb8a931115fe107620a97c91d3f0e81"

URI_x86_64_v2_texlive-multitoc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-multitoc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-multitoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-multitoc}"
SRC_URI[x86_64_v2_texlive-multitoc.sha256sum] = "f88d2165077365c9597afef9fb2ef5983d120584da5cee3308153049db20aead"

URI_x86_64_v2_texlive-natbib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-natbib-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-natbib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-natbib}"
SRC_URI[x86_64_v2_texlive-natbib.sha256sum] = "df68f4754790ea88ff34c04b4cf940074757e2bf55a79890524d0fe88b771285"

URI_x86_64_v2_texlive-ncctools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ncctools-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ncctools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ncctools}"
SRC_URI[x86_64_v2_texlive-ncctools.sha256sum] = "a0144d5465e59269d4213fa41984d667bf6c4e2decc5f0a19c7975769e719ae1"

URI_x86_64_v2_texlive-ncntrsbk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ncntrsbk-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ncntrsbk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ncntrsbk}"
SRC_URI[x86_64_v2_texlive-ncntrsbk.sha256sum] = "98e5ce251689971bbedccd6e38c22b87a1a425351e09f0c4db23761b6baf66f6"

URI_x86_64_v2_texlive-needspace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-needspace-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-needspace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-needspace}"
SRC_URI[x86_64_v2_texlive-needspace.sha256sum] = "95f67dcd9e9285fb0f2b47ba66c8b8fc9d02a4ad2b7845bf005f33aa40ec7482"

URI_x86_64_v2_texlive-newfloat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-newfloat-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-newfloat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-newfloat}"
SRC_URI[x86_64_v2_texlive-newfloat.sha256sum] = "4b23ead941616c108a5d8ff851402da9e5c146f1be078d828901018bf2dbeeb5"

URI_x86_64_v2_texlive-newunicodechar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-newunicodechar-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-newunicodechar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-newunicodechar}"
SRC_URI[x86_64_v2_texlive-newunicodechar.sha256sum] = "40714f7743e8eb2ac2fd1961bc96b57743a1a3834a02ae8fe517337c005242a3"

URI_x86_64_v2_texlive-norasi-c90 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-norasi-c90-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-norasi-c90;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-norasi-c90}"
SRC_URI[x86_64_v2_texlive-norasi-c90.sha256sum] = "86c72c7569742eb3fff6aca4bcbb9ee01fa79422e67395327a7e6ff6e03bf81c"

URI_x86_64_v2_texlive-notoccite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-notoccite-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-notoccite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-notoccite}"
SRC_URI[x86_64_v2_texlive-notoccite.sha256sum] = "61362aa5e3efc87ec91722ddbed4d99a829915365c9a2fbb4df5d50b3c55e52b"

URI_x86_64_v2_texlive-ntgclass = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ntgclass-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ntgclass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ntgclass}"
SRC_URI[x86_64_v2_texlive-ntgclass.sha256sum] = "0826c5024a9b8f5cef4b4a5b4d1aa3ea6598e177931102e485078ac11525f275"

URI_x86_64_v2_texlive-oberdiek = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-oberdiek-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-oberdiek;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-oberdiek}"
SRC_URI[x86_64_v2_texlive-oberdiek.sha256sum] = "d511a560f8dd5b60fb72048f677d557afe10fb446de6d737dc7b5c862af3d817"

URI_x86_64_v2_texlive-overpic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-overpic-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-overpic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-overpic}"
SRC_URI[x86_64_v2_texlive-overpic.sha256sum] = "c512c13fee7cda1cd881a8f0ec29ef2733fc9e0c5505c4a2d103dd12c6540510"

URI_x86_64_v2_texlive-palatino = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-palatino-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-palatino;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-palatino}"
SRC_URI[x86_64_v2_texlive-palatino.sha256sum] = "f4b8ca87abb259554ed271b38264b7031849cfc9e24934b6eb4f15f49787cee2"

URI_x86_64_v2_texlive-paralist = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-paralist-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-paralist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-paralist}"
SRC_URI[x86_64_v2_texlive-paralist.sha256sum] = "be73ac86606b59e9d77b84ac93ab56b6560fc988b9430fbcfd0704a157b567b6"

URI_x86_64_v2_texlive-parallel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-parallel-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-parallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-parallel}"
SRC_URI[x86_64_v2_texlive-parallel.sha256sum] = "f5706b9210820ceda6fdfde1b5dc908d0c8b0013ae191381ada6b016217d44ed"

URI_x86_64_v2_texlive-parskip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-parskip-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-parskip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-parskip}"
SRC_URI[x86_64_v2_texlive-parskip.sha256sum] = "6756638e39d4e02e9aa75116e01ed140b3949d087cafd27e888de8cf61a6f8af"

URI_x86_64_v2_texlive-passivetex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-passivetex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-passivetex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-passivetex}"
SRC_URI[x86_64_v2_texlive-passivetex.sha256sum] = "afc08ca31c45c6bda18f035c088bb2f1a22daec161c81d6f6526f3ec4f7860f4"

URI_x86_64_v2_texlive-pdfcol = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfcol-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pdfcol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfcol}"
SRC_URI[x86_64_v2_texlive-pdfcol.sha256sum] = "0580c7e6100ab0b96b951a693f706c08a280f3ca57e174e43581a0c4a02880a1"

URI_x86_64_v2_texlive-pdfcolfoot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfcolfoot-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pdfcolfoot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfcolfoot}"
SRC_URI[x86_64_v2_texlive-pdfcolfoot.sha256sum] = "e6607942bc6512b24c33c1500be396e994b677af64d50b535ef7ea7acd22a9fc"

URI_x86_64_v2_texlive-pdfcolmk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfcolmk-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pdfcolmk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfcolmk}"
SRC_URI[x86_64_v2_texlive-pdfcolmk.sha256sum] = "d25275c8fc860334d30f9df17d80f7c34e54318a414d659530aa2b4eafe90e29"

URI_x86_64_v2_texlive-pdfescape = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfescape-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pdfescape;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfescape}"
SRC_URI[x86_64_v2_texlive-pdfescape.sha256sum] = "8bf0b43b6ed76ac738eaefad44ffb676d428737a6af8540c0fc76827a348e1dc"

URI_x86_64_v2_texlive-pdflscape = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdflscape-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pdflscape;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdflscape}"
SRC_URI[x86_64_v2_texlive-pdflscape.sha256sum] = "b91d80458e001cb127796eb301a27de89476b47c5425d93f5ac7f98f6a89f0c9"

URI_x86_64_v2_texlive-pdfmanagement-testphase = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfmanagement-testphase-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pdfmanagement-testphase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfmanagement-testphase}"
SRC_URI[x86_64_v2_texlive-pdfmanagement-testphase.sha256sum] = "5f1a873db40a1e5b153ac5ac940e5dbfdc1fe686fe806363e5edb2d03cc9ae4f"

URI_x86_64_v2_texlive-pdfpages = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdfpages-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pdfpages;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdfpages}"
SRC_URI[x86_64_v2_texlive-pdfpages.sha256sum] = "171fe1bfa60028045e71296fa3521123179bd29dd63bcbc63e2616501021c535"

URI_x86_64_v2_texlive-pdftex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdftex-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-pdftex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdftex}"
SRC_URI[x86_64_v2_texlive-pdftex.sha256sum] = "d9e017ab679cad5e22a28ab7de6ee36744f66aa7100cc191b5c76f292fe8dd01"

URI_x86_64_v2_texlive-pdftexcmds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pdftexcmds-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pdftexcmds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pdftexcmds}"
SRC_URI[x86_64_v2_texlive-pdftexcmds.sha256sum] = "a6f8dcf5df94d43704c7cac84a86a4ee2c9d671ca2704e2772403531a05d5d75"

URI_x86_64_v2_texlive-pgf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pgf-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pgf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pgf}"
SRC_URI[x86_64_v2_texlive-pgf.sha256sum] = "b227f428c2eecf8b752135c82cc544caa1ef3d22a57d818275060115f8e6f465"

URI_x86_64_v2_texlive-philokalia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-philokalia-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-philokalia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-philokalia}"
SRC_URI[x86_64_v2_texlive-philokalia.sha256sum] = "456bfebaf2d04a34bfd63619f0724ce68f02c7f504d19e4fee91ba33ec907e8e"

URI_x86_64_v2_texlive-placeins = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-placeins-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-placeins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-placeins}"
SRC_URI[x86_64_v2_texlive-placeins.sha256sum] = "69531c2675747c1588cd7595243e7dbb3fce44350563ffacf9cb155e342ad1a1"

URI_x86_64_v2_texlive-plain = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-plain-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-plain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-plain}"
SRC_URI[x86_64_v2_texlive-plain.sha256sum] = "f00f64e08bdcaedbf1b8392cd9746b43abceefab46e4b39a0e46b3085d7092b7"

URI_x86_64_v2_texlive-polyglossia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-polyglossia-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-polyglossia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-polyglossia}"
SRC_URI[x86_64_v2_texlive-polyglossia.sha256sum] = "1e9806957af9cf5acc91e06b190a9185c36237d473ca368267c29526b02da75e"

URI_x86_64_v2_texlive-powerdot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-powerdot-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-powerdot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-powerdot}"
SRC_URI[x86_64_v2_texlive-powerdot.sha256sum] = "61ae74cc6c3a64e7eba43fd51c8df3432603f3b0a5d4c92bb5d9ddc1c5352e30"

URI_x86_64_v2_texlive-preprint = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-preprint-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-preprint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-preprint}"
SRC_URI[x86_64_v2_texlive-preprint.sha256sum] = "fc3ffc879457deeafd7945317bf5b2dba5cac8f31880f93888503ac4a100392b"

URI_x86_64_v2_texlive-psfrag = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-psfrag-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-psfrag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-psfrag}"
SRC_URI[x86_64_v2_texlive-psfrag.sha256sum] = "83dbb1550912ce54b38a0e31ec0666f274017dfec09710ab77a35ee2141674c6"

URI_x86_64_v2_texlive-pslatex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pslatex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pslatex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pslatex}"
SRC_URI[x86_64_v2_texlive-pslatex.sha256sum] = "94ecda67f4455d088d2d3ba1ec8f46ee1762b05fa38f46e930664e15f5af3e67"

URI_x86_64_v2_texlive-psnfss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-psnfss-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-psnfss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-psnfss}"
SRC_URI[x86_64_v2_texlive-psnfss.sha256sum] = "774150b48c23671d24cdab00358ad6f5b4552cb09cbd770fec527c5ecbe9c7ac"

URI_x86_64_v2_texlive-pspicture = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pspicture-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pspicture;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pspicture}"
SRC_URI[x86_64_v2_texlive-pspicture.sha256sum] = "23d16f1de485b474272142381887488bcdec69a27ce6559ddf574520957638d0"

URI_x86_64_v2_texlive-pst-3d = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-3d-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-3d}"
SRC_URI[x86_64_v2_texlive-pst-3d.sha256sum] = "dd50b53754315a5be52339597d56a15e8cd9a90ed8ad04424f3ff48dc1c830c3"

URI_x86_64_v2_texlive-pst-arrow = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-arrow-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-arrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-arrow}"
SRC_URI[x86_64_v2_texlive-pst-arrow.sha256sum] = "dccf985f5b28ced63f4fb1ddafa7b2b19bf871c44e410a3c594967566165a654"

URI_x86_64_v2_texlive-pst-blur = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-blur-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-blur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-blur}"
SRC_URI[x86_64_v2_texlive-pst-blur.sha256sum] = "1649bfcde134f05fb855b58992a3aa9b8b5355048368f958acc3f95c9db5aa8f"

URI_x86_64_v2_texlive-pst-coil = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-coil-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-coil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-coil}"
SRC_URI[x86_64_v2_texlive-pst-coil.sha256sum] = "160d55dcc76c99c732cd194e83db59c32db0f0c9f39ba8202d615910cc97306a"

URI_x86_64_v2_texlive-pst-eps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-eps-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-eps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-eps}"
SRC_URI[x86_64_v2_texlive-pst-eps.sha256sum] = "0855108c316ff7fa5d66260dfa7f00c03a2ff6f971ff848c7b85e078ca8a64ca"

URI_x86_64_v2_texlive-pst-fill = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-fill-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-fill;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-fill}"
SRC_URI[x86_64_v2_texlive-pst-fill.sha256sum] = "ea141f492835b41b76636052925fde98279c4633cf70826b627b44dad4e81e94"

URI_x86_64_v2_texlive-pst-grad = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-grad-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-grad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-grad}"
SRC_URI[x86_64_v2_texlive-pst-grad.sha256sum] = "261920ae36ab7c07b9b214b020c92f4ed6871ae6a0d7c73ccfb53943a9100958"

URI_x86_64_v2_texlive-pst-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-math-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-math}"
SRC_URI[x86_64_v2_texlive-pst-math.sha256sum] = "860376c0b50b132e1576f0cfff4435bd6c08120295c7cb1cc2842f8b6da31d9b"

URI_x86_64_v2_texlive-pst-node = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-node-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-node;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-node}"
SRC_URI[x86_64_v2_texlive-pst-node.sha256sum] = "c9a19623b26c8b655f29bef7b6904e2c34dab00242c59aebf00d9aee4c7ab941"

URI_x86_64_v2_texlive-pst-plot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-plot-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-plot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-plot}"
SRC_URI[x86_64_v2_texlive-pst-plot.sha256sum] = "d0a0681346c7158022df089537c9038df9efc358542c5f30efb9c1422a0b7796"

URI_x86_64_v2_texlive-pst-slpe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-slpe-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-slpe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-slpe}"
SRC_URI[x86_64_v2_texlive-pst-slpe.sha256sum] = "f782d9f4c2eeda9d738161bfb7d1aacb88a18c0c68f633e6f8080ed9dc8a8bf1"

URI_x86_64_v2_texlive-pst-text = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-text-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-text}"
SRC_URI[x86_64_v2_texlive-pst-text.sha256sum] = "4b98e891ced4484318da18015ee7fe4327ded6c0d2cd1ecc8ef4db5104fea17d"

URI_x86_64_v2_texlive-pst-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-tools-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-tools}"
SRC_URI[x86_64_v2_texlive-pst-tools.sha256sum] = "a79bfbbaf4cb3505e14cd1ea04d87dba9851e0af4deb867b04bb757823b81987"

URI_x86_64_v2_texlive-pst-tree = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pst-tree-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pst-tree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pst-tree}"
SRC_URI[x86_64_v2_texlive-pst-tree.sha256sum] = "a38627eec2fc979e3ddec6cb38d5de761531ddd3f2ca47532846320890fe28bd"

URI_x86_64_v2_texlive-pstricks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pstricks-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pstricks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pstricks}"
SRC_URI[x86_64_v2_texlive-pstricks.sha256sum] = "a5192cb0444c284c55a6c3ad05f64d3898677b674223d996221688edb19a1cf5"

URI_x86_64_v2_texlive-pstricks-add = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pstricks-add-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pstricks-add;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pstricks-add}"
SRC_URI[x86_64_v2_texlive-pstricks-add.sha256sum] = "505906b29966c344b4db19009a05314e9b0e4b979fad6e0a6f845fcd17c3dba6"

URI_x86_64_v2_texlive-ptext = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ptext-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ptext;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ptext}"
SRC_URI[x86_64_v2_texlive-ptext.sha256sum] = "af6008babccdb151bdf83a7ed5649f512311ee1a7bbf233254b7fc6fa730e656"

URI_x86_64_v2_texlive-pxfonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-pxfonts-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-pxfonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-pxfonts}"
SRC_URI[x86_64_v2_texlive-pxfonts.sha256sum] = "1b62c64c9389430615fa71dff7842f45b8354535f809eac5e3d1009ad9dec5b9"

URI_x86_64_v2_texlive-qstest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-qstest-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-qstest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-qstest}"
SRC_URI[x86_64_v2_texlive-qstest.sha256sum] = "c337f3011c082476db693b7b83ee757a36844670eca9aee0937cfa9880826cb2"

URI_x86_64_v2_texlive-ragged2e = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ragged2e-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ragged2e;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ragged2e}"
SRC_URI[x86_64_v2_texlive-ragged2e.sha256sum] = "2afe059c35c98e2429208730a86d39e2f6d2d97abf3374565b86050014af401c"

URI_x86_64_v2_texlive-rcs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-rcs-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-rcs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-rcs}"
SRC_URI[x86_64_v2_texlive-rcs.sha256sum] = "76d44caf821a021bab2793ab7bf6f4aa7d4bdbf7ef37631199561a3087ddfd83"

URI_x86_64_v2_texlive-realscripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-realscripts-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-realscripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-realscripts}"
SRC_URI[x86_64_v2_texlive-realscripts.sha256sum] = "89fb3e07dd9ecaac236e688de2ad6eedd1df28d88cf24626058fff162da7b8e5"

URI_x86_64_v2_texlive-refcount = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-refcount-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-refcount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-refcount}"
SRC_URI[x86_64_v2_texlive-refcount.sha256sum] = "39b1ce5ccaf357f1c8adfdda898132725c36268d306c970071786cd1f656d3ec"

URI_x86_64_v2_texlive-relsize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-relsize-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-relsize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-relsize}"
SRC_URI[x86_64_v2_texlive-relsize.sha256sum] = "0bbd113cc6af0f1dd8fda27c9172e75a88367dd616eb8dc0159df3d9aaf83898"

URI_x86_64_v2_texlive-rerunfilecheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-rerunfilecheck-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-rerunfilecheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-rerunfilecheck}"
SRC_URI[x86_64_v2_texlive-rerunfilecheck.sha256sum] = "ca22e1afa887b4cee17d4ab7e22dda9bb66c6135395d3a3a26a31c77bc86a411"

URI_x86_64_v2_texlive-rsfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-rsfs-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-rsfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-rsfs}"
SRC_URI[x86_64_v2_texlive-rsfs.sha256sum] = "e444d0722c33054bdb2e642f7a8b4a7b10997b1ea24d4f7400140b5e385c131b"

URI_x86_64_v2_texlive-sansmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sansmath-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-sansmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sansmath}"
SRC_URI[x86_64_v2_texlive-sansmath.sha256sum] = "f9d6c9e97b4dcc74885c4aadb32b5f351d8301bb949e69b793c7ba93bd7de9ed"

URI_x86_64_v2_texlive-sansmathaccent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sansmathaccent-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-sansmathaccent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sansmathaccent}"
SRC_URI[x86_64_v2_texlive-sansmathaccent.sha256sum] = "ca2c8813ed96754852e9267cf2fd6a8bd03f9dd3c252957fdda685c51c9f03a3"

URI_x86_64_v2_texlive-sauerj = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sauerj-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-sauerj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sauerj}"
SRC_URI[x86_64_v2_texlive-sauerj.sha256sum] = "836dc81327dd7a738013b3fc55aa221325d1d06528824e8c2b376086cf6dc1e1"

URI_x86_64_v2_texlive-scheme-basic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-scheme-basic-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-scheme-basic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-scheme-basic}"
SRC_URI[x86_64_v2_texlive-scheme-basic.sha256sum] = "412ce997c0fa6ea355244dbfce537124dfcdf64397aa67ebe91fa1cdb5902efb"

URI_x86_64_v2_texlive-section = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-section-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-section;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-section}"
SRC_URI[x86_64_v2_texlive-section.sha256sum] = "89d60c7cac2963c27c8cad7cdf41acebeb0812fc450c5624a7ab1e11b12b3620"

URI_x86_64_v2_texlive-sectsty = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sectsty-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-sectsty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sectsty}"
SRC_URI[x86_64_v2_texlive-sectsty.sha256sum] = "0927866505567ac67056b47afa147235c73b969c1c7e53c75e282dffc6a59331"

URI_x86_64_v2_texlive-seminar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-seminar-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-seminar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-seminar}"
SRC_URI[x86_64_v2_texlive-seminar.sha256sum] = "ed511008b61327699838fb1ff250ee40905dff8fe340133b0aec2d1f70a811f9"

URI_x86_64_v2_texlive-sepnum = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sepnum-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-sepnum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sepnum}"
SRC_URI[x86_64_v2_texlive-sepnum.sha256sum] = "6aa8424f84d6259e8e02117ba4d6f2b4018f412220a7efb180e7fd57638374cb"

URI_x86_64_v2_texlive-setspace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-setspace-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-setspace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-setspace}"
SRC_URI[x86_64_v2_texlive-setspace.sha256sum] = "c8943e59dae645ee3a24801cbcd0cf39b97741bb13eed8663dbffc8de042a06b"

URI_x86_64_v2_texlive-sfmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-sfmath-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-sfmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-sfmath}"
SRC_URI[x86_64_v2_texlive-sfmath.sha256sum] = "9766925d393cc6d74cd881b4b9b30f69ccd1f1fe390833b67db45eca2ba5a672"

URI_x86_64_v2_texlive-showexpl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-showexpl-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-showexpl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-showexpl}"
SRC_URI[x86_64_v2_texlive-showexpl.sha256sum] = "bd94f9486dbe3b83cf6dde756e2f5fcb7be5a8fb46eb978c6972f30845dc8202"

URI_x86_64_v2_texlive-soul = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-soul-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-soul;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-soul}"
SRC_URI[x86_64_v2_texlive-soul.sha256sum] = "a869c02eadb225c95e44aff00b3172b0099ea39120e6e29afddcb3c354b88d7f"

URI_x86_64_v2_texlive-stackengine = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-stackengine-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-stackengine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-stackengine}"
SRC_URI[x86_64_v2_texlive-stackengine.sha256sum] = "375bf86b8674d0915730d10c1c5bc410867e92b14eb851f690055d3bd9314678"

URI_x86_64_v2_texlive-stmaryrd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-stmaryrd-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-stmaryrd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-stmaryrd}"
SRC_URI[x86_64_v2_texlive-stmaryrd.sha256sum] = "eb82176321959fc3597743b2a7dfd3371ae2a940a931f879808061748f37fa9c"

URI_x86_64_v2_texlive-stringenc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-stringenc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-stringenc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-stringenc}"
SRC_URI[x86_64_v2_texlive-stringenc.sha256sum] = "98a6c3ae46121d583570ad59c35d9263638be13d0530ad3110040ac709709854"

URI_x86_64_v2_texlive-subfig = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-subfig-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-subfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-subfig}"
SRC_URI[x86_64_v2_texlive-subfig.sha256sum] = "671f0cd6109ca338aa10b4c2ea058918880eca8d025bc184e6c08e8b15760006"

URI_x86_64_v2_texlive-subfigure = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-subfigure-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-subfigure;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-subfigure}"
SRC_URI[x86_64_v2_texlive-subfigure.sha256sum] = "dd2de4a99680e26841acfa0bc0b152998605bf4aa4808e69425a212164674f09"

URI_x86_64_v2_texlive-svn-prov = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-svn-prov-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-svn-prov;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-svn-prov}"
SRC_URI[x86_64_v2_texlive-svn-prov.sha256sum] = "0c6294df9284aae1cfb0cca721908a6dfdb9db22cd979dacc8bcb6243f938638"

URI_x86_64_v2_texlive-symbol = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-symbol-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-symbol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-symbol}"
SRC_URI[x86_64_v2_texlive-symbol.sha256sum] = "18a4627802dc56a7edffd46d34ee84320378819496ac2bfcdc1f7507eef6e098"

URI_x86_64_v2_texlive-t2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-t2-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-t2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-t2}"
SRC_URI[x86_64_v2_texlive-t2.sha256sum] = "942e0ee5eb12513ef7044c377ba59de1f41a9b1c5aff6cd560ea2f36da0b4686"

URI_x86_64_v2_texlive-tabu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tabu-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-tabu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tabu}"
SRC_URI[x86_64_v2_texlive-tabu.sha256sum] = "06a24c680d3ef9f6ea5b38e19a805ff84b8f2b60bb49294361df4a7b3723a59d"

URI_x86_64_v2_texlive-tabulary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tabulary-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-tabulary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tabulary}"
SRC_URI[x86_64_v2_texlive-tabulary.sha256sum] = "535b085ea8059888b9410568fe2831a7c8df04f11357b62540cf62e84247b417"

URI_x86_64_v2_texlive-tex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-tex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex}"
SRC_URI[x86_64_v2_texlive-tex.sha256sum] = "667b20ad02dcc2b50e7cb74f35bf1be333366bf2b721dcf4c5f5db6dfb099ae6"

URI_x86_64_v2_texlive-tex-gyre = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex-gyre-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-tex-gyre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex-gyre}"
SRC_URI[x86_64_v2_texlive-tex-gyre.sha256sum] = "4b901f9d3c29c8ac7bbdab1cb1e19199ba7de33597772d5d68920ce6c57586d8"

URI_x86_64_v2_texlive-tex-gyre-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex-gyre-math-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-tex-gyre-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex-gyre-math}"
SRC_URI[x86_64_v2_texlive-tex-gyre-math.sha256sum] = "f7114fd6745630cdedeb44c0d19eae5eb3e5d947db2d6db9588442feab95c7c6"

URI_x86_64_v2_texlive-tex-ini-files = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex-ini-files-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-tex-ini-files;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex-ini-files}"
SRC_URI[x86_64_v2_texlive-tex-ini-files.sha256sum] = "ed6202c343157a5aa4ce39431595bdb78c0da15eb0e689595e3d59a01a24535b"

URI_x86_64_v2_texlive-tex4ht = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tex4ht-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-tex4ht;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tex4ht}"
SRC_URI[x86_64_v2_texlive-tex4ht.sha256sum] = "d1aa95fd006cb6f3f6b9347bf99a7da9bb1b9d929a85d6947b65c010445074dc"

URI_x86_64_v2_texlive-texlive-common-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-common-doc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-texlive-common-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-common-doc}"
SRC_URI[x86_64_v2_texlive-texlive-common-doc.sha256sum] = "6bd273c534d2d64efc2b079917e15d822e51e09243b6b3ae60a5b5baf027dc3c"

URI_x86_64_v2_texlive-texlive-en = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-en-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-texlive-en;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-en}"
SRC_URI[x86_64_v2_texlive-texlive-en.sha256sum] = "a4d7fd2f62d25251b1515e0ffe649786f003fc0f2d96f5a2bec443096dbb28fd"

URI_x86_64_v2_texlive-texlive-msg-translations = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-msg-translations-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-texlive-msg-translations;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-msg-translations}"
SRC_URI[x86_64_v2_texlive-texlive-msg-translations.sha256sum] = "712ab1fe8d86d43e69eb7a01d32cddb4451fc1f18643dd03151d2bb413b681d9"

URI_x86_64_v2_texlive-texlive-scripts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-scripts-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-texlive-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-scripts}"
SRC_URI[x86_64_v2_texlive-texlive-scripts.sha256sum] = "f051f2b1f29295c4fa82c7b2da8529d1f7b5d9b660fee10b57e5f85926c380d1"

URI_x86_64_v2_texlive-texlive-scripts-extra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive-scripts-extra-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-texlive-scripts-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive-scripts-extra}"
SRC_URI[x86_64_v2_texlive-texlive-scripts-extra.sha256sum] = "e3fef5e6e2742926842338b2a34968a75453447dfdc281c2d9b8d54c5c6c3dd3"

URI_x86_64_v2_texlive-texlive.infra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-texlive.infra-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-texlive.infra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-texlive.infra}"
SRC_URI[x86_64_v2_texlive-texlive.infra.sha256sum] = "f2a4c306825afb0f841c3dd3a157e83ed61308cfc9483fb9792dea0e76e63ac4"

URI_x86_64_v2_texlive-textcase = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-textcase-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-textcase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-textcase}"
SRC_URI[x86_64_v2_texlive-textcase.sha256sum] = "bf138681c07d66c9e068fde9b435022499700e36348146a0f7d663b2d0e916d4"

URI_x86_64_v2_texlive-textpos = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-textpos-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-textpos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-textpos}"
SRC_URI[x86_64_v2_texlive-textpos.sha256sum] = "b4e85085d3ef4f26933cfc424d58aa7f3cf599ce945340397c830e6bcfa3a2d8"

URI_x86_64_v2_texlive-threeparttable = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-threeparttable-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-threeparttable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-threeparttable}"
SRC_URI[x86_64_v2_texlive-threeparttable.sha256sum] = "2b433e53fc781b04d7633650d0eb64217ffe6e01f473a1e210fc4174c5381d88"

URI_x86_64_v2_texlive-thumbpdf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-thumbpdf-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-thumbpdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-thumbpdf}"
SRC_URI[x86_64_v2_texlive-thumbpdf.sha256sum] = "e8e4b0bc7fa98b9f4f396ac771167c6a49fbc48b0867dca9eddeebce317ed25b"

URI_x86_64_v2_texlive-times = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-times-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-times;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-times}"
SRC_URI[x86_64_v2_texlive-times.sha256sum] = "03cd8ae870eb7b0013e13dc9ae38970dd56e5de120ae2b9a23520ce4581d569b"

URI_x86_64_v2_texlive-tipa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tipa-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-tipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tipa}"
SRC_URI[x86_64_v2_texlive-tipa.sha256sum] = "5af720711efbbcb9c1f7241b18154e9235fa79fcdbf7c4f2a76e184858686fc9"

URI_x86_64_v2_texlive-titlesec = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-titlesec-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-titlesec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-titlesec}"
SRC_URI[x86_64_v2_texlive-titlesec.sha256sum] = "360fa066fe496758b2108c2b88734446d48f6a6f44fe85d7eff09372e98a209e"

URI_x86_64_v2_texlive-titling = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-titling-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-titling;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-titling}"
SRC_URI[x86_64_v2_texlive-titling.sha256sum] = "8fd7e60f3dda5250393fd2c2891b6ec78384f011781d405accd7c4d3015ea013"

URI_x86_64_v2_texlive-tocloft = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tocloft-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-tocloft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tocloft}"
SRC_URI[x86_64_v2_texlive-tocloft.sha256sum] = "f48a3bb9b51964a7f9504bef815277c00944c4def5b2dcb216d49f3525ef0f95"

URI_x86_64_v2_texlive-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-tools-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-tools}"
SRC_URI[x86_64_v2_texlive-tools.sha256sum] = "257f3a0b7df7a825907c8bba5dc501c6ae910744c7542718c1c65c10a20fc802"

URI_x86_64_v2_texlive-translator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-translator-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-translator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-translator}"
SRC_URI[x86_64_v2_texlive-translator.sha256sum] = "5d546c7ccf2c4fff63c30339f112e332217d79b7bd0ae01cb177dff7cd2d94ff"

URI_x86_64_v2_texlive-trimspaces = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-trimspaces-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-trimspaces;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-trimspaces}"
SRC_URI[x86_64_v2_texlive-trimspaces.sha256sum] = "ec69a92de112c06dd0e67b503f6d3b5aceee0f0e81547566d5f043ab92f34725"

URI_x86_64_v2_texlive-txfonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-txfonts-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-txfonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-txfonts}"
SRC_URI[x86_64_v2_texlive-txfonts.sha256sum] = "b1596ca93fc31ba0348a5461d0541eac96e62f1afbb260017b8a5425b89db71a"

URI_x86_64_v2_texlive-type1cm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-type1cm-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-type1cm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-type1cm}"
SRC_URI[x86_64_v2_texlive-type1cm.sha256sum] = "c0160184c2787b0cddcced38c7d4bb3270b4cd2201e950d0df63c45e7bbae788"

URI_x86_64_v2_texlive-typehtml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-typehtml-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-typehtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-typehtml}"
SRC_URI[x86_64_v2_texlive-typehtml.sha256sum] = "8ceb10c7e588b032a223d7f8fa2f8c11ee7bb3f7f3a3402753c92d7e4657ef36"

URI_x86_64_v2_texlive-ucharcat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ucharcat-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ucharcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ucharcat}"
SRC_URI[x86_64_v2_texlive-ucharcat.sha256sum] = "a8af724749d42c890d3b62d2ed9ab4a6a5d44f1c3a0c4b1a45f61d1cf992d6ec"

URI_x86_64_v2_texlive-ucharclasses = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ucharclasses-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ucharclasses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ucharclasses}"
SRC_URI[x86_64_v2_texlive-ucharclasses.sha256sum] = "d05fdb413796b3057b5099c3a58a503f8bacb2cc9a80fbee82691fa2ac285a52"

URI_x86_64_v2_texlive-ucs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ucs-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ucs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ucs}"
SRC_URI[x86_64_v2_texlive-ucs.sha256sum] = "07bc8da2db0d50fe56df3e255813bf8b0a9073e7be1cecd5ee3e57dd663af579"

URI_x86_64_v2_texlive-uhc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-uhc-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-uhc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uhc}"
SRC_URI[x86_64_v2_texlive-uhc.sha256sum] = "78287c94b6ac75273e8a39c89322835baeb30b86721e4348862527934897950d"

URI_x86_64_v2_texlive-ulem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-ulem-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-ulem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-ulem}"
SRC_URI[x86_64_v2_texlive-ulem.sha256sum] = "54b707dcf105aa44ebbfbc7d54239ad59b67bd26e4e1766010af3d76419c09af"

URI_x86_64_v2_texlive-underscore = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-underscore-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-underscore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-underscore}"
SRC_URI[x86_64_v2_texlive-underscore.sha256sum] = "fe7e316ba4902693e669a3c8c27bab51feacd184e178466dbb828f0ac7dc9046"

URI_x86_64_v2_texlive-unicode-data = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-unicode-data-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-unicode-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-unicode-data}"
SRC_URI[x86_64_v2_texlive-unicode-data.sha256sum] = "cefece59622e93adc393a3d2afb5ce0494b2c40d0238f0658f65eab6cf21365e"

URI_x86_64_v2_texlive-unicode-math = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-unicode-math-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-unicode-math;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-unicode-math}"
SRC_URI[x86_64_v2_texlive-unicode-math.sha256sum] = "50a146ccb314d8d508cd3ea532f27db5c891aa763c4455b608b19ff3b731610e"

URI_x86_64_v2_texlive-uniquecounter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-uniquecounter-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-uniquecounter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-uniquecounter}"
SRC_URI[x86_64_v2_texlive-uniquecounter.sha256sum] = "63ef4f106b622980ae7b2780f7a67bf5278c32a14cb0601b3fa01164b574426b"

URI_x86_64_v2_texlive-unisugar = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-unisugar-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-unisugar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-unisugar}"
SRC_URI[x86_64_v2_texlive-unisugar.sha256sum] = "e3b0ee50bcc06bc5918572a432988bd44234b2ca2fa64e404d2ad012aeb9bcdd"

URI_x86_64_v2_texlive-upquote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-upquote-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-upquote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-upquote}"
SRC_URI[x86_64_v2_texlive-upquote.sha256sum] = "110de7a1bf528c69657ca0a432952bfeb51f58de624699b929643f9703bf2bc9"

URI_x86_64_v2_texlive-url = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-url-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-url;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-url}"
SRC_URI[x86_64_v2_texlive-url.sha256sum] = "be1224b78c03cf3b46e25ce09c9b546411cfa862467e34595f844bd9301cc96c"

URI_x86_64_v2_texlive-utopia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-utopia-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-utopia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-utopia}"
SRC_URI[x86_64_v2_texlive-utopia.sha256sum] = "186eccde1525871a5b1689e9e120f3ed1896d8065a9fd6e3425a601b818dd76d"

URI_x86_64_v2_texlive-varwidth = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-varwidth-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-varwidth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-varwidth}"
SRC_URI[x86_64_v2_texlive-varwidth.sha256sum] = "ae073a8e166780dc327d2bfd41aa2fde62786d7ab7837fb532fad657440f68e0"

URI_x86_64_v2_texlive-wadalab = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wadalab-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-wadalab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wadalab}"
SRC_URI[x86_64_v2_texlive-wadalab.sha256sum] = "f8759218d5f444dd8ad0c99f508ec992ab6c6eddd7298d4ef19b684c7a34be69"

URI_x86_64_v2_texlive-was = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-was-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-was;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-was}"
SRC_URI[x86_64_v2_texlive-was.sha256sum] = "d7cc2995d7f8d5433d0ffcef0512fd69c95408753c6d81a144b5a55af365e77d"

URI_x86_64_v2_texlive-wasy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wasy-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-wasy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wasy}"
SRC_URI[x86_64_v2_texlive-wasy.sha256sum] = "ba8def3a826d36f2edf709d629c406742327403aa4ecad004512e565a1de05cd"

URI_x86_64_v2_texlive-wasy-type1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wasy-type1-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-wasy-type1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wasy-type1}"
SRC_URI[x86_64_v2_texlive-wasy-type1.sha256sum] = "bcd459eea94001f9a642a710f75c510e68e873a528d022e2d06b44f2a7672ce0"

URI_x86_64_v2_texlive-wasysym = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wasysym-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-wasysym;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wasysym}"
SRC_URI[x86_64_v2_texlive-wasysym.sha256sum] = "04c51f02d908da32a5f3fee7da1d8077ceb3eeba3221c59af8f2848dc01baf33"

URI_x86_64_v2_texlive-wrapfig = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-wrapfig-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-wrapfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-wrapfig}"
SRC_URI[x86_64_v2_texlive-wrapfig.sha256sum] = "399b62caa04654804395fc29690d5fc143c33c21a928c0d50b91ca2e8e943425"

URI_x86_64_v2_texlive-xcolor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xcolor-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xcolor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xcolor}"
SRC_URI[x86_64_v2_texlive-xcolor.sha256sum] = "9b508475dfca51bc1ef1e5a1c3ed77ce3b0b907370332b63bb28d0c7e0e11534"

URI_x86_64_v2_texlive-xecolor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xecolor-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xecolor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xecolor}"
SRC_URI[x86_64_v2_texlive-xecolor.sha256sum] = "cccbc197b8741972e8d3a7c9c2ade298bf179241bd71fd27764b33dbea5fcebc"

URI_x86_64_v2_texlive-xecyr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xecyr-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xecyr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xecyr}"
SRC_URI[x86_64_v2_texlive-xecyr.sha256sum] = "54cf4bfef5a81624f1550722ee3d6aa47a2323c7ab9d71ff5806301e0905e349"

URI_x86_64_v2_texlive-xeindex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xeindex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xeindex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xeindex}"
SRC_URI[x86_64_v2_texlive-xeindex.sha256sum] = "cc7cdadc917340fcf5444b7d04c5d13a875127f73757e8b2fb21278ac7854ab1"

URI_x86_64_v2_texlive-xepersian = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xepersian-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xepersian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xepersian}"
SRC_URI[x86_64_v2_texlive-xepersian.sha256sum] = "46f555af88922e5910b2eb753265b677abba34c505c13f75ea85d120e5080845"

URI_x86_64_v2_texlive-xesearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xesearch-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xesearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xesearch}"
SRC_URI[x86_64_v2_texlive-xesearch.sha256sum] = "74e2bb109cc86411da4243bda6b1a030c1dbf72884eb7601869fd39b7dcb1b9f"

URI_x86_64_v2_texlive-xetex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetex-20240311-6.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_texlive-xetex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetex}"
SRC_URI[x86_64_v2_texlive-xetex.sha256sum] = "2740bac25632e719500aa3a57bce75c22586e5b49192e168fc8be9cf06e3b5ab"

URI_x86_64_v2_texlive-xetex-itrans = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetex-itrans-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xetex-itrans;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetex-itrans}"
SRC_URI[x86_64_v2_texlive-xetex-itrans.sha256sum] = "22ced8354b2f844861be9c65da2441c039c6877a50ae2bdb8040608f6eb9b90e"

URI_x86_64_v2_texlive-xetex-pstricks = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetex-pstricks-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xetex-pstricks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetex-pstricks}"
SRC_URI[x86_64_v2_texlive-xetex-pstricks.sha256sum] = "120c39653a7b18acd50ed35278a0d463dedf7146768a43d602190bc3733f78c8"

URI_x86_64_v2_texlive-xetexconfig = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetexconfig-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xetexconfig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetexconfig}"
SRC_URI[x86_64_v2_texlive-xetexconfig.sha256sum] = "15d808adc6f4904626b31fbd95485f567a574214b107d8f3135ca9a519d6aa52"

URI_x86_64_v2_texlive-xetexfontinfo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xetexfontinfo-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xetexfontinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xetexfontinfo}"
SRC_URI[x86_64_v2_texlive-xetexfontinfo.sha256sum] = "08690393b10bc413f98b38045150396145427087c980cc91a1a55e215f5377b9"

URI_x86_64_v2_texlive-xfrac = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xfrac-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xfrac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xfrac}"
SRC_URI[x86_64_v2_texlive-xfrac.sha256sum] = "973c5bd49705f89206a87a430b921bece73d6d34c23aad251a680bfb1dc0570f"

URI_x86_64_v2_texlive-xifthen = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xifthen-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xifthen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xifthen}"
SRC_URI[x86_64_v2_texlive-xifthen.sha256sum] = "fee0f61fecce15434440123cdd83bdf93187954b7b893dbab46642abede349d5"

URI_x86_64_v2_texlive-xkeyval = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xkeyval-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xkeyval;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xkeyval}"
SRC_URI[x86_64_v2_texlive-xkeyval.sha256sum] = "e82c4b5ff85404ca8b92ccadb5568e18e499e9f83d5f1822319a50108b84fbaf"

URI_x86_64_v2_texlive-xltxtra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xltxtra-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xltxtra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xltxtra}"
SRC_URI[x86_64_v2_texlive-xltxtra.sha256sum] = "f508906a25c8637817f8de9308f1a5a4011fdedecc5309cc9590d292a166a958"

URI_x86_64_v2_texlive-xmltex = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xmltex-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xmltex;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xmltex}"
SRC_URI[x86_64_v2_texlive-xmltex.sha256sum] = "b16eac2029c3df8672cb09fa0220bcec09bde4c0f4528e47b04fe0f396b9864a"

URI_x86_64_v2_texlive-xpatch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xpatch-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xpatch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xpatch}"
SRC_URI[x86_64_v2_texlive-xpatch.sha256sum] = "6ff94baf9958e6ea26ee7a1c5b687e41ca0d599a189f0e8924d875f769cb1c41"

URI_x86_64_v2_texlive-xstring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xstring-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xstring}"
SRC_URI[x86_64_v2_texlive-xstring.sha256sum] = "ba20ae2031f1164b9da6848f3043a1ea87d77e0e40a77d6ced6b25984958d8c1"

URI_x86_64_v2_texlive-xtab = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xtab-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xtab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xtab}"
SRC_URI[x86_64_v2_texlive-xtab.sha256sum] = "afa16a6632066434269da7b7b784392bcb27f74cdc82511942d200df1a579c7c"

URI_x86_64_v2_texlive-xunicode = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-xunicode-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-xunicode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-xunicode}"
SRC_URI[x86_64_v2_texlive-xunicode.sha256sum] = "add880501fb7af236e0bc2d652e6de10f6dcad8434d183d0fe4f8d011100c1af"

URI_x86_64_v2_texlive-zapfchan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-zapfchan-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-zapfchan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zapfchan}"
SRC_URI[x86_64_v2_texlive-zapfchan.sha256sum] = "39e9c67716cf02f55be38741291feebb6f0e036b76d840231d10f161d1abeb5f"

URI_x86_64_v2_texlive-zapfding = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-zapfding-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-zapfding;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zapfding}"
SRC_URI[x86_64_v2_texlive-zapfding.sha256sum] = "d1d79735f8422338106cc53d1870c4de908c6d55fdbf4d5f9506d20e7d2569c4"

URI_x86_64_v2_texlive-zref = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/texlive-zref-20240311-6.el10.alma.1.noarch.rpm;name=x86_64_v2_texlive-zref;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_texlive-zref}"
SRC_URI[x86_64_v2_texlive-zref.sha256sum] = "12892da208bb91ced96443a2eed840a5c8f5dfad2ee24e6faa4e64447e2c6327"

URI_aarch64_texlive = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive}"
SRC_URI[aarch64_texlive.sha256sum] = "58db358602db71329b5a31d65bd304260d1dcd66f57cbc208251407ab27ae745"

URI_aarch64_texlive-acronym = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-acronym-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-acronym;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-acronym}"
SRC_URI[aarch64_texlive-acronym.sha256sum] = "80384fa1f2d7bdfcd6852338d08ad68c054362a4f2b1c7e8d37005d3ea53c3a1"

URI_aarch64_texlive-adjustbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-adjustbox-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-adjustbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-adjustbox}"
SRC_URI[aarch64_texlive-adjustbox.sha256sum] = "c09b968f9dd02437a34f774ed6e8ea134c7e9af928e100e471f141955c126d9f"

URI_aarch64_texlive-ae = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ae-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ae;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ae}"
SRC_URI[aarch64_texlive-ae.sha256sum] = "0fb257653f1d6898c62f1929190af40c0068640eefc4f7c7e92ac4a2b48773f6"

URI_aarch64_texlive-algorithms = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-algorithms-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-algorithms;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-algorithms}"
SRC_URI[aarch64_texlive-algorithms.sha256sum] = "5f76937e2aec9cdb7507c15b30edfb181f41fb39b7224c11e0d9872a7e3cb379"

URI_aarch64_texlive-alphalph = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-alphalph-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-alphalph;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-alphalph}"
SRC_URI[aarch64_texlive-alphalph.sha256sum] = "573b93d9032e6580a4862a21001f05addccf91fa70e5dbf0bd0b10c9a8745eaf"

URI_aarch64_texlive-amscls = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-amscls-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-amscls;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-amscls}"
SRC_URI[aarch64_texlive-amscls.sha256sum] = "6a73433e635f068fe038c7f52a0ca5644312c514c5fc82b1410614cbb6dfb1a0"

URI_aarch64_texlive-amsfonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-amsfonts-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-amsfonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-amsfonts}"
SRC_URI[aarch64_texlive-amsfonts.sha256sum] = "f107712e65d0d874157dd5fc51b89efe7850173926ff7debc908c4f62de3cac8"

URI_aarch64_texlive-amsmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-amsmath-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-amsmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-amsmath}"
SRC_URI[aarch64_texlive-amsmath.sha256sum] = "17a2219a95182aa7507cdad5d1740dc0d39182a1af07a74a16f27034bbad00d9"

URI_aarch64_texlive-anyfontsize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-anyfontsize-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-anyfontsize;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-anyfontsize}"
SRC_URI[aarch64_texlive-anyfontsize.sha256sum] = "381c13e8c59ee286de95db119fb4a695eda324ef3a785d94a564a9763647480f"

URI_aarch64_texlive-anysize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-anysize-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-anysize;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-anysize}"
SRC_URI[aarch64_texlive-anysize.sha256sum] = "2ca1d2a41d4c6137cb5083a6e6b6d531c5b04a9c09f52063d8d5a6d23f69d538"

URI_aarch64_texlive-appendix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-appendix-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-appendix;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-appendix}"
SRC_URI[aarch64_texlive-appendix.sha256sum] = "f375389870a91b3a22df20b51664961db638db3cbab6264eeded8d10934bd077"

URI_aarch64_texlive-arphic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-arphic-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-arphic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-arphic}"
SRC_URI[aarch64_texlive-arphic.sha256sum] = "11d02081cde3e4b0ed0622059a55946aa86916e697ae15564e435c686e15d0e8"

URI_aarch64_texlive-atbegshi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-atbegshi-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-atbegshi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-atbegshi}"
SRC_URI[aarch64_texlive-atbegshi.sha256sum] = "295d86b25bfa1e5f95412c206b5aee476f01ddcf9b279e684f3e73e3178d7de2"

URI_aarch64_texlive-attachfile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-attachfile-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-attachfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-attachfile}"
SRC_URI[aarch64_texlive-attachfile.sha256sum] = "080259fa58dace76b0092833c318eb796627caa1165bbb6539ae285abcf2b172"

URI_aarch64_texlive-attachfile2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-attachfile2-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-attachfile2;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-attachfile2}"
SRC_URI[aarch64_texlive-attachfile2.sha256sum] = "676ad3b7bac5ff7f9196d220398f701a49f77cf0450afdba78fd0d94d536a571"

URI_aarch64_texlive-atveryend = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-atveryend-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-atveryend;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-atveryend}"
SRC_URI[aarch64_texlive-atveryend.sha256sum] = "2eca624c348f5721e0b1e5865b048de9372b71d48d564f98ac4b41d05059042b"

URI_aarch64_texlive-auxhook = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-auxhook-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-auxhook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-auxhook}"
SRC_URI[aarch64_texlive-auxhook.sha256sum] = "b72c4c7de62a90983b656c2e7de2d7ee102b580235970ddc4bc79beb40b5704e"

URI_aarch64_texlive-avantgar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-avantgar-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-avantgar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-avantgar}"
SRC_URI[aarch64_texlive-avantgar.sha256sum] = "a19df22647aca95f88007b08f826a22c1c965b2f6f74c945af6e9ec461487680"

URI_aarch64_texlive-awesomebox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-awesomebox-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-awesomebox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-awesomebox}"
SRC_URI[aarch64_texlive-awesomebox.sha256sum] = "c4584aee759c5558273ce0d79244e0dbde853348935dcfbddf18f3a169b12f91"

URI_aarch64_texlive-babel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-babel-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-babel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel}"
SRC_URI[aarch64_texlive-babel.sha256sum] = "1dcc02dc4e984ef44ad7c5a9b1e0d4d38a70078f8cd957c84cfdc21dcc605fe7"

URI_aarch64_texlive-babel-english = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-babel-english-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-babel-english;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babel-english}"
SRC_URI[aarch64_texlive-babel-english.sha256sum] = "d9326890402a3c878c67cd6ce2f254d7b93d7429d214f9f0723e40bd0815fd73"

URI_aarch64_texlive-babelbib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-babelbib-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-babelbib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-babelbib}"
SRC_URI[aarch64_texlive-babelbib.sha256sum] = "54c2db77beb2b3a8c7279771e721ce9b5b49f49aac5d58a2b3a0a68644e45aee"

URI_aarch64_texlive-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-base-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-base}"
SRC_URI[aarch64_texlive-base.sha256sum] = "f30f92141d89fd3f1e4151f7e547ad6123df18f21e7737a453a06ba90826ed8c"

URI_aarch64_texlive-beamer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-beamer-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-beamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-beamer}"
SRC_URI[aarch64_texlive-beamer.sha256sum] = "eeba85d2946f2dd18aed02b741c87b187f2a733f40ed43b97edc46878b0baef1"

URI_aarch64_texlive-bera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bera-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-bera;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bera}"
SRC_URI[aarch64_texlive-bera.sha256sum] = "637e2ff791a2454dec51c6b3a2f942011477e66e0763ff906a912a8883854879"

URI_aarch64_texlive-beton = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-beton-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-beton;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-beton}"
SRC_URI[aarch64_texlive-beton.sha256sum] = "56e05d1de31dcda54bb1c744618e1e54cf39bd47f0b691a22b624dbc4f5c1612"

URI_aarch64_texlive-bibtex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bibtex-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-bibtex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bibtex}"
SRC_URI[aarch64_texlive-bibtex.sha256sum] = "f4105a426a88bd598c8447e08b5253849b3156bc5329ca61968edb9faf6f5d1f"

URI_aarch64_texlive-bibtopic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bibtopic-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-bibtopic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bibtopic}"
SRC_URI[aarch64_texlive-bibtopic.sha256sum] = "8d0d6a1d3d4dc7c1f8f2beebac2fb2aeb6fe6f9a0db3757e7332f184330d34a3"

URI_aarch64_texlive-bidi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bidi-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-bidi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bidi}"
SRC_URI[aarch64_texlive-bidi.sha256sum] = "224b77c121c697427a7d612ca5182e37af42b0b35fc3878b0a1dd1f76be3479e"

URI_aarch64_texlive-bigfoot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bigfoot-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-bigfoot;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bigfoot}"
SRC_URI[aarch64_texlive-bigfoot.sha256sum] = "13ebf6960a6f75dcafbb17d12513b5637f0ae02c61d135d2e6923356704f9314"

URI_aarch64_texlive-bigintcalc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bigintcalc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-bigintcalc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bigintcalc}"
SRC_URI[aarch64_texlive-bigintcalc.sha256sum] = "0bcfc2c881f5244642e20f31e9ffc8e6a90813a67066321a829542a9985090ba"

URI_aarch64_texlive-bitset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bitset-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-bitset;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bitset}"
SRC_URI[aarch64_texlive-bitset.sha256sum] = "7f06d43a6a9bf0a6743e2ee306f1cb47e2fbf41e068558940e31b76841bab028"

URI_aarch64_texlive-bookman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bookman-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-bookman;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bookman}"
SRC_URI[aarch64_texlive-bookman.sha256sum] = "f9a4bf36c66a10af3f37b65daaf33754d252422a9728ca11b3f933fc98dc5109"

URI_aarch64_texlive-bookmark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-bookmark-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-bookmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-bookmark}"
SRC_URI[aarch64_texlive-bookmark.sha256sum] = "c8c4dc21be42820ebbcc200ce2ac84e18179770ed662f072da82e8caf9f7f843"

URI_aarch64_texlive-booktabs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-booktabs-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-booktabs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-booktabs}"
SRC_URI[aarch64_texlive-booktabs.sha256sum] = "418c9be694074f0e04c5092bf41aee762f245bad3a3cfd81b7f7cefc114c2a6f"

URI_aarch64_texlive-breakurl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-breakurl-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-breakurl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-breakurl}"
SRC_URI[aarch64_texlive-breakurl.sha256sum] = "3c988e45436192d600d95b0a9e95340a3fc49442c247563a169b1b1c0ecb33f9"

URI_aarch64_texlive-breqn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-breqn-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-breqn;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-breqn}"
SRC_URI[aarch64_texlive-breqn.sha256sum] = "d00c452fb7580fbd82b3772555c0b77fe3d4e48fa5467ed8c932c5171dcff8f2"

URI_aarch64_texlive-capt-of = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-capt-of-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-capt-of;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-capt-of}"
SRC_URI[aarch64_texlive-capt-of.sha256sum] = "62e95360f73e03c47ad3ae7d9c6fbce0252ff366e6e1960bf01d4c6428868b2c"

URI_aarch64_texlive-caption = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-caption-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-caption;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-caption}"
SRC_URI[aarch64_texlive-caption.sha256sum] = "40cc219930f99223116aa4617ed66adea917a763443a19cb837aca2465fb3020"

URI_aarch64_texlive-carlisle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-carlisle-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-carlisle;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-carlisle}"
SRC_URI[aarch64_texlive-carlisle.sha256sum] = "959d0d66160e6168bb19e686a2afa16cdba7c3e0867ee1afeac66373f66f70dd"

URI_aarch64_texlive-catchfile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-catchfile-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-catchfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-catchfile}"
SRC_URI[aarch64_texlive-catchfile.sha256sum] = "4b3c5c55d12082d5478f5634da483bb306223f4a01680c6598909fc30c6e84d4"

URI_aarch64_texlive-changebar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-changebar-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-changebar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-changebar}"
SRC_URI[aarch64_texlive-changebar.sha256sum] = "0ca4815d28c5b989d9c1b8ac1cf1886c88bfc046265dd866f468ecfc4713d5de"

URI_aarch64_texlive-changepage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-changepage-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-changepage;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-changepage}"
SRC_URI[aarch64_texlive-changepage.sha256sum] = "f4c6ea88a24837d3782cfdedcf1eecaceb7b4c7a8822d75b345e976952b9da7e"

URI_aarch64_texlive-charter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-charter-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-charter;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-charter}"
SRC_URI[aarch64_texlive-charter.sha256sum] = "6394a86a98403238affec0041f71a678b28dd421031856160901e5692a401629"

URI_aarch64_texlive-chngcntr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-chngcntr-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-chngcntr;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-chngcntr}"
SRC_URI[aarch64_texlive-chngcntr.sha256sum] = "31a94a228c39165845d067f533563ebd2db4da05ec6b0678aafee198945e2451"

URI_aarch64_texlive-cite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cite-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-cite;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cite}"
SRC_URI[aarch64_texlive-cite.sha256sum] = "b73557625108444c13d74bbf737b5fb5abd565da9cf4b5698c7e22a3a9e20ad8"

URI_aarch64_texlive-classpack = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-classpack-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-classpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-classpack}"
SRC_URI[aarch64_texlive-classpack.sha256sum] = "51ca8bfe2a9e3314a1bf36ec91aae11a9c22045aa8fa06efbdb19f72726e57a7"

URI_aarch64_texlive-cm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cm-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-cm;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cm}"
SRC_URI[aarch64_texlive-cm.sha256sum] = "ae49f8db4e695a6a7d80493ba6c59172b3074c870a7707ef04bfbcfe34cfce2b"

URI_aarch64_texlive-cm-lgc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cm-lgc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-cm-lgc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cm-lgc}"
SRC_URI[aarch64_texlive-cm-lgc.sha256sum] = "b87d86d71b9a9344e2bcd0d513427a2f5013a951ac7d8e67f9e1d065c1372c59"

URI_aarch64_texlive-cm-super = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cm-super-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-cm-super;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cm-super}"
SRC_URI[aarch64_texlive-cm-super.sha256sum] = "76e64407c06fa64af32e6fbc6ac75f1755ed037eba20aa94b9ebaf28c45ff1b7"

URI_aarch64_texlive-cmap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cmap-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-cmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cmap}"
SRC_URI[aarch64_texlive-cmap.sha256sum] = "6c2ef512b04a3362483cc106eac8496d674ec4af66bad72cdb6549ee81610bb6"

URI_aarch64_texlive-cmextra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cmextra-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-cmextra;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cmextra}"
SRC_URI[aarch64_texlive-cmextra.sha256sum] = "c401dd194f10ac87536ed4ad5d4df74afd6d85ebc9c16291bc65fd751f7f01d1"

URI_aarch64_texlive-cns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-cns-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-cns;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-cns}"
SRC_URI[aarch64_texlive-cns.sha256sum] = "2eb9a8438901bc5e1a63a953316241274960ffc009bf89de4442da0f82a7b71c"

URI_aarch64_texlive-collectbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collectbox-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-collectbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collectbox}"
SRC_URI[aarch64_texlive-collectbox.sha256sum] = "c242eaf525b3cb3b052e8ef5ed0c720f0b8e70fd189a089514c8144720e8d8c6"

URI_aarch64_texlive-collection-basic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-basic-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-collection-basic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-basic}"
SRC_URI[aarch64_texlive-collection-basic.sha256sum] = "f7b794fe0ef684eacc79233c8020636c3cff4ba5d8da629cd005aecad77bf68c"

URI_aarch64_texlive-collection-fontsrecommended = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-fontsrecommended-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-collection-fontsrecommended;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-fontsrecommended}"
SRC_URI[aarch64_texlive-collection-fontsrecommended.sha256sum] = "3add18de434f20d376fd6a40bd4bd9d9da4d9d799b9915c15a8abf7e125cedbd"

URI_aarch64_texlive-collection-htmlxml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-htmlxml-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-collection-htmlxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-htmlxml}"
SRC_URI[aarch64_texlive-collection-htmlxml.sha256sum] = "464ad91a3670ed1cbae454515311b1f30297a3db205f54705185ae9bbf45f64f"

URI_aarch64_texlive-collection-latex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-latex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-collection-latex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-latex}"
SRC_URI[aarch64_texlive-collection-latex.sha256sum] = "dc69f2e5672cb81527261433883b599c742d496c7071fd905644451a0513ff00"

URI_aarch64_texlive-collection-latexrecommended = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-latexrecommended-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-collection-latexrecommended;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-latexrecommended}"
SRC_URI[aarch64_texlive-collection-latexrecommended.sha256sum] = "6930bb95cc8de7b139cd1ba4b697a714506c08d015b7ed096fae97691253d63b"
RPROVIDES:texlive-collection-latexrecommended:aarch64 = "virtual/texlive-latex"

URI_aarch64_texlive-collection-xetex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-collection-xetex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-collection-xetex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-collection-xetex}"
SRC_URI[aarch64_texlive-collection-xetex.sha256sum] = "110697017a3459301a4fb12912af10bed839f4f131ffcfec31d184b1d1b8d6ae"

URI_aarch64_texlive-colorprofiles = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-colorprofiles-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-colorprofiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-colorprofiles}"
SRC_URI[aarch64_texlive-colorprofiles.sha256sum] = "746d6e79468a06f281edb374034b308b11f90866faa29ff002902d99e9b6e25f"

URI_aarch64_texlive-colortbl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-colortbl-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-colortbl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-colortbl}"
SRC_URI[aarch64_texlive-colortbl.sha256sum] = "2f566676c3e4b2efc1790365130a0b62b4fbb376d3d27d8b1c7e94a63eac5918"

URI_aarch64_texlive-context = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-context-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-context;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-context}"
SRC_URI[aarch64_texlive-context.sha256sum] = "56f78fb17e73d38a3f80920e9a459ed0e2e353ca4f6b3b66f3b29c5ab41d147e"

URI_aarch64_texlive-count1to = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-count1to-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-count1to;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-count1to}"
SRC_URI[aarch64_texlive-count1to.sha256sum] = "ac90587180e366b7ad6e83d7ecb295cf5b036840bb7eb06fe0edf337920fec07"

URI_aarch64_texlive-courier = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-courier-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-courier;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-courier}"
SRC_URI[aarch64_texlive-courier.sha256sum] = "bb5a61c3b3bda61e260abefaa387abadc04701381783f9d2edb169d1c1c6665f"

URI_aarch64_texlive-crop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-crop-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-crop;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-crop}"
SRC_URI[aarch64_texlive-crop.sha256sum] = "18bede7196d41e4bdf4b432592a5a513a94722a4f03b7ea0a0510239f3a331f6"

URI_aarch64_texlive-csquotes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-csquotes-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-csquotes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-csquotes}"
SRC_URI[aarch64_texlive-csquotes.sha256sum] = "7ce14f7931974b92af2e5345c64845ecc9f4e24ba1693219de990e4fcb29c8ba"

URI_aarch64_texlive-ctable = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ctable-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ctable;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctable}"
SRC_URI[aarch64_texlive-ctable.sha256sum] = "45d2cbfd38c2eec8d564c3804fc538bb72f397e3cf1cb8d4093d0014de695ea6"

URI_aarch64_texlive-ctablestack = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ctablestack-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ctablestack;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ctablestack}"
SRC_URI[aarch64_texlive-ctablestack.sha256sum] = "26bec7a1ac7920b5a01d1ee7727b6ad1ca7df0399b9c137c4e1d6ff48be044f6"

URI_aarch64_texlive-currfile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-currfile-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-currfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-currfile}"
SRC_URI[aarch64_texlive-currfile.sha256sum] = "acbc23e0e445025166bf9e43f8f2fda47e2acb9e28513019a57072f9879db676"

URI_aarch64_texlive-datetime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-datetime-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-datetime;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-datetime}"
SRC_URI[aarch64_texlive-datetime.sha256sum] = "e1e309bcd8f3510cbdc3102b2ff342603aa69ecdc94db8c64038499a882737b9"

URI_aarch64_texlive-dehyph = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dehyph-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-dehyph;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dehyph}"
SRC_URI[aarch64_texlive-dehyph.sha256sum] = "403f6dd37ca093acbe1c27173a382fac646be4a4c121f41de1cad03f4cc7aae1"

URI_aarch64_texlive-dvipdfmx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dvipdfmx-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-dvipdfmx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dvipdfmx}"
SRC_URI[aarch64_texlive-dvipdfmx.sha256sum] = "95999993d5d9fad9a5515ab168b112daff516c8c7e521d921d50abd4e01a1995"

URI_aarch64_texlive-dvipng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dvipng-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-dvipng;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dvipng}"
SRC_URI[aarch64_texlive-dvipng.sha256sum] = "a6fca178a88294d9048168392a3fb16d2cc98772a1ae216fc125f2d72945655a"

URI_aarch64_texlive-dvips = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dvips-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-dvips;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dvips}"
SRC_URI[aarch64_texlive-dvips.sha256sum] = "b31595f34ed435c2580905952066ed27859a4649267477728f30ed34df97f529"

URI_aarch64_texlive-dvisvgm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-dvisvgm-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-dvisvgm;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-dvisvgm}"
SRC_URI[aarch64_texlive-dvisvgm.sha256sum] = "72f65829b6363be52735e8513efe857630d81be267c48c5b6625679b1883bbf9"

URI_aarch64_texlive-ec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ec-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ec;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ec}"
SRC_URI[aarch64_texlive-ec.sha256sum] = "48ac3abc9c5450c15b8b1e0de9497b9a00d27d1b6685f5db4667183a1b969db3"

URI_aarch64_texlive-eepic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-eepic-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-eepic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-eepic}"
SRC_URI[aarch64_texlive-eepic.sha256sum] = "d5e3a165eb897d0bb04c072acf8ad4b1bf52629431ec71a765db410de986fd21"

URI_aarch64_texlive-enctex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-enctex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-enctex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-enctex}"
SRC_URI[aarch64_texlive-enctex.sha256sum] = "b02a1bfad6c86befc855166562d9a3abd68d15177cea4435d04502c5f9528d06"

URI_aarch64_texlive-enumitem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-enumitem-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-enumitem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-enumitem}"
SRC_URI[aarch64_texlive-enumitem.sha256sum] = "2e5967cdffbc9912713d859c193cecd125544ee9a48453ea82ae50eae45534bb"

URI_aarch64_texlive-environ = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-environ-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-environ;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-environ}"
SRC_URI[aarch64_texlive-environ.sha256sum] = "19c2781efa855af00ef9c765a149f7d35a08aba6b93caa77733ba94939b329fc"

URI_aarch64_texlive-epsf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-epsf-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-epsf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-epsf}"
SRC_URI[aarch64_texlive-epsf.sha256sum] = "7fc3387d069cf6ba7cf14a9ab1a2d320361fac81c3e9ff89cd990c64a8136c02"

URI_aarch64_texlive-epstopdf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-epstopdf-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-epstopdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-epstopdf}"
SRC_URI[aarch64_texlive-epstopdf.sha256sum] = "f0683f2637e6d4fd717bef50780908026df1e0de85cd72f77ebc1eaa535ac9d6"

URI_aarch64_texlive-epstopdf-pkg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-epstopdf-pkg-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-epstopdf-pkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-epstopdf-pkg}"
SRC_URI[aarch64_texlive-epstopdf-pkg.sha256sum] = "ec7784f996193554258a228eec8b5450d03d657ba86f22f9c7a38510079f1810"

URI_aarch64_texlive-eqparbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-eqparbox-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-eqparbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-eqparbox}"
SRC_URI[aarch64_texlive-eqparbox.sha256sum] = "4011bc6cf3cf2809396e3f6bc5d71f8cf524bf91ca5dd4ba7871eb067352c093"

URI_aarch64_texlive-eso-pic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-eso-pic-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-eso-pic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-eso-pic}"
SRC_URI[aarch64_texlive-eso-pic.sha256sum] = "3db7a50dda6f558da4c38a9a87d0a55d07ffb1b60932b87b7c6a2a4078aacc3d"

URI_aarch64_texlive-etex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-etex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etex}"
SRC_URI[aarch64_texlive-etex.sha256sum] = "014b1d983e4bd39ce7a68727d2b204e2d88967feb5e0c60ef555b234099708b8"

URI_aarch64_texlive-etex-pkg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etex-pkg-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-etex-pkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etex-pkg}"
SRC_URI[aarch64_texlive-etex-pkg.sha256sum] = "bd34dc7dc0c6ab1c722c375b1db2bd898efd1d7e8c0e2d20d8edb539f29a7e0a"

URI_aarch64_texlive-etexcmds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etexcmds-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-etexcmds;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etexcmds}"
SRC_URI[aarch64_texlive-etexcmds.sha256sum] = "47e104e48120e1f09051b53535598948386743d88489ace87474f3b653c5ae12"

URI_aarch64_texlive-etoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etoc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-etoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etoc}"
SRC_URI[aarch64_texlive-etoc.sha256sum] = "61121845a5bb93eab230f944d9ccbe47f6861a192693647d4ccef6f22441c01d"

URI_aarch64_texlive-etoolbox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-etoolbox-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-etoolbox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-etoolbox}"
SRC_URI[aarch64_texlive-etoolbox.sha256sum] = "39a9ce6182c981cb2e82cea6732f837c9209226deff45ae05594cc0cc8b074be"

URI_aarch64_texlive-euenc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-euenc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-euenc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-euenc}"
SRC_URI[aarch64_texlive-euenc.sha256sum] = "d148dc37ba667695e25e24155633df9d8bf2081b35959ad03d25cd72f43b0779"

URI_aarch64_texlive-euler = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-euler-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-euler;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-euler}"
SRC_URI[aarch64_texlive-euler.sha256sum] = "0201c692753b163541a99c5d0acf4e786305b8c096fb809b9ab31b1b0ec04636"

URI_aarch64_texlive-euro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-euro-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-euro;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-euro}"
SRC_URI[aarch64_texlive-euro.sha256sum] = "07e9108f56c4005cd9094ca674c9e2577812eb09e734563936f24923ff194e9b"

URI_aarch64_texlive-eurosym = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-eurosym-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-eurosym;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-eurosym}"
SRC_URI[aarch64_texlive-eurosym.sha256sum] = "2a1fc9c0701a153ace2fe7c6e2d670afa6e5345ef5b91e9bb2b9b26db38adf07"

URI_aarch64_texlive-everysel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-everysel-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-everysel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-everysel}"
SRC_URI[aarch64_texlive-everysel.sha256sum] = "61c62b6c5ed0d5dfda8d4882e4a10e785e786a5e8bb4622dfd3eb2f70e73c0ad"

URI_aarch64_texlive-everyshi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-everyshi-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-everyshi;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-everyshi}"
SRC_URI[aarch64_texlive-everyshi.sha256sum] = "2a9786006c369c36d607e1af84b20f9660e236da63af50d08d2f629fc952f82b"

URI_aarch64_texlive-extsizes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-extsizes-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-extsizes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-extsizes}"
SRC_URI[aarch64_texlive-extsizes.sha256sum] = "e79240055ee15e9a2caeaac5d34c7d8586234c4d982860ff558bc69f4d3b18e7"

URI_aarch64_texlive-fancybox = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fancybox-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fancybox;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fancybox}"
SRC_URI[aarch64_texlive-fancybox.sha256sum] = "c6069fc0aecbbd84ca16cc82cb77276e2d304c522282c8d7ef2062d47bf8f1d0"

URI_aarch64_texlive-fancyhdr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fancyhdr-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fancyhdr;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fancyhdr}"
SRC_URI[aarch64_texlive-fancyhdr.sha256sum] = "b0f7c77fc844716845af8251c936532cf28014e892abd1c8f116723f1ca99fa7"

URI_aarch64_texlive-fancyref = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fancyref-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fancyref;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fancyref}"
SRC_URI[aarch64_texlive-fancyref.sha256sum] = "569aa8a0cec469248af09667521c459134d1da507afb84b305c794a4ed7179cd"

URI_aarch64_texlive-fancyvrb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fancyvrb-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fancyvrb;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fancyvrb}"
SRC_URI[aarch64_texlive-fancyvrb.sha256sum] = "7d19c675b3cbdeab8170a0394073e38c61b601c426d93b1bfdd0a31158738c3a"

URI_aarch64_texlive-filecontents = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-filecontents-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-filecontents;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-filecontents}"
SRC_URI[aarch64_texlive-filecontents.sha256sum] = "2948f80cea5f02cf43db56041dfb8f8afc4b69fb8f86e559060745ddfdc24efe"

URI_aarch64_texlive-filehook = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-filehook-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-filehook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-filehook}"
SRC_URI[aarch64_texlive-filehook.sha256sum] = "50dc59da4a488e658f4fe3d8391b98fc2783ac70d6e23f99746b602dcb264766"

URI_aarch64_texlive-finstrut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-finstrut-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-finstrut;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-finstrut}"
SRC_URI[aarch64_texlive-finstrut.sha256sum] = "c350133983f8cd563b9c442cd7d32a3f6c0e179e459167b234084ab2258c4348"

URI_aarch64_texlive-firstaid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-firstaid-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-firstaid;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-firstaid}"
SRC_URI[aarch64_texlive-firstaid.sha256sum] = "0fdcb66b075c624f6e9d9db272615749d9256d758b9573db72592f4513275373"

URI_aarch64_texlive-fix2col = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fix2col-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fix2col;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fix2col}"
SRC_URI[aarch64_texlive-fix2col.sha256sum] = "393bcfd7f164afde626ec7d911ec2a630190b6157756758f3a7a4e876a8d5655"

URI_aarch64_texlive-fixlatvian = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fixlatvian-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fixlatvian;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fixlatvian}"
SRC_URI[aarch64_texlive-fixlatvian.sha256sum] = "135b71abbc41b7f524ebe61bde08f4ee5c8e2cfd6813a0e74d04aa3206b4edfa"

URI_aarch64_texlive-float = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-float-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-float;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-float}"
SRC_URI[aarch64_texlive-float.sha256sum] = "f402162aa2a442ea203d4be65def559dfb00685ea0bcdc13241fe9b68116b6fd"

URI_aarch64_texlive-fmtcount = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fmtcount-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fmtcount;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fmtcount}"
SRC_URI[aarch64_texlive-fmtcount.sha256sum] = "77844632d37d6fc29d414d6c547727632b055f165287754b0b24f1983d92251a"

URI_aarch64_texlive-fncychap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fncychap-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fncychap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fncychap}"
SRC_URI[aarch64_texlive-fncychap.sha256sum] = "c9f32eb74c0257cf90f8ca93686ee91166432292b8ad6b67f6415a758d1e3a66"

URI_aarch64_texlive-fontawesome = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontawesome-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fontawesome;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontawesome}"
SRC_URI[aarch64_texlive-fontawesome.sha256sum] = "e03f881fa6dc91cda715bffe6cdaf3891fd551acca2e5f539dd6f091feea7e29"

URI_aarch64_texlive-fontbook = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontbook-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fontbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontbook}"
SRC_URI[aarch64_texlive-fontbook.sha256sum] = "1863d5298e25dc1a802dfd51923e83f375e919afbe66df911788f60bcb3dc61a"

URI_aarch64_texlive-fonts-tlwg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fonts-tlwg-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fonts-tlwg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fonts-tlwg}"
SRC_URI[aarch64_texlive-fonts-tlwg.sha256sum] = "05f2b8083ba82e9977f8d5a870be4f4dbef115ddffddbff64b654a0b425e4da9"

URI_aarch64_texlive-fontspec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontspec-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fontspec;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontspec}"
SRC_URI[aarch64_texlive-fontspec.sha256sum] = "cffbbacae4ae0f75bcc8b504e5e4e58e09515afafe476ae0eff1b0bc92218e9f"

URI_aarch64_texlive-fontware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontware-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-fontware;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontware}"
SRC_URI[aarch64_texlive-fontware.sha256sum] = "c54d9fd8ec3d8268b2766522f5860acc560222f90cb7bff806206f95cb3396f6"

URI_aarch64_texlive-fontwrap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fontwrap-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fontwrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fontwrap}"
SRC_URI[aarch64_texlive-fontwrap.sha256sum] = "0086949aed1024998faa0172cbc2731d7f470d79a09524ff1748f0952d638605"

URI_aarch64_texlive-footmisc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-footmisc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-footmisc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-footmisc}"
SRC_URI[aarch64_texlive-footmisc.sha256sum] = "ee14f50683fc41462b05b6a6a2f27e4c2226ad0d2d2c170714eaa8a47f6e11b6"

URI_aarch64_texlive-footnotehyper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-footnotehyper-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-footnotehyper;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-footnotehyper}"
SRC_URI[aarch64_texlive-footnotehyper.sha256sum] = "7a927d53a7c02f69ff59b937f4cd64ba8e7d8afb7e4d7cc266bdcd6d3ecf30fe"

URI_aarch64_texlive-fp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fp-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fp;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fp}"
SRC_URI[aarch64_texlive-fp.sha256sum] = "84e34a32773e66354a3ab4f8bb1bc4d7020622af2e62098dc1a6aa4ca4107de2"

URI_aarch64_texlive-fpl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-fpl-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-fpl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-fpl}"
SRC_URI[aarch64_texlive-fpl.sha256sum] = "e7238cd1394edf7340233f2ffa87087e4e03672c3c98fa393dac090cd56f94d3"

URI_aarch64_texlive-framed = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-framed-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-framed;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-framed}"
SRC_URI[aarch64_texlive-framed.sha256sum] = "b658553d759319888e9dda915535e52f679b4370f4b5863fd53925cc36f0d92f"

URI_aarch64_texlive-garuda-c90 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-garuda-c90-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-garuda-c90;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-garuda-c90}"
SRC_URI[aarch64_texlive-garuda-c90.sha256sum] = "56a724141ff9c4df2be59599737acf15dc38865ba0e1f8c20b1b4243039130e8"

URI_aarch64_texlive-geometry = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-geometry-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-geometry;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-geometry}"
SRC_URI[aarch64_texlive-geometry.sha256sum] = "2768e7de33a65a85831672c02dd30a1957fc907b97a094ae93aa8022ead9d88f"

URI_aarch64_texlive-gettitlestring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-gettitlestring-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-gettitlestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gettitlestring}"
SRC_URI[aarch64_texlive-gettitlestring.sha256sum] = "f6ff748bfeb73d8de7f779ccab9c30e79aa4f1bdd6711abeef142d8d7bec2ecb"

URI_aarch64_texlive-glyphlist = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-glyphlist-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-glyphlist;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-glyphlist}"
SRC_URI[aarch64_texlive-glyphlist.sha256sum] = "e212f021a29a3ab52a275f5ecf2544d2abd9881a8172bcb0013ec1667d9bdd48"

URI_aarch64_texlive-gnu-freefont = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/texlive-gnu-freefont-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-gnu-freefont;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gnu-freefont}"
SRC_URI[aarch64_texlive-gnu-freefont.sha256sum] = "c296e6088139fa10aaf3ae8f0c93857cb0ebb2836f15a90ab2264c190616c938"

URI_aarch64_texlive-graphics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-graphics-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-graphics;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-graphics}"
SRC_URI[aarch64_texlive-graphics.sha256sum] = "01faaea46589ef98503bf28bbffc1d494b3583fabdd621955deeff7a44cda524"

URI_aarch64_texlive-graphics-cfg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-graphics-cfg-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-graphics-cfg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-graphics-cfg}"
SRC_URI[aarch64_texlive-graphics-cfg.sha256sum] = "64c0bd4c2c34dc6320cfb05dd7142eafe8ce486e4969200b7a2f5f764ee59a34"

URI_aarch64_texlive-graphics-def = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-graphics-def-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-graphics-def;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-graphics-def}"
SRC_URI[aarch64_texlive-graphics-def.sha256sum] = "a32f33d499e66e3253fecea682accfc20e85e3f6765530e240dd9ccb0a6de98f"

URI_aarch64_texlive-grfext = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-grfext-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-grfext;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-grfext}"
SRC_URI[aarch64_texlive-grfext.sha256sum] = "e5f603f7c0ad6871edd1fa5d14ea649a2ab54603556cbe3d466346b684925f7e"

URI_aarch64_texlive-grffile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-grffile-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-grffile;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-grffile}"
SRC_URI[aarch64_texlive-grffile.sha256sum] = "7a55cc789709a475f28213d85d2e02f4bab8969dcb8cee2618a3973f909804f3"

URI_aarch64_texlive-gsftopk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-gsftopk-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-gsftopk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-gsftopk}"
SRC_URI[aarch64_texlive-gsftopk.sha256sum] = "d603de404f6886c6a00302187fb4e5e05b813df6b387f2669ce820a0e401d96a"

URI_aarch64_texlive-hanging = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hanging-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hanging;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hanging}"
SRC_URI[aarch64_texlive-hanging.sha256sum] = "a594aad0f2c1914918251969b83c39af74e558d5f4e73cf9e055ad340a58ccf5"

URI_aarch64_texlive-helvetic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-helvetic-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-helvetic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-helvetic}"
SRC_URI[aarch64_texlive-helvetic.sha256sum] = "87cd8d4c47303cc331e11d6c720ea7aaa5cc12409784fa1a2d394a4339b389a5"

URI_aarch64_texlive-hobsub = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hobsub-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hobsub;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hobsub}"
SRC_URI[aarch64_texlive-hobsub.sha256sum] = "40289846013334eff7bb5f349284a80291aa73c4e051924bf2052be8762bdf09"

URI_aarch64_texlive-hologo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hologo-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hologo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hologo}"
SRC_URI[aarch64_texlive-hologo.sha256sum] = "e0092f4756bf3dd780997a1cb920bd1c28e17cd1a53862f92a0c754690404ebc"

URI_aarch64_texlive-hopatch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hopatch-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hopatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hopatch}"
SRC_URI[aarch64_texlive-hopatch.sha256sum] = "20a4586b8a54083397c38016c3fff8f77dd151bb9bd89d66fcc2340f6f5cfa52"

URI_aarch64_texlive-hycolor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hycolor-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hycolor;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hycolor}"
SRC_URI[aarch64_texlive-hycolor.sha256sum] = "79ed570c4b50f5041833e2cdf76d77e2dcc1c93397d08f126ce9b521781e54f5"

URI_aarch64_texlive-hypcap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hypcap-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hypcap;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hypcap}"
SRC_URI[aarch64_texlive-hypcap.sha256sum] = "e73f2655c8eaa42d168c656f03887cd75ab8b1b35ec6c29b0d4b983abddaad26"

URI_aarch64_texlive-hypdoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hypdoc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hypdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hypdoc}"
SRC_URI[aarch64_texlive-hypdoc.sha256sum] = "05eb7c042e90994b8954fbfe65542e6750dcc463250ace80a34eccd618055367"

URI_aarch64_texlive-hyperref = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyperref-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hyperref;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyperref}"
SRC_URI[aarch64_texlive-hyperref.sha256sum] = "0891e994f73b69beca1271ad32f3b8e2b643767912d1a318404e55f0d988d007"

URI_aarch64_texlive-hyph-utf8 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyph-utf8-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hyph-utf8;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyph-utf8}"
SRC_URI[aarch64_texlive-hyph-utf8.sha256sum] = "bfe5bc6b04f7efe86304f570db5d5b469262f38a10a510d4eaaadca9404338a3"

URI_aarch64_texlive-hyphen-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyphen-base-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hyphen-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphen-base}"
SRC_URI[aarch64_texlive-hyphen-base.sha256sum] = "b1a976656d19ab7106bbd0f6cf7cfa884ec9e037bf82b8d6b5039fe894c19b59"

URI_aarch64_texlive-hyphenat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyphenat-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hyphenat;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphenat}"
SRC_URI[aarch64_texlive-hyphenat.sha256sum] = "82cf85f17d8c3ef681fdbbec71a04d237fce1a2388c7c70f9085b4bb89a47154"

URI_aarch64_texlive-hyphenex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-hyphenex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-hyphenex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-hyphenex}"
SRC_URI[aarch64_texlive-hyphenex.sha256sum] = "49ea954cc7947840498c9930a3fbbeddadc449f549d100ef435e7d0ede500ce1"

URI_aarch64_texlive-ifmtarg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ifmtarg-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ifmtarg;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ifmtarg}"
SRC_URI[aarch64_texlive-ifmtarg.sha256sum] = "7859a6849ab01becec00bf43be6e6e55beed3448088434a06bc0c6667651d9cd"

URI_aarch64_texlive-ifoddpage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ifoddpage-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ifoddpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ifoddpage}"
SRC_URI[aarch64_texlive-ifoddpage.sha256sum] = "8df5bc691d3b764cba406d3171ebe55f402059183dd566ff00c7b3483c5946c2"

URI_aarch64_texlive-ifplatform = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ifplatform-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ifplatform;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ifplatform}"
SRC_URI[aarch64_texlive-ifplatform.sha256sum] = "3236800a65a081cca0df47bac6f266bb7bad73ba29f690442e3b5d2f0bbe9040"

URI_aarch64_texlive-iftex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-iftex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-iftex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-iftex}"
SRC_URI[aarch64_texlive-iftex.sha256sum] = "113e73cd99da13331f58d85641afa6563cab2824dc7c3336083bc39fb6537821"

URI_aarch64_texlive-import = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-import-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-import;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-import}"
SRC_URI[aarch64_texlive-import.sha256sum] = "cca9ed88d3f7c44ff9d956d3390962219e0874750c9d024b7418c8e9aa27b8a0"

URI_aarch64_texlive-index = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-index-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-index}"
SRC_URI[aarch64_texlive-index.sha256sum] = "c439e4aebfba5682408baeca0f5a92a966f2136e8b1699a74b699c79f784dd9a"

URI_aarch64_texlive-infwarerr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-infwarerr-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-infwarerr;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-infwarerr}"
SRC_URI[aarch64_texlive-infwarerr.sha256sum] = "fba458b303a6a43ddeb80da45ce1feb69aa6788907c83c98c801620f4475a9de"

URI_aarch64_texlive-intcalc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-intcalc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-intcalc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-intcalc}"
SRC_URI[aarch64_texlive-intcalc.sha256sum] = "ef6520a190e4061250975b90c360d280ada0a2349dd92edc9d18cbafdeb940e6"

URI_aarch64_texlive-jadetex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-jadetex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-jadetex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-jadetex}"
SRC_URI[aarch64_texlive-jadetex.sha256sum] = "6ed140f416faf992726f339bb42da18f9983fd0a48d1b5a7677fc5e9def22dc1"

URI_aarch64_texlive-jknapltx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-jknapltx-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-jknapltx;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-jknapltx}"
SRC_URI[aarch64_texlive-jknapltx.sha256sum] = "8526833d8344fa4b8e4244b4cf6445791a30c287809081e4609df0c06472a72c"

URI_aarch64_texlive-kastrup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kastrup-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-kastrup;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kastrup}"
SRC_URI[aarch64_texlive-kastrup.sha256sum] = "f3109bc708c4d0a25f3f472e7287d43b81ef16baff7e8b0ec61fd58d42ccd593"

URI_aarch64_texlive-kerkis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kerkis-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-kerkis;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kerkis}"
SRC_URI[aarch64_texlive-kerkis.sha256sum] = "8ae85530dbb1e35869277fd4c9b8b8d835ea158a9d91f14f80c4184899ea9033"

URI_aarch64_texlive-knuth-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-knuth-lib-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-knuth-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-knuth-lib}"
SRC_URI[aarch64_texlive-knuth-lib.sha256sum] = "d04bc812dc39655db8a301483a58a254a7f31a3f30de411937291a2679090682"

URI_aarch64_texlive-knuth-local = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-knuth-local-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-knuth-local;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-knuth-local}"
SRC_URI[aarch64_texlive-knuth-local.sha256sum] = "296134cc7ec32374b65ce8c92595754c7fe0085603fa16e53885b170971cae26"

URI_aarch64_texlive-koma-script = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-koma-script-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-koma-script;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-koma-script}"
SRC_URI[aarch64_texlive-koma-script.sha256sum] = "5bbb3b43ba18de53d44081ef46f06a91c4645ef01ebbc6a2d52f85fe939e6522"

URI_aarch64_texlive-kpathsea = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kpathsea-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-kpathsea;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kpathsea}"
SRC_URI[aarch64_texlive-kpathsea.sha256sum] = "98260096fb4863a5ed11c56866bdaf23cace035a38fa0f6b1a237199ceb0890c"

URI_aarch64_texlive-kvdefinekeys = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kvdefinekeys-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-kvdefinekeys;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kvdefinekeys}"
SRC_URI[aarch64_texlive-kvdefinekeys.sha256sum] = "4a455b5e9aefb328c5b6525c642f48b6bea31e8b82708c2306d3d14e0a2b3ef4"

URI_aarch64_texlive-kvoptions = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kvoptions-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-kvoptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kvoptions}"
SRC_URI[aarch64_texlive-kvoptions.sha256sum] = "77d437a37ea29a33ac360cb2f1417b03c495db05f92ed0e23a8eec6dd466235e"

URI_aarch64_texlive-kvsetkeys = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-kvsetkeys-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-kvsetkeys;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-kvsetkeys}"
SRC_URI[aarch64_texlive-kvsetkeys.sha256sum] = "d2b0dafa7d530d748923ad9c18be15b759ce25b2e11fa5ddb794b9d1c9fb68ba"

URI_aarch64_texlive-l3backend = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-l3backend-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-l3backend;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-l3backend}"
SRC_URI[aarch64_texlive-l3backend.sha256sum] = "e3a97e0241e90fe3228344d82c04fdbfa008ffe0335917cdc1059d106eef6b2e"

URI_aarch64_texlive-l3experimental = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-l3experimental-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-l3experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-l3experimental}"
SRC_URI[aarch64_texlive-l3experimental.sha256sum] = "c1784848004a561b79aed23993f6178240e2328827783bb2dc9af6cf5d29f774"

URI_aarch64_texlive-l3kernel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-l3kernel-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-l3kernel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-l3kernel}"
SRC_URI[aarch64_texlive-l3kernel.sha256sum] = "3f50c482d0919eb03d3717be656211c3fc74fa649f23edafe5ec1f766041d7c8"

URI_aarch64_texlive-l3packages = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-l3packages-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-l3packages;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-l3packages}"
SRC_URI[aarch64_texlive-l3packages.sha256sum] = "7455fdbe2b063bbfded616cf37d01e551b00d6cb94c681f806d64768c561af09"

URI_aarch64_texlive-lastpage = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lastpage-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lastpage;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lastpage}"
SRC_URI[aarch64_texlive-lastpage.sha256sum] = "67ecf5884734c7231bbcb13bd949c8cb7f8ee48627bc17b287f9c499c7e0a95c"

URI_aarch64_texlive-latex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-latex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex}"
SRC_URI[aarch64_texlive-latex.sha256sum] = "196828451e412f49361c0d45becdaf7c24c6daecbdba08a2ddf62657596c7e3c"
RPROVIDES:texlive-latex:aarch64 = "virtual/tex_alltt.sty_ virtual/tex_article.cls_ virtual/tex_doc.sty_ virtual/tex_exscale.sty_ virtual/tex_fix-cm.sty_ virtual/tex_fixltx2e.sty_ virtual/tex_flafter.sty_ virtual/tex_fontenc.sty_ virtual/tex_ifthen.sty_ virtual/tex_inputenc.sty_ virtual/tex_latexsym.sty_ virtual/tex_makeidx.sty_ virtual/tex_oldlfont.sty_ virtual/tex_shortvrb.sty_ virtual/tex_t1cmr.fd_ virtual/tex_textcomp.sty_ virtual/texlive-latex"

URI_aarch64_texlive-latex-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latex-fonts-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-latex-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex-fonts}"
SRC_URI[aarch64_texlive-latex-fonts.sha256sum] = "842e3474fdd0712ff119471bf4021632e2138c9ef8c2f682c9aaafe55b67f672"

URI_aarch64_texlive-latex2man = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latex2man-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-latex2man;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latex2man}"
SRC_URI[aarch64_texlive-latex2man.sha256sum] = "a93b36bd4e050624ce36e7d72f346582e5fbf7bcfb80de791467248d1d8a9ae0"

URI_aarch64_texlive-latexbug = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latexbug-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-latexbug;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latexbug}"
SRC_URI[aarch64_texlive-latexbug.sha256sum] = "0c33e76c7f143207b91f005736a7add709c5de3b2f803701892459fac4ae035a"

URI_aarch64_texlive-latexconfig = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-latexconfig-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-latexconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-latexconfig}"
SRC_URI[aarch64_texlive-latexconfig.sha256sum] = "9e736904162a3c6308d12735315c448036d4b42a4ac2cf6720244c1572eee353"

URI_aarch64_texlive-letltxmacro = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-letltxmacro-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-letltxmacro;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-letltxmacro}"
SRC_URI[aarch64_texlive-letltxmacro.sha256sum] = "60edd39a2c3360d43c563f38262cc71e3946fa94df52e69d3eb83706736435a9"

URI_aarch64_texlive-lettrine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lettrine-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lettrine;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lettrine}"
SRC_URI[aarch64_texlive-lettrine.sha256sum] = "90f0a7973f5d279605449d6c99dd4bb22a848d14310905c2fe2889d8b1ffd78b"

URI_aarch64_texlive-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lib-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lib}"
SRC_URI[aarch64_texlive-lib.sha256sum] = "05cdbbb0b53424c5f6b4c352aacb1f204120274444b0c9c766cc8e228e084c0d"

URI_aarch64_texlive-lib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/texlive-lib-devel-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-lib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lib-devel}"
SRC_URI[aarch64_texlive-lib-devel.sha256sum] = "56d23a8ae07e11fa35abb7a62bf32541b7014dc8aa2aaf0400caaf72deaedafe"

URI_aarch64_texlive-linegoal = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-linegoal-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-linegoal;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-linegoal}"
SRC_URI[aarch64_texlive-linegoal.sha256sum] = "3cd16f6ed480459ad397f90694d33ef44ba86294f24f5e9246e3d9a3af7ef800"

URI_aarch64_texlive-lineno = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lineno-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lineno;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lineno}"
SRC_URI[aarch64_texlive-lineno.sha256sum] = "2530af73b80c534944a3ced8f15d66327846c6e8900fb5a56b6b810dc1789a97"

URI_aarch64_texlive-listings = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-listings-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-listings;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-listings}"
SRC_URI[aarch64_texlive-listings.sha256sum] = "82bf3cab6361cd60cc203d3597ed47f0dc7d419400371349508c3d004bce04b2"

URI_aarch64_texlive-listofitems = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-listofitems-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-listofitems;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-listofitems}"
SRC_URI[aarch64_texlive-listofitems.sha256sum] = "76e3a64236c2c36014198b078450077dd09d13f8ae8c83bef4175fb42112466b"

URI_aarch64_texlive-lm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lm-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lm;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lm}"
SRC_URI[aarch64_texlive-lm.sha256sum] = "023a9f5cae2326a5f5766af0be9136c62710fb6e5ea400d8633eac4ab367f2a3"

URI_aarch64_texlive-lm-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lm-math-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lm-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lm-math}"
SRC_URI[aarch64_texlive-lm-math.sha256sum] = "ccdfea596e47a14ed61288e3cbd77eb1e2cc6b7a6a25814608ef0e72dded91de"

URI_aarch64_texlive-ltabptch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ltabptch-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ltabptch;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ltabptch}"
SRC_URI[aarch64_texlive-ltabptch.sha256sum] = "b84a81a204db471532282f3a0e8177c642b8376e32c378d4dc31aa8eaa1c37bb"

URI_aarch64_texlive-ltxcmds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ltxcmds-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ltxcmds;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ltxcmds}"
SRC_URI[aarch64_texlive-ltxcmds.sha256sum] = "d9f231abfcfa07b45de491655d684528259821242715b8c902800e688dee0e92"

URI_aarch64_texlive-ltxmisc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ltxmisc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ltxmisc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ltxmisc}"
SRC_URI[aarch64_texlive-ltxmisc.sha256sum] = "64bb1d4ab0b04b75138543c229894b8d71b3f6961827766f7c250e2541f2cfcc"

URI_aarch64_texlive-lua-alt-getopt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lua-alt-getopt-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lua-alt-getopt;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lua-alt-getopt}"
SRC_URI[aarch64_texlive-lua-alt-getopt.sha256sum] = "fd3c063f7febf3ba5f0dd6ef40eb73ffb0fde2648911fe49f4ef6530695b737d"

URI_aarch64_texlive-lua-uni-algos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lua-uni-algos-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lua-uni-algos;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lua-uni-algos}"
SRC_URI[aarch64_texlive-lua-uni-algos.sha256sum] = "569d07855b42dc5ede6eee97290c5e400a13d318cccb3f0cd4c95cada8319a3f"

URI_aarch64_texlive-luahbtex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luahbtex-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-luahbtex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luahbtex}"
SRC_URI[aarch64_texlive-luahbtex.sha256sum] = "7a36916807492d53ac6f8a353aa8621ac6d1a923d223a114fa5b11c3bcd55ab5"

URI_aarch64_texlive-lualatex-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lualatex-math-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lualatex-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lualatex-math}"
SRC_URI[aarch64_texlive-lualatex-math.sha256sum] = "d3130cd75a23497a0f3ffe201aa65917abc0955bc1ea558ea27c548acb0c6b4a"

URI_aarch64_texlive-lualibs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lualibs-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lualibs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lualibs}"
SRC_URI[aarch64_texlive-lualibs.sha256sum] = "60f187d1e2f17ddac08e36b152e4773e3cb30403430bfdddbfbbb6f0607db913"

URI_aarch64_texlive-luaotfload = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luaotfload-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-luaotfload;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luaotfload}"
SRC_URI[aarch64_texlive-luaotfload.sha256sum] = "b5395e55e600822395fecfdf2e78fce6ff3d723ec72d9328360634fd297c07eb"

URI_aarch64_texlive-luatex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luatex-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-luatex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatex}"
SRC_URI[aarch64_texlive-luatex.sha256sum] = "b9c284adbc164f28e30d33ce6f6579dd8cdb21cb9a47632050c15217f3bae3a8"

URI_aarch64_texlive-luatex85 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luatex85-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-luatex85;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatex85}"
SRC_URI[aarch64_texlive-luatex85.sha256sum] = "e3945ad747d36d07b4acb3059f689e3c54254d987796df61db5bf2954a93fb15"

URI_aarch64_texlive-luatexbase = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-luatexbase-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-luatexbase;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-luatexbase}"
SRC_URI[aarch64_texlive-luatexbase.sha256sum] = "e25f399a5ceb45521d6a3c0ff26fac61d431cd145abfbfd6052677754e00261d"

URI_aarch64_texlive-lwarp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-lwarp-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-lwarp;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-lwarp}"
SRC_URI[aarch64_texlive-lwarp.sha256sum] = "baf0871a050235fa4e68564a0e3789edcdefa151f722ab07f11a4bd8475e3d81"

URI_aarch64_texlive-makecmds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-makecmds-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-makecmds;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-makecmds}"
SRC_URI[aarch64_texlive-makecmds.sha256sum] = "c2cdb39afcb413e6b2bf124244f2996eb37131796b62e9d246cc1cd1b064b10e"

URI_aarch64_texlive-makeindex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-makeindex-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-makeindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-makeindex}"
SRC_URI[aarch64_texlive-makeindex.sha256sum] = "7d510575778f5aabda2e27e025403c97578bc63f640b456b5b693b771d20d10c"

URI_aarch64_texlive-manfnt-font = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-manfnt-font-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-manfnt-font;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-manfnt-font}"
SRC_URI[aarch64_texlive-manfnt-font.sha256sum] = "f3d39aa21674853bf5f7137728357072f5b471329067146594a33808d00e752b"

URI_aarch64_texlive-marginnote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-marginnote-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-marginnote;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-marginnote}"
SRC_URI[aarch64_texlive-marginnote.sha256sum] = "da03c01579f019f5ca28a51793f15c00fe171b3d744fa10340d395b0b22fef46"

URI_aarch64_texlive-marvosym = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-marvosym-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-marvosym;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-marvosym}"
SRC_URI[aarch64_texlive-marvosym.sha256sum] = "4c636a9ba8c9a29b824ac7d7e7f3ab339e0fa6909a69ea7fbb844d882b9ac88e"

URI_aarch64_texlive-mathpazo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mathpazo-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mathpazo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mathpazo}"
SRC_URI[aarch64_texlive-mathpazo.sha256sum] = "4b6bfaee1cd48101850a23c8f8a24e7b4659446fcd58a0059d3125e163568ca9"

URI_aarch64_texlive-mathspec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mathspec-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mathspec;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mathspec}"
SRC_URI[aarch64_texlive-mathspec.sha256sum] = "cc6ffcd6f90b8cb18578baaf33a27f90e5b9ccef1567ef881275ec43cfbef163"

URI_aarch64_texlive-mathtools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mathtools-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mathtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mathtools}"
SRC_URI[aarch64_texlive-mathtools.sha256sum] = "a11610473afc8599c5bdb6b06a69a3701c9b290c8f1367794d1c28edcc5607cf"

URI_aarch64_texlive-mdwtools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mdwtools-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mdwtools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mdwtools}"
SRC_URI[aarch64_texlive-mdwtools.sha256sum] = "14f3decbf84afac279c2b306246595ab15c7853f0d3b5d2610980a78ca5ff13d"

URI_aarch64_texlive-memoir = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-memoir-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-memoir;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-memoir}"
SRC_URI[aarch64_texlive-memoir.sha256sum] = "fed013c39b371e4067bd2e6a5db23d234bf54a4bd2117c025acd00426b5236ac"

URI_aarch64_texlive-metafont = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-metafont-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-metafont;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-metafont}"
SRC_URI[aarch64_texlive-metafont.sha256sum] = "ffeb42945702a9f0ab1530d47c175c6389d3a8a0eddfd6c5117c9887005b17b1"

URI_aarch64_texlive-metalogo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-metalogo-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-metalogo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-metalogo}"
SRC_URI[aarch64_texlive-metalogo.sha256sum] = "7dea5ffa7ef54f30db2b9ac940eec33bb9a484c967634ea4f0b5ccea924ea78c"

URI_aarch64_texlive-metapost = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-metapost-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-metapost;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-metapost}"
SRC_URI[aarch64_texlive-metapost.sha256sum] = "b3e00ddc4a59aea14c9ba166f93edf175d695e3bc311af4da55834d6d820c653"

URI_aarch64_texlive-mflogo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mflogo-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mflogo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mflogo}"
SRC_URI[aarch64_texlive-mflogo.sha256sum] = "1fb2ed54edb6e36f1fa39781279f0da42a882f997eb4ed62866d2ce190606d33"

URI_aarch64_texlive-mflogo-font = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mflogo-font-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mflogo-font;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mflogo-font}"
SRC_URI[aarch64_texlive-mflogo-font.sha256sum] = "53a93e050229d495559f753d92b4820f51ab5009add8b7a35d69672244958a7f"

URI_aarch64_texlive-mfnfss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mfnfss-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mfnfss;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mfnfss}"
SRC_URI[aarch64_texlive-mfnfss.sha256sum] = "5fb8665b1d3c4ba968e279b6cac3c7af056743f9c8bb7f7cbd2045bbaf09c33d"

URI_aarch64_texlive-mfware = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mfware-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-mfware;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mfware}"
SRC_URI[aarch64_texlive-mfware.sha256sum] = "bac6f6f8d11f89baf6173e86bb7d3cad810703871eb6b9f86cc89b8f4b325513"

URI_aarch64_texlive-microtype = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-microtype-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-microtype;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-microtype}"
SRC_URI[aarch64_texlive-microtype.sha256sum] = "4d6f2a835327b3b1161fda23ed3309889a8716bed2fa40dcdbd869bc48432886"

URI_aarch64_texlive-minitoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-minitoc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-minitoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-minitoc}"
SRC_URI[aarch64_texlive-minitoc.sha256sum] = "c138a00447dfd3bcf1b0f10177f25e54e7ac98f1cb764ec4915d45d5378ce748"

URI_aarch64_texlive-mnsymbol = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mnsymbol-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mnsymbol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mnsymbol}"
SRC_URI[aarch64_texlive-mnsymbol.sha256sum] = "57d0cef8c5bca9439577578a1be3aab23c57d72b49c3b7ac6e1921ada078e920"

URI_aarch64_texlive-modes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-modes-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-modes;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-modes}"
SRC_URI[aarch64_texlive-modes.sha256sum] = "509e15cab7a15eb00eb97de059ce0efde17b1e568b59ae594ced5f931f5d4305"

URI_aarch64_texlive-mparhack = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mparhack-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mparhack;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mparhack}"
SRC_URI[aarch64_texlive-mparhack.sha256sum] = "c9e7dcc0b149c84e899d259235951baa832a9543ce55a2107d44cf897c147ca8"

URI_aarch64_texlive-mptopdf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-mptopdf-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-mptopdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-mptopdf}"
SRC_URI[aarch64_texlive-mptopdf.sha256sum] = "d8e6d477015a80c3432399d6c1190004757b15deefe86975df55c373bf58df2d"

URI_aarch64_texlive-multido = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-multido-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-multido;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-multido}"
SRC_URI[aarch64_texlive-multido.sha256sum] = "a5f914229f58455b5eb022bc69c5e7c9ff035b1fe0c76b38e9ad31d10b1e8152"

URI_aarch64_texlive-multirow = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-multirow-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-multirow;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-multirow}"
SRC_URI[aarch64_texlive-multirow.sha256sum] = "faabdd2c319163d313d3c35d0c4369b73fb8a931115fe107620a97c91d3f0e81"

URI_aarch64_texlive-multitoc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-multitoc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-multitoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-multitoc}"
SRC_URI[aarch64_texlive-multitoc.sha256sum] = "f88d2165077365c9597afef9fb2ef5983d120584da5cee3308153049db20aead"

URI_aarch64_texlive-natbib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-natbib-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-natbib;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-natbib}"
SRC_URI[aarch64_texlive-natbib.sha256sum] = "df68f4754790ea88ff34c04b4cf940074757e2bf55a79890524d0fe88b771285"

URI_aarch64_texlive-ncctools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ncctools-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ncctools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ncctools}"
SRC_URI[aarch64_texlive-ncctools.sha256sum] = "a0144d5465e59269d4213fa41984d667bf6c4e2decc5f0a19c7975769e719ae1"

URI_aarch64_texlive-ncntrsbk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ncntrsbk-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ncntrsbk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ncntrsbk}"
SRC_URI[aarch64_texlive-ncntrsbk.sha256sum] = "98e5ce251689971bbedccd6e38c22b87a1a425351e09f0c4db23761b6baf66f6"

URI_aarch64_texlive-needspace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-needspace-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-needspace;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-needspace}"
SRC_URI[aarch64_texlive-needspace.sha256sum] = "95f67dcd9e9285fb0f2b47ba66c8b8fc9d02a4ad2b7845bf005f33aa40ec7482"

URI_aarch64_texlive-newfloat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-newfloat-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-newfloat;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-newfloat}"
SRC_URI[aarch64_texlive-newfloat.sha256sum] = "4b23ead941616c108a5d8ff851402da9e5c146f1be078d828901018bf2dbeeb5"

URI_aarch64_texlive-newunicodechar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-newunicodechar-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-newunicodechar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-newunicodechar}"
SRC_URI[aarch64_texlive-newunicodechar.sha256sum] = "40714f7743e8eb2ac2fd1961bc96b57743a1a3834a02ae8fe517337c005242a3"

URI_aarch64_texlive-norasi-c90 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-norasi-c90-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-norasi-c90;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-norasi-c90}"
SRC_URI[aarch64_texlive-norasi-c90.sha256sum] = "86c72c7569742eb3fff6aca4bcbb9ee01fa79422e67395327a7e6ff6e03bf81c"

URI_aarch64_texlive-notoccite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-notoccite-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-notoccite;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-notoccite}"
SRC_URI[aarch64_texlive-notoccite.sha256sum] = "61362aa5e3efc87ec91722ddbed4d99a829915365c9a2fbb4df5d50b3c55e52b"

URI_aarch64_texlive-ntgclass = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ntgclass-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ntgclass;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ntgclass}"
SRC_URI[aarch64_texlive-ntgclass.sha256sum] = "0826c5024a9b8f5cef4b4a5b4d1aa3ea6598e177931102e485078ac11525f275"

URI_aarch64_texlive-oberdiek = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-oberdiek-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-oberdiek;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-oberdiek}"
SRC_URI[aarch64_texlive-oberdiek.sha256sum] = "d511a560f8dd5b60fb72048f677d557afe10fb446de6d737dc7b5c862af3d817"

URI_aarch64_texlive-overpic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-overpic-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-overpic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-overpic}"
SRC_URI[aarch64_texlive-overpic.sha256sum] = "c512c13fee7cda1cd881a8f0ec29ef2733fc9e0c5505c4a2d103dd12c6540510"

URI_aarch64_texlive-palatino = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-palatino-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-palatino;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-palatino}"
SRC_URI[aarch64_texlive-palatino.sha256sum] = "f4b8ca87abb259554ed271b38264b7031849cfc9e24934b6eb4f15f49787cee2"

URI_aarch64_texlive-paralist = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-paralist-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-paralist;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-paralist}"
SRC_URI[aarch64_texlive-paralist.sha256sum] = "be73ac86606b59e9d77b84ac93ab56b6560fc988b9430fbcfd0704a157b567b6"

URI_aarch64_texlive-parallel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-parallel-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-parallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-parallel}"
SRC_URI[aarch64_texlive-parallel.sha256sum] = "f5706b9210820ceda6fdfde1b5dc908d0c8b0013ae191381ada6b016217d44ed"

URI_aarch64_texlive-parskip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-parskip-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-parskip;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-parskip}"
SRC_URI[aarch64_texlive-parskip.sha256sum] = "6756638e39d4e02e9aa75116e01ed140b3949d087cafd27e888de8cf61a6f8af"

URI_aarch64_texlive-passivetex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-passivetex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-passivetex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-passivetex}"
SRC_URI[aarch64_texlive-passivetex.sha256sum] = "afc08ca31c45c6bda18f035c088bb2f1a22daec161c81d6f6526f3ec4f7860f4"

URI_aarch64_texlive-pdfcol = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfcol-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pdfcol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfcol}"
SRC_URI[aarch64_texlive-pdfcol.sha256sum] = "0580c7e6100ab0b96b951a693f706c08a280f3ca57e174e43581a0c4a02880a1"

URI_aarch64_texlive-pdfcolfoot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfcolfoot-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pdfcolfoot;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfcolfoot}"
SRC_URI[aarch64_texlive-pdfcolfoot.sha256sum] = "e6607942bc6512b24c33c1500be396e994b677af64d50b535ef7ea7acd22a9fc"

URI_aarch64_texlive-pdfcolmk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfcolmk-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pdfcolmk;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfcolmk}"
SRC_URI[aarch64_texlive-pdfcolmk.sha256sum] = "d25275c8fc860334d30f9df17d80f7c34e54318a414d659530aa2b4eafe90e29"

URI_aarch64_texlive-pdfescape = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfescape-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pdfescape;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfescape}"
SRC_URI[aarch64_texlive-pdfescape.sha256sum] = "8bf0b43b6ed76ac738eaefad44ffb676d428737a6af8540c0fc76827a348e1dc"

URI_aarch64_texlive-pdflscape = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdflscape-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pdflscape;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdflscape}"
SRC_URI[aarch64_texlive-pdflscape.sha256sum] = "b91d80458e001cb127796eb301a27de89476b47c5425d93f5ac7f98f6a89f0c9"

URI_aarch64_texlive-pdfmanagement-testphase = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfmanagement-testphase-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pdfmanagement-testphase;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfmanagement-testphase}"
SRC_URI[aarch64_texlive-pdfmanagement-testphase.sha256sum] = "5f1a873db40a1e5b153ac5ac940e5dbfdc1fe686fe806363e5edb2d03cc9ae4f"

URI_aarch64_texlive-pdfpages = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdfpages-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pdfpages;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdfpages}"
SRC_URI[aarch64_texlive-pdfpages.sha256sum] = "171fe1bfa60028045e71296fa3521123179bd29dd63bcbc63e2616501021c535"

URI_aarch64_texlive-pdftex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdftex-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-pdftex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdftex}"
SRC_URI[aarch64_texlive-pdftex.sha256sum] = "d7de4ef393aca5941407759e2b5d231977e1e38bc1508690806b2788881ecac4"

URI_aarch64_texlive-pdftexcmds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pdftexcmds-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pdftexcmds;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pdftexcmds}"
SRC_URI[aarch64_texlive-pdftexcmds.sha256sum] = "a6f8dcf5df94d43704c7cac84a86a4ee2c9d671ca2704e2772403531a05d5d75"

URI_aarch64_texlive-pgf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pgf-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pgf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pgf}"
SRC_URI[aarch64_texlive-pgf.sha256sum] = "b227f428c2eecf8b752135c82cc544caa1ef3d22a57d818275060115f8e6f465"

URI_aarch64_texlive-philokalia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-philokalia-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-philokalia;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-philokalia}"
SRC_URI[aarch64_texlive-philokalia.sha256sum] = "456bfebaf2d04a34bfd63619f0724ce68f02c7f504d19e4fee91ba33ec907e8e"

URI_aarch64_texlive-placeins = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-placeins-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-placeins;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-placeins}"
SRC_URI[aarch64_texlive-placeins.sha256sum] = "69531c2675747c1588cd7595243e7dbb3fce44350563ffacf9cb155e342ad1a1"

URI_aarch64_texlive-plain = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-plain-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-plain;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-plain}"
SRC_URI[aarch64_texlive-plain.sha256sum] = "f00f64e08bdcaedbf1b8392cd9746b43abceefab46e4b39a0e46b3085d7092b7"

URI_aarch64_texlive-polyglossia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-polyglossia-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-polyglossia;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-polyglossia}"
SRC_URI[aarch64_texlive-polyglossia.sha256sum] = "1e9806957af9cf5acc91e06b190a9185c36237d473ca368267c29526b02da75e"

URI_aarch64_texlive-powerdot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-powerdot-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-powerdot;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-powerdot}"
SRC_URI[aarch64_texlive-powerdot.sha256sum] = "61ae74cc6c3a64e7eba43fd51c8df3432603f3b0a5d4c92bb5d9ddc1c5352e30"

URI_aarch64_texlive-preprint = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-preprint-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-preprint;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-preprint}"
SRC_URI[aarch64_texlive-preprint.sha256sum] = "fc3ffc879457deeafd7945317bf5b2dba5cac8f31880f93888503ac4a100392b"

URI_aarch64_texlive-psfrag = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-psfrag-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-psfrag;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-psfrag}"
SRC_URI[aarch64_texlive-psfrag.sha256sum] = "83dbb1550912ce54b38a0e31ec0666f274017dfec09710ab77a35ee2141674c6"

URI_aarch64_texlive-pslatex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pslatex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pslatex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pslatex}"
SRC_URI[aarch64_texlive-pslatex.sha256sum] = "94ecda67f4455d088d2d3ba1ec8f46ee1762b05fa38f46e930664e15f5af3e67"

URI_aarch64_texlive-psnfss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-psnfss-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-psnfss;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-psnfss}"
SRC_URI[aarch64_texlive-psnfss.sha256sum] = "774150b48c23671d24cdab00358ad6f5b4552cb09cbd770fec527c5ecbe9c7ac"

URI_aarch64_texlive-pspicture = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pspicture-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pspicture;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pspicture}"
SRC_URI[aarch64_texlive-pspicture.sha256sum] = "23d16f1de485b474272142381887488bcdec69a27ce6559ddf574520957638d0"

URI_aarch64_texlive-pst-3d = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-3d-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-3d}"
SRC_URI[aarch64_texlive-pst-3d.sha256sum] = "dd50b53754315a5be52339597d56a15e8cd9a90ed8ad04424f3ff48dc1c830c3"

URI_aarch64_texlive-pst-arrow = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-arrow-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-arrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-arrow}"
SRC_URI[aarch64_texlive-pst-arrow.sha256sum] = "dccf985f5b28ced63f4fb1ddafa7b2b19bf871c44e410a3c594967566165a654"

URI_aarch64_texlive-pst-blur = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-blur-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-blur;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-blur}"
SRC_URI[aarch64_texlive-pst-blur.sha256sum] = "1649bfcde134f05fb855b58992a3aa9b8b5355048368f958acc3f95c9db5aa8f"

URI_aarch64_texlive-pst-coil = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-coil-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-coil;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-coil}"
SRC_URI[aarch64_texlive-pst-coil.sha256sum] = "160d55dcc76c99c732cd194e83db59c32db0f0c9f39ba8202d615910cc97306a"

URI_aarch64_texlive-pst-eps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-eps-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-eps;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-eps}"
SRC_URI[aarch64_texlive-pst-eps.sha256sum] = "0855108c316ff7fa5d66260dfa7f00c03a2ff6f971ff848c7b85e078ca8a64ca"

URI_aarch64_texlive-pst-fill = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-fill-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-fill;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-fill}"
SRC_URI[aarch64_texlive-pst-fill.sha256sum] = "ea141f492835b41b76636052925fde98279c4633cf70826b627b44dad4e81e94"

URI_aarch64_texlive-pst-grad = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-grad-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-grad;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-grad}"
SRC_URI[aarch64_texlive-pst-grad.sha256sum] = "261920ae36ab7c07b9b214b020c92f4ed6871ae6a0d7c73ccfb53943a9100958"

URI_aarch64_texlive-pst-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-math-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-math}"
SRC_URI[aarch64_texlive-pst-math.sha256sum] = "860376c0b50b132e1576f0cfff4435bd6c08120295c7cb1cc2842f8b6da31d9b"

URI_aarch64_texlive-pst-node = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-node-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-node;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-node}"
SRC_URI[aarch64_texlive-pst-node.sha256sum] = "c9a19623b26c8b655f29bef7b6904e2c34dab00242c59aebf00d9aee4c7ab941"

URI_aarch64_texlive-pst-plot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-plot-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-plot;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-plot}"
SRC_URI[aarch64_texlive-pst-plot.sha256sum] = "d0a0681346c7158022df089537c9038df9efc358542c5f30efb9c1422a0b7796"

URI_aarch64_texlive-pst-slpe = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-slpe-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-slpe;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-slpe}"
SRC_URI[aarch64_texlive-pst-slpe.sha256sum] = "f782d9f4c2eeda9d738161bfb7d1aacb88a18c0c68f633e6f8080ed9dc8a8bf1"

URI_aarch64_texlive-pst-text = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-text-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-text}"
SRC_URI[aarch64_texlive-pst-text.sha256sum] = "4b98e891ced4484318da18015ee7fe4327ded6c0d2cd1ecc8ef4db5104fea17d"

URI_aarch64_texlive-pst-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-tools-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-tools}"
SRC_URI[aarch64_texlive-pst-tools.sha256sum] = "a79bfbbaf4cb3505e14cd1ea04d87dba9851e0af4deb867b04bb757823b81987"

URI_aarch64_texlive-pst-tree = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pst-tree-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pst-tree;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pst-tree}"
SRC_URI[aarch64_texlive-pst-tree.sha256sum] = "a38627eec2fc979e3ddec6cb38d5de761531ddd3f2ca47532846320890fe28bd"

URI_aarch64_texlive-pstricks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pstricks-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pstricks;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pstricks}"
SRC_URI[aarch64_texlive-pstricks.sha256sum] = "a5192cb0444c284c55a6c3ad05f64d3898677b674223d996221688edb19a1cf5"

URI_aarch64_texlive-pstricks-add = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pstricks-add-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pstricks-add;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pstricks-add}"
SRC_URI[aarch64_texlive-pstricks-add.sha256sum] = "505906b29966c344b4db19009a05314e9b0e4b979fad6e0a6f845fcd17c3dba6"

URI_aarch64_texlive-ptext = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ptext-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ptext;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ptext}"
SRC_URI[aarch64_texlive-ptext.sha256sum] = "af6008babccdb151bdf83a7ed5649f512311ee1a7bbf233254b7fc6fa730e656"

URI_aarch64_texlive-pxfonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-pxfonts-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-pxfonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-pxfonts}"
SRC_URI[aarch64_texlive-pxfonts.sha256sum] = "1b62c64c9389430615fa71dff7842f45b8354535f809eac5e3d1009ad9dec5b9"

URI_aarch64_texlive-qstest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-qstest-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-qstest;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-qstest}"
SRC_URI[aarch64_texlive-qstest.sha256sum] = "c337f3011c082476db693b7b83ee757a36844670eca9aee0937cfa9880826cb2"

URI_aarch64_texlive-ragged2e = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ragged2e-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ragged2e;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ragged2e}"
SRC_URI[aarch64_texlive-ragged2e.sha256sum] = "2afe059c35c98e2429208730a86d39e2f6d2d97abf3374565b86050014af401c"

URI_aarch64_texlive-rcs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-rcs-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-rcs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-rcs}"
SRC_URI[aarch64_texlive-rcs.sha256sum] = "76d44caf821a021bab2793ab7bf6f4aa7d4bdbf7ef37631199561a3087ddfd83"

URI_aarch64_texlive-realscripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-realscripts-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-realscripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-realscripts}"
SRC_URI[aarch64_texlive-realscripts.sha256sum] = "89fb3e07dd9ecaac236e688de2ad6eedd1df28d88cf24626058fff162da7b8e5"

URI_aarch64_texlive-refcount = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-refcount-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-refcount;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-refcount}"
SRC_URI[aarch64_texlive-refcount.sha256sum] = "39b1ce5ccaf357f1c8adfdda898132725c36268d306c970071786cd1f656d3ec"

URI_aarch64_texlive-relsize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-relsize-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-relsize;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-relsize}"
SRC_URI[aarch64_texlive-relsize.sha256sum] = "0bbd113cc6af0f1dd8fda27c9172e75a88367dd616eb8dc0159df3d9aaf83898"

URI_aarch64_texlive-rerunfilecheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-rerunfilecheck-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-rerunfilecheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-rerunfilecheck}"
SRC_URI[aarch64_texlive-rerunfilecheck.sha256sum] = "ca22e1afa887b4cee17d4ab7e22dda9bb66c6135395d3a3a26a31c77bc86a411"

URI_aarch64_texlive-rsfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-rsfs-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-rsfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-rsfs}"
SRC_URI[aarch64_texlive-rsfs.sha256sum] = "e444d0722c33054bdb2e642f7a8b4a7b10997b1ea24d4f7400140b5e385c131b"

URI_aarch64_texlive-sansmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sansmath-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-sansmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sansmath}"
SRC_URI[aarch64_texlive-sansmath.sha256sum] = "f9d6c9e97b4dcc74885c4aadb32b5f351d8301bb949e69b793c7ba93bd7de9ed"

URI_aarch64_texlive-sansmathaccent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sansmathaccent-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-sansmathaccent;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sansmathaccent}"
SRC_URI[aarch64_texlive-sansmathaccent.sha256sum] = "ca2c8813ed96754852e9267cf2fd6a8bd03f9dd3c252957fdda685c51c9f03a3"

URI_aarch64_texlive-sauerj = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sauerj-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-sauerj;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sauerj}"
SRC_URI[aarch64_texlive-sauerj.sha256sum] = "836dc81327dd7a738013b3fc55aa221325d1d06528824e8c2b376086cf6dc1e1"

URI_aarch64_texlive-scheme-basic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-scheme-basic-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-scheme-basic;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-scheme-basic}"
SRC_URI[aarch64_texlive-scheme-basic.sha256sum] = "412ce997c0fa6ea355244dbfce537124dfcdf64397aa67ebe91fa1cdb5902efb"

URI_aarch64_texlive-section = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-section-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-section;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-section}"
SRC_URI[aarch64_texlive-section.sha256sum] = "89d60c7cac2963c27c8cad7cdf41acebeb0812fc450c5624a7ab1e11b12b3620"

URI_aarch64_texlive-sectsty = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sectsty-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-sectsty;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sectsty}"
SRC_URI[aarch64_texlive-sectsty.sha256sum] = "0927866505567ac67056b47afa147235c73b969c1c7e53c75e282dffc6a59331"

URI_aarch64_texlive-seminar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-seminar-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-seminar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-seminar}"
SRC_URI[aarch64_texlive-seminar.sha256sum] = "ed511008b61327699838fb1ff250ee40905dff8fe340133b0aec2d1f70a811f9"

URI_aarch64_texlive-sepnum = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sepnum-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-sepnum;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sepnum}"
SRC_URI[aarch64_texlive-sepnum.sha256sum] = "6aa8424f84d6259e8e02117ba4d6f2b4018f412220a7efb180e7fd57638374cb"

URI_aarch64_texlive-setspace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-setspace-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-setspace;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-setspace}"
SRC_URI[aarch64_texlive-setspace.sha256sum] = "c8943e59dae645ee3a24801cbcd0cf39b97741bb13eed8663dbffc8de042a06b"

URI_aarch64_texlive-sfmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-sfmath-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-sfmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-sfmath}"
SRC_URI[aarch64_texlive-sfmath.sha256sum] = "9766925d393cc6d74cd881b4b9b30f69ccd1f1fe390833b67db45eca2ba5a672"

URI_aarch64_texlive-showexpl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-showexpl-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-showexpl;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-showexpl}"
SRC_URI[aarch64_texlive-showexpl.sha256sum] = "bd94f9486dbe3b83cf6dde756e2f5fcb7be5a8fb46eb978c6972f30845dc8202"

URI_aarch64_texlive-soul = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-soul-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-soul;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-soul}"
SRC_URI[aarch64_texlive-soul.sha256sum] = "a869c02eadb225c95e44aff00b3172b0099ea39120e6e29afddcb3c354b88d7f"

URI_aarch64_texlive-stackengine = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-stackengine-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-stackengine;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-stackengine}"
SRC_URI[aarch64_texlive-stackengine.sha256sum] = "375bf86b8674d0915730d10c1c5bc410867e92b14eb851f690055d3bd9314678"

URI_aarch64_texlive-stmaryrd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-stmaryrd-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-stmaryrd;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-stmaryrd}"
SRC_URI[aarch64_texlive-stmaryrd.sha256sum] = "eb82176321959fc3597743b2a7dfd3371ae2a940a931f879808061748f37fa9c"

URI_aarch64_texlive-stringenc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-stringenc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-stringenc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-stringenc}"
SRC_URI[aarch64_texlive-stringenc.sha256sum] = "98a6c3ae46121d583570ad59c35d9263638be13d0530ad3110040ac709709854"

URI_aarch64_texlive-subfig = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-subfig-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-subfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-subfig}"
SRC_URI[aarch64_texlive-subfig.sha256sum] = "671f0cd6109ca338aa10b4c2ea058918880eca8d025bc184e6c08e8b15760006"

URI_aarch64_texlive-subfigure = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-subfigure-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-subfigure;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-subfigure}"
SRC_URI[aarch64_texlive-subfigure.sha256sum] = "dd2de4a99680e26841acfa0bc0b152998605bf4aa4808e69425a212164674f09"

URI_aarch64_texlive-svn-prov = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-svn-prov-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-svn-prov;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-svn-prov}"
SRC_URI[aarch64_texlive-svn-prov.sha256sum] = "0c6294df9284aae1cfb0cca721908a6dfdb9db22cd979dacc8bcb6243f938638"

URI_aarch64_texlive-symbol = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-symbol-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-symbol;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-symbol}"
SRC_URI[aarch64_texlive-symbol.sha256sum] = "18a4627802dc56a7edffd46d34ee84320378819496ac2bfcdc1f7507eef6e098"

URI_aarch64_texlive-t2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-t2-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-t2;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-t2}"
SRC_URI[aarch64_texlive-t2.sha256sum] = "942e0ee5eb12513ef7044c377ba59de1f41a9b1c5aff6cd560ea2f36da0b4686"

URI_aarch64_texlive-tabu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tabu-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-tabu;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tabu}"
SRC_URI[aarch64_texlive-tabu.sha256sum] = "06a24c680d3ef9f6ea5b38e19a805ff84b8f2b60bb49294361df4a7b3723a59d"

URI_aarch64_texlive-tabulary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tabulary-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-tabulary;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tabulary}"
SRC_URI[aarch64_texlive-tabulary.sha256sum] = "535b085ea8059888b9410568fe2831a7c8df04f11357b62540cf62e84247b417"

URI_aarch64_texlive-tex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-tex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex}"
SRC_URI[aarch64_texlive-tex.sha256sum] = "6ebbeb365cc97c084f07f7ccbc4784b76d40e528b082ee14f953abb48d317f4d"

URI_aarch64_texlive-tex-gyre = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex-gyre-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-tex-gyre;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex-gyre}"
SRC_URI[aarch64_texlive-tex-gyre.sha256sum] = "4b901f9d3c29c8ac7bbdab1cb1e19199ba7de33597772d5d68920ce6c57586d8"

URI_aarch64_texlive-tex-gyre-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex-gyre-math-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-tex-gyre-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex-gyre-math}"
SRC_URI[aarch64_texlive-tex-gyre-math.sha256sum] = "f7114fd6745630cdedeb44c0d19eae5eb3e5d947db2d6db9588442feab95c7c6"

URI_aarch64_texlive-tex-ini-files = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex-ini-files-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-tex-ini-files;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex-ini-files}"
SRC_URI[aarch64_texlive-tex-ini-files.sha256sum] = "ed6202c343157a5aa4ce39431595bdb78c0da15eb0e689595e3d59a01a24535b"

URI_aarch64_texlive-tex4ht = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tex4ht-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-tex4ht;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tex4ht}"
SRC_URI[aarch64_texlive-tex4ht.sha256sum] = "f4a15638489a1d61e2eee8f12bcc7f17d1d4ac5ad93ffa670605d478fd0dfe15"

URI_aarch64_texlive-texlive-common-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-common-doc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-texlive-common-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-common-doc}"
SRC_URI[aarch64_texlive-texlive-common-doc.sha256sum] = "6bd273c534d2d64efc2b079917e15d822e51e09243b6b3ae60a5b5baf027dc3c"

URI_aarch64_texlive-texlive-en = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-en-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-texlive-en;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-en}"
SRC_URI[aarch64_texlive-texlive-en.sha256sum] = "a4d7fd2f62d25251b1515e0ffe649786f003fc0f2d96f5a2bec443096dbb28fd"

URI_aarch64_texlive-texlive-msg-translations = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-msg-translations-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-texlive-msg-translations;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-msg-translations}"
SRC_URI[aarch64_texlive-texlive-msg-translations.sha256sum] = "712ab1fe8d86d43e69eb7a01d32cddb4451fc1f18643dd03151d2bb413b681d9"

URI_aarch64_texlive-texlive-scripts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-scripts-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-texlive-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-scripts}"
SRC_URI[aarch64_texlive-texlive-scripts.sha256sum] = "f051f2b1f29295c4fa82c7b2da8529d1f7b5d9b660fee10b57e5f85926c380d1"

URI_aarch64_texlive-texlive-scripts-extra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive-scripts-extra-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-texlive-scripts-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive-scripts-extra}"
SRC_URI[aarch64_texlive-texlive-scripts-extra.sha256sum] = "e3fef5e6e2742926842338b2a34968a75453447dfdc281c2d9b8d54c5c6c3dd3"

URI_aarch64_texlive-texlive.infra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-texlive.infra-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-texlive.infra;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-texlive.infra}"
SRC_URI[aarch64_texlive-texlive.infra.sha256sum] = "f2a4c306825afb0f841c3dd3a157e83ed61308cfc9483fb9792dea0e76e63ac4"

URI_aarch64_texlive-textcase = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-textcase-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-textcase;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-textcase}"
SRC_URI[aarch64_texlive-textcase.sha256sum] = "bf138681c07d66c9e068fde9b435022499700e36348146a0f7d663b2d0e916d4"

URI_aarch64_texlive-textpos = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-textpos-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-textpos;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-textpos}"
SRC_URI[aarch64_texlive-textpos.sha256sum] = "b4e85085d3ef4f26933cfc424d58aa7f3cf599ce945340397c830e6bcfa3a2d8"

URI_aarch64_texlive-threeparttable = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-threeparttable-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-threeparttable;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-threeparttable}"
SRC_URI[aarch64_texlive-threeparttable.sha256sum] = "2b433e53fc781b04d7633650d0eb64217ffe6e01f473a1e210fc4174c5381d88"

URI_aarch64_texlive-thumbpdf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-thumbpdf-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-thumbpdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-thumbpdf}"
SRC_URI[aarch64_texlive-thumbpdf.sha256sum] = "e8e4b0bc7fa98b9f4f396ac771167c6a49fbc48b0867dca9eddeebce317ed25b"

URI_aarch64_texlive-times = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-times-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-times;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-times}"
SRC_URI[aarch64_texlive-times.sha256sum] = "03cd8ae870eb7b0013e13dc9ae38970dd56e5de120ae2b9a23520ce4581d569b"

URI_aarch64_texlive-tipa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tipa-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-tipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tipa}"
SRC_URI[aarch64_texlive-tipa.sha256sum] = "5af720711efbbcb9c1f7241b18154e9235fa79fcdbf7c4f2a76e184858686fc9"

URI_aarch64_texlive-titlesec = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-titlesec-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-titlesec;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-titlesec}"
SRC_URI[aarch64_texlive-titlesec.sha256sum] = "360fa066fe496758b2108c2b88734446d48f6a6f44fe85d7eff09372e98a209e"

URI_aarch64_texlive-titling = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-titling-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-titling;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-titling}"
SRC_URI[aarch64_texlive-titling.sha256sum] = "8fd7e60f3dda5250393fd2c2891b6ec78384f011781d405accd7c4d3015ea013"

URI_aarch64_texlive-tocloft = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tocloft-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-tocloft;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tocloft}"
SRC_URI[aarch64_texlive-tocloft.sha256sum] = "f48a3bb9b51964a7f9504bef815277c00944c4def5b2dcb216d49f3525ef0f95"

URI_aarch64_texlive-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-tools-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-tools}"
SRC_URI[aarch64_texlive-tools.sha256sum] = "257f3a0b7df7a825907c8bba5dc501c6ae910744c7542718c1c65c10a20fc802"

URI_aarch64_texlive-translator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-translator-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-translator;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-translator}"
SRC_URI[aarch64_texlive-translator.sha256sum] = "5d546c7ccf2c4fff63c30339f112e332217d79b7bd0ae01cb177dff7cd2d94ff"

URI_aarch64_texlive-trimspaces = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-trimspaces-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-trimspaces;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-trimspaces}"
SRC_URI[aarch64_texlive-trimspaces.sha256sum] = "ec69a92de112c06dd0e67b503f6d3b5aceee0f0e81547566d5f043ab92f34725"

URI_aarch64_texlive-txfonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-txfonts-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-txfonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-txfonts}"
SRC_URI[aarch64_texlive-txfonts.sha256sum] = "b1596ca93fc31ba0348a5461d0541eac96e62f1afbb260017b8a5425b89db71a"

URI_aarch64_texlive-type1cm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-type1cm-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-type1cm;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-type1cm}"
SRC_URI[aarch64_texlive-type1cm.sha256sum] = "c0160184c2787b0cddcced38c7d4bb3270b4cd2201e950d0df63c45e7bbae788"

URI_aarch64_texlive-typehtml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-typehtml-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-typehtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-typehtml}"
SRC_URI[aarch64_texlive-typehtml.sha256sum] = "8ceb10c7e588b032a223d7f8fa2f8c11ee7bb3f7f3a3402753c92d7e4657ef36"

URI_aarch64_texlive-ucharcat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ucharcat-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ucharcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ucharcat}"
SRC_URI[aarch64_texlive-ucharcat.sha256sum] = "a8af724749d42c890d3b62d2ed9ab4a6a5d44f1c3a0c4b1a45f61d1cf992d6ec"

URI_aarch64_texlive-ucharclasses = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ucharclasses-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ucharclasses;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ucharclasses}"
SRC_URI[aarch64_texlive-ucharclasses.sha256sum] = "d05fdb413796b3057b5099c3a58a503f8bacb2cc9a80fbee82691fa2ac285a52"

URI_aarch64_texlive-ucs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ucs-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ucs;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ucs}"
SRC_URI[aarch64_texlive-ucs.sha256sum] = "07bc8da2db0d50fe56df3e255813bf8b0a9073e7be1cecd5ee3e57dd663af579"

URI_aarch64_texlive-uhc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-uhc-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-uhc;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uhc}"
SRC_URI[aarch64_texlive-uhc.sha256sum] = "78287c94b6ac75273e8a39c89322835baeb30b86721e4348862527934897950d"

URI_aarch64_texlive-ulem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-ulem-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-ulem;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-ulem}"
SRC_URI[aarch64_texlive-ulem.sha256sum] = "54b707dcf105aa44ebbfbc7d54239ad59b67bd26e4e1766010af3d76419c09af"

URI_aarch64_texlive-underscore = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-underscore-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-underscore;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-underscore}"
SRC_URI[aarch64_texlive-underscore.sha256sum] = "fe7e316ba4902693e669a3c8c27bab51feacd184e178466dbb828f0ac7dc9046"

URI_aarch64_texlive-unicode-data = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-unicode-data-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-unicode-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-unicode-data}"
SRC_URI[aarch64_texlive-unicode-data.sha256sum] = "cefece59622e93adc393a3d2afb5ce0494b2c40d0238f0658f65eab6cf21365e"

URI_aarch64_texlive-unicode-math = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-unicode-math-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-unicode-math;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-unicode-math}"
SRC_URI[aarch64_texlive-unicode-math.sha256sum] = "50a146ccb314d8d508cd3ea532f27db5c891aa763c4455b608b19ff3b731610e"

URI_aarch64_texlive-uniquecounter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-uniquecounter-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-uniquecounter;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-uniquecounter}"
SRC_URI[aarch64_texlive-uniquecounter.sha256sum] = "63ef4f106b622980ae7b2780f7a67bf5278c32a14cb0601b3fa01164b574426b"

URI_aarch64_texlive-unisugar = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-unisugar-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-unisugar;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-unisugar}"
SRC_URI[aarch64_texlive-unisugar.sha256sum] = "e3b0ee50bcc06bc5918572a432988bd44234b2ca2fa64e404d2ad012aeb9bcdd"

URI_aarch64_texlive-upquote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-upquote-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-upquote;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-upquote}"
SRC_URI[aarch64_texlive-upquote.sha256sum] = "110de7a1bf528c69657ca0a432952bfeb51f58de624699b929643f9703bf2bc9"

URI_aarch64_texlive-url = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-url-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-url;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-url}"
SRC_URI[aarch64_texlive-url.sha256sum] = "be1224b78c03cf3b46e25ce09c9b546411cfa862467e34595f844bd9301cc96c"

URI_aarch64_texlive-utopia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-utopia-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-utopia;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-utopia}"
SRC_URI[aarch64_texlive-utopia.sha256sum] = "186eccde1525871a5b1689e9e120f3ed1896d8065a9fd6e3425a601b818dd76d"

URI_aarch64_texlive-varwidth = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-varwidth-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-varwidth;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-varwidth}"
SRC_URI[aarch64_texlive-varwidth.sha256sum] = "ae073a8e166780dc327d2bfd41aa2fde62786d7ab7837fb532fad657440f68e0"

URI_aarch64_texlive-wadalab = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wadalab-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-wadalab;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wadalab}"
SRC_URI[aarch64_texlive-wadalab.sha256sum] = "f8759218d5f444dd8ad0c99f508ec992ab6c6eddd7298d4ef19b684c7a34be69"

URI_aarch64_texlive-was = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-was-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-was;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-was}"
SRC_URI[aarch64_texlive-was.sha256sum] = "d7cc2995d7f8d5433d0ffcef0512fd69c95408753c6d81a144b5a55af365e77d"

URI_aarch64_texlive-wasy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wasy-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-wasy;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wasy}"
SRC_URI[aarch64_texlive-wasy.sha256sum] = "ba8def3a826d36f2edf709d629c406742327403aa4ecad004512e565a1de05cd"

URI_aarch64_texlive-wasy-type1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wasy-type1-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-wasy-type1;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wasy-type1}"
SRC_URI[aarch64_texlive-wasy-type1.sha256sum] = "bcd459eea94001f9a642a710f75c510e68e873a528d022e2d06b44f2a7672ce0"

URI_aarch64_texlive-wasysym = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wasysym-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-wasysym;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wasysym}"
SRC_URI[aarch64_texlive-wasysym.sha256sum] = "04c51f02d908da32a5f3fee7da1d8077ceb3eeba3221c59af8f2848dc01baf33"

URI_aarch64_texlive-wrapfig = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-wrapfig-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-wrapfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-wrapfig}"
SRC_URI[aarch64_texlive-wrapfig.sha256sum] = "399b62caa04654804395fc29690d5fc143c33c21a928c0d50b91ca2e8e943425"

URI_aarch64_texlive-xcolor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xcolor-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xcolor;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xcolor}"
SRC_URI[aarch64_texlive-xcolor.sha256sum] = "9b508475dfca51bc1ef1e5a1c3ed77ce3b0b907370332b63bb28d0c7e0e11534"

URI_aarch64_texlive-xecolor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xecolor-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xecolor;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xecolor}"
SRC_URI[aarch64_texlive-xecolor.sha256sum] = "cccbc197b8741972e8d3a7c9c2ade298bf179241bd71fd27764b33dbea5fcebc"

URI_aarch64_texlive-xecyr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xecyr-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xecyr;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xecyr}"
SRC_URI[aarch64_texlive-xecyr.sha256sum] = "54cf4bfef5a81624f1550722ee3d6aa47a2323c7ab9d71ff5806301e0905e349"

URI_aarch64_texlive-xeindex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xeindex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xeindex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xeindex}"
SRC_URI[aarch64_texlive-xeindex.sha256sum] = "cc7cdadc917340fcf5444b7d04c5d13a875127f73757e8b2fb21278ac7854ab1"

URI_aarch64_texlive-xepersian = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xepersian-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xepersian;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xepersian}"
SRC_URI[aarch64_texlive-xepersian.sha256sum] = "46f555af88922e5910b2eb753265b677abba34c505c13f75ea85d120e5080845"

URI_aarch64_texlive-xesearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xesearch-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xesearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xesearch}"
SRC_URI[aarch64_texlive-xesearch.sha256sum] = "74e2bb109cc86411da4243bda6b1a030c1dbf72884eb7601869fd39b7dcb1b9f"

URI_aarch64_texlive-xetex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetex-20240311-6.el10.alma.1.aarch64.rpm;name=aarch64_texlive-xetex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetex}"
SRC_URI[aarch64_texlive-xetex.sha256sum] = "2745fdb82cf549a57bd912221c503b3951da4054c641bd167eb1ed89c18ec212"

URI_aarch64_texlive-xetex-itrans = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetex-itrans-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xetex-itrans;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetex-itrans}"
SRC_URI[aarch64_texlive-xetex-itrans.sha256sum] = "22ced8354b2f844861be9c65da2441c039c6877a50ae2bdb8040608f6eb9b90e"

URI_aarch64_texlive-xetex-pstricks = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetex-pstricks-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xetex-pstricks;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetex-pstricks}"
SRC_URI[aarch64_texlive-xetex-pstricks.sha256sum] = "120c39653a7b18acd50ed35278a0d463dedf7146768a43d602190bc3733f78c8"

URI_aarch64_texlive-xetexconfig = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetexconfig-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xetexconfig;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetexconfig}"
SRC_URI[aarch64_texlive-xetexconfig.sha256sum] = "15d808adc6f4904626b31fbd95485f567a574214b107d8f3135ca9a519d6aa52"

URI_aarch64_texlive-xetexfontinfo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xetexfontinfo-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xetexfontinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xetexfontinfo}"
SRC_URI[aarch64_texlive-xetexfontinfo.sha256sum] = "08690393b10bc413f98b38045150396145427087c980cc91a1a55e215f5377b9"

URI_aarch64_texlive-xfrac = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xfrac-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xfrac;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xfrac}"
SRC_URI[aarch64_texlive-xfrac.sha256sum] = "973c5bd49705f89206a87a430b921bece73d6d34c23aad251a680bfb1dc0570f"

URI_aarch64_texlive-xifthen = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xifthen-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xifthen;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xifthen}"
SRC_URI[aarch64_texlive-xifthen.sha256sum] = "fee0f61fecce15434440123cdd83bdf93187954b7b893dbab46642abede349d5"

URI_aarch64_texlive-xkeyval = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xkeyval-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xkeyval;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xkeyval}"
SRC_URI[aarch64_texlive-xkeyval.sha256sum] = "e82c4b5ff85404ca8b92ccadb5568e18e499e9f83d5f1822319a50108b84fbaf"

URI_aarch64_texlive-xltxtra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xltxtra-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xltxtra;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xltxtra}"
SRC_URI[aarch64_texlive-xltxtra.sha256sum] = "f508906a25c8637817f8de9308f1a5a4011fdedecc5309cc9590d292a166a958"

URI_aarch64_texlive-xmltex = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xmltex-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xmltex;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xmltex}"
SRC_URI[aarch64_texlive-xmltex.sha256sum] = "b16eac2029c3df8672cb09fa0220bcec09bde4c0f4528e47b04fe0f396b9864a"

URI_aarch64_texlive-xpatch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xpatch-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xpatch;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xpatch}"
SRC_URI[aarch64_texlive-xpatch.sha256sum] = "6ff94baf9958e6ea26ee7a1c5b687e41ca0d599a189f0e8924d875f769cb1c41"

URI_aarch64_texlive-xstring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xstring-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xstring}"
SRC_URI[aarch64_texlive-xstring.sha256sum] = "ba20ae2031f1164b9da6848f3043a1ea87d77e0e40a77d6ced6b25984958d8c1"

URI_aarch64_texlive-xtab = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xtab-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xtab;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xtab}"
SRC_URI[aarch64_texlive-xtab.sha256sum] = "afa16a6632066434269da7b7b784392bcb27f74cdc82511942d200df1a579c7c"

URI_aarch64_texlive-xunicode = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-xunicode-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-xunicode;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-xunicode}"
SRC_URI[aarch64_texlive-xunicode.sha256sum] = "add880501fb7af236e0bc2d652e6de10f6dcad8434d183d0fe4f8d011100c1af"

URI_aarch64_texlive-zapfchan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-zapfchan-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-zapfchan;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zapfchan}"
SRC_URI[aarch64_texlive-zapfchan.sha256sum] = "39e9c67716cf02f55be38741291feebb6f0e036b76d840231d10f161d1abeb5f"

URI_aarch64_texlive-zapfding = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-zapfding-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-zapfding;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zapfding}"
SRC_URI[aarch64_texlive-zapfding.sha256sum] = "d1d79735f8422338106cc53d1870c4de908c6d55fdbf4d5f9506d20e7d2569c4"

URI_aarch64_texlive-zref = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/texlive-zref-20240311-6.el10.alma.1.noarch.rpm;name=aarch64_texlive-zref;unpack=0"
SRC_URI:append = " ${URI_aarch64_texlive-zref}"
SRC_URI[aarch64_texlive-zref.sha256sum] = "12892da208bb91ced96443a2eed840a5c8f5dfad2ee24e6faa4e64447e2c6327"

RDEPENDS:texlive = " \
 texlive-collection-latexrecommended \
 texlive-kpathsea \
 texlive-scheme-basic \
 "
RDEPENDS:texlive-acronym = " \
 texlive-base \
 texlive-bigfoot \
 texlive-kpathsea \
 texlive-relsize \
 texlive-xstring \
 "
RDEPENDS:texlive-adjustbox = " \
 texlive-base \
 texlive-collectbox \
 texlive-graphics \
 texlive-ifoddpage \
 texlive-kpathsea \
 texlive-pgf \
 texlive-tools \
 texlive-varwidth \
 texlive-xkeyval \
 "
RDEPENDS:texlive-ae = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-algorithms = " \
 texlive-base \
 texlive-float \
 texlive-graphics \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-alphalph = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-amscls = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 texlive-url \
 virtual/tex_doc.sty_ \
 "
RDEPENDS:texlive-amsfonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-amsmath = " \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-anyfontsize = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-anysize = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-appendix = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-arphic = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-atbegshi = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-attachfile = " \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-iftex \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-attachfile2 = " \
 perl-Digest-MD5 \
 perl-Getopt-Long \
 perl-POSIX \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-atveryend = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-auxhook = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-avantgar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-awesomebox = " \
 texlive-base \
 texlive-fontawesome \
 texlive-iftex \
 texlive-tools \
 texlive-xcolor \
 texlive-xltxtra \
 "
RDEPENDS:texlive-babel = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-babel-english = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-babelbib = " \
 texlive-babel \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-base = " \
 bash \
 virtual/coreutils \
 "
RDEPENDS:texlive-beamer = " \
 texlive-amscls \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-atbegshi \
 texlive-base \
 texlive-beamer \
 texlive-etoolbox \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-iftex \
 texlive-kpathsea \
 texlive-pgf \
 texlive-sansmathaccent \
 texlive-tools \
 texlive-translator \
 texlive-ucs \
 texlive-xcolor \
 virtual/tex_inputenc.sty_ \
 "
RDEPENDS:texlive-bera = " \
 texlive-base \
 texlive-bera \
 texlive-graphics \
 texlive-kpathsea \
 virtual/tex_fontenc.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-beton = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bibtex = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-bibtopic = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-bidi = " \
 texlive-auxhook \
 texlive-base \
 texlive-bidi \
 texlive-changepage \
 texlive-etoolbox \
 texlive-fancyhdr \
 texlive-geometry \
 texlive-graphics \
 texlive-hopatch \
 texlive-hyperref \
 texlive-iftex \
 texlive-kpathsea \
 texlive-ltxcmds \
 texlive-marvosym \
 texlive-natbib \
 texlive-paralist \
 texlive-placeins \
 texlive-ragged2e \
 texlive-sauerj \
 texlive-setspace \
 texlive-showexpl \
 texlive-titlesec \
 texlive-tools \
 texlive-url \
 texlive-xcolor \
 texlive-xifthen \
 texlive-zref \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-bigfoot = " \
 texlive-base \
 texlive-bigfoot \
 texlive-etex-pkg \
 texlive-kpathsea \
 texlive-ncctools \
 "
RDEPENDS:texlive-bigintcalc = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bitset = " \
 texlive-bigintcalc \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bookman = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-bookmark = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-booktabs = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-breakurl = " \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-xkeyval \
 "
RDEPENDS:texlive-breqn = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-tools \
 "
RDEPENDS:texlive-capt-of = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-caption = " \
 texlive-base \
 texlive-caption \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-carlisle = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-catchfile = " \
 texlive-etexcmds \
 texlive-infwarerr \
 texlive-kpathsea \
 texlive-ltxcmds \
 "
RDEPENDS:texlive-changebar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-changepage = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-charter = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-chngcntr = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cite = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-classpack = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cm = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cm-lgc = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cm-super = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_t1cmr.fd_ \
 "
RDEPENDS:texlive-cmap = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cmextra = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-cns = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-collectbox = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-collection-basic = " \
 texlive-amsfonts \
 texlive-base \
 texlive-bibtex \
 texlive-cm \
 texlive-colorprofiles \
 texlive-dvipdfmx \
 texlive-dvips \
 texlive-ec \
 texlive-enctex \
 texlive-etex \
 texlive-etex-pkg \
 texlive-glyphlist \
 texlive-graphics-def \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-hyphenex \
 texlive-ifplatform \
 texlive-iftex \
 texlive-knuth-lib \
 texlive-knuth-local \
 texlive-kpathsea \
 texlive-lua-alt-getopt \
 texlive-luahbtex \
 texlive-luatex \
 texlive-makeindex \
 texlive-metafont \
 texlive-mflogo \
 texlive-mfware \
 texlive-modes \
 texlive-pdftex \
 texlive-plain \
 texlive-tex \
 texlive-tex-ini-files \
 texlive-texlive-common-doc \
 texlive-texlive-en \
 texlive-texlive-msg-translations \
 texlive-texlive-scripts \
 texlive-texlive.infra \
 texlive-unicode-data \
 "
RDEPENDS:texlive-collection-fontsrecommended = " \
 texlive-avantgar \
 texlive-base \
 texlive-bookman \
 texlive-charter \
 texlive-cm-super \
 texlive-cmextra \
 texlive-collection-basic \
 texlive-courier \
 texlive-ec \
 texlive-euro \
 texlive-eurosym \
 texlive-fpl \
 texlive-helvetic \
 texlive-lm \
 texlive-lm-math \
 texlive-manfnt-font \
 texlive-marvosym \
 texlive-mathpazo \
 texlive-mflogo-font \
 texlive-ncntrsbk \
 texlive-palatino \
 texlive-pxfonts \
 texlive-rsfs \
 texlive-symbol \
 texlive-tex-gyre \
 texlive-tex-gyre-math \
 texlive-times \
 texlive-tipa \
 texlive-txfonts \
 texlive-utopia \
 texlive-wasy \
 texlive-wasy-type1 \
 texlive-wasysym \
 texlive-zapfchan \
 texlive-zapfding \
 "
RDEPENDS:texlive-collection-htmlxml = " \
 texlive-base \
 texlive-classpack \
 texlive-collection-basic \
 texlive-collection-fontsrecommended \
 texlive-collection-latex \
 texlive-jadetex \
 texlive-passivetex \
 texlive-tex-ini-files \
 texlive-tex4ht \
 texlive-xmltex \
 "
RDEPENDS:texlive-collection-latex = " \
 texlive-ae \
 texlive-amscls \
 texlive-amsmath \
 texlive-atbegshi \
 texlive-atveryend \
 texlive-auxhook \
 texlive-babel \
 texlive-babel-english \
 texlive-babelbib \
 texlive-base \
 texlive-bitset \
 texlive-bookmark \
 texlive-carlisle \
 texlive-collection-basic \
 texlive-colortbl \
 texlive-epstopdf-pkg \
 texlive-etexcmds \
 texlive-fancyhdr \
 texlive-firstaid \
 texlive-fix2col \
 texlive-geometry \
 texlive-gettitlestring \
 texlive-graphics \
 texlive-graphics-cfg \
 texlive-grfext \
 texlive-hycolor \
 texlive-hypcap \
 texlive-hyperref \
 texlive-intcalc \
 texlive-kvdefinekeys \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-latex \
 texlive-latex-fonts \
 texlive-latexconfig \
 texlive-letltxmacro \
 texlive-ltxcmds \
 texlive-ltxmisc \
 texlive-mfnfss \
 texlive-mptopdf \
 texlive-natbib \
 texlive-oberdiek \
 texlive-pdfescape \
 texlive-pslatex \
 texlive-psnfss \
 texlive-pspicture \
 texlive-refcount \
 texlive-rerunfilecheck \
 texlive-stringenc \
 texlive-tools \
 texlive-uniquecounter \
 texlive-url \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-collection-latexrecommended = " \
 texlive-anysize \
 texlive-attachfile2 \
 texlive-base \
 texlive-beamer \
 texlive-booktabs \
 texlive-breqn \
 texlive-caption \
 texlive-cite \
 texlive-cmap \
 texlive-collection-fontsrecommended \
 texlive-collection-latex \
 texlive-count1to \
 texlive-crop \
 texlive-ctable \
 texlive-eso-pic \
 texlive-etoolbox \
 texlive-euenc \
 texlive-euler \
 texlive-everysel \
 texlive-everyshi \
 texlive-extsizes \
 texlive-fancybox \
 texlive-fancyref \
 texlive-fancyvrb \
 texlive-filehook \
 texlive-float \
 texlive-fontspec \
 texlive-footnotehyper \
 texlive-fp \
 texlive-grffile \
 texlive-hologo \
 texlive-index \
 texlive-infwarerr \
 texlive-jknapltx \
 texlive-koma-script \
 texlive-l3experimental \
 texlive-latexbug \
 texlive-lineno \
 texlive-listings \
 texlive-lwarp \
 texlive-mathspec \
 texlive-mathtools \
 texlive-mdwtools \
 texlive-memoir \
 texlive-metalogo \
 texlive-microtype \
 texlive-multitoc \
 texlive-newfloat \
 texlive-ntgclass \
 texlive-parskip \
 texlive-pdfcolfoot \
 texlive-pdflscape \
 texlive-pdfmanagement-testphase \
 texlive-pdfpages \
 texlive-polyglossia \
 texlive-psfrag \
 texlive-ragged2e \
 texlive-rcs \
 texlive-sansmath \
 texlive-section \
 texlive-seminar \
 texlive-sepnum \
 texlive-setspace \
 texlive-subfig \
 texlive-textcase \
 texlive-thumbpdf \
 texlive-translator \
 texlive-typehtml \
 texlive-ucharcat \
 texlive-underscore \
 texlive-unicode-math \
 texlive-xcolor \
 texlive-xfrac \
 texlive-xkeyval \
 texlive-xltxtra \
 texlive-xunicode \
 "
RDEPENDS:texlive-collection-xetex = " \
 texlive-awesomebox \
 texlive-base \
 texlive-collection-basic \
 texlive-fixlatvian \
 texlive-fontbook \
 texlive-fontwrap \
 texlive-philokalia \
 texlive-ptext \
 texlive-realscripts \
 texlive-ucharclasses \
 texlive-unisugar \
 texlive-xecolor \
 texlive-xecyr \
 texlive-xeindex \
 texlive-xesearch \
 texlive-xetex \
 texlive-xetex-itrans \
 texlive-xetex-pstricks \
 texlive-xetexconfig \
 texlive-xetexfontinfo \
 "
RDEPENDS:texlive-colorprofiles = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-colortbl = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-context = " \
 bash \
 perl-Tk \
 perl-base \
 perl-libs \
 texlive-amsfonts \
 texlive-base \
 texlive-kpathsea \
 texlive-lm \
 texlive-lm-math \
 texlive-luatex \
 texlive-manfnt-font \
 texlive-metapost \
 texlive-mflogo-font \
 texlive-mptopdf \
 texlive-pdftex \
 texlive-pst-plot \
 texlive-pstricks \
 texlive-stmaryrd \
 texlive-texlive-scripts \
 texlive-xetex \
 virtual/coreutils \
 "
RDEPENDS:texlive-count1to = " \
 texlive-base \
 texlive-everyshi \
 texlive-kpathsea \
 "
RDEPENDS:texlive-courier = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-crop = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-csquotes = " \
 texlive-base \
 texlive-etoolbox \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ctable = " \
 bash \
 texlive-base \
 texlive-booktabs \
 texlive-etoolbox \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tools \
 texlive-xkeyval \
 "
RDEPENDS:texlive-ctablestack = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-currfile = " \
 texlive-base \
 texlive-filehook \
 texlive-kpathsea \
 texlive-kvoptions \
 "
RDEPENDS:texlive-datetime = " \
 texlive-base \
 texlive-fmtcount \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-dehyph = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-dvipdfmx = " \
 bash \
 texlive-base \
 texlive-glyphlist \
 texlive-graphics-def \
 texlive-kpathsea \
 texlive-xetex \
 "
RDEPENDS:texlive-dvipng = " \
 freetype \
 gd \
 glibc \
 info \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-dvips = " \
 glibc \
 info \
 texlive-base \
 texlive-kpathsea \
 texlive-latex-fonts \
 texlive-lib \
 "
RDEPENDS:texlive-dvisvgm = " \
 freetype \
 glibc \
 libgcc \
 libgs \
 libstdc++ \
 potrace \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 zlib-ng-compat \
 "
RDEPENDS:texlive-ec = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-eepic = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-enctex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-enumitem = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-environ = " \
 texlive-base \
 texlive-kpathsea \
 texlive-trimspaces \
 "
RDEPENDS:texlive-epsf = " \
 bash \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-epstopdf = " \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-epstopdf-pkg = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-eqparbox = " \
 texlive-base \
 texlive-environ \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-eso-pic = " \
 texlive-atbegshi \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-xcolor \
 "
RDEPENDS:texlive-etex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-etex-pkg = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-etexcmds = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-etoc = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-etoolbox = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-euenc = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-euler = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-euro = " \
 texlive-base \
 texlive-fp \
 texlive-kpathsea \
 "
RDEPENDS:texlive-eurosym = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-everysel = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-everyshi = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-extsizes = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_exscale.sty_ \
 "
RDEPENDS:texlive-fancybox = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fancyhdr = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fancyref = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-fancyvrb = " \
 texlive-base \
 texlive-fancyvrb \
 texlive-graphics \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-filecontents = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-filehook = " \
 texlive-base \
 texlive-currfile \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-pgf \
 "
RDEPENDS:texlive-finstrut = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-firstaid = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fix2col = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fixlatvian = " \
 texlive-base \
 texlive-bigfoot \
 texlive-caption \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-polyglossia \
 texlive-svn-prov \
 texlive-tools \
 texlive-was \
 texlive-xstring \
 "
RDEPENDS:texlive-float = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fmtcount = " \
 texlive-amsmath \
 texlive-base \
 texlive-etoolbox \
 texlive-graphics \
 texlive-kpathsea \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-fncychap = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fontawesome = " \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 texlive-texlive-scripts \
 "
RDEPENDS:texlive-fontbook = " \
 texlive-base \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-xunicode \
 "
RDEPENDS:texlive-fonts-tlwg = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fontspec = " \
 texlive-base \
 texlive-kastrup \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lm \
 texlive-luaotfload \
 texlive-xunicode \
 virtual/tex_fixltx2e.sty_ \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-fontware = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-fontwrap = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-footmisc = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-footnotehyper = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fp = " \
 texlive-base \
 texlive-fp \
 texlive-kpathsea \
 "
RDEPENDS:texlive-fpl = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-framed = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-garuda-c90 = " \
 texlive-base \
 texlive-fonts-tlwg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-geometry = " \
 texlive-atbegshi \
 texlive-base \
 texlive-graphics \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gettitlestring = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-glyphlist = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gnu-freefont = " \
 bash \
 fontforge \
 perl-interpreter \
 python-unversioned-command \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-graphics = " \
 texlive-base \
 texlive-graphics-cfg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-graphics-cfg = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-graphics-def = " \
 texlive-base \
 texlive-epstopdf-pkg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-grfext = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-grffile = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-gsftopk = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-hanging = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-helvetic = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hobsub = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hologo = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hopatch = " \
 texlive-kpathsea \
 texlive-ltxcmds \
 "
RDEPENDS:texlive-hycolor = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hypcap = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hypdoc = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyperref = " \
 texlive-atbegshi \
 texlive-auxhook \
 texlive-base \
 texlive-bitset \
 texlive-etexcmds \
 texlive-gettitlestring \
 texlive-graphics \
 texlive-hobsub \
 texlive-hycolor \
 texlive-iftex \
 texlive-infwarerr \
 texlive-intcalc \
 texlive-kpathsea \
 texlive-kvdefinekeys \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-letltxmacro \
 texlive-ltxcmds \
 texlive-memoir \
 texlive-pdfescape \
 texlive-pdftexcmds \
 texlive-refcount \
 texlive-rerunfilecheck \
 texlive-stringenc \
 texlive-url \
 texlive-zapfding \
 "
RDEPENDS:texlive-hyph-utf8 = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphen-base = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphenat = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-hyphenex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ifmtarg = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ifoddpage = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ifplatform = " \
 texlive-base \
 texlive-catchfile \
 texlive-iftex \
 texlive-kpathsea \
 texlive-pdftexcmds \
 "
RDEPENDS:texlive-iftex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-import = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-index = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-infwarerr = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-intcalc = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-jadetex = " \
 texlive-base \
 texlive-kpathsea \
 texlive-latex \
 texlive-passivetex \
 texlive-pdftex \
 texlive-tex \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-jknapltx = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-kastrup = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kerkis = " \
 texlive-base \
 texlive-kpathsea \
 texlive-txfonts \
 "
RDEPENDS:texlive-knuth-lib = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-knuth-local = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-koma-script = " \
 texlive-amsmath \
 texlive-babelbib \
 texlive-base \
 texlive-bookmark \
 texlive-booktabs \
 texlive-etoolbox \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-listings \
 texlive-marginnote \
 texlive-mparhack \
 texlive-tools \
 texlive-xcolor \
 virtual/tex_fontenc.sty_ \
 virtual/tex_inputenc.sty_ \
 virtual/tex_makeidx.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-kpathsea = " \
 bash \
 glibc \
 grep \
 texlive-base \
 texlive-lib \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-kvdefinekeys = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kvoptions = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-kvsetkeys = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-l3backend = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-l3experimental = " \
 texlive-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-l3kernel = " \
 texlive-alphalph \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-booktabs \
 texlive-colortbl \
 texlive-csquotes \
 texlive-enumitem \
 texlive-fancyvrb \
 texlive-graphics \
 texlive-hologo \
 texlive-hypdoc \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-lm \
 texlive-psnfss \
 texlive-tools \
 texlive-underscore \
 virtual/tex_doc.sty_ \
 virtual/tex_fontenc.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-l3packages = " \
 texlive-amsmath \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-l3kernel \
 "
RDEPENDS:texlive-lastpage = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex = " \
 texlive-base \
 texlive-cm-super \
 texlive-hypdoc \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-latex-fonts \
 texlive-latexconfig \
 texlive-luatex \
 texlive-pdftex \
 texlive-psnfss \
 texlive-tools \
 texlive-url \
 virtual/coreutils \
 "
RDEPENDS:texlive-latex-fonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latex2man = " \
 info \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-libs \
 texlive-base \
 texlive-fancyhdr \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-latexbug = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-latexconfig = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-letltxmacro = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lettrine = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lib = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:texlive-lib-devel = " \
 pkgconf-pkg-config \
 texlive-lib \
 texlive-lib-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:texlive-linegoal = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-kpathsea \
 texlive-zref \
 "
RDEPENDS:texlive-lineno = " \
 texlive-base \
 texlive-finstrut \
 texlive-kpathsea \
 texlive-ltabptch \
 texlive-tools \
 "
RDEPENDS:texlive-listings = " \
 texlive-algorithms \
 texlive-base \
 texlive-fancyvrb \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-url \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-listofitems = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lm = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lm-math = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ltabptch = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-ltxcmds = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ltxmisc = " \
 texlive-base \
 texlive-beton \
 texlive-euler \
 texlive-graphics \
 texlive-kpathsea \
 texlive-minitoc \
 texlive-natbib \
 texlive-psnfss \
 texlive-tools \
 virtual/tex_makeidx.sty_ \
 "
RDEPENDS:texlive-lua-alt-getopt = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-lua-uni-algos = " \
 texlive-kpathsea \
 texlive-luatex \
 texlive-unicode-data \
 "
RDEPENDS:texlive-luahbtex:x86_64_v2 = " \
 glibc \
 harfbuzz \
 libgcc \
 libpng \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-luatex \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-unicode-data \
 zlib-ng-compat \
 zziplib \
"
RDEPENDS:texlive-luahbtex:aarch64 = " \
 glibc \
 harfbuzz \
 libpng \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-luatex \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-unicode-data \
 zlib-ng-compat \
 zziplib \
"
RDEPENDS:texlive-lualatex-math = " \
 texlive-base \
 texlive-etoolbox \
 texlive-filehook \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-luatexbase \
 "
RDEPENDS:texlive-lualibs = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-luaotfload = " \
 texlive-base \
 texlive-kpathsea \
 texlive-lua-alt-getopt \
 texlive-lua-uni-algos \
 texlive-lualibs \
 texlive-luatexbase \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-luatex = " \
 glibc \
 libpng \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-graphics-def \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-texlive-scripts \
 texlive-unicode-data \
 virtual/coreutils \
 zlib-ng-compat \
 zziplib \
 "
RDEPENDS:texlive-luatex85 = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-luatexbase = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-iftex \
 texlive-kpathsea \
 texlive-luatexbase \
 "
RDEPENDS:texlive-lwarp = " \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-makecmds = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-makeindex = " \
 bash \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 "
RDEPENDS:texlive-manfnt-font = " \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive-scripts \
 "
RDEPENDS:texlive-marginnote = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-marvosym = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mathpazo = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mathspec = " \
 texlive-amsmath \
 texlive-base \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-iftex \
 texlive-kpathsea \
 texlive-mnsymbol \
 texlive-xkeyval \
 "
RDEPENDS:texlive-mathtools = " \
 texlive-amsmath \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-mathtools \
 texlive-tools \
 "
RDEPENDS:texlive-mdwtools = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-memoir = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-metafont = " \
 glibc \
 libX11 \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-metalogo = " \
 texlive-base \
 texlive-fontspec \
 texlive-graphics \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-metapost = " \
 cairo \
 glibc \
 gmp \
 libpng \
 mpfr \
 pixman \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 texlive-texlive-scripts \
 zlib-ng-compat \
 "
RDEPENDS:texlive-mflogo = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mflogo-font = " \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive-scripts \
 "
RDEPENDS:texlive-mfnfss = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mfware = " \
 glibc \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 texlive-mfware \
 "
RDEPENDS:texlive-microtype = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-minitoc = " \
 texlive-base \
 texlive-kpathsea \
 texlive-minitoc \
 texlive-notoccite \
 texlive-placeins \
 virtual/tex_flafter.sty_ \
 "
RDEPENDS:texlive-mnsymbol = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-modes = " \
 bash \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mparhack = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-mptopdf = " \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-multido = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-multirow = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-multitoc = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-natbib = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ncctools = " \
 texlive-amsmath \
 texlive-base \
 texlive-bigfoot \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ncntrsbk = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-needspace = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-newfloat = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-newunicodechar = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-norasi-c90 = " \
 texlive-base \
 texlive-fonts-tlwg \
 texlive-kpathsea \
 "
RDEPENDS:texlive-notoccite = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ntgclass = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-oberdiek = " \
 texlive-amsmath \
 texlive-atveryend \
 texlive-auxhook \
 texlive-base \
 texlive-bigintcalc \
 texlive-carlisle \
 texlive-etexcmds \
 texlive-fontspec \
 texlive-fp \
 texlive-graphics \
 texlive-grfext \
 texlive-grffile \
 texlive-hologo \
 texlive-hypcap \
 texlive-hypdoc \
 texlive-hyperref \
 texlive-iftex \
 texlive-index \
 texlive-infwarerr \
 texlive-intcalc \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-kvsetkeys \
 texlive-letltxmacro \
 texlive-ltxcmds \
 texlive-parallel \
 texlive-pdfcol \
 texlive-pdfescape \
 texlive-pdftexcmds \
 texlive-sauerj \
 texlive-tools \
 texlive-unicode-math \
 texlive-uniquecounter \
 texlive-zref \
 "
RDEPENDS:texlive-overpic = " \
 texlive-base \
 texlive-eepic \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-palatino = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-paralist = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-parallel = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-parskip = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-passivetex = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 texlive-marvosym \
 texlive-passivetex \
 texlive-psnfss \
 texlive-tipa \
 texlive-tools \
 texlive-ulem \
 texlive-url \
 virtual/tex_fontenc.sty_ \
 virtual/tex_ifthen.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-pdfcol = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfcolfoot = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfcolmk = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfescape = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdflscape = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfmanagement-testphase = " \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pdfpages = " \
 texlive-base \
 texlive-count1to \
 texlive-eso-pic \
 texlive-graphics \
 texlive-kpathsea \
 texlive-pdflscape \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-pdftex = " \
 bash \
 glibc \
 libgcc \
 libpng \
 libstdc++ \
 perl-libs \
 texlive-base \
 texlive-cm \
 texlive-etex \
 texlive-graphics-def \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-texlive-scripts \
 virtual//usr/bin/env \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:texlive-pdftexcmds = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pgf = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-pgf \
 texlive-xcolor \
 texlive-xkeyval \
 "
RDEPENDS:texlive-philokalia = " \
 texlive-base \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-lettrine \
 texlive-xltxtra \
 texlive-xunicode \
 "
RDEPENDS:texlive-placeins = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-plain = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-polyglossia = " \
 texlive-base \
 texlive-bidi \
 texlive-etoolbox \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-makecmds \
 texlive-polyglossia \
 texlive-tools \
 texlive-xkeyval \
 "
RDEPENDS:texlive-powerdot = " \
 texlive-amsfonts \
 texlive-base \
 texlive-enumitem \
 texlive-geometry \
 texlive-graphics \
 texlive-hyperref \
 texlive-iftex \
 texlive-kpathsea \
 texlive-psnfss \
 texlive-pst-blur \
 texlive-pst-grad \
 texlive-pst-slpe \
 texlive-pst-text \
 texlive-pstricks \
 texlive-tools \
 texlive-type1cm \
 texlive-xcolor \
 texlive-xkeyval \
 "
RDEPENDS:texlive-preprint = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-psfrag = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pslatex = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-psnfss = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-symbol \
 texlive-zapfding \
 "
RDEPENDS:texlive-pspicture = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pst-3d = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-arrow = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pst-blur = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-coil = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-eps = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-fill = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-grad = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-math = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pst-node = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-plot = " \
 texlive-base \
 texlive-kpathsea \
 texlive-multido \
 texlive-pstricks \
 texlive-xkeyval \
 "
RDEPENDS:texlive-pst-slpe = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-text = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-tools = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pst-tree = " \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-pstricks = " \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-babel \
 texlive-base \
 texlive-bera \
 texlive-booktabs \
 texlive-breakurl \
 texlive-caption \
 texlive-chngcntr \
 texlive-eso-pic \
 texlive-fancyvrb \
 texlive-filecontents \
 texlive-footmisc \
 texlive-graphics \
 texlive-hyperref \
 texlive-iftex \
 texlive-koma-script \
 texlive-kpathsea \
 texlive-multido \
 texlive-paralist \
 texlive-pst-3d \
 texlive-pst-arrow \
 texlive-pst-coil \
 texlive-pst-eps \
 texlive-pst-fill \
 texlive-pst-grad \
 texlive-pst-node \
 texlive-pst-plot \
 texlive-pst-text \
 texlive-pst-tools \
 texlive-pst-tree \
 texlive-pstricks-add \
 texlive-ragged2e \
 texlive-setspace \
 texlive-showexpl \
 texlive-subfig \
 texlive-tools \
 texlive-xcolor \
 texlive-xkeyval \
 virtual/tex_fontenc.sty_ \
 virtual/tex_makeidx.sty_ \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-pstricks-add = " \
 texlive-base \
 texlive-kpathsea \
 texlive-multido \
 texlive-pst-3d \
 texlive-pst-math \
 texlive-pst-node \
 texlive-pst-plot \
 texlive-pstricks \
 "
RDEPENDS:texlive-ptext = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-pxfonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-qstest = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-ragged2e = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-rcs = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-realscripts = " \
 texlive-base \
 texlive-fontspec \
 texlive-kpathsea \
 "
RDEPENDS:texlive-refcount = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-relsize = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-rerunfilecheck = " \
 texlive-atveryend \
 texlive-kpathsea \
 texlive-uniquecounter \
 "
RDEPENDS:texlive-rsfs = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sansmath = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sansmathaccent = " \
 texlive-base \
 texlive-filehook \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sauerj = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-scheme-basic = " \
 texlive-base \
 texlive-collection-basic \
 texlive-collection-latex \
 virtual/coreutils \
 "
RDEPENDS:texlive-section = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sectsty = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-seminar = " \
 bash \
 texlive-base \
 texlive-kpathsea \
 texlive-pstricks \
 "
RDEPENDS:texlive-sepnum = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-setspace = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-sfmath = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-showexpl = " \
 texlive-attachfile \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-listings \
 texlive-tools \
 texlive-varwidth \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-soul = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-stackengine = " \
 texlive-base \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-listofitems \
 "
RDEPENDS:texlive-stmaryrd = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-stringenc = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-subfig = " \
 texlive-base \
 texlive-caption \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-subfigure = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-svn-prov = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-symbol = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-t2 = " \
 texlive-amsfonts \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-tabu = " \
 texlive-base \
 texlive-kpathsea \
 texlive-linegoal \
 texlive-tools \
 texlive-varwidth \
 "
RDEPENDS:texlive-tabulary = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-tex = " \
 glibc \
 texlive-base \
 texlive-cm \
 texlive-hyphen-base \
 texlive-knuth-lib \
 texlive-kpathsea \
 texlive-lib \
 texlive-plain \
 texlive-texlive-scripts \
 virtual/coreutils \
 "
RDEPENDS:texlive-tex-gyre = " \
 texlive-base \
 texlive-kpathsea \
 texlive-kvoptions \
 texlive-tex-gyre \
 "
RDEPENDS:texlive-tex-gyre-math = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tex-ini-files = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tex4ht = " \
 bash \
 glibc \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 texlive-lib \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-texlive-common-doc = " \
 "
RDEPENDS:texlive-texlive-en = " \
 bash \
 info \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-texlive-msg-translations = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-texlive-scripts = " \
 bash \
 perl-File-Basename \
 perl-File-Find \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-libs \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive.infra \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-texlive-scripts-extra = " \
 bash \
 texlive-base \
 texlive-kpathsea \
 texlive-texlive.infra \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-texlive.infra = " \
 bash \
 perl-Digest-MD5 \
 perl-Exporter \
 perl-File-Find \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Text-Unidecode \
 perl-XML-Parser \
 perl-XML-XPath \
 perl-constant \
 perl-libs \
 perl-vars \
 texlive-base \
 texlive-kpathsea \
 virtual//usr/bin/env \
 "
RDEPENDS:texlive-textcase = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-textpos = " \
 texlive-base \
 texlive-everyshi \
 texlive-kpathsea \
 "
RDEPENDS:texlive-threeparttable = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-thumbpdf = " \
 ghostscript \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-times = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tipa = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tipa \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-titlesec = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-titling = " \
 texlive-base \
 texlive-kpathsea \
 virtual/coreutils \
 "
RDEPENDS:texlive-tocloft = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-tools = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-translator = " \
 texlive-graphics \
 texlive-kpathsea \
 "
RDEPENDS:texlive-trimspaces = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-txfonts = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-type1cm = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-typehtml = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_exscale.sty_ \
 "
RDEPENDS:texlive-ucharcat = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ucharclasses = " \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ucs = " \
 perl-Carp \
 perl-Data-Dumper \
 perl-Getopt-Long \
 perl-IO \
 perl-interpreter \
 perl-libs \
 perl-vars \
 texlive-base \
 texlive-graphics \
 texlive-hyperref \
 texlive-kpathsea \
 virtual/tex_fontenc.sty_ \
 "
RDEPENDS:texlive-uhc = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-ulem = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-underscore = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-unicode-data = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-unicode-math = " \
 texlive-base \
 texlive-catchfile \
 texlive-filehook \
 texlive-fontspec \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-lualatex-math \
 texlive-luaotfload \
 texlive-luatexbase \
 virtual/tex_fix-cm.sty_ \
 "
RDEPENDS:texlive-uniquecounter = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-unisugar = " \
 texlive-base \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-upquote = " \
 texlive-base \
 texlive-kpathsea \
 virtual/tex_textcomp.sty_ \
 "
RDEPENDS:texlive-url = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-utopia = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-varwidth = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-wadalab = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-was = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-wasy = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-wasy-type1 = " \
 texlive-kpathsea \
 texlive-wasy \
 "
RDEPENDS:texlive-wasysym = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-wrapfig = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xcolor = " \
 texlive-base \
 texlive-colortbl \
 texlive-kpathsea \
 texlive-pdfcolmk \
 "
RDEPENDS:texlive-xecolor = " \
 texlive-base \
 texlive-fontspec \
 texlive-iftex \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xecyr = " \
 texlive-base \
 texlive-kpathsea \
 texlive-t2 \
 texlive-xltxtra \
 texlive-xunicode \
 "
RDEPENDS:texlive-xeindex = " \
 texlive-base \
 texlive-kpathsea \
 texlive-xesearch \
 virtual/tex_makeidx.sty_ \
 "
RDEPENDS:texlive-xepersian = " \
 python-unversioned-command \
 texlive-base \
 texlive-bidi \
 texlive-datetime \
 texlive-fancybox \
 texlive-fancyhdr \
 texlive-fontspec \
 texlive-geometry \
 texlive-hyphenat \
 texlive-iftex \
 texlive-kpathsea \
 texlive-lastpage \
 texlive-multido \
 texlive-preprint \
 texlive-psnfss \
 texlive-ragged2e \
 texlive-setspace \
 texlive-textpos \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-xesearch = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xetex = " \
 fontconfig \
 freetype \
 glibc \
 graphite2 \
 harfbuzz \
 libgcc \
 libicu \
 libpaper \
 libpng \
 libstdc++ \
 teckit \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-dvipdfmx \
 texlive-etex \
 texlive-graphics-def \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-latex-fonts \
 texlive-lib \
 texlive-lm \
 texlive-plain \
 texlive-tex-ini-files \
 texlive-unicode-data \
 texlive-xetexconfig \
 virtual/coreutils \
 virtual/texlive-latex \
 zlib-ng-compat \
 "
RDEPENDS:texlive-xetex-itrans = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xetex-pstricks = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xetexconfig = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xetexfontinfo = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xfrac = " \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xifthen = " \
 texlive-base \
 texlive-etex-pkg \
 texlive-ifmtarg \
 texlive-kpathsea \
 texlive-tools \
 virtual/tex_ifthen.sty_ \
 "
RDEPENDS:texlive-xkeyval = " \
 texlive-base \
 texlive-kpathsea \
 texlive-tools \
 "
RDEPENDS:texlive-xltxtra = " \
 texlive-base \
 texlive-fontspec \
 texlive-iftex \
 texlive-kpathsea \
 texlive-metalogo \
 texlive-realscripts \
 "
RDEPENDS:texlive-xmltex = " \
 texlive-babel \
 texlive-base \
 texlive-cm \
 texlive-dehyph \
 texlive-hyph-utf8 \
 texlive-hyphen-base \
 texlive-kpathsea \
 texlive-l3backend \
 texlive-l3kernel \
 texlive-l3packages \
 texlive-latex-fonts \
 texlive-latexconfig \
 texlive-pdftex \
 texlive-tex \
 texlive-tex-ini-files \
 texlive-unicode-data \
 virtual/texlive-latex \
 "
RDEPENDS:texlive-xpatch = " \
 texlive-base \
 texlive-etoolbox \
 texlive-kpathsea \
 texlive-l3kernel \
 texlive-l3packages \
 "
RDEPENDS:texlive-xstring = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xtab = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-xunicode = " \
 texlive-base \
 texlive-graphics \
 texlive-kpathsea \
 texlive-tipa \
 "
RDEPENDS:texlive-zapfchan = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zapfding = " \
 texlive-base \
 texlive-kpathsea \
 "
RDEPENDS:texlive-zref = " \
 texlive-kpathsea \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_ rpm/virtual/texlive-latex"

PROVIDES:append:aarch64 = " rpm/virtual/tex_alltt.sty_ rpm/virtual/tex_article.cls_ rpm/virtual/tex_doc.sty_ rpm/virtual/tex_exscale.sty_ rpm/virtual/tex_fix-cm.sty_ rpm/virtual/tex_fixltx2e.sty_ rpm/virtual/tex_flafter.sty_ rpm/virtual/tex_fontenc.sty_ rpm/virtual/tex_ifthen.sty_ rpm/virtual/tex_inputenc.sty_ rpm/virtual/tex_latexsym.sty_ rpm/virtual/tex_makeidx.sty_ rpm/virtual/tex_oldlfont.sty_ rpm/virtual/tex_shortvrb.sty_ rpm/virtual/tex_t1cmr.fd_ rpm/virtual/tex_textcomp.sty_ rpm/virtual/texlive-latex"
