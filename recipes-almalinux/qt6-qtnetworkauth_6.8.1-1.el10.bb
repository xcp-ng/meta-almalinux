# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtnetworkauth"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtnetworkauth \
 qt6-qtnetworkauth-devel \
 qt6-qtnetworkauth-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtnetworkauth-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26a5e57bd1bbf59838eea56332bcebef2480525bc4909b7dc68b49c1d7658b83"

URI_x86_64_v2_qt6-qtnetworkauth = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtnetworkauth-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtnetworkauth}"
SRC_URI[x86_64_v2_qt6-qtnetworkauth.sha256sum] = "c9e45a08296d1240d099909e542c39638768f5c5047799f1cccfaa9de2d609f3"

URI_x86_64_v2_qt6-qtnetworkauth-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtnetworkauth-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtnetworkauth-devel}"
SRC_URI[x86_64_v2_qt6-qtnetworkauth-devel.sha256sum] = "93501edc55928abc00da9824a02d1b48c0b15549e2f90664e09057bcd8bdc27c"

URI_x86_64_v2_qt6-qtnetworkauth-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtnetworkauth-examples-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtnetworkauth-examples}"
SRC_URI[x86_64_v2_qt6-qtnetworkauth-examples.sha256sum] = "529f8c41effe97d4234cc8d15ad3b64d8c526fa808cc0fa0dcf93e50f93569a3"

URI_aarch64_qt6-qtnetworkauth = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtnetworkauth-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtnetworkauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtnetworkauth}"
SRC_URI[aarch64_qt6-qtnetworkauth.sha256sum] = "0b8d409aae5be3cc1c5de0e0823539c97aa814eef45aa07ec2a1344aeea1ce69"

URI_aarch64_qt6-qtnetworkauth-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtnetworkauth-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtnetworkauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtnetworkauth-devel}"
SRC_URI[aarch64_qt6-qtnetworkauth-devel.sha256sum] = "a80c63f79332217845fdd97307470581e75cd9d7586a4401bd4007d11f196c18"

URI_aarch64_qt6-qtnetworkauth-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtnetworkauth-examples-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtnetworkauth-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtnetworkauth-examples}"
SRC_URI[aarch64_qt6-qtnetworkauth-examples.sha256sum] = "8ac1a538bebe0832714c30e5b44b33a7042411076a9eac0ada049688fbd36b77"

RDEPENDS:qt6-qtnetworkauth = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:qt6-qtnetworkauth-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtnetworkauth \
 "
RDEPENDS:qt6-qtnetworkauth-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtnetworkauth \
 "
