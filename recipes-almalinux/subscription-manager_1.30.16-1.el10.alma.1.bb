# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "subscription-manager"
PV = "1.30.16"
PR = "1.el10.alma.1"
PACKAGES = " \
 libdnf-plugin-subscription-manager \
 python3-cloud-what \
 python3-subscription-manager-rhsm \
 subscription-manager \
 subscription-manager-plugin-ostree \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/subscription-manager-1.30.16-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c748f50cbb338817ccb4d1ef1f7014ce620ea96ff7c81b268f9e276f1d6d1f1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdnf-plugin-subscription-manager-1.30.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI[x86_64_v2_libdnf-plugin-subscription-manager.sha256sum] = "72d87902913b6e88bf76e44ae127a5d3f38c9519688a620b232d6008a94ab193"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-cloud-what-1.30.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-cloud-what;unpack=0"
SRC_URI[x86_64_v2_python3-cloud-what.sha256sum] = "08cd132ac381403f997f9d0bae49ae130c27e045760b1725886e04593101b028"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-subscription-manager-rhsm-1.30.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-subscription-manager-rhsm;unpack=0"
SRC_URI[x86_64_v2_python3-subscription-manager-rhsm.sha256sum] = "80dab6ff5e60823f10b7308ffbec078ac6f8c716a9f830502e5edd525beebeb3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-1.30.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager;unpack=0"
SRC_URI[x86_64_v2_subscription-manager.sha256sum] = "c1fcbb3dd92771e9a0cf636e1af03d8763f77341daab61ddcb5b97d1fcbda0a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-plugin-ostree-1.30.16-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager-plugin-ostree;unpack=0"
SRC_URI[x86_64_v2_subscription-manager-plugin-ostree.sha256sum] = "81bc8697dcccdea7680dbcee3b0d9aa5820ad6b9048c43a34f6f816c86d5f4db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdnf-plugin-subscription-manager-1.30.16-1.el10.alma.1.aarch64.rpm;name=aarch64_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI[aarch64_libdnf-plugin-subscription-manager.sha256sum] = "287820296a2bd5b05eb738ca2b6f00ea579afccf23274c403b7ee25419ba0746"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-cloud-what-1.30.16-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-cloud-what;unpack=0"
SRC_URI[aarch64_python3-cloud-what.sha256sum] = "0974a68e561a56c8d759a7fc70fe04b489223a2678bf67c46797f9c9ad71a954"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-subscription-manager-rhsm-1.30.16-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-subscription-manager-rhsm;unpack=0"
SRC_URI[aarch64_python3-subscription-manager-rhsm.sha256sum] = "ee3461259f58e6d2c2fb2b917bfb58bc7aab3005117d078fbfcf26f8243efac3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-1.30.16-1.el10.alma.1.aarch64.rpm;name=aarch64_subscription-manager;unpack=0"
SRC_URI[aarch64_subscription-manager.sha256sum] = "5ddeac5821274897c8762ce9d44a8ef93c27009473b9ebf3be5f3b947c5f14cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-plugin-ostree-1.30.16-1.el10.alma.1.aarch64.rpm;name=aarch64_subscription-manager-plugin-ostree;unpack=0"
SRC_URI[aarch64_subscription-manager-plugin-ostree.sha256sum] = "74eb3d1ae4d3c53fc3177fe61f3743eac658b8a2374dda39ce758a4c8c4bec04"

RDEPENDS:libdnf-plugin-subscription-manager = " \
 glib2 \
 glibc \
 json-c \
 libdnf \
 librepo \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-cloud-what = " \
 dmidecode \
 python3 \
 python3-requests \
 "
RDEPENDS:python3-subscription-manager-rhsm = " \
 glibc \
 openssl-libs \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-iniparse \
 python3-rpm \
 subscription-manager-rhsm-certificates \
 "
RDEPENDS:subscription-manager = " \
 bash \
 dmidecode \
 findutils \
 glib2 \
 glibc \
 iproute \
 libdnf-plugin-subscription-manager \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-dbus \
 python3-decorator \
 python3-dnf \
 python3-dnf-plugins-core \
 python3-gobject-base \
 python3-iniparse \
 python3-inotify \
 python3-librepo \
 python3-subscription-manager-rhsm \
 subscription-manager-rhsm-certificates \
 systemd \
 virt-what \
 "
RDEPENDS:subscription-manager-plugin-ostree = " \
 python3 \
 python3-gobject-base \
 python3-iniparse \
 subscription-manager \
 "
