# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-guice"
PV = "5.1.0"
PR = "12.el10"
PACKAGES = " \
 google-guice \
 google-guice-javadoc \
 guice-assistedinject \
 guice-bom \
 guice-extensions \
 guice-grapher \
 guice-jmx \
 guice-jndi \
 guice-parent \
 guice-servlet \
 guice-throwingproviders \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/google-guice-5.1.0-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "338f7924402fdc7d8b7c8c1b0d410deb92177bcc91b494d1077ec8e0ab6c1e69"

URI_x86_64_v2_google-guice = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-guice-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_google-guice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-guice}"
SRC_URI[x86_64_v2_google-guice.sha256sum] = "b9827f1885fac78374f7ef1a978df278b753bf938050dc10662129c6de112f62"

URI_x86_64_v2_google-guice-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/google-guice-javadoc-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_google-guice-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-guice-javadoc}"
SRC_URI[x86_64_v2_google-guice-javadoc.sha256sum] = "41350471753ef1706451c6d07db7f821a0c9d7511b797ec2304e07294344dcc6"

URI_x86_64_v2_guice-assistedinject = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guice-assistedinject-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_guice-assistedinject;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guice-assistedinject}"
SRC_URI[x86_64_v2_guice-assistedinject.sha256sum] = "16cd8954cc9a6ae40f021fb1404ca5c181e93177b3c0b08ca3628f546445c1ab"

URI_x86_64_v2_guice-bom = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guice-bom-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_guice-bom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guice-bom}"
SRC_URI[x86_64_v2_guice-bom.sha256sum] = "925d047a2c1df6c5446b6b27997a07959e38debf5c30b240c59d4cfef5c3f140"

URI_x86_64_v2_guice-extensions = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guice-extensions-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_guice-extensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guice-extensions}"
SRC_URI[x86_64_v2_guice-extensions.sha256sum] = "214e0a8fcba224fe8f9f797531e62de1200052982aeedcccfb76e282e80d952a"

URI_x86_64_v2_guice-grapher = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guice-grapher-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_guice-grapher;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guice-grapher}"
SRC_URI[x86_64_v2_guice-grapher.sha256sum] = "282c6f1bdbd7d98af9f815621dd609f6a05c3e63ee9f54c5d02e78d761c5ddae"

URI_x86_64_v2_guice-jmx = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guice-jmx-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_guice-jmx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guice-jmx}"
SRC_URI[x86_64_v2_guice-jmx.sha256sum] = "b86f0c12a14aa18861e23f3fa5892ed50db67d43c7d1a6969bd7a6f1ea456f5a"

URI_x86_64_v2_guice-jndi = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guice-jndi-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_guice-jndi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guice-jndi}"
SRC_URI[x86_64_v2_guice-jndi.sha256sum] = "fe508b9c7e888ef95606e645a9ef4ec9d68978a8df467b06430e410f0d7736b9"

URI_x86_64_v2_guice-parent = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guice-parent-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_guice-parent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guice-parent}"
SRC_URI[x86_64_v2_guice-parent.sha256sum] = "794b9eb338249b47d54108e9119ef967d30f6f6ec2822c50e5dbbf035486b32c"

URI_x86_64_v2_guice-servlet = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guice-servlet-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_guice-servlet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guice-servlet}"
SRC_URI[x86_64_v2_guice-servlet.sha256sum] = "1be0aa5ef4685983bff3be8eefabf6d32ad6b203417fb38cadfba14b8beb94b6"

URI_x86_64_v2_guice-throwingproviders = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/guice-throwingproviders-5.1.0-12.el10.noarch.rpm;name=x86_64_v2_guice-throwingproviders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_guice-throwingproviders}"
SRC_URI[x86_64_v2_guice-throwingproviders.sha256sum] = "52020f784d2fe56e67431b62f4ac72ac0af6684a4016711652a1d50b2162e92b"

URI_aarch64_google-guice = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-guice-5.1.0-12.el10.noarch.rpm;name=aarch64_google-guice;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-guice}"
SRC_URI[aarch64_google-guice.sha256sum] = "b9827f1885fac78374f7ef1a978df278b753bf938050dc10662129c6de112f62"

URI_aarch64_google-guice-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/google-guice-javadoc-5.1.0-12.el10.noarch.rpm;name=aarch64_google-guice-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-guice-javadoc}"
SRC_URI[aarch64_google-guice-javadoc.sha256sum] = "41350471753ef1706451c6d07db7f821a0c9d7511b797ec2304e07294344dcc6"

URI_aarch64_guice-assistedinject = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guice-assistedinject-5.1.0-12.el10.noarch.rpm;name=aarch64_guice-assistedinject;unpack=0"
SRC_URI:append = " ${URI_aarch64_guice-assistedinject}"
SRC_URI[aarch64_guice-assistedinject.sha256sum] = "16cd8954cc9a6ae40f021fb1404ca5c181e93177b3c0b08ca3628f546445c1ab"

URI_aarch64_guice-bom = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guice-bom-5.1.0-12.el10.noarch.rpm;name=aarch64_guice-bom;unpack=0"
SRC_URI:append = " ${URI_aarch64_guice-bom}"
SRC_URI[aarch64_guice-bom.sha256sum] = "925d047a2c1df6c5446b6b27997a07959e38debf5c30b240c59d4cfef5c3f140"

URI_aarch64_guice-extensions = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guice-extensions-5.1.0-12.el10.noarch.rpm;name=aarch64_guice-extensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_guice-extensions}"
SRC_URI[aarch64_guice-extensions.sha256sum] = "214e0a8fcba224fe8f9f797531e62de1200052982aeedcccfb76e282e80d952a"

URI_aarch64_guice-grapher = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guice-grapher-5.1.0-12.el10.noarch.rpm;name=aarch64_guice-grapher;unpack=0"
SRC_URI:append = " ${URI_aarch64_guice-grapher}"
SRC_URI[aarch64_guice-grapher.sha256sum] = "282c6f1bdbd7d98af9f815621dd609f6a05c3e63ee9f54c5d02e78d761c5ddae"

URI_aarch64_guice-jmx = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guice-jmx-5.1.0-12.el10.noarch.rpm;name=aarch64_guice-jmx;unpack=0"
SRC_URI:append = " ${URI_aarch64_guice-jmx}"
SRC_URI[aarch64_guice-jmx.sha256sum] = "b86f0c12a14aa18861e23f3fa5892ed50db67d43c7d1a6969bd7a6f1ea456f5a"

URI_aarch64_guice-jndi = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guice-jndi-5.1.0-12.el10.noarch.rpm;name=aarch64_guice-jndi;unpack=0"
SRC_URI:append = " ${URI_aarch64_guice-jndi}"
SRC_URI[aarch64_guice-jndi.sha256sum] = "fe508b9c7e888ef95606e645a9ef4ec9d68978a8df467b06430e410f0d7736b9"

URI_aarch64_guice-parent = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guice-parent-5.1.0-12.el10.noarch.rpm;name=aarch64_guice-parent;unpack=0"
SRC_URI:append = " ${URI_aarch64_guice-parent}"
SRC_URI[aarch64_guice-parent.sha256sum] = "794b9eb338249b47d54108e9119ef967d30f6f6ec2822c50e5dbbf035486b32c"

URI_aarch64_guice-servlet = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guice-servlet-5.1.0-12.el10.noarch.rpm;name=aarch64_guice-servlet;unpack=0"
SRC_URI:append = " ${URI_aarch64_guice-servlet}"
SRC_URI[aarch64_guice-servlet.sha256sum] = "1be0aa5ef4685983bff3be8eefabf6d32ad6b203417fb38cadfba14b8beb94b6"

URI_aarch64_guice-throwingproviders = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/guice-throwingproviders-5.1.0-12.el10.noarch.rpm;name=aarch64_guice-throwingproviders;unpack=0"
SRC_URI:append = " ${URI_aarch64_guice-throwingproviders}"
SRC_URI[aarch64_guice-throwingproviders.sha256sum] = "52020f784d2fe56e67431b62f4ac72ac0af6684a4016711652a1d50b2162e92b"

RDEPENDS:google-guice = " \
 aopalliance \
 atinject \
 guava \
 javapackages-filesystem \
 "
RDEPENDS:google-guice-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:guice-assistedinject = " \
 google-guice \
 javapackages-filesystem \
 "
RDEPENDS:guice-bom = " \
 guice-parent \
 javapackages-filesystem \
 "
RDEPENDS:guice-extensions = " \
 google-guice \
 guice-parent \
 javapackages-filesystem \
 maven-bundle-plugin \
 maven-remote-resources-plugin \
 maven-source-plugin \
 "
RDEPENDS:guice-grapher = " \
 google-guice \
 guice-assistedinject \
 javapackages-filesystem \
 "
RDEPENDS:guice-jmx = " \
 google-guice \
 javapackages-filesystem \
 "
RDEPENDS:guice-jndi = " \
 google-guice \
 javapackages-filesystem \
 "
RDEPENDS:guice-parent = " \
 javapackages-filesystem \
 "
RDEPENDS:guice-servlet = " \
 google-guice \
 javapackages-filesystem \
 "
RDEPENDS:guice-throwingproviders = " \
 google-guice \
 javapackages-filesystem \
 jsr-305 \
 "
