# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DateTime-TimeZone-Tzfile"
PV = "0.011"
PR = "18.el10_0"
PACKAGES = " \
 perl-DateTime-TimeZone-Tzfile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-DateTime-TimeZone-Tzfile-0.011-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5558015e73b224b4fa93351237f2e37178ab69272dd3cb7d6954f47311a14c1b"

URI_x86_64_v2_perl-DateTime-TimeZone-Tzfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DateTime-TimeZone-Tzfile-0.011-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-DateTime-TimeZone-Tzfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DateTime-TimeZone-Tzfile}"
SRC_URI[x86_64_v2_perl-DateTime-TimeZone-Tzfile.sha256sum] = "599efc742410955a909ff5344233432d1d9bff524bd2353357d3106c67c364fd"

URI_aarch64_perl-DateTime-TimeZone-Tzfile = "${EPEL_MIRROR}/aarch64/Packages/p/perl-DateTime-TimeZone-Tzfile-0.011-18.el10_0.noarch.rpm;name=aarch64_perl-DateTime-TimeZone-Tzfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DateTime-TimeZone-Tzfile}"
SRC_URI[aarch64_perl-DateTime-TimeZone-Tzfile.sha256sum] = "b6ebb468ddc7cd860383cfe1d58b250b3efe87431840c85bb5b95b6ccaead6cb"

RDEPENDS:perl-DateTime-TimeZone-Tzfile = " \
 perl-Carp \
 perl-Date-ISO8601 \
 perl-DateTime-TimeZone-SystemV \
 perl-IO \
 perl-Params-Classify \
 perl-libs \
 "
