# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-apcu"
PV = "5.1.23"
PR = "5.el10"
PACKAGES = " \
 apcu-panel \
 php-pecl-apcu \
 php-pecl-apcu-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php-pecl-apcu-5.1.23-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1f3a52b12e201dead9175aed0cbf2094e1e66e323415e3977d6a34e4d2164e6"

URI_x86_64_v2_apcu-panel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apcu-panel-5.1.23-5.el10.noarch.rpm;name=x86_64_v2_apcu-panel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apcu-panel}"
SRC_URI[x86_64_v2_apcu-panel.sha256sum] = "dc011fa8715dac1a5cc4dfaba16e0f95af4f672eb37adfbaecde0323f78c00de"

URI_x86_64_v2_php-pecl-apcu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pecl-apcu-5.1.23-5.el10.x86_64_v2.rpm;name=x86_64_v2_php-pecl-apcu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-apcu}"
SRC_URI[x86_64_v2_php-pecl-apcu.sha256sum] = "7e39ff5637a593b8f6c9a2bb615b2a16e5c474e4db56b293006ba2b4f747d1e0"

URI_x86_64_v2_php-pecl-apcu-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pecl-apcu-devel-5.1.23-5.el10.x86_64_v2.rpm;name=x86_64_v2_php-pecl-apcu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-apcu-devel}"
SRC_URI[x86_64_v2_php-pecl-apcu-devel.sha256sum] = "54d80119b80fef847a52d74a128351cd707d465f0b83ebac7653d0e655c722d0"

URI_aarch64_apcu-panel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apcu-panel-5.1.23-5.el10.noarch.rpm;name=aarch64_apcu-panel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apcu-panel}"
SRC_URI[aarch64_apcu-panel.sha256sum] = "dc011fa8715dac1a5cc4dfaba16e0f95af4f672eb37adfbaecde0323f78c00de"

URI_aarch64_php-pecl-apcu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pecl-apcu-5.1.23-5.el10.aarch64.rpm;name=aarch64_php-pecl-apcu;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-apcu}"
SRC_URI[aarch64_php-pecl-apcu.sha256sum] = "c77ead3fac957f1e14191addd681e55f71b0507a5d43fb349133d05dd08c923b"

URI_aarch64_php-pecl-apcu-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pecl-apcu-devel-5.1.23-5.el10.aarch64.rpm;name=aarch64_php-pecl-apcu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-apcu-devel}"
SRC_URI[aarch64_php-pecl-apcu-devel.sha256sum] = "29fef407be5ea055707de6ca5d9ac09385a6ee2dc51ca3f2cda32ed213fdcaf5"

RDEPENDS:apcu-panel = " \
 httpd \
 php-fpm \
 php-gd \
 php-pecl-apcu \
 "
RDEPENDS:php-pecl-apcu = " \
 glibc \
 php-common \
 "
RDEPENDS:php-pecl-apcu-devel = " \
 php-devel \
 php-pecl-apcu \
 "
