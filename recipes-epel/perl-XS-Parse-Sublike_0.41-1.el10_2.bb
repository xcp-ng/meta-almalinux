# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XS-Parse-Sublike"
PV = "0.41"
PR = "1.el10_2"
PACKAGES = " \
 perl-XS-Parse-Sublike \
 perl-XS-Parse-Sublike-Builder \
 perl-XS-Parse-Sublike-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XS-Parse-Sublike-0.41-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d0bed04dc68365499a9f22c00aa3ac34e01c11c248091c9b893bc002cd18e6c"

URI_x86_64_v2_perl-XS-Parse-Sublike = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Sublike-0.41-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Sublike;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Sublike}"
SRC_URI[x86_64_v2_perl-XS-Parse-Sublike.sha256sum] = "1616694947364e30fe851a8c6ca4ba8e37b7d0588126f270240de522ef9a2d07"

URI_x86_64_v2_perl-XS-Parse-Sublike-Builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Sublike-Builder-0.41-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Sublike-Builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Sublike-Builder}"
SRC_URI[x86_64_v2_perl-XS-Parse-Sublike-Builder.sha256sum] = "abe382fb725f5ff626f02751cc906ec0905ec450ae23c215dfe543bb9059dce2"

URI_x86_64_v2_perl-XS-Parse-Sublike-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Sublike-tests-0.41-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Sublike-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Sublike-tests}"
SRC_URI[x86_64_v2_perl-XS-Parse-Sublike-tests.sha256sum] = "82c7d7ae033afc90b5177428982b787e0c1b895dbad988f6655beded5e3c1836"

URI_aarch64_perl-XS-Parse-Sublike = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Sublike-0.41-1.el10_2.aarch64.rpm;name=aarch64_perl-XS-Parse-Sublike;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Sublike}"
SRC_URI[aarch64_perl-XS-Parse-Sublike.sha256sum] = "db36a2eed3f5c05822b7251f5f2071698f60c33be2a350d0fa85a9483b0aac3b"

URI_aarch64_perl-XS-Parse-Sublike-Builder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Sublike-Builder-0.41-1.el10_2.aarch64.rpm;name=aarch64_perl-XS-Parse-Sublike-Builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Sublike-Builder}"
SRC_URI[aarch64_perl-XS-Parse-Sublike-Builder.sha256sum] = "c67d4ff63cb5c44f28f6ae4e8c149e188b25fc2125dbd2384d208ee75c92eb87"

URI_aarch64_perl-XS-Parse-Sublike-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Sublike-tests-0.41-1.el10_2.aarch64.rpm;name=aarch64_perl-XS-Parse-Sublike-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Sublike-tests}"
SRC_URI[aarch64_perl-XS-Parse-Sublike-tests.sha256sum] = "8242d4ee49c950af488a9f64752867d9693697e0fc456d6ec60e374a7c934346"

RDEPENDS:perl-XS-Parse-Sublike = " \
 glibc \
 perl-Carp \
 perl-XS-Parse-Sublike \
 perl-libs \
 "
RDEPENDS:perl-XS-Parse-Sublike-Builder = " \
 perl-File-ShareDir \
 perl-PathTools \
 perl-XS-Parse-Sublike \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-XS-Parse-Sublike-tests = " \
 bash \
 glibc \
 perl-B \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-XS-Parse-Sublike \
 perl-interpreter \
 perl-lib \
 perl-libs \
 "
