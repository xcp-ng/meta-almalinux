# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-affine"
PV = "2.4.0"
PR = "9.el10_1"
PACKAGES = " \
 python3-affine \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-affine-2.4.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d786f3e9d9adfd112d6222e27962ead0e7bd55bea89be9d87f7bb8d5940e05a"

URI_x86_64_v2_python3-affine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-affine-2.4.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-affine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-affine}"
SRC_URI[x86_64_v2_python3-affine.sha256sum] = "e79ae568499aa4cb3ee76d5b6ef89a05af14c5f45de88637552ccfd9655e4e86"

URI_aarch64_python3-affine = "${EPEL_MIRROR}/aarch64/Packages/p/python3-affine-2.4.0-9.el10_1.noarch.rpm;name=aarch64_python3-affine;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-affine}"
SRC_URI[aarch64_python3-affine.sha256sum] = "4f84b2b057eb54c85af4511b4c7bac88b897928c4cfdc1a396d91b528bbb80bf"

RDEPENDS:python3-affine = " \
 python3 \
 "
