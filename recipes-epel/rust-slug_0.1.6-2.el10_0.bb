# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-slug"
PV = "0.1.6"
PR = "2.el10_0"
PACKAGES = " \
 rust-slug+default-devel \
 rust-slug-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-slug-0.1.6-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54a5e3099166ea288a0615759637ae97d2115665ad6780559c167c96a82cf079"

URI_x86_64_v2_rust-slug+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slug+default-devel-0.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slug+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slug+default-devel}"
SRC_URI[x86_64_v2_rust-slug+default-devel.sha256sum] = "20380bf6709655f224e4ad1710d5a356e2d218eae6e3e39d40525bba5584cbc0"

URI_x86_64_v2_rust-slug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-slug-devel-0.1.6-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-slug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-slug-devel}"
SRC_URI[x86_64_v2_rust-slug-devel.sha256sum] = "a3d1e103c3c75bfad95705424a82c7c764194e0b0b3a461145c503b75d0118db"

URI_aarch64_rust-slug+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slug+default-devel-0.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-slug+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slug+default-devel}"
SRC_URI[aarch64_rust-slug+default-devel.sha256sum] = "522dec74c364d642624fd2d93e25da47104bbf171e8623073072936bc71a1fa4"

URI_aarch64_rust-slug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-slug-devel-0.1.6-2.el10_0.noarch.rpm;name=aarch64_rust-slug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-slug-devel}"
SRC_URI[aarch64_rust-slug-devel.sha256sum] = "20cff14f4a2fd5d0e6abe3a7f4b2347b6a3aea88837b0ac147c29d99e83de2ed"

RDEPENDS:rust-slug+default-devel = " \
 cargo \
 rust-slug-devel \
 "
RDEPENDS:rust-slug-devel = " \
 cargo \
 rust-deunicode+default-devel \
 "
