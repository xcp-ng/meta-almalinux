# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Business-ISBN"
PV = "3.014"
PR = "2.el10_3"
PACKAGES = " \
 perl-Business-ISBN \
 perl-Business-ISBN-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Business-ISBN-3.014-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3ee511a1943f24b73fc595f1c2426895552ec2ec8f96eea478188bc0ae279daa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISBN-3.014-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISBN;unpack=0"
SRC_URI[x86_64_v2_perl-Business-ISBN.sha256sum] = "57e4db2b152f76edbea217dc221b9179e0bb32bddd4a67e00c754b5619f0fc11"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Business-ISBN-tests-3.014-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Business-ISBN-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Business-ISBN-tests.sha256sum] = "3e5494e76809bc0d276b88ddd0c15d42e2dc413ca70fce488c2fe9104ef8c674"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISBN-3.014-2.el10_3.noarch.rpm;name=aarch64_perl-Business-ISBN;unpack=0"
SRC_URI[aarch64_perl-Business-ISBN.sha256sum] = "b23839dd21236cf0f24bba70a7c7c9f2bbc4dcf2d7b65f1e4eda9ac3849cf1ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Business-ISBN-tests-3.014-2.el10_3.noarch.rpm;name=aarch64_perl-Business-ISBN-tests;unpack=0"
SRC_URI[aarch64_perl-Business-ISBN-tests.sha256sum] = "8b86d0dc856ac06cc3b46510a4c2ae8fba8e6119f4dacc15b47cbddc15568ee9"

RDEPENDS:perl-Business-ISBN = " \
 perl-Business-ISBN \
 perl-Business-ISBN-Data \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-subs \
 perl-vars \
 "
RDEPENDS:perl-Business-ISBN-tests = " \
 bash \
 perl-Business-ISBN \
 perl-Data-Dumper \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
