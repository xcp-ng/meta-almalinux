# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libva-nvidia-driver"
PV = "0.0.17"
PR = "1.el10_3"
PACKAGES = " \
 libva-nvidia-driver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libva-nvidia-driver-0.0.17-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cce80b4a8286d794ef19e480df97f9c0ffb4e0421aee4a73e80b8e5c55451af7"

URI_x86_64_v2_libva-nvidia-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libva-nvidia-driver-0.0.17-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libva-nvidia-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libva-nvidia-driver}"
SRC_URI[x86_64_v2_libva-nvidia-driver.sha256sum] = "dd84643b0498da6306b47e384ec5b91035d32e50e710247873e9353fb64d3826"

URI_aarch64_libva-nvidia-driver = "${EPEL_MIRROR}/aarch64/Packages/l/libva-nvidia-driver-0.0.17-1.el10_3.aarch64.rpm;name=aarch64_libva-nvidia-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_libva-nvidia-driver}"
SRC_URI[aarch64_libva-nvidia-driver.sha256sum] = "29c7a9ca6c5f648fdbf2d53be72d0a48a2422319557e6170dac933ed910280b0"

RDEPENDS:libva-nvidia-driver = " \
 glibc \
 gstreamer1-plugins-bad-free-libs \
 libglvnd-egl \
 "
