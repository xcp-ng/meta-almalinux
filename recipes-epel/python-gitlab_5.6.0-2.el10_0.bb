# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gitlab"
PV = "5.6.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-gitlab \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gitlab-5.6.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22d30b2a9bf83e0f3cd9fe14fa126eafdf42310c881b97712598b2fe8d5893a4"

URI_aarch64_python3-gitlab = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gitlab-5.6.0-2.el10_0.noarch.rpm;name=aarch64_python3-gitlab;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gitlab}"
SRC_URI[aarch64_python3-gitlab.sha256sum] = "81184f59dcf612e5478046636c02f648a5fa0ef895927a65151f2c6f4f2603ad"

RDEPENDS:python3-gitlab = " \
 python3 \
 python3-requests \
 python3-requests-toolbelt \
 "
