# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unicode-width"
PV = "0.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-unicode-width+cjk-devel \
 rust-unicode-width+default-devel \
 rust-unicode-width+no_std-devel \
 rust-unicode-width-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-unicode-width-0.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "da993a6fbc3daed3d9ad159bdbb67488853bd7288ee520ac9d1afb88160df81a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width+cjk-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width+cjk-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-width+cjk-devel.sha256sum] = "b8a75a1349b5141cffb5fb0cad79e0536fbfda7e07e5ce300d59e86f725b4ac5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width+default-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-width+default-devel.sha256sum] = "10c68d3c53ed23f8bec88ee1fe80b21c6f749c403916b67f1391f88e14a77ef4"
RPROVIDES:rust-unicode-width+default-devel:append:x86_64_v2 = " virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~ virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width+no_std-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width+no_std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-width+no_std-devel.sha256sum] = "8fbcf3844db13b972eaa214a251118d5c19fbf2bd536eb691e44d53c0c917577"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unicode-width-devel-0.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unicode-width-devel;unpack=0"
SRC_URI[x86_64_v2_rust-unicode-width-devel.sha256sum] = "cb50470505efc11d92d3bc9202059931908d4f0f3556215a223c3fb68ff90ce6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width+cjk-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-width+cjk-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-width+cjk-devel.sha256sum] = "955e3d3fc4c8a10c89179045f4045c58cc1e0a1d849809fae2168a6f9e6bab7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width+default-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-width+default-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-width+default-devel.sha256sum] = "cc0fd28416e54571e18b550a3ab7caf2f9bd678c9ba014ee71f65a1c62d3be9d"
RPROVIDES:rust-unicode-width+default-devel:append:aarch64 = " virtual/crate_unicode-width/default__ge_0.0.0_with_crate_unicode-width/default__lt_1.0.0~ virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width+no_std-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-width+no_std-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-width+no_std-devel.sha256sum] = "5fe8cfb8f81a34975382647f6c89c9148f4130c1af66024c3b3fa09e94d344d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-unicode-width-devel-0.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-unicode-width-devel;unpack=0"
SRC_URI[aarch64_rust-unicode-width-devel.sha256sum] = "846b80a040a7d933955d347588b77925f97d1578124665bdcbee6b6a8c02a7cb"

RDEPENDS:rust-unicode-width+cjk-devel = " \
 cargo \
 rust-unicode-width-devel \
 "
RDEPENDS:rust-unicode-width+default-devel = " \
 cargo \
 rust-unicode-width+cjk-devel \
 rust-unicode-width-devel \
 "
RDEPENDS:rust-unicode-width+no_std-devel = " \
 cargo \
 rust-unicode-width-devel \
 "
RDEPENDS:rust-unicode-width-devel = " \
 cargo \
 rust \
 "
