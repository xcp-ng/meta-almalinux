# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-bugsnag-panicwrap"
PV = "1.3.4"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-bugsnag-panicwrap-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-bugsnag-panicwrap-1.3.4-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "840bee671fa023349651392eea4e62fc6f1ee26a3663c6bce7f685ce1ae595ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-bugsnag-panicwrap-devel-1.3.4-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-bugsnag-panicwrap-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-bugsnag-panicwrap-devel.sha256sum] = "99897354e3fe5d2877d0fac6382b599e37ec7041edf64b29a034fcc05435b049"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-bugsnag-panicwrap-devel-1.3.4-6.el10_0.noarch.rpm;name=aarch64_golang-github-bugsnag-panicwrap-devel;unpack=0"
SRC_URI[aarch64_golang-github-bugsnag-panicwrap-devel.sha256sum] = "f0cab9f6a2808fa5f9f2b45389bb3a9881f9d19a6d5fa5ca1b8d3f2278c5db3c"

RDEPENDS:golang-github-bugsnag-panicwrap-devel = " \
 go-filesystem \
 "
