# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksmtp"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ksmtp \
 ksmtp-devel \
 ksmtp-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksmtp-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76ea379d7fef7de4a3596fabdc1d9c086f4c353cb2f1ab8bc7219492818eb3e0"

URI_x86_64_v2_ksmtp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp}"
SRC_URI[x86_64_v2_ksmtp.sha256sum] = "a7348ec9dc853ecaf837b16fbc02cc70cf33b0279215eaa462f1bd5cadae0848"

URI_x86_64_v2_ksmtp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksmtp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp-devel}"
SRC_URI[x86_64_v2_ksmtp-devel.sha256sum] = "88cabf66df18cc0da4f557e0125d53eead388deb367ffce04a30aff49d74f0ec"

URI_x86_64_v2_ksmtp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksmtp-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ksmtp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksmtp-doc}"
SRC_URI[x86_64_v2_ksmtp-doc.sha256sum] = "4c18b4d48e2f1e0b4cb72cddfb47e1c024336e680b7e73bc38ba0c4d98230854"

URI_aarch64_ksmtp = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ksmtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp}"
SRC_URI[aarch64_ksmtp.sha256sum] = "f680047896440147ed5990a03e63ed267df4a0091f466cb6f2098a5048362c78"

URI_aarch64_ksmtp-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ksmtp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp-devel}"
SRC_URI[aarch64_ksmtp-devel.sha256sum] = "77ab141de2649b06e7eeb84195562c45bffd13ce4d50661d7df5eca018fdc1f8"

URI_aarch64_ksmtp-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ksmtp-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_ksmtp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksmtp-doc}"
SRC_URI[aarch64_ksmtp-doc.sha256sum] = "a0d218c4626c45ae7238756b6cb0dcd0848cc716dc564bd682302ff53a331855"

RDEPENDS:ksmtp = " \
 cyrus-sasl-lib \
 cyrus-sasl-plain \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ksmtp-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kmime-devel \
 ksmtp \
 "
RDEPENDS:ksmtp-doc = " \
 "
