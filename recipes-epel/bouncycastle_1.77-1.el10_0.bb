# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bouncycastle"
PV = "1.77"
PR = "1.el10_0"
PACKAGES = " \
 bouncycastle \
 bouncycastle-javadoc \
 bouncycastle-jmail \
 bouncycastle-mail \
 bouncycastle-pg \
 bouncycastle-pkix \
 bouncycastle-tls \
 bouncycastle-util \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bouncycastle-1.77-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70de819d9db56eb2b7eeae4ca97f11119910c7bd53271c934f2c9aae80c05306"

URI_x86_64_v2_bouncycastle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bouncycastle-1.77-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bouncycastle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bouncycastle}"
SRC_URI[x86_64_v2_bouncycastle.sha256sum] = "c402f402452041bb60b826638fda7db9eb8f618312c0790ecf19b5e071d9ded0"

URI_x86_64_v2_bouncycastle-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bouncycastle-javadoc-1.77-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bouncycastle-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bouncycastle-javadoc}"
SRC_URI[x86_64_v2_bouncycastle-javadoc.sha256sum] = "d94b2eda9bb84801ea00dc8da36228f5ccaab2bc3eb9b52e6ba496d40262883a"

URI_x86_64_v2_bouncycastle-jmail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bouncycastle-jmail-1.77-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bouncycastle-jmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bouncycastle-jmail}"
SRC_URI[x86_64_v2_bouncycastle-jmail.sha256sum] = "05152d29198c879b624280c80fcac6b88216a02f8b7167dc4ce255e0a326f1ec"

URI_x86_64_v2_bouncycastle-mail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bouncycastle-mail-1.77-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bouncycastle-mail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bouncycastle-mail}"
SRC_URI[x86_64_v2_bouncycastle-mail.sha256sum] = "f602b7a4d5422af1d28465310f95cb469585bc4e01156a5e9e035f076d48298b"

URI_x86_64_v2_bouncycastle-pg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bouncycastle-pg-1.77-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bouncycastle-pg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bouncycastle-pg}"
SRC_URI[x86_64_v2_bouncycastle-pg.sha256sum] = "afbc3d810fcf1e6ccd1ec95729a639fb916f6a85c46c6185b016a6dc930f31a3"

URI_x86_64_v2_bouncycastle-pkix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bouncycastle-pkix-1.77-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bouncycastle-pkix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bouncycastle-pkix}"
SRC_URI[x86_64_v2_bouncycastle-pkix.sha256sum] = "b2c298b0e79aa71a988c2d497cb1e5ae33abd56f725769ebad3561b720ce4c59"

URI_x86_64_v2_bouncycastle-tls = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bouncycastle-tls-1.77-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bouncycastle-tls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bouncycastle-tls}"
SRC_URI[x86_64_v2_bouncycastle-tls.sha256sum] = "3c214d4ef2c2f6f58cdeff415607275771208651af40a754aed65a590a807b8b"

URI_x86_64_v2_bouncycastle-util = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bouncycastle-util-1.77-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bouncycastle-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bouncycastle-util}"
SRC_URI[x86_64_v2_bouncycastle-util.sha256sum] = "4d69e97b57780408391442a7e55cfa52f5688efe3b9356cc5400fdec092a6a4b"

URI_aarch64_bouncycastle = "${EPEL_MIRROR}/aarch64/Packages/b/bouncycastle-1.77-1.el10_0.noarch.rpm;name=aarch64_bouncycastle;unpack=0"
SRC_URI:append = " ${URI_aarch64_bouncycastle}"
SRC_URI[aarch64_bouncycastle.sha256sum] = "2ef3269df043dd8c09881e5ef40c68b17c3c527dbe05b4602e34abfbacd02bb9"

URI_aarch64_bouncycastle-javadoc = "${EPEL_MIRROR}/aarch64/Packages/b/bouncycastle-javadoc-1.77-1.el10_0.noarch.rpm;name=aarch64_bouncycastle-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bouncycastle-javadoc}"
SRC_URI[aarch64_bouncycastle-javadoc.sha256sum] = "f8f96bb575915d09ae79fd342a9bbcec3b6599f06f3eba0bbe7d056901f08a41"

URI_aarch64_bouncycastle-jmail = "${EPEL_MIRROR}/aarch64/Packages/b/bouncycastle-jmail-1.77-1.el10_0.noarch.rpm;name=aarch64_bouncycastle-jmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_bouncycastle-jmail}"
SRC_URI[aarch64_bouncycastle-jmail.sha256sum] = "a238cdf056c785e27a06597cf0c977d4751ca45a6a2bb67cc1b7a5c9259c17a5"

URI_aarch64_bouncycastle-mail = "${EPEL_MIRROR}/aarch64/Packages/b/bouncycastle-mail-1.77-1.el10_0.noarch.rpm;name=aarch64_bouncycastle-mail;unpack=0"
SRC_URI:append = " ${URI_aarch64_bouncycastle-mail}"
SRC_URI[aarch64_bouncycastle-mail.sha256sum] = "221aeda0da9f76bd6e4b96a92030a9d9abc2513ed81adaa23db6dec1ef407b59"

URI_aarch64_bouncycastle-pg = "${EPEL_MIRROR}/aarch64/Packages/b/bouncycastle-pg-1.77-1.el10_0.noarch.rpm;name=aarch64_bouncycastle-pg;unpack=0"
SRC_URI:append = " ${URI_aarch64_bouncycastle-pg}"
SRC_URI[aarch64_bouncycastle-pg.sha256sum] = "eb654ab217628a22d1fa79d8f37ddb48fcaa8d3974827ae1b929b52409ac7054"

URI_aarch64_bouncycastle-pkix = "${EPEL_MIRROR}/aarch64/Packages/b/bouncycastle-pkix-1.77-1.el10_0.noarch.rpm;name=aarch64_bouncycastle-pkix;unpack=0"
SRC_URI:append = " ${URI_aarch64_bouncycastle-pkix}"
SRC_URI[aarch64_bouncycastle-pkix.sha256sum] = "fe798e8e7b2e67204a84771c9f86b389aaf4807dfc6ec9c588afa584d87fd730"

URI_aarch64_bouncycastle-tls = "${EPEL_MIRROR}/aarch64/Packages/b/bouncycastle-tls-1.77-1.el10_0.noarch.rpm;name=aarch64_bouncycastle-tls;unpack=0"
SRC_URI:append = " ${URI_aarch64_bouncycastle-tls}"
SRC_URI[aarch64_bouncycastle-tls.sha256sum] = "7f7caff944177291c1a8c4691bdb479dcfe0f18e46db535af5fb93c18b9ba34f"

URI_aarch64_bouncycastle-util = "${EPEL_MIRROR}/aarch64/Packages/b/bouncycastle-util-1.77-1.el10_0.noarch.rpm;name=aarch64_bouncycastle-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_bouncycastle-util}"
SRC_URI[aarch64_bouncycastle-util.sha256sum] = "91b66c6f9ec07e200e0f02d25f277c3c1878b4e8b4f6f2ac73757e4d33bcb820"

RDEPENDS:bouncycastle = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 "
RDEPENDS:bouncycastle-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:bouncycastle-jmail = " \
 bouncycastle \
 bouncycastle-pkix \
 bouncycastle-util \
 javapackages-filesystem \
 "
RDEPENDS:bouncycastle-mail = " \
 bouncycastle \
 bouncycastle-pkix \
 bouncycastle-util \
 javapackages-filesystem \
 "
RDEPENDS:bouncycastle-pg = " \
 bouncycastle \
 javapackages-filesystem \
 "
RDEPENDS:bouncycastle-pkix = " \
 bouncycastle \
 bouncycastle-util \
 javapackages-filesystem \
 "
RDEPENDS:bouncycastle-tls = " \
 bouncycastle \
 bouncycastle-util \
 javapackages-filesystem \
 "
RDEPENDS:bouncycastle-util = " \
 bouncycastle \
 javapackages-filesystem \
 "
