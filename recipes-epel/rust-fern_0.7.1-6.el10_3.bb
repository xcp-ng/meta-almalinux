# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fern"
PV = "0.7.1"
PR = "6.el10_3"
PACKAGES = " \
 rust-fern+chrono-devel \
 rust-fern+colored-devel \
 rust-fern+date-based-devel \
 rust-fern+default-devel \
 rust-fern+libc-devel \
 rust-fern+meta-logging-in-format-devel \
 rust-fern+syslog-7-devel \
 rust-fern+syslog7-devel \
 rust-fern-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fern-0.7.1-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55e4e03456234e9acba1481aae031fea826512849680f0db9d94a56b97845759"

URI_x86_64_v2_rust-fern+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+chrono-devel-0.7.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+chrono-devel}"
SRC_URI[x86_64_v2_rust-fern+chrono-devel.sha256sum] = "0b363cc0c4eb5971b4f30ac177959931cd07bc2123ded0bd1977a168b7a6dbb3"

URI_x86_64_v2_rust-fern+colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+colored-devel-0.7.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+colored-devel}"
SRC_URI[x86_64_v2_rust-fern+colored-devel.sha256sum] = "0a7d827857312f4e6b7f6230e2a413d03ad527486d5c5c802f395532d94881ff"

URI_x86_64_v2_rust-fern+date-based-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+date-based-devel-0.7.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+date-based-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+date-based-devel}"
SRC_URI[x86_64_v2_rust-fern+date-based-devel.sha256sum] = "81c59f4d0a77756e015d7d9271a8c02daabb50be899e5a1fea52b66a02a28b10"

URI_x86_64_v2_rust-fern+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+default-devel-0.7.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+default-devel}"
SRC_URI[x86_64_v2_rust-fern+default-devel.sha256sum] = "bd48ecdafe21db4927a2c642af3d753c8bb3e4907a08ae13cdfb6f57c150193d"

URI_x86_64_v2_rust-fern+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+libc-devel-0.7.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+libc-devel}"
SRC_URI[x86_64_v2_rust-fern+libc-devel.sha256sum] = "d18d6b230745f4f48b7ebf444375347109a30709fc199713446f3900bcf65249"

URI_x86_64_v2_rust-fern+meta-logging-in-format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+meta-logging-in-format-devel-0.7.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+meta-logging-in-format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+meta-logging-in-format-devel}"
SRC_URI[x86_64_v2_rust-fern+meta-logging-in-format-devel.sha256sum] = "b4db29e8c2886e028e60f1e234bdb0d0d3095c7a0d59bde8c7a44b01e130eb62"

URI_x86_64_v2_rust-fern+syslog-7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+syslog-7-devel-0.7.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+syslog-7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+syslog-7-devel}"
SRC_URI[x86_64_v2_rust-fern+syslog-7-devel.sha256sum] = "7f8745575325064bd9d0fa0fd56ddb7bda320afe7ea8ae0f73dee14fdd1f5d42"

URI_x86_64_v2_rust-fern+syslog7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+syslog7-devel-0.7.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+syslog7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+syslog7-devel}"
SRC_URI[x86_64_v2_rust-fern+syslog7-devel.sha256sum] = "967e8acedc05179bb6f1d96ad9574cfb41713355793490e1412faa4aaece6595"

URI_x86_64_v2_rust-fern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern-devel-0.7.1-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern-devel}"
SRC_URI[x86_64_v2_rust-fern-devel.sha256sum] = "0e0f2df26626a2c3ee677e47143b221e54fa5d2170c0ca82af1035d8185b7e71"

URI_aarch64_rust-fern+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+chrono-devel-0.7.1-6.el10_3.noarch.rpm;name=aarch64_rust-fern+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+chrono-devel}"
SRC_URI[aarch64_rust-fern+chrono-devel.sha256sum] = "0b4e52d0f29ff4d64c7e1c7cce1d802179c810984ab26fe606c9125ca8a2efe9"

URI_aarch64_rust-fern+colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+colored-devel-0.7.1-6.el10_3.noarch.rpm;name=aarch64_rust-fern+colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+colored-devel}"
SRC_URI[aarch64_rust-fern+colored-devel.sha256sum] = "b96e6bfa8dc25669102cc7456c9cbf691341b91cf199a2a0a4f548fa8c1f6c26"

URI_aarch64_rust-fern+date-based-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+date-based-devel-0.7.1-6.el10_3.noarch.rpm;name=aarch64_rust-fern+date-based-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+date-based-devel}"
SRC_URI[aarch64_rust-fern+date-based-devel.sha256sum] = "6b6966fef78f0240fb5edd6d39e7b75e1ac695fdb91b7da3613bb82f445b30d6"

URI_aarch64_rust-fern+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+default-devel-0.7.1-6.el10_3.noarch.rpm;name=aarch64_rust-fern+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+default-devel}"
SRC_URI[aarch64_rust-fern+default-devel.sha256sum] = "844be35623215289c145e4bf18db406d16e8335481f10283e4a4918f80eb9cce"

URI_aarch64_rust-fern+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+libc-devel-0.7.1-6.el10_3.noarch.rpm;name=aarch64_rust-fern+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+libc-devel}"
SRC_URI[aarch64_rust-fern+libc-devel.sha256sum] = "61d61406e2ae8834269860b1413e37c7d387790926f0cf935e079e5cdd7e5334"

URI_aarch64_rust-fern+meta-logging-in-format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+meta-logging-in-format-devel-0.7.1-6.el10_3.noarch.rpm;name=aarch64_rust-fern+meta-logging-in-format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+meta-logging-in-format-devel}"
SRC_URI[aarch64_rust-fern+meta-logging-in-format-devel.sha256sum] = "d78ae18f604d14e2fbd5d922b7c80c44212c9a134441ca3eaee22042238f5d2b"

URI_aarch64_rust-fern+syslog-7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+syslog-7-devel-0.7.1-6.el10_3.noarch.rpm;name=aarch64_rust-fern+syslog-7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+syslog-7-devel}"
SRC_URI[aarch64_rust-fern+syslog-7-devel.sha256sum] = "8f99dd3474e5b57eed16514cddce424cd79cd2f74b1b82a610e49c160fe0dbc3"

URI_aarch64_rust-fern+syslog7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+syslog7-devel-0.7.1-6.el10_3.noarch.rpm;name=aarch64_rust-fern+syslog7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+syslog7-devel}"
SRC_URI[aarch64_rust-fern+syslog7-devel.sha256sum] = "c3e24a788e17e069833eba8394196bf4a8766164ddb94864abedcb0b20047173"

URI_aarch64_rust-fern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern-devel-0.7.1-6.el10_3.noarch.rpm;name=aarch64_rust-fern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern-devel}"
SRC_URI[aarch64_rust-fern-devel.sha256sum] = "76c0f5b38ee140a698a0f65896d596453b51f540a9c393a8449414be3928afb0"

RDEPENDS:rust-fern+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+colored-devel = " \
 cargo \
 rust-colored2+default-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+date-based-devel = " \
 cargo \
 rust-fern+chrono-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+default-devel = " \
 cargo \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+libc-devel = " \
 cargo \
 rust-fern-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-fern+meta-logging-in-format-devel = " \
 cargo \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+syslog-7-devel = " \
 cargo \
 rust-fern+syslog7-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+syslog7-devel = " \
 cargo \
 rust-fern-devel \
 rust-syslog+default-devel \
 "
RDEPENDS:rust-fern-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-log+std-devel \
 "
