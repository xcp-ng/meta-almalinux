# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rcssmin"
PV = "1.2.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-rcssmin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rcssmin-1.2.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5eacd81b489478800fd07864233e377bb7a48e17f7b26e54f6a89fef3234666"

URI_x86_64_v2_python3-rcssmin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rcssmin-1.2.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rcssmin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rcssmin}"
SRC_URI[x86_64_v2_python3-rcssmin.sha256sum] = "85409b58a2bbc42bfcb166e0405209cedc52bd562216fef895041c5152cdf4af"

URI_aarch64_python3-rcssmin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rcssmin-1.2.2-1.el10_1.aarch64.rpm;name=aarch64_python3-rcssmin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rcssmin}"
SRC_URI[aarch64_python3-rcssmin.sha256sum] = "41de60604ecbaecce1a177bd4ff42a53c5e81bf29585e0e4e4ecd14f55587f60"

RDEPENDS:python3-rcssmin = " \
 glibc \
 python3 \
 "
