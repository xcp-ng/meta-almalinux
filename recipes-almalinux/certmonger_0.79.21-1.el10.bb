# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "certmonger"
PV = "0.79.21"
PR = "1.el10"
PACKAGES = " \
 certmonger \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/certmonger-0.79.21-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08c33227ba8c4d45ee36ad49ac0f3128b70a271ffc91ca92ed2702468c6b80e9"

URI_x86_64_v2_certmonger = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/certmonger-0.79.21-1.el10.x86_64_v2.rpm;name=x86_64_v2_certmonger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_certmonger}"
SRC_URI[x86_64_v2_certmonger.sha256sum] = "c31d959b16006c8059c75907c8a9597ae34ecf674083a99e815d38ea6f0dda43"

URI_aarch64_certmonger = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/certmonger-0.79.21-1.el10.aarch64.rpm;name=aarch64_certmonger;unpack=0"
SRC_URI:append = " ${URI_aarch64_certmonger}"
SRC_URI[aarch64_certmonger.sha256sum] = "804e7e9cf3e861d62e7fd45554e34460e43b2a1221317fed18197393f89df26d"

RDEPENDS:certmonger = " \
 bash \
 dbus \
 dbus-libs \
 dbus-tools \
 glibc \
 jansson \
 krb5-libs \
 libcom_err \
 libidn2 \
 libtalloc \
 libtevent \
 libuuid \
 libxml2 \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 popt \
 sed \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
