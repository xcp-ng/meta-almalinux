# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grub2-breeze-theme"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 grub2-breeze-theme \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/grub2-breeze-theme-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8e5fa507559f0daa42b5c44f8edc2952a82dfe44df7c6ad71094de39ed351063"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grub2-breeze-theme-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grub2-breeze-theme;unpack=0"
SRC_URI[x86_64_v2_grub2-breeze-theme.sha256sum] = "5d77f8324ba9c9713adf6b1e950b74236f17ab346151441a883f01edfed64335"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/grub2-breeze-theme-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_grub2-breeze-theme;unpack=0"
SRC_URI[aarch64_grub2-breeze-theme.sha256sum] = "637ff62968614bb79e9e3369e5c2d13df2d32a5883784198e5e86ee471709b98"

RDEPENDS:grub2-breeze-theme:x86_64_v2 = " \
 grub2-pc \
"
RDEPENDS:grub2-breeze-theme:aarch64 = " \
 grub2-efi-aa64 \
"
