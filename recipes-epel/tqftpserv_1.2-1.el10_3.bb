# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tqftpserv"
PV = "1.2"
PR = "1.el10_3"
PACKAGES = " \
 tqftpserv \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tqftpserv-1.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "14b580ff5f9559e9fa624c9d06714661f96095371be3ceaae800efed50aabd30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tqftpserv-1.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tqftpserv;unpack=0"
SRC_URI[x86_64_v2_tqftpserv.sha256sum] = "9320362ed1e69e3db6c54fce40b37e37cdcb5012abbdb009bd7f7d5c33ea3f10"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tqftpserv-1.2-1.el10_3.aarch64.rpm;name=aarch64_tqftpserv;unpack=0"
SRC_URI[aarch64_tqftpserv.sha256sum] = "e9bb3e481c0325cbc294cb9bf124e9b0a4ce1fe6909b3e34c5709e5968aeb11a"

RDEPENDS:tqftpserv = " \
 bash \
 glibc \
 libzstd \
 qrtr-libs \
 "
