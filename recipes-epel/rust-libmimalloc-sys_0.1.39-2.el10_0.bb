# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libmimalloc-sys"
PV = "0.1.39"
PR = "2.el10_0"
PACKAGES = " \
 rust-libmimalloc-sys+arena-devel \
 rust-libmimalloc-sys+cty-devel \
 rust-libmimalloc-sys+debug-devel \
 rust-libmimalloc-sys+debug_in_debug-devel \
 rust-libmimalloc-sys+default-devel \
 rust-libmimalloc-sys+extended-devel \
 rust-libmimalloc-sys+local_dynamic_tls-devel \
 rust-libmimalloc-sys+no_thp-devel \
 rust-libmimalloc-sys+override-devel \
 rust-libmimalloc-sys+secure-devel \
 rust-libmimalloc-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libmimalloc-sys-0.1.39-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5170a03f0777f232df59853dc1ebe650831037195cf7becde4afa79553129f7"

URI_x86_64_v2_rust-libmimalloc-sys+arena-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+arena-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+arena-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+arena-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+arena-devel.sha256sum] = "691975c5783ec14b2b1c3ed54f07521eab7db1a29ddcbe75a2c6c753f8a68d08"

URI_x86_64_v2_rust-libmimalloc-sys+cty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+cty-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+cty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+cty-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+cty-devel.sha256sum] = "6c5ae7e64ca81e4177ddc47f58b19a07f14e6ecb694a0fd41bfd53e8c46a6a53"

URI_x86_64_v2_rust-libmimalloc-sys+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+debug-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+debug-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+debug-devel.sha256sum] = "d84cee630f4a8c8c37ee796a7b3bb975e24679e4ee6250a8f933a70bbeb1b879"

URI_x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+debug_in_debug-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel.sha256sum] = "7a72f57d5f9cb191a480b70d0102c3e3b944b093516572a7a07282b45f7884af"

URI_x86_64_v2_rust-libmimalloc-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+default-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+default-devel.sha256sum] = "26e3d583e0c05bcd5229c7b0f84ea367934eda852661e5dffca018c5e54ea383"

URI_x86_64_v2_rust-libmimalloc-sys+extended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+extended-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+extended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+extended-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+extended-devel.sha256sum] = "dc26e66fcd5a11d4eef40557eba8046c32e561720f6c0d48a2d6b344496e9833"

URI_x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+local_dynamic_tls-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel.sha256sum] = "e6b1ee97b8b4879dbbd9ec7778ad290f247c7a48c2655e098164c514c7c303b7"

URI_x86_64_v2_rust-libmimalloc-sys+no_thp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+no_thp-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+no_thp-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+no_thp-devel.sha256sum] = "3d733ee90cf5791adfa2139a0ef0c96a35501f294bea8ac6daa36830de0789a9"

URI_x86_64_v2_rust-libmimalloc-sys+override-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+override-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+override-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+override-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+override-devel.sha256sum] = "d534f5cee6fe0b46317aa71ab97d97d4995c2c00f3b9203190d0eca64a7bfe58"

URI_x86_64_v2_rust-libmimalloc-sys+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+secure-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+secure-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+secure-devel.sha256sum] = "95d3e8718a494bf4bc5adab2ba0a30d2e44bbe21b1b32b23f684905d70d2e30f"

URI_x86_64_v2_rust-libmimalloc-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys-devel-0.1.39-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys-devel.sha256sum] = "81ac37a47101ecf723d5d6c36baf99c5b2b64706b36b5fcddc618d969cac3a19"

URI_aarch64_rust-libmimalloc-sys+arena-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+arena-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+arena-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+arena-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+arena-devel.sha256sum] = "d2dd53e66a2bc7bd2cc7468a12d0f899049b15eee268a443bf9740e1128d51ac"

URI_aarch64_rust-libmimalloc-sys+cty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+cty-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+cty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+cty-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+cty-devel.sha256sum] = "b9e37412c0c0fa2a66c8820f81315f400d8cdd0be9933729891f83b4bbf8148d"

URI_aarch64_rust-libmimalloc-sys+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+debug-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+debug-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+debug-devel.sha256sum] = "a65bd0532880ef98ea7d7714652d5bdd9ad40c1b7e8776b7af4786d779973be1"

URI_aarch64_rust-libmimalloc-sys+debug_in_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+debug_in_debug-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+debug_in_debug-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+debug_in_debug-devel.sha256sum] = "620935c6f0e995758d5e0381916177781589e56b688cb1ce74fb8d01c8e5b544"

URI_aarch64_rust-libmimalloc-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+default-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+default-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+default-devel.sha256sum] = "f5a03b5cdd4d759f0b72d26b6bb67325e9b9d6b8f2824167d8f0f799afeaad21"

URI_aarch64_rust-libmimalloc-sys+extended-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+extended-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+extended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+extended-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+extended-devel.sha256sum] = "f826d63c6b474bad6398d2cbd56330b30f2833f5b64f0fa1f0d24a534d6e3924"

URI_aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+local_dynamic_tls-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel.sha256sum] = "f7e27f92d29b51a1b320b6643b0571c4231557dff0bd04ae4fc091ce9f7f12a0"

URI_aarch64_rust-libmimalloc-sys+no_thp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+no_thp-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+no_thp-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+no_thp-devel.sha256sum] = "fc38205464f06c5008ba7fae0b5847d64d309cca28baff37707383d10d2829e6"

URI_aarch64_rust-libmimalloc-sys+override-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+override-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+override-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+override-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+override-devel.sha256sum] = "0e316fc06e135ef6e8148fe75cdbeac7dafe9f53b58cdcaabb384e975341395c"

URI_aarch64_rust-libmimalloc-sys+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+secure-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+secure-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+secure-devel.sha256sum] = "63f239cacadf71d368945bd9ee9f4f748bb698d69185a22f84f816089f9ba65b"

URI_aarch64_rust-libmimalloc-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys-devel-0.1.39-2.el10_0.noarch.rpm;name=aarch64_rust-libmimalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys-devel.sha256sum] = "db144c4f22d816e40024a757407727c3438caff06d0aedfbf9d47d5addbd8b49"

RDEPENDS:rust-libmimalloc-sys+arena-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+cty-devel = " \
 cargo \
 rust-cty+default-devel \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+debug-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+debug_in_debug-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+default-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+extended-devel = " \
 cargo \
 rust-libmimalloc-sys+cty-devel \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+local_dynamic_tls-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+no_thp-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+override-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+secure-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-libc+default-devel \
 "
