# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-attribute-derive-macro"
PV = "0.10.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-attribute-derive-macro+default-devel \
 rust-attribute-derive-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-attribute-derive-macro-0.10.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd6e373f729da12035d539575f74e32c34eafdb6785fbd93888eb17d266ba7d8"

URI_x86_64_v2_rust-attribute-derive-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-attribute-derive-macro+default-devel-0.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-attribute-derive-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-attribute-derive-macro+default-devel}"
SRC_URI[x86_64_v2_rust-attribute-derive-macro+default-devel.sha256sum] = "71a2586d2b3dab3129fefa501d40de5a6df98794574665cf470f867c0c8f623b"

URI_x86_64_v2_rust-attribute-derive-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-attribute-derive-macro-devel-0.10.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-attribute-derive-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-attribute-derive-macro-devel}"
SRC_URI[x86_64_v2_rust-attribute-derive-macro-devel.sha256sum] = "a1eed4dab4bce8d15198b314d53124ea3ec58f78912925a1663a0c11d11386b9"

URI_aarch64_rust-attribute-derive-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-attribute-derive-macro+default-devel-0.10.5-1.el10_2.noarch.rpm;name=aarch64_rust-attribute-derive-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-attribute-derive-macro+default-devel}"
SRC_URI[aarch64_rust-attribute-derive-macro+default-devel.sha256sum] = "e89e645529906c22d29998ce3d84b1f4bddb4da9af2511e5d4312b7a6508c503"

URI_aarch64_rust-attribute-derive-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-attribute-derive-macro-devel-0.10.5-1.el10_2.noarch.rpm;name=aarch64_rust-attribute-derive-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-attribute-derive-macro-devel}"
SRC_URI[aarch64_rust-attribute-derive-macro-devel.sha256sum] = "cd4a6b28ac41981522824abadbf58389acfe8b2dc5b358185672e37df1d69891"

RDEPENDS:rust-attribute-derive-macro+default-devel = " \
 cargo \
 rust-attribute-derive-macro-devel \
 "
RDEPENDS:rust-attribute-derive-macro-devel = " \
 cargo \
 rust-collection_literals+default-devel \
 rust-interpolator+default-devel \
 rust-interpolator+iter-devel \
 rust-manyhow+default-devel \
 rust-proc-macro-utils+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-quote-use+default-devel \
 rust-syn2+default-devel \
 "
