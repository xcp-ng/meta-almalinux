# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkg-config"
PV = "0.3.32"
PR = "1.el10_1"
PACKAGES = " \
 rust-pkg-config+default-devel \
 rust-pkg-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pkg-config-0.3.32-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8d2fb814a25d8520b3e174ed34cdf9bfe699895167b0baf8fb4b9117f099a80"

URI_x86_64_v2_rust-pkg-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config+default-devel-0.3.32-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkg-config+default-devel}"
SRC_URI[x86_64_v2_rust-pkg-config+default-devel.sha256sum] = "658635107475272d2b5cf1f300749ded86eae9d4bd22494c698acbeef333beb2"

URI_x86_64_v2_rust-pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkg-config-devel-0.3.32-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkg-config-devel}"
SRC_URI[x86_64_v2_rust-pkg-config-devel.sha256sum] = "b87b505519efde0658d7df46e3cc85d266808c8cdf5f3c46d3edec5d103946f7"

URI_aarch64_rust-pkg-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config+default-devel-0.3.32-1.el10_1.noarch.rpm;name=aarch64_rust-pkg-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkg-config+default-devel}"
SRC_URI[aarch64_rust-pkg-config+default-devel.sha256sum] = "14f0d22f1b98027cf98b841163a0a337c29b202162d50cdc60d522d28d6e63f7"

URI_aarch64_rust-pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkg-config-devel-0.3.32-1.el10_1.noarch.rpm;name=aarch64_rust-pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkg-config-devel}"
SRC_URI[aarch64_rust-pkg-config-devel.sha256sum] = "7659bbd007ed8831f85c021d8a5e00381dac36e6c04617b3e427839c4e209697"

RDEPENDS:rust-pkg-config+default-devel = " \
 cargo \
 rust-pkg-config-devel \
 "
RDEPENDS:rust-pkg-config-devel = " \
 cargo \
 pkgconf-pkg-config \
 rust \
 "
