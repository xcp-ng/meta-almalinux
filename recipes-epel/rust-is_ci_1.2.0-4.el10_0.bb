# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is_ci"
PV = "1.2.0"
PR = "4.el10_0"
PACKAGES = " \
 is_ci \
 rust-is_ci+default-devel \
 rust-is_ci-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is_ci-1.2.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b17c9a12ee8179e9ec60850eff6faecdce9d30979966e8eb73a5f5a2f1406ab9"

URI_x86_64_v2_is_ci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/is_ci-1.2.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_is_ci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_is_ci}"
SRC_URI[x86_64_v2_is_ci.sha256sum] = "a77416a8217bb9ebe5be174c2c4e4c1cf6f000a6efab066f4286fcf14a99bff1"

URI_x86_64_v2_rust-is_ci+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_ci+default-devel-1.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_ci+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_ci+default-devel}"
SRC_URI[x86_64_v2_rust-is_ci+default-devel.sha256sum] = "c25e681f62fcee6265cd18dfa3b9bc29ea7d9cbb799ec90ab0206fe6d28361e7"

URI_x86_64_v2_rust-is_ci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is_ci-devel-1.2.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is_ci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is_ci-devel}"
SRC_URI[x86_64_v2_rust-is_ci-devel.sha256sum] = "38d7048c543d0aa527a69608a0679b6d395b48673b372013d0470e28e24bdca6"

URI_aarch64_is_ci = "${EPEL_MIRROR}/aarch64/Packages/i/is_ci-1.2.0-4.el10_0.aarch64.rpm;name=aarch64_is_ci;unpack=0"
SRC_URI:append = " ${URI_aarch64_is_ci}"
SRC_URI[aarch64_is_ci.sha256sum] = "afb4e56203e14c65f6bc3b68d9099d6abd8feaf1f909c38708d63de85d0c72f5"

URI_aarch64_rust-is_ci+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_ci+default-devel-1.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-is_ci+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_ci+default-devel}"
SRC_URI[aarch64_rust-is_ci+default-devel.sha256sum] = "8be1a93148597d8361b0949dcde3659d058d8ce0109e38e1110992d7edc6afd7"

URI_aarch64_rust-is_ci-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is_ci-devel-1.2.0-4.el10_0.noarch.rpm;name=aarch64_rust-is_ci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is_ci-devel}"
SRC_URI[aarch64_rust-is_ci-devel.sha256sum] = "8e261650e5e112f959282ea8251cecb11276678f15fa34b36270684fd6c19095"

RDEPENDS:is_ci = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-is_ci+default-devel = " \
 cargo \
 rust-is_ci-devel \
 "
RDEPENDS:rust-is_ci-devel = " \
 cargo \
 "
