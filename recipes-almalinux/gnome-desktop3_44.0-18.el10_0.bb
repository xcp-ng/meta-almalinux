# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-desktop3"
PV = "44.0"
PR = "18.el10_0"
PACKAGES = " \
 gnome-desktop3 \
 gnome-desktop3-devel \
 gnome-desktop4 \
 gnome-desktop4-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-desktop3-44.0-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7f9102b6cf6fd8738566f1fd6abd3b9bc44c6653b629bc79c9bb52aaa8d9e41"

URI_x86_64_v2_gnome-desktop3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-desktop3-44.0-18.el10_0.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop3}"
SRC_URI[x86_64_v2_gnome-desktop3.sha256sum] = "f46afaf9718ad81cca79b17ba902ad928bbb7ba5aee6e208cb2ab43ec8c05278"

URI_x86_64_v2_gnome-desktop3-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-desktop3-devel-44.0-18.el10_0.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop3-devel}"
SRC_URI[x86_64_v2_gnome-desktop3-devel.sha256sum] = "ed8a31aa8094c4fa01d30a2756fa68243344e43fd058f10f95011557dc6412d4"

URI_x86_64_v2_gnome-desktop4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-desktop4-44.0-18.el10_0.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop4}"
SRC_URI[x86_64_v2_gnome-desktop4.sha256sum] = "53280de8c1f71a52735297a40ef13efd3094c38408bc22a87fcc8a3f58118e1a"

URI_x86_64_v2_gnome-desktop4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-desktop4-devel-44.0-18.el10_0.x86_64_v2.rpm;name=x86_64_v2_gnome-desktop4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-desktop4-devel}"
SRC_URI[x86_64_v2_gnome-desktop4-devel.sha256sum] = "f24e04950bc0829d27a2659895ff3c28c68c3a3c623a05b0623cd046835e29d3"

URI_aarch64_gnome-desktop3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-desktop3-44.0-18.el10_0.aarch64.rpm;name=aarch64_gnome-desktop3;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop3}"
SRC_URI[aarch64_gnome-desktop3.sha256sum] = "3147ce1c46eaf6e830c7b25ab324949c2a60580a26bd31ae7b38f1d03d5c09d3"

URI_aarch64_gnome-desktop3-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-desktop3-devel-44.0-18.el10_0.aarch64.rpm;name=aarch64_gnome-desktop3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop3-devel}"
SRC_URI[aarch64_gnome-desktop3-devel.sha256sum] = "6bca999ca1e57fb3dbc50cfae94a9d6dbfdb0ca76e54efe4fa705db3d8ab85cb"

URI_aarch64_gnome-desktop4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-desktop4-44.0-18.el10_0.aarch64.rpm;name=aarch64_gnome-desktop4;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop4}"
SRC_URI[aarch64_gnome-desktop4.sha256sum] = "469648a479614850a5fb9b1f44c5e157d9cd723923840e89629867bbf95380fc"

URI_aarch64_gnome-desktop4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-desktop4-devel-44.0-18.el10_0.aarch64.rpm;name=aarch64_gnome-desktop4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-desktop4-devel}"
SRC_URI[aarch64_gnome-desktop4-devel.sha256sum] = "f83c110e0cf13fdeb61b0a104a465c3369725a52d0284975942bfb0ab01524e1"

RDEPENDS:gnome-desktop3 = " \
 bubblewrap \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gsettings-desktop-schemas \
 gtk3 \
 libgcc \
 libseccomp \
 libxkbcommon \
 shared-mime-info \
 systemd-libs \
 "
RDEPENDS:gnome-desktop3-devel = " \
 gdk-pixbuf2-devel \
 glib2-devel \
 gnome-desktop3 \
 gsettings-desktop-schemas-devel \
 gtk3-devel \
 iso-codes-devel \
 libseccomp-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 systemd-devel \
 xkeyboard-config-devel \
 "
RDEPENDS:gnome-desktop4 = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-desktop3 \
 gtk4 \
 libgcc \
 libseccomp \
 libxkbcommon \
 systemd-libs \
 "
RDEPENDS:gnome-desktop4-devel = " \
 gdk-pixbuf2-devel \
 glib2-devel \
 gnome-desktop4 \
 gnome-desktop4-devel \
 gsettings-desktop-schemas-devel \
 gtk4-devel \
 iso-codes-devel \
 libseccomp-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 systemd-devel \
 xkeyboard-config-devel \
 "
