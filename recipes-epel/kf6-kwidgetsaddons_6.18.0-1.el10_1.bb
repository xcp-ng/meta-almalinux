# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwidgetsaddons"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kwidgetsaddons \
 kf6-kwidgetsaddons-devel \
 kf6-kwidgetsaddons-doc \
 kf6-kwidgetsaddons-html \
 python3-kf6-kwidgetsaddons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwidgetsaddons-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "269098a5671b7c9c4191567e1f99b15b589cbcc2c3150dd8600234f95ffe7693"

URI_x86_64_v2_kf6-kwidgetsaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons.sha256sum] = "bb84f5a2b1e92eaecffba547801e28b7b1f9fbb99057edd3d8c2df6deb476899"

URI_x86_64_v2_kf6-kwidgetsaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-devel}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-devel.sha256sum] = "0d89ef73d83708a509d7b93978d16cafe3297385a4f163882089512b7ecd7bbd"

URI_x86_64_v2_kf6-kwidgetsaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-doc}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-doc.sha256sum] = "7fb24029e26ce3721c5d174638b3c5d508e43f96a0dbb79fd4c16e830b16f381"

URI_x86_64_v2_kf6-kwidgetsaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwidgetsaddons-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwidgetsaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwidgetsaddons-html}"
SRC_URI[x86_64_v2_kf6-kwidgetsaddons-html.sha256sum] = "fa2bc9aca5f5ec5a04ace26eb5925c2e4c4216f42913c7299b1aa9cac248b2dc"

URI_x86_64_v2_python3-kf6-kwidgetsaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kwidgetsaddons-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kwidgetsaddons}"
SRC_URI[x86_64_v2_python3-kf6-kwidgetsaddons.sha256sum] = "3966700145f509dff2f0e2dd3aaad5a3cf7eec87900dd4f912023eafc6350186"

URI_aarch64_kf6-kwidgetsaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons}"
SRC_URI[aarch64_kf6-kwidgetsaddons.sha256sum] = "6f2b569565adcf280a360027b0f441cac2df392904dd701813944beffe14f299"

URI_aarch64_kf6-kwidgetsaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kwidgetsaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-devel}"
SRC_URI[aarch64_kf6-kwidgetsaddons-devel.sha256sum] = "bf1aa27205defcd053ef97757b86cf666d857cc5d3dd6dec6269393c574bad6e"

URI_aarch64_kf6-kwidgetsaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kwidgetsaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-doc}"
SRC_URI[aarch64_kf6-kwidgetsaddons-doc.sha256sum] = "7c1aaa881d524e4c6c9e6770e04c42ce1cfab1560a996fa8f9f727263603216e"

URI_aarch64_kf6-kwidgetsaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwidgetsaddons-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kwidgetsaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwidgetsaddons-html}"
SRC_URI[aarch64_kf6-kwidgetsaddons-html.sha256sum] = "1e4a86a1e9c0d7c19e87e3c5c67b9d85f6cb2bd7dd21857f9b7925e783a1a10f"

URI_aarch64_python3-kf6-kwidgetsaddons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kwidgetsaddons-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_python3-kf6-kwidgetsaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kwidgetsaddons}"
SRC_URI[aarch64_python3-kf6-kwidgetsaddons.sha256sum] = "b0ed42dcf8de0bac3f6848093afe6e6b90df50ef385468a1d00008db93d0068e"

RDEPENDS:kf6-kwidgetsaddons = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwidgetsaddons-doc = " \
 "
RDEPENDS:kf6-kwidgetsaddons-html = " \
 "
RDEPENDS:python3-kf6-kwidgetsaddons = " \
 glibc \
 kf6-kwidgetsaddons \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
