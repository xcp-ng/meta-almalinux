# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "slf4j"
PV = "1.7.32"
PR = "13.el10"
PACKAGES = " \
 jcl-over-slf4j \
 jul-to-slf4j \
 log4j-over-slf4j \
 slf4j \
 slf4j-javadoc \
 slf4j-jcl \
 slf4j-jdk14 \
 slf4j-manual \
 slf4j-migrator \
 slf4j-sources \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/slf4j-1.7.32-13.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "740fbbe4fc7bb37082d14a643c463f5d5e1dd972d07a5678e94d3ef6e4d0a030"

URI_x86_64_v2_jcl-over-slf4j = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jcl-over-slf4j-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_jcl-over-slf4j;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jcl-over-slf4j}"
SRC_URI[x86_64_v2_jcl-over-slf4j.sha256sum] = "23f9fa02919c1aafa1843aa86848713f5cf86c1ef0dc25243f9afa6cbcf4c4dd"

URI_x86_64_v2_jul-to-slf4j = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jul-to-slf4j-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_jul-to-slf4j;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jul-to-slf4j}"
SRC_URI[x86_64_v2_jul-to-slf4j.sha256sum] = "48bf40d6c0c71959e5aad492c97f2702baba75a67cb0fb8a097e11a414a89b64"

URI_x86_64_v2_log4j-over-slf4j = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/log4j-over-slf4j-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_log4j-over-slf4j;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4j-over-slf4j}"
SRC_URI[x86_64_v2_log4j-over-slf4j.sha256sum] = "3a8df0ae6ece67b78610fa002d2946f7bc01551f1f1603fe7d971d1f6e8e123a"

URI_x86_64_v2_slf4j = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/slf4j-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_slf4j;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slf4j}"
SRC_URI[x86_64_v2_slf4j.sha256sum] = "3434ad7606c595540f2672af0dddea3d0721c8baa9cff9c04cdd56e5f4afd045"

URI_x86_64_v2_slf4j-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/slf4j-javadoc-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_slf4j-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slf4j-javadoc}"
SRC_URI[x86_64_v2_slf4j-javadoc.sha256sum] = "c788decf9bf6f5fb95fb81dff884b1e6a064800fcf1aa5c2538c907234772546"

URI_x86_64_v2_slf4j-jcl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/slf4j-jcl-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_slf4j-jcl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slf4j-jcl}"
SRC_URI[x86_64_v2_slf4j-jcl.sha256sum] = "01247777d80724afbf43519be71caa914bde9d38bf94302485df78f2a8c9e946"

URI_x86_64_v2_slf4j-jdk14 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/slf4j-jdk14-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_slf4j-jdk14;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slf4j-jdk14}"
SRC_URI[x86_64_v2_slf4j-jdk14.sha256sum] = "3766d9726a6f4dfac5dcea1df4f6b23f11dd4ca4a4d52cf3cab1c0942e544a58"

URI_x86_64_v2_slf4j-manual = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/slf4j-manual-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_slf4j-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slf4j-manual}"
SRC_URI[x86_64_v2_slf4j-manual.sha256sum] = "cd8cbc958016c1c646addf9f44158033a1c1d85674147144d2600d4d8205a3c3"

URI_x86_64_v2_slf4j-migrator = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/slf4j-migrator-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_slf4j-migrator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slf4j-migrator}"
SRC_URI[x86_64_v2_slf4j-migrator.sha256sum] = "79fa103506d6077c7aeddc4b4731f022e40091ddc7efe1284884890c97a38ef2"

URI_x86_64_v2_slf4j-sources = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/slf4j-sources-1.7.32-13.el10.noarch.rpm;name=x86_64_v2_slf4j-sources;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_slf4j-sources}"
SRC_URI[x86_64_v2_slf4j-sources.sha256sum] = "d011a498b339f6dbc5537c9177a41e781b07c250376ce2a7e83877ca174e6089"

URI_aarch64_jcl-over-slf4j = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jcl-over-slf4j-1.7.32-13.el10.noarch.rpm;name=aarch64_jcl-over-slf4j;unpack=0"
SRC_URI:append = " ${URI_aarch64_jcl-over-slf4j}"
SRC_URI[aarch64_jcl-over-slf4j.sha256sum] = "23f9fa02919c1aafa1843aa86848713f5cf86c1ef0dc25243f9afa6cbcf4c4dd"

URI_aarch64_jul-to-slf4j = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jul-to-slf4j-1.7.32-13.el10.noarch.rpm;name=aarch64_jul-to-slf4j;unpack=0"
SRC_URI:append = " ${URI_aarch64_jul-to-slf4j}"
SRC_URI[aarch64_jul-to-slf4j.sha256sum] = "48bf40d6c0c71959e5aad492c97f2702baba75a67cb0fb8a097e11a414a89b64"

URI_aarch64_log4j-over-slf4j = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/log4j-over-slf4j-1.7.32-13.el10.noarch.rpm;name=aarch64_log4j-over-slf4j;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4j-over-slf4j}"
SRC_URI[aarch64_log4j-over-slf4j.sha256sum] = "3a8df0ae6ece67b78610fa002d2946f7bc01551f1f1603fe7d971d1f6e8e123a"

URI_aarch64_slf4j = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/slf4j-1.7.32-13.el10.noarch.rpm;name=aarch64_slf4j;unpack=0"
SRC_URI:append = " ${URI_aarch64_slf4j}"
SRC_URI[aarch64_slf4j.sha256sum] = "3434ad7606c595540f2672af0dddea3d0721c8baa9cff9c04cdd56e5f4afd045"

URI_aarch64_slf4j-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/slf4j-javadoc-1.7.32-13.el10.noarch.rpm;name=aarch64_slf4j-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_slf4j-javadoc}"
SRC_URI[aarch64_slf4j-javadoc.sha256sum] = "c788decf9bf6f5fb95fb81dff884b1e6a064800fcf1aa5c2538c907234772546"

URI_aarch64_slf4j-jcl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/slf4j-jcl-1.7.32-13.el10.noarch.rpm;name=aarch64_slf4j-jcl;unpack=0"
SRC_URI:append = " ${URI_aarch64_slf4j-jcl}"
SRC_URI[aarch64_slf4j-jcl.sha256sum] = "01247777d80724afbf43519be71caa914bde9d38bf94302485df78f2a8c9e946"

URI_aarch64_slf4j-jdk14 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/slf4j-jdk14-1.7.32-13.el10.noarch.rpm;name=aarch64_slf4j-jdk14;unpack=0"
SRC_URI:append = " ${URI_aarch64_slf4j-jdk14}"
SRC_URI[aarch64_slf4j-jdk14.sha256sum] = "3766d9726a6f4dfac5dcea1df4f6b23f11dd4ca4a4d52cf3cab1c0942e544a58"

URI_aarch64_slf4j-manual = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/slf4j-manual-1.7.32-13.el10.noarch.rpm;name=aarch64_slf4j-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_slf4j-manual}"
SRC_URI[aarch64_slf4j-manual.sha256sum] = "cd8cbc958016c1c646addf9f44158033a1c1d85674147144d2600d4d8205a3c3"

URI_aarch64_slf4j-migrator = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/slf4j-migrator-1.7.32-13.el10.noarch.rpm;name=aarch64_slf4j-migrator;unpack=0"
SRC_URI:append = " ${URI_aarch64_slf4j-migrator}"
SRC_URI[aarch64_slf4j-migrator.sha256sum] = "79fa103506d6077c7aeddc4b4731f022e40091ddc7efe1284884890c97a38ef2"

URI_aarch64_slf4j-sources = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/slf4j-sources-1.7.32-13.el10.noarch.rpm;name=aarch64_slf4j-sources;unpack=0"
SRC_URI:append = " ${URI_aarch64_slf4j-sources}"
SRC_URI[aarch64_slf4j-sources.sha256sum] = "d011a498b339f6dbc5537c9177a41e781b07c250376ce2a7e83877ca174e6089"

RDEPENDS:jcl-over-slf4j = " \
 javapackages-filesystem \
 slf4j \
 "
RDEPENDS:jul-to-slf4j = " \
 javapackages-filesystem \
 slf4j \
 "
RDEPENDS:log4j-over-slf4j = " \
 javapackages-filesystem \
 slf4j \
 "
RDEPENDS:slf4j = " \
 javapackages-filesystem \
 "
RDEPENDS:slf4j-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:slf4j-jcl = " \
 apache-commons-logging \
 javapackages-filesystem \
 slf4j \
 "
RDEPENDS:slf4j-jdk14 = " \
 javapackages-filesystem \
 slf4j \
 "
RDEPENDS:slf4j-manual = " \
 "
RDEPENDS:slf4j-migrator = " \
 javapackages-filesystem \
 "
RDEPENDS:slf4j-sources = " \
 apache-commons-logging \
 javapackages-filesystem \
 slf4j \
 "
