# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml"
PV = "0.9.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-toml+debug-devel \
 rust-toml+default-devel \
 rust-toml+display-devel \
 rust-toml+fast_hash-devel \
 rust-toml+parse-devel \
 rust-toml+preserve_order-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml+unbounded-devel \
 rust-toml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml-0.9.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "459c3466ee611c1d9183760effc9d98a0a64da641ab1295417a8a8ec0f3d3aca"

URI_x86_64_v2_rust-toml+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+debug-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+debug-devel}"
SRC_URI[x86_64_v2_rust-toml+debug-devel.sha256sum] = "3e5563366da1c2c3037620ace60697fa68de59f8d57498f039378b46630576cb"

URI_x86_64_v2_rust-toml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+default-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+default-devel}"
SRC_URI[x86_64_v2_rust-toml+default-devel.sha256sum] = "516abec1b43d15e6d0a8c0a4f6fda946ed275b17bdf6a8a799328b70fdf75b0d"

URI_x86_64_v2_rust-toml+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+display-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+display-devel}"
SRC_URI[x86_64_v2_rust-toml+display-devel.sha256sum] = "cd7c7457f301d04a70414f724560a6af6f609e9c8258749c68f458d31d0eafa1"

URI_x86_64_v2_rust-toml+fast_hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+fast_hash-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+fast_hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+fast_hash-devel}"
SRC_URI[x86_64_v2_rust-toml+fast_hash-devel.sha256sum] = "d31de6f72373bd265c4405070996b1895c2e1f69c88aa7c59fee3a4d4c08281f"

URI_x86_64_v2_rust-toml+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+parse-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+parse-devel}"
SRC_URI[x86_64_v2_rust-toml+parse-devel.sha256sum] = "19446a87066175aed7b693d16d909f467e610ff9d97b632e118faba48470c4c8"

URI_x86_64_v2_rust-toml+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+preserve_order-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-toml+preserve_order-devel.sha256sum] = "468aa889096d142b1296029bcbb4a9ef10aa8fcdf2114b392e3f768367f65070"

URI_x86_64_v2_rust-toml+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+serde-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+serde-devel}"
SRC_URI[x86_64_v2_rust-toml+serde-devel.sha256sum] = "aa0e123a56d0141b45d66131c7c2b6924fb39d8299baacc59d399abf73c4509f"

URI_x86_64_v2_rust-toml+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+std-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+std-devel}"
SRC_URI[x86_64_v2_rust-toml+std-devel.sha256sum] = "885099d2133d7e662db7f49054737584f1ec3df7b61447b823dfc1691bcc684f"

URI_x86_64_v2_rust-toml+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml+unbounded-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml+unbounded-devel.sha256sum] = "fc2c00042c48f1ef6e0bcd9666917af94f0becb9d286236d262669c7e8f5f514"

URI_x86_64_v2_rust-toml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml-devel-0.9.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml-devel}"
SRC_URI[x86_64_v2_rust-toml-devel.sha256sum] = "a884f4959acb3ed3743974af43fd7cb2df0cebf69c541abca42ba6a5648cabc5"

URI_aarch64_rust-toml+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+debug-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+debug-devel}"
SRC_URI[aarch64_rust-toml+debug-devel.sha256sum] = "a85256eeb60d0497b1246e9a1ed52581d49b19127c0fe6c19cf9f1e0d7bf71d6"

URI_aarch64_rust-toml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+default-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+default-devel}"
SRC_URI[aarch64_rust-toml+default-devel.sha256sum] = "1e2c53bd077bbdcc8351c3030a8a1357521572533389e4e51a67f206cb4124ec"

URI_aarch64_rust-toml+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+display-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+display-devel}"
SRC_URI[aarch64_rust-toml+display-devel.sha256sum] = "861af9830a301272b1955508b34e5f0e9339ee2353b058179a194925cdb975e7"

URI_aarch64_rust-toml+fast_hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+fast_hash-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml+fast_hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+fast_hash-devel}"
SRC_URI[aarch64_rust-toml+fast_hash-devel.sha256sum] = "cfaefed4a26c7d0fcdeaf122fe783802bc3c2e78c4095b85f78edd27b61e4623"

URI_aarch64_rust-toml+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+parse-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+parse-devel}"
SRC_URI[aarch64_rust-toml+parse-devel.sha256sum] = "361f4e49a711d43b041e4d73d40123420bfd567b2de5ad92336c59c88a80d6d9"

URI_aarch64_rust-toml+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+preserve_order-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+preserve_order-devel}"
SRC_URI[aarch64_rust-toml+preserve_order-devel.sha256sum] = "adb8e40ec236ef2ac51a44d131a3375e90334734cead95fc957861ebe20b5ca5"

URI_aarch64_rust-toml+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+serde-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+serde-devel}"
SRC_URI[aarch64_rust-toml+serde-devel.sha256sum] = "e75f2931bb8b6af4f6933b2ec6472991fd46ac3b251507197d4453302ff4fb2a"

URI_aarch64_rust-toml+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+std-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+std-devel}"
SRC_URI[aarch64_rust-toml+std-devel.sha256sum] = "53840492e037cf090b2e71526151f6fd9ad36467ca3bd3e2fe22e557dcbb37a9"

URI_aarch64_rust-toml+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml+unbounded-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml+unbounded-devel}"
SRC_URI[aarch64_rust-toml+unbounded-devel.sha256sum] = "7098a42c4d257cc085ceb6b36d4c6c139d99e249be303adc39f4a70e6c2a92ae"

URI_aarch64_rust-toml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml-devel-0.9.11-1.el10_1.noarch.rpm;name=aarch64_rust-toml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml-devel}"
SRC_URI[aarch64_rust-toml-devel.sha256sum] = "753225763e6afaefb9611851ae919fc380e76500359303fca0112b696c6bc5f2"

RDEPENDS:rust-toml+debug-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml+default-devel = " \
 cargo \
 rust-toml+display-devel \
 rust-toml+parse-devel \
 rust-toml+serde-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+display-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml+fast_hash-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-toml+preserve_order-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+parse-devel = " \
 cargo \
 rust-toml-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser-devel \
 rust-winnow-devel \
 "
RDEPENDS:rust-toml+preserve_order-devel = " \
 cargo \
 rust-indexmap-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 "
RDEPENDS:rust-toml+serde-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-serde_spanned+serde-devel \
 rust-toml-devel \
 rust-toml_datetime+serde-devel \
 "
RDEPENDS:rust-toml+std-devel = " \
 cargo \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+std-devel \
 rust-toml-devel \
 rust-toml_datetime+std-devel \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 rust-toml_writer+alloc-devel \
 rust-toml_writer+std-devel \
 rust-toml_writer-devel \
 "
RDEPENDS:rust-toml+unbounded-devel = " \
 cargo \
 rust-toml-devel \
 "
RDEPENDS:rust-toml-devel = " \
 cargo \
 rust \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned-devel \
 rust-toml_datetime+alloc-devel \
 rust-toml_datetime-devel \
 "
