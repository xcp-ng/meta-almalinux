# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cepces"
PV = "0.3.17"
PR = "2.el10_2"
PACKAGES = " \
 cepces \
 cepces-certmonger \
 cepces-selinux \
 python3-cepces \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cepces-0.3.17-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95753cbe785015cea00b35432486c8bed8a7e2f0087b10ff8378966406472554"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-0.3.17-2.el10_2.noarch.rpm;name=x86_64_v2_cepces;unpack=0"
SRC_URI[x86_64_v2_cepces.sha256sum] = "120d3dc7264d1b572e7187fb8beca53a71583a2c66ab6fd03b2e9fb9bafbd653"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-certmonger-0.3.17-2.el10_2.noarch.rpm;name=x86_64_v2_cepces-certmonger;unpack=0"
SRC_URI[x86_64_v2_cepces-certmonger.sha256sum] = "0300abda333be4d7eaed6900ebd7be00e5d268faf5fd98218062397525bafd33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cepces-selinux-0.3.17-2.el10_2.noarch.rpm;name=x86_64_v2_cepces-selinux;unpack=0"
SRC_URI[x86_64_v2_cepces-selinux.sha256sum] = "d1b8a491bcabc0b33b90df4ef0e1a15890069055aa8505e77ac182282d923d52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-cepces-0.3.17-2.el10_2.noarch.rpm;name=x86_64_v2_python3-cepces;unpack=0"
SRC_URI[x86_64_v2_python3-cepces.sha256sum] = "bfbb7ee44d081b1e886e1f64848c74d6be702106ace07ed404868bd213209b98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-0.3.17-2.el10_2.noarch.rpm;name=aarch64_cepces;unpack=0"
SRC_URI[aarch64_cepces.sha256sum] = "120d3dc7264d1b572e7187fb8beca53a71583a2c66ab6fd03b2e9fb9bafbd653"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-certmonger-0.3.17-2.el10_2.noarch.rpm;name=aarch64_cepces-certmonger;unpack=0"
SRC_URI[aarch64_cepces-certmonger.sha256sum] = "0300abda333be4d7eaed6900ebd7be00e5d268faf5fd98218062397525bafd33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cepces-selinux-0.3.17-2.el10_2.noarch.rpm;name=aarch64_cepces-selinux;unpack=0"
SRC_URI[aarch64_cepces-selinux.sha256sum] = "d1b8a491bcabc0b33b90df4ef0e1a15890069055aa8505e77ac182282d923d52"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-cepces-0.3.17-2.el10_2.noarch.rpm;name=aarch64_python3-cepces;unpack=0"
SRC_URI[aarch64_python3-cepces.sha256sum] = "bfbb7ee44d081b1e886e1f64848c74d6be702106ace07ed404868bd213209b98"

RDEPENDS:cepces = " \
 cepces-selinux \
 python3-cepces \
 "
RDEPENDS:cepces-certmonger = " \
 bash \
 cepces \
 certmonger \
 python3 \
 "
RDEPENDS:cepces-selinux = " \
 bash \
 cepces \
 selinux-policy-targeted \
 "
RDEPENDS:python3-cepces = " \
 krb5-libs \
 python3 \
 python3-cryptography \
 python3-requests \
 python3-requests-gssapi \
 "
