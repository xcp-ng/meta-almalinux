# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmongocrypt"
PV = "1.15.2"
PR = "1.el10_2"
PACKAGES = " \
 libmongocrypt \
 libmongocrypt-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libmongocrypt-1.15.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "913c98c7e01805972afef07c7ef21d4bda4455300849b17d5192383256fbe5fb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-1.15.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt;unpack=0"
SRC_URI[x86_64_v2_libmongocrypt.sha256sum] = "7b11b06eb3079fcec7b5269bd9a92253f7d28f552aa9f83272fcf04756a843ce"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmongocrypt-devel-1.15.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmongocrypt-devel;unpack=0"
SRC_URI[x86_64_v2_libmongocrypt-devel.sha256sum] = "739bfa0c5598e2ec6476a1227448af0b0c3c8aa0ed72047b2cfdea59d34f27b6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-1.15.2-1.el10_2.aarch64.rpm;name=aarch64_libmongocrypt;unpack=0"
SRC_URI[aarch64_libmongocrypt.sha256sum] = "b508362f843078436f803d07f1e43c01075dfcbd07a1a5c213b48501f19628be"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libmongocrypt-devel-1.15.2-1.el10_2.aarch64.rpm;name=aarch64_libmongocrypt-devel;unpack=0"
SRC_URI[aarch64_libmongocrypt-devel.sha256sum] = "4f68690dbc5f09c9372b9c3efebe9bb942340efab3e5469e0aa5830af654add6"

RDEPENDS:libmongocrypt = " \
 glibc \
 libbson \
 openssl-libs \
 "
RDEPENDS:libmongocrypt-devel = " \
 cmake-filesystem \
 libbson-devel \
 libmongocrypt \
 pkgconf-pkg-config \
 "
