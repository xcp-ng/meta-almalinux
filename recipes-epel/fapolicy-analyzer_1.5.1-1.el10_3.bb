# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fapolicy-analyzer"
PV = "1.5.1"
PR = "1.el10_3"
PACKAGES = " \
 fapolicy-analyzer \
 fapolicy-analyzer-cli \
 fapolicy-analyzer-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fapolicy-analyzer-1.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ffe57ae2d5f9dced2570d4f21e9337e3b93fd84200226e5f0cca05d4666b7f0"

URI_x86_64_v2_fapolicy-analyzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fapolicy-analyzer-1.5.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fapolicy-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicy-analyzer}"
SRC_URI[x86_64_v2_fapolicy-analyzer.sha256sum] = "738812e73b0a604cfe5dabb5ad2937578fd4acb2b042263d43c198fdbe8da0d7"

URI_x86_64_v2_fapolicy-analyzer-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fapolicy-analyzer-cli-1.5.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fapolicy-analyzer-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicy-analyzer-cli}"
SRC_URI[x86_64_v2_fapolicy-analyzer-cli.sha256sum] = "d10d57480679e4c6f18f2eab6de5cd0a1a85580fb17c43a4b4d6dd8b2102f218"

URI_x86_64_v2_fapolicy-analyzer-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fapolicy-analyzer-gui-1.5.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fapolicy-analyzer-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fapolicy-analyzer-gui}"
SRC_URI[x86_64_v2_fapolicy-analyzer-gui.sha256sum] = "5cdf113ec923564e5347f533cf5535bd22aad6d75b48efc03532daf664865bae"

URI_aarch64_fapolicy-analyzer = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-1.5.1-1.el10_3.aarch64.rpm;name=aarch64_fapolicy-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer}"
SRC_URI[aarch64_fapolicy-analyzer.sha256sum] = "08f2bff5d920b03fe821bc709d979520e8114fa2ee26501d77dd3b4c338ad4a7"

URI_aarch64_fapolicy-analyzer-cli = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-cli-1.5.1-1.el10_3.aarch64.rpm;name=aarch64_fapolicy-analyzer-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer-cli}"
SRC_URI[aarch64_fapolicy-analyzer-cli.sha256sum] = "6d0b36e1271630125ba008ce485ce8982ef2027a85a92c3e63bf2cf0c808de45"

URI_aarch64_fapolicy-analyzer-gui = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-gui-1.5.1-1.el10_3.aarch64.rpm;name=aarch64_fapolicy-analyzer-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer-gui}"
SRC_URI[aarch64_fapolicy-analyzer-gui.sha256sum] = "cc0096cbd677a4e3181a981168e7cf695151cf7529fcfe8583cffd5b8c11f736"

RDEPENDS:fapolicy-analyzer = " \
 fapolicy-analyzer-cli \
 fapolicy-analyzer-gui \
 "
RDEPENDS:fapolicy-analyzer-cli = " \
 audit-libs \
 dbus-libs \
 glibc \
 libgcc \
 lmdb-libs \
 "
RDEPENDS:fapolicy-analyzer-gui = " \
 audit-libs \
 bash \
 dbus-libs \
 glibc \
 gnome-icon-theme \
 gtk3 \
 gtksourceview3 \
 libgcc \
 lmdb-libs \
 mesa-dri-drivers \
 python3 \
 python3-configargparse \
 python3-gobject \
 python3-matplotlib \
 python3-more-itertools \
 python3-rx \
 python3-tomli \
 webkit2gtk4.1 \
 "
