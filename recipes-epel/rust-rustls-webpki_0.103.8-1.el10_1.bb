# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-webpki"
PV = "0.103.8"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki+default-devel \
 rust-rustls-webpki+ring-devel \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-webpki-0.103.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb3f0bf1ccbfbef793b8a94301cc009fc3405c78a0842b4107aa0906507939bd"

URI_x86_64_v2_rust-rustls-webpki+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+alloc-devel-0.103.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+alloc-devel.sha256sum] = "9873ddc9f130266f303410b6dec7c48f1507d3cf4421f8e983f5a3e2eb03b273"

URI_x86_64_v2_rust-rustls-webpki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+default-devel-0.103.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+default-devel.sha256sum] = "da46634e6033f3c6c64f9fe0eb53d39bac2b692e780fd2673faa718b68c8c66b"

URI_x86_64_v2_rust-rustls-webpki+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+ring-devel-0.103.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+ring-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+ring-devel.sha256sum] = "f7ff92b73a9fcdab53cc9ed5720f4377ad6792bcf78660fcc34a1142fe5b9d38"

URI_x86_64_v2_rust-rustls-webpki+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+std-devel-0.103.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+std-devel.sha256sum] = "a79bbb9792a13aef4aa474231f18753b08a7a4e0c97088a573ba282730783e26"

URI_x86_64_v2_rust-rustls-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki-devel-0.103.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki-devel.sha256sum] = "7e1f258c7a121c821fb79fa95406a76fe13d7472560926f2a7060d7045be3fa5"

URI_aarch64_rust-rustls-webpki+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+alloc-devel-0.103.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+alloc-devel}"
SRC_URI[aarch64_rust-rustls-webpki+alloc-devel.sha256sum] = "788552f3ee0912e200f6e57b6aee8306665bf6b1f019a17dd68954f20662b2d8"

URI_aarch64_rust-rustls-webpki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+default-devel-0.103.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+default-devel}"
SRC_URI[aarch64_rust-rustls-webpki+default-devel.sha256sum] = "39b1e23b7edaa435c664387f8cf1f60ba77884f8cefa905bf0008ddc9fb732b6"

URI_aarch64_rust-rustls-webpki+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+ring-devel-0.103.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+ring-devel}"
SRC_URI[aarch64_rust-rustls-webpki+ring-devel.sha256sum] = "5d13b5fbc776e7272afd5c572b07f3f2675983dd06df39f54ea3af836ee3f828"

URI_aarch64_rust-rustls-webpki+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+std-devel-0.103.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+std-devel}"
SRC_URI[aarch64_rust-rustls-webpki+std-devel.sha256sum] = "75aa3959d109c6857cb90e2d66cc9d71725821b11b8d5e58cae5f0ec9258bf87"

URI_aarch64_rust-rustls-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki-devel-0.103.8-1.el10_1.noarch.rpm;name=aarch64_rust-rustls-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki-devel}"
SRC_URI[aarch64_rust-rustls-webpki-devel.sha256sum] = "d7790fe33c7531bff0e05784776fb5c77554c9b77538d0a3d24d2e45ddeebb41"

RDEPENDS:rust-rustls-webpki+alloc-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+default-devel = " \
 cargo \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+ring-devel = " \
 cargo \
 rust-ring-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+std-devel = " \
 cargo \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 rust-untrusted+default-devel \
 "
