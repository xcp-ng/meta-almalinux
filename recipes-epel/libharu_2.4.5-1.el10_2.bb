# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libharu"
PV = "2.4.5"
PR = "1.el10_2"
PACKAGES = " \
 libharu \
 libharu-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libharu-2.4.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "786c9896540da03207d7a09638d71e3414ba76c623fa9bdf2f940b2adea697b0"

URI_x86_64_v2_libharu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libharu-2.4.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libharu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libharu}"
SRC_URI[x86_64_v2_libharu.sha256sum] = "bea3d34e51de9c6295a186cfa5467b2bf576d03556f51d6f4d804e9146392735"

URI_x86_64_v2_libharu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libharu-devel-2.4.5-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libharu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libharu-devel}"
SRC_URI[x86_64_v2_libharu-devel.sha256sum] = "ba3332d36e3b276ec18716c009e98edaa363ec7e2406ae1642c2f5add8931f70"

URI_aarch64_libharu = "${EPEL_MIRROR}/aarch64/Packages/l/libharu-2.4.5-1.el10_2.aarch64.rpm;name=aarch64_libharu;unpack=0"
SRC_URI:append = " ${URI_aarch64_libharu}"
SRC_URI[aarch64_libharu.sha256sum] = "b171ec48beef9c9c283fbce4e4c205e8e4e5fd24d5e9329bd9481c6617f781cb"

URI_aarch64_libharu-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libharu-devel-2.4.5-1.el10_2.aarch64.rpm;name=aarch64_libharu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libharu-devel}"
SRC_URI[aarch64_libharu-devel.sha256sum] = "9450c1b37b894c6a3aba65e49eb6c46eda2bed157b7bd0b0146e37753cf1674d"

RDEPENDS:libharu = " \
 glibc \
 libpng \
 zlib-ng-compat \
 "
RDEPENDS:libharu-devel = " \
 libharu \
 "
