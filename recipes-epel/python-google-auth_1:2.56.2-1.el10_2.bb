# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-auth"
PE = "1"
PV = "2.56.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-google-auth \
 python3-google-auth+aiohttp \
 python3-google-auth+enterprise_cert \
 python3-google-auth+pyjwt \
 python3-google-auth+pyopenssl \
 python3-google-auth+requests \
 python3-google-auth+urllib3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-auth-2.56.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "065d516920d44fc3b2eb450069fcfdfef76f24298ebce4970d6446ae43703f5c"

URI_x86_64_v2_python3-google-auth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth-2.56.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth}"
SRC_URI[x86_64_v2_python3-google-auth.sha256sum] = "01b572f944118ba3dc14b876d9a2e93f198a9e164b9f8c2d8c90f0a06d8031c9"

URI_x86_64_v2_python3-google-auth+aiohttp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+aiohttp-2.56.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+aiohttp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+aiohttp}"
SRC_URI[x86_64_v2_python3-google-auth+aiohttp.sha256sum] = "22a16dc9f7745c188d0993a3ca2ade9be8994a4ebfa4099280a6086e61684b65"

URI_x86_64_v2_python3-google-auth+enterprise_cert = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+enterprise_cert-2.56.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+enterprise_cert;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+enterprise_cert}"
SRC_URI[x86_64_v2_python3-google-auth+enterprise_cert.sha256sum] = "492ee9d9cf43c663521840f1b9362e013728e67b211a0e0d82da97299c88277b"

URI_x86_64_v2_python3-google-auth+pyjwt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+pyjwt-2.56.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+pyjwt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+pyjwt}"
SRC_URI[x86_64_v2_python3-google-auth+pyjwt.sha256sum] = "b10686049df1a9d8ef96038d4e29cf52b328d531e0630206bdc37aeda950084e"

URI_x86_64_v2_python3-google-auth+pyopenssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+pyopenssl-2.56.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+pyopenssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+pyopenssl}"
SRC_URI[x86_64_v2_python3-google-auth+pyopenssl.sha256sum] = "37524e03a8d2fd38e9967755d95d127177d3d56c4637514a7ce07e51a9ed4288"

URI_x86_64_v2_python3-google-auth+requests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+requests-2.56.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+requests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+requests}"
SRC_URI[x86_64_v2_python3-google-auth+requests.sha256sum] = "4c4492b8e7deac509b3f24f790b03beff0ba3ed96dc493ba3dbefba83081767e"

URI_x86_64_v2_python3-google-auth+urllib3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-auth+urllib3-2.56.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-auth+urllib3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-auth+urllib3}"
SRC_URI[x86_64_v2_python3-google-auth+urllib3.sha256sum] = "9aa6bc0c110b7f85ac3afefc7ce5d406e1cd86c8b9edca2c06c85f4c61f2bec4"

URI_aarch64_python3-google-auth = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth-2.56.2-1.el10_2.noarch.rpm;name=aarch64_python3-google-auth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth}"
SRC_URI[aarch64_python3-google-auth.sha256sum] = "796569cb13463b6e3d9b28514ae32cf7271f4bbbcd2b208470a3f5e83283a4f8"

URI_aarch64_python3-google-auth+aiohttp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+aiohttp-2.56.2-1.el10_2.noarch.rpm;name=aarch64_python3-google-auth+aiohttp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+aiohttp}"
SRC_URI[aarch64_python3-google-auth+aiohttp.sha256sum] = "a8272d3a15b0ac00feb2a71fe9073f243593c9e43d7108663a8704dcda0b5799"

URI_aarch64_python3-google-auth+enterprise_cert = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+enterprise_cert-2.56.2-1.el10_2.noarch.rpm;name=aarch64_python3-google-auth+enterprise_cert;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+enterprise_cert}"
SRC_URI[aarch64_python3-google-auth+enterprise_cert.sha256sum] = "7e6a000bb7e61312e84c010f5a90952de979978fb296f6654c51b92736c6730e"

URI_aarch64_python3-google-auth+pyjwt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+pyjwt-2.56.2-1.el10_2.noarch.rpm;name=aarch64_python3-google-auth+pyjwt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+pyjwt}"
SRC_URI[aarch64_python3-google-auth+pyjwt.sha256sum] = "a2e32954abdeb88fd9d902527e44ff2e598863a9924a638f9a62f3db6deb9a94"

URI_aarch64_python3-google-auth+pyopenssl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+pyopenssl-2.56.2-1.el10_2.noarch.rpm;name=aarch64_python3-google-auth+pyopenssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+pyopenssl}"
SRC_URI[aarch64_python3-google-auth+pyopenssl.sha256sum] = "9b6904a7c67bccebb649f3070b53ddf1cf7b36876165d8eb4fb0ea6359f10b1e"

URI_aarch64_python3-google-auth+requests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+requests-2.56.2-1.el10_2.noarch.rpm;name=aarch64_python3-google-auth+requests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+requests}"
SRC_URI[aarch64_python3-google-auth+requests.sha256sum] = "6db58567be0a2b110767ae40ed202985a311707b4f483fe93a96b8ebca3d257d"

URI_aarch64_python3-google-auth+urllib3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-auth+urllib3-2.56.2-1.el10_2.noarch.rpm;name=aarch64_python3-google-auth+urllib3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-auth+urllib3}"
SRC_URI[aarch64_python3-google-auth+urllib3.sha256sum] = "9256081375b09dc338fa94dcf5d121a2194523b69e1d5a7525b051b995a8fec4"

RDEPENDS:python3-google-auth = " \
 python3 \
 python3-cryptography \
 python3-pyasn1-modules \
 "
RDEPENDS:python3-google-auth+aiohttp = " \
 python3 \
 python3-aiohttp \
 python3-google-auth \
 python3-requests \
 "
RDEPENDS:python3-google-auth+enterprise_cert = " \
 python3 \
 python3-cryptography \
 python3-google-auth \
 "
RDEPENDS:python3-google-auth+pyjwt = " \
 python3 \
 python3-google-auth \
 python3-jwt \
 "
RDEPENDS:python3-google-auth+pyopenssl = " \
 python3 \
 python3-cryptography \
 python3-google-auth \
 "
RDEPENDS:python3-google-auth+requests = " \
 python3 \
 python3-google-auth \
 python3-requests \
 "
RDEPENDS:python3-google-auth+urllib3 = " \
 python3 \
 python3-google-auth \
 python3-packaging \
 python3-urllib3 \
 "
