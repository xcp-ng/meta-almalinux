# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmd"
PV = "1.2.0"
PR = "1.el10_1"
PACKAGES = " \
 libmd \
 libmd-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libmd-1.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "261146b79849b791ce27eb66f6a487a5f43713527938313992ec9075b0300101"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmd-1.2.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmd;unpack=0"
SRC_URI[x86_64_v2_libmd.sha256sum] = "4221fb4a457c77f05a0ed9da59f1b8bbdb3bbe0f0df886c78ce70edc928ffd1c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmd-devel-1.2.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmd-devel;unpack=0"
SRC_URI[x86_64_v2_libmd-devel.sha256sum] = "777256424e257e868db96a94b3556b91d86e196154b6d97f7ac37e213d796167"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libmd-1.2.0-1.el10_1.aarch64.rpm;name=aarch64_libmd;unpack=0"
SRC_URI[aarch64_libmd.sha256sum] = "1e89ac49881d774e12dc298f6de5ed6f8e11511746be1c1f8ff4b8007bd979ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libmd-devel-1.2.0-1.el10_1.aarch64.rpm;name=aarch64_libmd-devel;unpack=0"
SRC_URI[aarch64_libmd-devel.sha256sum] = "a4f8f97fcacc59b20edffa7fa0f9ebf7315d26f060a67cbbdfefb7bdbd12d512"

RDEPENDS:libmd = " \
 glibc \
 "
RDEPENDS:libmd-devel = " \
 libmd \
 pkgconf-pkg-config \
 "
