# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kunifiedpush"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kunifiedpush \
 kunifiedpush-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kunifiedpush-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0997e36b174a68afd0b2b005493187a1e1c910b5bbb12b707164cc63ec9552fe"

URI_x86_64_v2_kunifiedpush = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kunifiedpush}"
SRC_URI[x86_64_v2_kunifiedpush.sha256sum] = "0bd912330440147bbe8b979af48a62a779925baf813d8446c4b2ec15a1a30ef3"

URI_x86_64_v2_kunifiedpush-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kunifiedpush-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kunifiedpush-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kunifiedpush-devel}"
SRC_URI[x86_64_v2_kunifiedpush-devel.sha256sum] = "1614bc1b2df8a8a7bb94147eb960692e4a9f1e5664d1a4215de6fa4b9b8482f8"

URI_aarch64_kunifiedpush = "${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kunifiedpush;unpack=0"
SRC_URI:append = " ${URI_aarch64_kunifiedpush}"
SRC_URI[aarch64_kunifiedpush.sha256sum] = "ea6dca355f41c30530b88d8e3d3a9cfb7faceb5e9b7a9252c603b3ce1c1effd7"

URI_aarch64_kunifiedpush-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kunifiedpush-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kunifiedpush-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kunifiedpush-devel}"
SRC_URI[aarch64_kunifiedpush-devel.sha256sum] = "31c405b9465d97475ae29ab915a06cd9b18c48224cbb31e769a0b62b9729b016"

RDEPENDS:kunifiedpush = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kservice \
 kf6-solid \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebsockets \
 "
RDEPENDS:kunifiedpush-devel = " \
 cmake-filesystem \
 kunifiedpush \
 "
