# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sereal"
PV = "5.006"
PR = "1.el10_2"
PACKAGES = " \
 perl-Sereal \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Sereal-5.006-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4be95217d407e28d659b619278d24f7cae344ac51ac0340219a41b2798f24dc0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sereal-5.006-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sereal;unpack=0"
SRC_URI[x86_64_v2_perl-Sereal.sha256sum] = "2f4b796eab58fb15c065d57917249a1f7bcbad5665020a341586e81e78cc7197"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Sereal-5.006-1.el10_2.noarch.rpm;name=aarch64_perl-Sereal;unpack=0"
SRC_URI[aarch64_perl-Sereal.sha256sum] = "46d735998804adcab782bf62606fe947467c8a69887019eeb79ae8d5eadca2a1"

RDEPENDS:perl-Sereal = " \
 perl-Exporter \
 perl-Sereal-Decoder \
 perl-Sereal-Encoder \
 perl-libs \
 "
