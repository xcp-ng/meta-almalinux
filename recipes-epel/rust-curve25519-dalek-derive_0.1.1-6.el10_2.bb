# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curve25519-dalek-derive"
PV = "0.1.1"
PR = "6.el10_2"
PACKAGES = " \
 rust-curve25519-dalek-derive+default-devel \
 rust-curve25519-dalek-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-curve25519-dalek-derive-0.1.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b72e2829b787bb5d0e9ea872c25ee402a656c5bdff11b01cb559d3816a35063f"

URI_x86_64_v2_rust-curve25519-dalek-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek-derive+default-devel-0.1.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek-derive+default-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek-derive+default-devel.sha256sum] = "3c22fbf247ecd5d4054f8bc484e5ff7173f1d1f6c2e5acce1c90deec5aac71bc"

URI_x86_64_v2_rust-curve25519-dalek-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curve25519-dalek-derive-devel-0.1.1-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curve25519-dalek-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curve25519-dalek-derive-devel}"
SRC_URI[x86_64_v2_rust-curve25519-dalek-derive-devel.sha256sum] = "b0ac74447a33eeb09b206fc6b2ae03f68831f2a309c2817901541a0cf39fe8f7"

URI_aarch64_rust-curve25519-dalek-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek-derive+default-devel-0.1.1-6.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek-derive+default-devel}"
SRC_URI[aarch64_rust-curve25519-dalek-derive+default-devel.sha256sum] = "78087a5766c498a5cb408770d4f2a6fa289225e73fdd113d8aebcfb5032680e5"

URI_aarch64_rust-curve25519-dalek-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curve25519-dalek-derive-devel-0.1.1-6.el10_2.noarch.rpm;name=aarch64_rust-curve25519-dalek-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curve25519-dalek-derive-devel}"
SRC_URI[aarch64_rust-curve25519-dalek-derive-devel.sha256sum] = "d8b807128d73b41355df3e63b1d0c2554a93938a4709fe487af8deee829ea604"

RDEPENDS:rust-curve25519-dalek-derive+default-devel = " \
 cargo \
 rust-curve25519-dalek-derive-devel \
 "
RDEPENDS:rust-curve25519-dalek-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
