# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-curl-sys"
PV = "0.4.89"
PR = "1.el10_3"
PACKAGES = " \
 rust-curl-sys+default-devel \
 rust-curl-sys+http2-devel \
 rust-curl-sys+ntlm-devel \
 rust-curl-sys+openssl-sys-devel \
 rust-curl-sys+poll_7_68_0-devel \
 rust-curl-sys+protocol-ftp-devel \
 rust-curl-sys+spnego-devel \
 rust-curl-sys+ssl-devel \
 rust-curl-sys+upkeep_7_62_0-devel \
 rust-curl-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-curl-sys-0.4.89-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f3c3b5f0a2752b0fd5309c7c01ad1143f2d1e1cc5fc5fd9ba4dc937dc354307"

URI_x86_64_v2_rust-curl-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+default-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+default-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+default-devel.sha256sum] = "97d2bf4e2a7f4c56cf7493b9d6830d5f4ae5719d07efec97bf83d99222558435"

URI_x86_64_v2_rust-curl-sys+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+http2-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+http2-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+http2-devel.sha256sum] = "8ccd5584fec7a1491c7aea8578f48f52cdd830ce78a520c99b47d30fb8406b15"

URI_x86_64_v2_rust-curl-sys+ntlm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+ntlm-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+ntlm-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+ntlm-devel.sha256sum] = "fd4922adbf356cbf3df6ba5b86d609e0bfddfecc7b0dfea2135382dee6ff3f89"

URI_x86_64_v2_rust-curl-sys+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+openssl-sys-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+openssl-sys-devel.sha256sum] = "236b4a98d1bdeaefb760918bf0fccf1c5bc61017dc061018f37dc417d8368e10"

URI_x86_64_v2_rust-curl-sys+poll_7_68_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+poll_7_68_0-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+poll_7_68_0-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+poll_7_68_0-devel.sha256sum] = "f95304a8ca6423ab529140c51dea292edd80d61a50978a6bebba1bdc339a75db"

URI_x86_64_v2_rust-curl-sys+protocol-ftp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+protocol-ftp-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+protocol-ftp-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+protocol-ftp-devel.sha256sum] = "24921188614439a16abb82747ef200028e7fac1162e04e5af52d297efb328620"

URI_x86_64_v2_rust-curl-sys+spnego-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+spnego-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+spnego-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+spnego-devel.sha256sum] = "d3de0f39f4d7d6e7f85af97745fea61cb6ef0b0cb492db761caac66b127d2d73"

URI_x86_64_v2_rust-curl-sys+ssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+ssl-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+ssl-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+ssl-devel.sha256sum] = "1e22828bf6931a5fd885cfd546b99240086ad0c1c88c710e1c7d0fafc60efac9"

URI_x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys+upkeep_7_62_0-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel}"
SRC_URI[x86_64_v2_rust-curl-sys+upkeep_7_62_0-devel.sha256sum] = "59e41e610e11d9009fbd0f5bd90680d794f88129f304696b121a45c440dfb36d"

URI_x86_64_v2_rust-curl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-curl-sys-devel-0.4.89-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-curl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-curl-sys-devel}"
SRC_URI[x86_64_v2_rust-curl-sys-devel.sha256sum] = "4e1c67302af6e1f74593e643fb2d6872562bd7404981e5490da4296bafd9703b"

URI_aarch64_rust-curl-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+default-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+default-devel}"
SRC_URI[aarch64_rust-curl-sys+default-devel.sha256sum] = "0d12f7a1d733e0007cc4787488c1bdc133ca09799402f044312c20215fbdd644"

URI_aarch64_rust-curl-sys+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+http2-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+http2-devel}"
SRC_URI[aarch64_rust-curl-sys+http2-devel.sha256sum] = "842f4eac43a0a4dfe423d7868bb712dddeda077f477f9e0df2351edc73d89d97"

URI_aarch64_rust-curl-sys+ntlm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+ntlm-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys+ntlm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+ntlm-devel}"
SRC_URI[aarch64_rust-curl-sys+ntlm-devel.sha256sum] = "c8b42fc4c80f41198a6b1d50201f72c313656223f5570c256bb8465e50a182f1"

URI_aarch64_rust-curl-sys+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+openssl-sys-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+openssl-sys-devel}"
SRC_URI[aarch64_rust-curl-sys+openssl-sys-devel.sha256sum] = "408f5b0ea9a88b218238fbe085455363b7a53a62eb06de864e08d3b1c708f645"

URI_aarch64_rust-curl-sys+poll_7_68_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+poll_7_68_0-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys+poll_7_68_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+poll_7_68_0-devel}"
SRC_URI[aarch64_rust-curl-sys+poll_7_68_0-devel.sha256sum] = "9fbf5a33ae3ba0f4a279e1184f7d5651cd2ea000e02bb7b026a0c30219c82bc4"

URI_aarch64_rust-curl-sys+protocol-ftp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+protocol-ftp-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys+protocol-ftp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+protocol-ftp-devel}"
SRC_URI[aarch64_rust-curl-sys+protocol-ftp-devel.sha256sum] = "e1408a248d4c1ed4c107d0a07ecae61aa9dd467d6c752639c5d39d536fcaa3fe"

URI_aarch64_rust-curl-sys+spnego-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+spnego-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys+spnego-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+spnego-devel}"
SRC_URI[aarch64_rust-curl-sys+spnego-devel.sha256sum] = "37044dceb91647cf39c7ac6596084b1d1afc1a03826ac063621d5f98c0b493fe"

URI_aarch64_rust-curl-sys+ssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+ssl-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys+ssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+ssl-devel}"
SRC_URI[aarch64_rust-curl-sys+ssl-devel.sha256sum] = "130520d1e329e95b7085503f36cfb32789579a576e42ae12c36bf44f2432bb18"

URI_aarch64_rust-curl-sys+upkeep_7_62_0-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys+upkeep_7_62_0-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys+upkeep_7_62_0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys+upkeep_7_62_0-devel}"
SRC_URI[aarch64_rust-curl-sys+upkeep_7_62_0-devel.sha256sum] = "15febad5c963747242799a8c5fef261bffd5afca674832113c5a3b63b0c73966"

URI_aarch64_rust-curl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-curl-sys-devel-0.4.89-1.el10_3.noarch.rpm;name=aarch64_rust-curl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-curl-sys-devel}"
SRC_URI[aarch64_rust-curl-sys-devel.sha256sum] = "2bf7e38e17ea9d084d7dd31655ee1d6d9e5c03aefc9dc0e59979486932446712"

RDEPENDS:rust-curl-sys+default-devel = " \
 cargo \
 rust-curl-sys+ssl-devel \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+http2-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+ntlm-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+openssl-sys-devel = " \
 cargo \
 rust-curl-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-curl-sys+poll_7_68_0-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+protocol-ftp-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+spnego-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+ssl-devel = " \
 cargo \
 rust-curl-sys+openssl-sys-devel \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys+upkeep_7_62_0-devel = " \
 cargo \
 rust-curl-sys-devel \
 "
RDEPENDS:rust-curl-sys-devel = " \
 cargo \
 libcurl-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 "
