# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lifeguard"
PV = "0.6.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-lifeguard+default-devel \
 rust-lifeguard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lifeguard-0.6.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41a236c63d136b059692afc0566a041c460857a31b113f01c649d1a4fbf1ce2e"

URI_x86_64_v2_rust-lifeguard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lifeguard+default-devel-0.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lifeguard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lifeguard+default-devel}"
SRC_URI[x86_64_v2_rust-lifeguard+default-devel.sha256sum] = "9b32dc61f1eb49a7dc1a6b1d70f8e456e07791e4cf6ebe856015114cd927d424"

URI_x86_64_v2_rust-lifeguard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lifeguard-devel-0.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lifeguard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lifeguard-devel}"
SRC_URI[x86_64_v2_rust-lifeguard-devel.sha256sum] = "e75120a170e9cbc3788c97ff9a8dda413728c56c735f596e8ca6c6455bb851a2"

URI_aarch64_rust-lifeguard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lifeguard+default-devel-0.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-lifeguard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lifeguard+default-devel}"
SRC_URI[aarch64_rust-lifeguard+default-devel.sha256sum] = "f5e0615243cba511d9be1d6fc243513d2c70c534c1e0b2ddc6e15fcdc3a1509a"

URI_aarch64_rust-lifeguard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lifeguard-devel-0.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-lifeguard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lifeguard-devel}"
SRC_URI[aarch64_rust-lifeguard-devel.sha256sum] = "c7d3f684da3619bc1a695c7aa634a83470aa7a44ed0b726f07405e026b498064"

RDEPENDS:rust-lifeguard+default-devel = " \
 cargo \
 rust-lifeguard-devel \
 "
RDEPENDS:rust-lifeguard-devel = " \
 cargo \
 "
