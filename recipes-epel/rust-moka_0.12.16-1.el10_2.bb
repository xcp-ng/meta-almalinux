# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-moka"
PV = "0.12.16"
PR = "1.el10_2"
PACKAGES = " \
 rust-moka+default-devel \
 rust-moka+future-devel \
 rust-moka+logging-devel \
 rust-moka+quanta-devel \
 rust-moka+sync-devel \
 rust-moka-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-moka-0.12.16-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89a85ad394d4b2aeac87ffc6fd4facf0a41eed055f361d3b8b3bfdc14dcb4f34"

URI_x86_64_v2_rust-moka+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+default-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moka+default-devel}"
SRC_URI[x86_64_v2_rust-moka+default-devel.sha256sum] = "66dcaa9b423407243ffa80216b02cb5ac4b0096e2f9db63f3870bd990f1771da"

URI_x86_64_v2_rust-moka+future-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+future-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+future-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moka+future-devel}"
SRC_URI[x86_64_v2_rust-moka+future-devel.sha256sum] = "df80505011491f563b19bc4a2c9dbc86d06c96d6599d3c8bb8d18c3784fa54c1"

URI_x86_64_v2_rust-moka+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+logging-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moka+logging-devel}"
SRC_URI[x86_64_v2_rust-moka+logging-devel.sha256sum] = "398b7fcc4bcbedecc418076efa0f538ff82ee71e595d13951092a5ed9d0256d3"

URI_x86_64_v2_rust-moka+quanta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+quanta-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+quanta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moka+quanta-devel}"
SRC_URI[x86_64_v2_rust-moka+quanta-devel.sha256sum] = "a42d94ca46abcfc015de60cbca1b3fefc6929553ffad61ab6da7006aaaaf13e7"

URI_x86_64_v2_rust-moka+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka+sync-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moka+sync-devel}"
SRC_URI[x86_64_v2_rust-moka+sync-devel.sha256sum] = "85ed34472d93b3d0c88899db196122852926039c3e628dd02345febf07c488d9"

URI_x86_64_v2_rust-moka-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moka-devel-0.12.16-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moka-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moka-devel}"
SRC_URI[x86_64_v2_rust-moka-devel.sha256sum] = "7e8c629e47dfc33de44d1fd7f297a37ba1b0b21fd36597defa9d07f080e7a55d"

URI_aarch64_rust-moka+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+default-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-moka+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moka+default-devel}"
SRC_URI[aarch64_rust-moka+default-devel.sha256sum] = "d0415976e0b2f0d7f087aa2ae2e3540b5e1fa1f26e7a81b7ad064b458d2f3910"

URI_aarch64_rust-moka+future-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+future-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-moka+future-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moka+future-devel}"
SRC_URI[aarch64_rust-moka+future-devel.sha256sum] = "a4595d0b8d3b02675495963d2bb2bbf91b973bfe041b878fc022e0c378530204"

URI_aarch64_rust-moka+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+logging-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-moka+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moka+logging-devel}"
SRC_URI[aarch64_rust-moka+logging-devel.sha256sum] = "6b7a8109f828f774068617dce0b8f7abc0c0bf83d568264eddec329b34ac988d"

URI_aarch64_rust-moka+quanta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+quanta-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-moka+quanta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moka+quanta-devel}"
SRC_URI[aarch64_rust-moka+quanta-devel.sha256sum] = "5950916cf8a957643efb4f22692da2a51cdbaa9434f44c1307c87a599b742f6e"

URI_aarch64_rust-moka+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moka+sync-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-moka+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moka+sync-devel}"
SRC_URI[aarch64_rust-moka+sync-devel.sha256sum] = "e5cbca6e730b2cfdfacacb5520639fe6a97598ac93ae2db26921f7aab93ae9e7"

URI_aarch64_rust-moka-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moka-devel-0.12.16-1.el10_2.noarch.rpm;name=aarch64_rust-moka-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moka-devel}"
SRC_URI[aarch64_rust-moka-devel.sha256sum] = "9468205c0c24c3ec4261679c81e22b70bc57b90541ec6b269ba1bb4cc1cb8a4a"

RDEPENDS:rust-moka+default-devel = " \
 cargo \
 rust-moka-devel \
 "
RDEPENDS:rust-moka+future-devel = " \
 cargo \
 rust-async-lock+default-devel \
 rust-event-listener+default-devel \
 rust-futures-util+default-devel \
 rust-moka-devel \
 "
RDEPENDS:rust-moka+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-moka-devel \
 "
RDEPENDS:rust-moka+quanta-devel = " \
 cargo \
 rust-moka-devel \
 rust-quanta+default-devel \
 "
RDEPENDS:rust-moka+sync-devel = " \
 cargo \
 rust-moka-devel \
 "
RDEPENDS:rust-moka-devel = " \
 cargo \
 rust \
 rust-crossbeam-channel+default-devel \
 rust-crossbeam-epoch+default-devel \
 rust-crossbeam-utils+default-devel \
 rust-equivalent+default-devel \
 rust-parking_lot+default-devel \
 rust-portable-atomic+default-devel \
 rust-smallvec+default-devel \
 rust-tagptr+default-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 "
