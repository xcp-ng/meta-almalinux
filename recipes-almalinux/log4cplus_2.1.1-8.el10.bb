# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4cplus"
PV = "2.1.1"
PR = "8.el10"
PACKAGES = " \
 log4cplus \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/log4cplus-2.1.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "955656cb984e4e2b3f7fd1810c4a846733c90207639ad7cdbde825415cc2731b"

URI_x86_64_v2_log4cplus = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/log4cplus-2.1.1-8.el10.x86_64_v2.rpm;name=x86_64_v2_log4cplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cplus}"
SRC_URI[x86_64_v2_log4cplus.sha256sum] = "92aa93f69480df9d0bb13e1818b0b41e08f42212e9886370e5aeee79824afc55"

URI_aarch64_log4cplus = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/log4cplus-2.1.1-8.el10.aarch64.rpm;name=aarch64_log4cplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cplus}"
SRC_URI[aarch64_log4cplus.sha256sum] = "7f27f3773fea5f221a7dfad7c699d6fda26f7de5dc0c65f3ef3cbaac7ba6bad8"

RDEPENDS:log4cplus:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
"
RDEPENDS:log4cplus:aarch64 = " \
 glibc \
 libatomic \
 libgcc \
 libstdc++ \
"
