# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtcharts"
PV = "6.10.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtcharts \
 qt6-qtcharts-devel \
 qt6-qtcharts-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtcharts-6.10.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe3818a4cda8bb7bf5747d3b3fe4f20b8ebdabe9069d8ad908d6278fba874d49"

URI_x86_64_v2_qt6-qtcharts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtcharts-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcharts}"
SRC_URI[x86_64_v2_qt6-qtcharts.sha256sum] = "137bd85e2daaf01efb3d5e484fd2726491c4b901cb2802778aa0f8adfd6c6c8b"

URI_x86_64_v2_qt6-qtcharts-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtcharts-devel-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcharts-devel}"
SRC_URI[x86_64_v2_qt6-qtcharts-devel.sha256sum] = "9d70b4f50ef7e519dedbde52d837e7b0ff99ebd4a64107bdf9366650412b7b34"

URI_x86_64_v2_qt6-qtcharts-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtcharts-examples-6.10.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcharts-examples}"
SRC_URI[x86_64_v2_qt6-qtcharts-examples.sha256sum] = "621c28a607197e9920bb6a9964a1196dea651cbed4b6402fa64bba5d43b79520"

URI_aarch64_qt6-qtcharts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtcharts-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcharts}"
SRC_URI[aarch64_qt6-qtcharts.sha256sum] = "955089f40643f61d15cd52142c2e5b0875483a8f9ed5e0888e4a672dea62fae9"

URI_aarch64_qt6-qtcharts-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtcharts-devel-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcharts-devel}"
SRC_URI[aarch64_qt6-qtcharts-devel.sha256sum] = "0c49b4edd0a6f37a098ac244250d33a13ca660a2aac9b5a05bde3867264dc848"

URI_aarch64_qt6-qtcharts-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtcharts-examples-6.10.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcharts-examples}"
SRC_URI[aarch64_qt6-qtcharts-examples.sha256sum] = "5a09116c96f7e8ab53d7df7404e3525577d4ec3cd62809bc4cbd8adc229b8494"

RDEPENDS:qt6-qtcharts = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtcharts-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtcharts \
 qt6-qtcharts-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qtcharts-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 "
