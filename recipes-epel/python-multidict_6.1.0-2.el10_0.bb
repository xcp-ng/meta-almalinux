# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-multidict"
PV = "6.1.0"
PR = "2.el10_0"
PACKAGES = " \
 python3-multidict \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-multidict-6.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a42770e1e69ddf5b8904f02d397a9e1639d434cc4e1fcbb22c030368ca5a9961"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-multidict-6.1.0-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-multidict;unpack=0"
SRC_URI[x86_64_v2_python3-multidict.sha256sum] = "30fa91ba4bbb84163ee363f91198caf6a62b29ad38ef461173e644f6a218c2c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-multidict-6.1.0-2.el10_0.aarch64.rpm;name=aarch64_python3-multidict;unpack=0"
SRC_URI[aarch64_python3-multidict.sha256sum] = "e9c289f92215ab87f3e40a359310c16364eb2e45dedbbbfcddc39fc6dc8205bf"

RDEPENDS:python3-multidict = " \
 glibc \
 python3 \
 "
