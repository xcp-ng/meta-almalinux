# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "realmd"
PV = "0.17.1"
PR = "14.el10"
PACKAGES = " \
 realmd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/realmd-0.17.1-14.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e15475c3c9f9026bdff0c2082ced99a2bc27bb6ba98154fe306667327bd5f60e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/realmd-0.17.1-14.el10.x86_64_v2.rpm;name=x86_64_v2_realmd;unpack=0"
SRC_URI[x86_64_v2_realmd.sha256sum] = "231bc33774615477a81ac5b4c9fe707d20259e2fb6038113ef299520e7f9cb8e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/realmd-0.17.1-14.el10.aarch64.rpm;name=aarch64_realmd;unpack=0"
SRC_URI[aarch64_realmd.sha256sum] = "2fcc1a6b538cff05cd8ecd20b2b7f944d901c11f2641b1867067167b22d661d5"

RDEPENDS:realmd = " \
 authselect \
 bash \
 glib2 \
 glibc \
 krb5-libs \
 openldap \
 polkit \
 polkit-libs \
 systemd-libs \
 "
