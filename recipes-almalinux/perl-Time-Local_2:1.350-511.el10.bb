# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Time-Local"
PE = "2"
PV = "1.350"
PR = "511.el10"
PACKAGES = " \
 perl-Time-Local \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Time-Local-1.350-511.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "906e58ff4b53187e8fb87cc6c89da0f6d41faa1364a8840518e542b13edb6884"

URI_x86_64_v2_perl-Time-Local = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Time-Local-1.350-511.el10.noarch.rpm;name=x86_64_v2_perl-Time-Local;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Time-Local}"
SRC_URI[x86_64_v2_perl-Time-Local.sha256sum] = "3a4cb41e150dc2f774c690fc8257b7f5064a3b5b1f4f40cb5438e1d125224347"

URI_aarch64_perl-Time-Local = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Time-Local-1.350-511.el10.noarch.rpm;name=aarch64_perl-Time-Local;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Time-Local}"
SRC_URI[aarch64_perl-Time-Local.sha256sum] = "3a4cb41e150dc2f774c690fc8257b7f5064a3b5b1f4f40cb5438e1d125224347"

RDEPENDS:perl-Time-Local = " \
 perl-Carp \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-parent \
 "
