# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "compat-lua"
PV = "5.1.5"
PR = "25.el10_0"
PACKAGES = " \
 compat-lua \
 compat-lua-devel \
 compat-lua-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/compat-lua-5.1.5-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "706974b38880ecefd071b063ad528f2fc43f6e7a28b4c4ba526f609a3ae29863"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-lua-5.1.5-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_compat-lua;unpack=0"
SRC_URI[x86_64_v2_compat-lua.sha256sum] = "893821a9998e4fc7ee9f9671ccbf0e69e7fefcc8dbc27e9633130167b7d139f7"
RPROVIDES:compat-lua:append:x86_64_v2 = " virtual/lua"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-lua-devel-5.1.5-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_compat-lua-devel;unpack=0"
SRC_URI[x86_64_v2_compat-lua-devel.sha256sum] = "dcd73ec6d8c56573e81811d96ecca1794ec2c99aabe97789db85d2250f993566"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-lua-libs-5.1.5-25.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_compat-lua-libs;unpack=0"
SRC_URI[x86_64_v2_compat-lua-libs.sha256sum] = "9fa175f32574ea657d591330a09cc0cdd9cb3e32d532d3b54eb3eb5aa3359bc6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/compat-lua-5.1.5-25.el10_0.aarch64.rpm;name=aarch64_compat-lua;unpack=0"
SRC_URI[aarch64_compat-lua.sha256sum] = "4018eead43655d6db3118d8460c548f5f4091bfc8225f638aa19f3835677d70c"
RPROVIDES:compat-lua:append:aarch64 = " virtual/lua"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/compat-lua-devel-5.1.5-25.el10_0.aarch64.rpm;name=aarch64_compat-lua-devel;unpack=0"
SRC_URI[aarch64_compat-lua-devel.sha256sum] = "f89f92b240a8d0cfc5cec72c9f7fc614cb37503c6de5a876853796a7138cb6af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/compat-lua-libs-5.1.5-25.el10_0.aarch64.rpm;name=aarch64_compat-lua-libs;unpack=0"
SRC_URI[aarch64_compat-lua-libs.sha256sum] = "8ce339e47be1572b8aacbef5c8abf39da4d88aa60500818399dd5cc3c93f23a2"

RDEPENDS:compat-lua = " \
 compat-lua-libs \
 glibc \
 readline \
 "
RDEPENDS:compat-lua-devel = " \
 compat-lua-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:compat-lua-libs = " \
 glibc \
 "
