# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit"
PV = "125"
PR = "3.el10"
PACKAGES = " \
 polkit \
 polkit-devel \
 polkit-docs \
 polkit-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/polkit-125-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1486c85a9d252e832ca1244f5381eff796fa727ad655340c4989f97b73b3edbb"

URI_x86_64_v2_polkit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/polkit-125-3.el10.x86_64_v2.rpm;name=x86_64_v2_polkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit}"
SRC_URI[x86_64_v2_polkit.sha256sum] = "7e04edaea3b5e0f7a3b4cb88ee85f86c7f9d4052575ea6896c5922decb531b58"

URI_x86_64_v2_polkit-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/polkit-devel-125-3.el10.x86_64_v2.rpm;name=x86_64_v2_polkit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-devel}"
SRC_URI[x86_64_v2_polkit-devel.sha256sum] = "c4d65463bd4780e29ba143bf7e41194bcfbadb9b61dd57d36f53d2614df80f92"

URI_x86_64_v2_polkit-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/polkit-docs-125-3.el10.noarch.rpm;name=x86_64_v2_polkit-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-docs}"
SRC_URI[x86_64_v2_polkit-docs.sha256sum] = "7f7dde7699542c9b2b542b7a5107ace8e9d77741552790d45faede5b46e7021e"

URI_x86_64_v2_polkit-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/polkit-libs-125-3.el10.x86_64_v2.rpm;name=x86_64_v2_polkit-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-libs}"
SRC_URI[x86_64_v2_polkit-libs.sha256sum] = "d7d078e4f13c0b7e5d8ecc45d9154baf619c2f3860510cf7a7b4123f1da74f3f"

URI_aarch64_polkit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/polkit-125-3.el10.aarch64.rpm;name=aarch64_polkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit}"
SRC_URI[aarch64_polkit.sha256sum] = "f95754dd101571d817df368a05cf1b996ad4886d3ce495736f4e6dd0252e56bf"

URI_aarch64_polkit-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/polkit-devel-125-3.el10.aarch64.rpm;name=aarch64_polkit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-devel}"
SRC_URI[aarch64_polkit-devel.sha256sum] = "c5987d3780793719cb0bc16bc8538870b8f98f5b5ebbf43a01e9c098757a9f6b"

URI_aarch64_polkit-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/polkit-docs-125-3.el10.noarch.rpm;name=aarch64_polkit-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-docs}"
SRC_URI[aarch64_polkit-docs.sha256sum] = "7f7dde7699542c9b2b542b7a5107ace8e9d77741552790d45faede5b46e7021e"

URI_aarch64_polkit-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/polkit-libs-125-3.el10.aarch64.rpm;name=aarch64_polkit-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-libs}"
SRC_URI[aarch64_polkit-libs.sha256sum] = "a9ec3e2237231ce2472be41db54a12a254d0bdbf1a2bf40092f5b25752c75f18"

RDEPENDS:polkit = " \
 bash \
 dbus \
 duktape \
 expat \
 glib2 \
 glibc \
 pam-libs \
 polkit-libs \
 shadow-utils \
 systemd \
 systemd-libs \
 "
RDEPENDS:polkit-devel = " \
 glib2-devel \
 pkgconf-pkg-config \
 polkit-devel \
 polkit-docs \
 polkit-libs \
 "
RDEPENDS:polkit-docs = " \
 polkit-devel \
 "
RDEPENDS:polkit-libs = " \
 glib2 \
 glibc \
 systemd-libs \
 "
