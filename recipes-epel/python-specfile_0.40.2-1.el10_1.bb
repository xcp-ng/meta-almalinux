# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-specfile"
PV = "0.40.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-specfile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-specfile-0.40.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c40b63f416b6ffa3a8cf60ab6b2ba6ae00c29fce9a854f859071fa4686a627d"

URI_x86_64_v2_python3-specfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-specfile-0.40.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-specfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-specfile}"
SRC_URI[x86_64_v2_python3-specfile.sha256sum] = "0cb3c6d06bd7455468e0f6f8d90b5668ab53d283e573730261a4756b908d9864"

URI_aarch64_python3-specfile = "${EPEL_MIRROR}/aarch64/Packages/p/python3-specfile-0.40.2-1.el10_1.noarch.rpm;name=aarch64_python3-specfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-specfile}"
SRC_URI[aarch64_python3-specfile.sha256sum] = "ba9c74936d4d009c9eaaff372ce39aba672d8fc77785e22267ce6c47949b4b71"

RDEPENDS:python3-specfile = " \
 python3 \
 python3-rpm \
 "
