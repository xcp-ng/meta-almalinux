# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strip-ansi-escapes0.1"
PV = "0.1.1"
PR = "7.el10_2"
PACKAGES = " \
 rust-strip-ansi-escapes0.1+default-devel \
 rust-strip-ansi-escapes0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strip-ansi-escapes0.1-0.1.1-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8abea59a4dac0e212635a4ad15dd7680baabd8b285c083ddf1529ce3f450ff0"

URI_x86_64_v2_rust-strip-ansi-escapes0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strip-ansi-escapes0.1+default-devel-0.1.1-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strip-ansi-escapes0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strip-ansi-escapes0.1+default-devel}"
SRC_URI[x86_64_v2_rust-strip-ansi-escapes0.1+default-devel.sha256sum] = "3214f6e8ff4edacc217cf99c94ca274b458dfad6ebd8a586417013ac7bdc00b8"

URI_x86_64_v2_rust-strip-ansi-escapes0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strip-ansi-escapes0.1-devel-0.1.1-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strip-ansi-escapes0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strip-ansi-escapes0.1-devel}"
SRC_URI[x86_64_v2_rust-strip-ansi-escapes0.1-devel.sha256sum] = "21974ff5d69ae6fe84ca922619cb7e6d239bfbbb657856b263c86b8cbf258a39"

URI_aarch64_rust-strip-ansi-escapes0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strip-ansi-escapes0.1+default-devel-0.1.1-7.el10_2.noarch.rpm;name=aarch64_rust-strip-ansi-escapes0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strip-ansi-escapes0.1+default-devel}"
SRC_URI[aarch64_rust-strip-ansi-escapes0.1+default-devel.sha256sum] = "0c3af87baffa35f0164f1bc64a86ca74cb378a91a962981232ba1b27b719a063"

URI_aarch64_rust-strip-ansi-escapes0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strip-ansi-escapes0.1-devel-0.1.1-7.el10_2.noarch.rpm;name=aarch64_rust-strip-ansi-escapes0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strip-ansi-escapes0.1-devel}"
SRC_URI[aarch64_rust-strip-ansi-escapes0.1-devel.sha256sum] = "2f527259fef0a674d4906267578e868ab11ece973e832b130646bf3808b1905a"

RDEPENDS:rust-strip-ansi-escapes0.1+default-devel = " \
 cargo \
 rust-strip-ansi-escapes0.1-devel \
 "
RDEPENDS:rust-strip-ansi-escapes0.1-devel = " \
 cargo \
 rust-vte+default-devel \
 "
