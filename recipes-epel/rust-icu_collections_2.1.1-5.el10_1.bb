# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_collections"
PV = "2.1.1"
PR = "5.el10_1"
PACKAGES = " \
 rust-icu_collections+alloc-devel \
 rust-icu_collections+databake-devel \
 rust-icu_collections+default-devel \
 rust-icu_collections+serde-devel \
 rust-icu_collections-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_collections-2.1.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3201b2b3cbc563c300689c3adb934c2fd5b77e0db48eb8e98609990ed6a87fa"

URI_x86_64_v2_rust-icu_collections+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+alloc-devel-2.1.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+alloc-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+alloc-devel.sha256sum] = "dfc378a14b88188f55a1cdd9996df023a8dd1b4fcaa618639c0680b0d6981c47"

URI_x86_64_v2_rust-icu_collections+databake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+databake-devel-2.1.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+databake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+databake-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+databake-devel.sha256sum] = "b505a020beabe4d192731fea69efdec8a31d7fdf0faf49c65576ca550c893816"

URI_x86_64_v2_rust-icu_collections+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+default-devel-2.1.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+default-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+default-devel.sha256sum] = "aad4db3ca460aed57c1ff4026ce9ec79262f37321b3879712d605e818a2491e6"

URI_x86_64_v2_rust-icu_collections+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections+serde-devel-2.1.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_collections+serde-devel.sha256sum] = "cf095200f29663a81eb63ae8568cdfcbe0c5d8c7028035405b042a748848f4af"

URI_x86_64_v2_rust-icu_collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_collections-devel-2.1.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_collections-devel}"
SRC_URI[x86_64_v2_rust-icu_collections-devel.sha256sum] = "fa3e5a1f2259573d26e01b105d540641aa9599e28a28f2f31f0012df7551537c"

URI_aarch64_rust-icu_collections+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+alloc-devel-2.1.1-5.el10_1.noarch.rpm;name=aarch64_rust-icu_collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+alloc-devel}"
SRC_URI[aarch64_rust-icu_collections+alloc-devel.sha256sum] = "010006116d49039ab480ee925c931097034b934462c60f174ac9fd798afbe711"

URI_aarch64_rust-icu_collections+databake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+databake-devel-2.1.1-5.el10_1.noarch.rpm;name=aarch64_rust-icu_collections+databake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+databake-devel}"
SRC_URI[aarch64_rust-icu_collections+databake-devel.sha256sum] = "f817b19f7488ee50e751ce919190f99675cc13878baf5e5acbba5c5f692f1e11"

URI_aarch64_rust-icu_collections+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+default-devel-2.1.1-5.el10_1.noarch.rpm;name=aarch64_rust-icu_collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+default-devel}"
SRC_URI[aarch64_rust-icu_collections+default-devel.sha256sum] = "92551cbd6fb76e15b5eafd1fbe6ca8e85c2372738001c653ecbe43975c9d00a5"

URI_aarch64_rust-icu_collections+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections+serde-devel-2.1.1-5.el10_1.noarch.rpm;name=aarch64_rust-icu_collections+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections+serde-devel}"
SRC_URI[aarch64_rust-icu_collections+serde-devel.sha256sum] = "acf9ac7a29b383637f58ff9225f17af708769222aeb7192c1ea2eebbd46eef5b"

URI_aarch64_rust-icu_collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_collections-devel-2.1.1-5.el10_1.noarch.rpm;name=aarch64_rust-icu_collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_collections-devel}"
SRC_URI[aarch64_rust-icu_collections-devel.sha256sum] = "01befc15933c722b33df002e807cbbc7ce03322c973a84fe38e783f882b2746d"

RDEPENDS:rust-icu_collections+alloc-devel = " \
 cargo \
 rust-icu_collections-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+alloc-devel \
 "
RDEPENDS:rust-icu_collections+databake-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_collections-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_collections+default-devel = " \
 cargo \
 rust-icu_collections-devel \
 "
RDEPENDS:rust-icu_collections+serde-devel = " \
 cargo \
 rust-icu_collections+alloc-devel \
 rust-icu_collections-devel \
 rust-potential_utf+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_collections-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 rust-yoke+derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 rust-zerovec+derive-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
