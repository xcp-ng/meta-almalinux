# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nss-mdns"
PV = "0.15.1"
PR = "12.el10_0"
PACKAGES = " \
 nss-mdns \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nss-mdns-0.15.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3461e5120a0f4bb32b31a8e4f7caa188eb510557d2a73c8c7e7b9a980911046"

URI_x86_64_v2_nss-mdns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nss-mdns-0.15.1-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nss-mdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-mdns}"
SRC_URI[x86_64_v2_nss-mdns.sha256sum] = "7379fa21bb50d05d2263e10b23721abd9d02f32589fa42a4c2e0895e76a03dbe"

URI_aarch64_nss-mdns = "${EPEL_MIRROR}/aarch64/Packages/n/nss-mdns-0.15.1-12.el10_0.aarch64.rpm;name=aarch64_nss-mdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-mdns}"
SRC_URI[aarch64_nss-mdns.sha256sum] = "04dc5df6dba7af4d848aa5dd1693e8d33183484b2aca5893ab271490b3c76955"

RDEPENDS:nss-mdns = " \
 authselect \
 avahi \
 bash \
 glibc \
 "
