# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktnef"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ktnef \
 ktnef-devel \
 ktnef-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktnef-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "502beeec93afdfe7b5d0df1ccbda2217ca4d2ded27d4196871c6841da46a0202"

URI_x86_64_v2_ktnef = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktnef}"
SRC_URI[x86_64_v2_ktnef.sha256sum] = "c2220a098624b7325a4ac640976292a8dbc6682605efda56549ab718025f8871"

URI_x86_64_v2_ktnef-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktnef-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktnef-devel}"
SRC_URI[x86_64_v2_ktnef-devel.sha256sum] = "4c30637335f87f6e6cf9e8103e5a796ccb2c765f9f57de3edaf8ef2191f717fa"

URI_x86_64_v2_ktnef-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktnef-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ktnef-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktnef-doc}"
SRC_URI[x86_64_v2_ktnef-doc.sha256sum] = "5e895764f723eff70623711efeb29f91248ad730c8992e04a4ece18c6294c61d"

URI_aarch64_ktnef = "${EPEL_MIRROR}/aarch64/Packages/k/ktnef-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ktnef;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktnef}"
SRC_URI[aarch64_ktnef.sha256sum] = "5784487ffe10b69c2d940f1576dd44893dd8274ca6b7c153e08e40e5e7230585"

URI_aarch64_ktnef-devel = "${EPEL_MIRROR}/aarch64/Packages/k/ktnef-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ktnef-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktnef-devel}"
SRC_URI[aarch64_ktnef-devel.sha256sum] = "be38b7e9a289532a5ed3a900022a886263d04bc1fe79ce539b24b665b8f90c9a"

URI_aarch64_ktnef-doc = "${EPEL_MIRROR}/aarch64/Packages/k/ktnef-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_ktnef-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktnef-doc}"
SRC_URI[aarch64_ktnef-doc.sha256sum] = "be0dbca28eaa56efe072dfac8de95c7e047d353fc39babbbf6859531bea38b27"

RDEPENDS:ktnef = " \
 glibc \
 kcalutils \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:ktnef-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 ktnef \
 "
RDEPENDS:ktnef-doc = " \
 "
