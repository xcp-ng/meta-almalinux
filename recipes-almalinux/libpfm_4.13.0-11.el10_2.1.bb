# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpfm"
PV = "4.13.0"
PR = "11.el10_2.1"
PACKAGES = " \
 libpfm \
 libpfm-devel \
 python3-libpfm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libpfm-4.13.0-11.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01593b1f3c7ab1dcd4ed81a1e341be3775033091f922386815cef740a7cd9a18"

URI_x86_64_v2_libpfm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpfm-4.13.0-11.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libpfm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpfm}"
SRC_URI[x86_64_v2_libpfm.sha256sum] = "2bdcac88758b5951defca0d5e0b7895d125b9baad00d41c5b4c7d1aa48b67d5b"

URI_x86_64_v2_libpfm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpfm-devel-4.13.0-11.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_libpfm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpfm-devel}"
SRC_URI[x86_64_v2_libpfm-devel.sha256sum] = "21c2c284e8e8c3c649a7a2694b96d35de1bf336849a11a62041f37757fb27224"

URI_x86_64_v2_python3-libpfm = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-libpfm-4.13.0-11.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_python3-libpfm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libpfm}"
SRC_URI[x86_64_v2_python3-libpfm.sha256sum] = "ad93fb2e68e263395d4db85c30afb4189641e9a329cc73dc4e77bf37a99024ae"

URI_aarch64_libpfm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpfm-4.13.0-11.el10_2.1.aarch64.rpm;name=aarch64_libpfm;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpfm}"
SRC_URI[aarch64_libpfm.sha256sum] = "03281c02dc93a547b26b24f5ad91bbe60b989865fd91a8036982e6add43ebf5e"

URI_aarch64_libpfm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpfm-devel-4.13.0-11.el10_2.1.aarch64.rpm;name=aarch64_libpfm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpfm-devel}"
SRC_URI[aarch64_libpfm-devel.sha256sum] = "eeb94283eff1d902f96cc780c8f81e78212b4dfdf421f73df3e717ce4119ba20"

URI_aarch64_python3-libpfm = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-libpfm-4.13.0-11.el10_2.1.aarch64.rpm;name=aarch64_python3-libpfm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libpfm}"
SRC_URI[aarch64_python3-libpfm.sha256sum] = "fd652cfc411d34c26d86f4b7970e09e57af7c1b8bb279f1e139c82fff68801ec"

RDEPENDS:libpfm = " \
 glibc \
 "
RDEPENDS:libpfm-devel = " \
 libpfm \
 "
RDEPENDS:python3-libpfm = " \
 glibc \
 libpfm \
 python3 \
 "
