# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-vpl-gpu-rt"
PV = "26.1.6"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 intel-vpl-gpu-rt \
 intel-vpl-gpu-rt-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-vpl-gpu-rt-26.1.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f220379e196103c2527b9fca73ce69ee4ad920876f6ae3af02d279d358ab6449"

URI_x86_64_v2_intel-vpl-gpu-rt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-vpl-gpu-rt-26.1.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-vpl-gpu-rt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-vpl-gpu-rt}"
SRC_URI[x86_64_v2_intel-vpl-gpu-rt.sha256sum] = "5e65d8dbe1d4e6c87ab52668e7e43468f96e47753a2a7f894f7f6c4d919c451d"

URI_x86_64_v2_intel-vpl-gpu-rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-vpl-gpu-rt-devel-26.1.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-vpl-gpu-rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-vpl-gpu-rt-devel}"
SRC_URI[x86_64_v2_intel-vpl-gpu-rt-devel.sha256sum] = "7b038660815c6d1600d62f96da04b0ce94c5242e8509ca00501e88b7a51ecdb5"

RDEPENDS:intel-vpl-gpu-rt = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 libvpl \
 "
RDEPENDS:intel-vpl-gpu-rt-devel = " \
 intel-vpl-gpu-rt \
 pkgconf-pkg-config \
 "
