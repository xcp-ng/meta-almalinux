# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-sony-gobreaker"
PV = "0.5.0"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-sony-gobreaker-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-sony-gobreaker-0.5.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "75c3bc7ea9f7729f84608002683b89f65718106334c03005d949f9e126b824d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-sony-gobreaker-devel-0.5.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-sony-gobreaker-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-sony-gobreaker-devel.sha256sum] = "826741aefd2a5567b691f0535aaa24610a12aa1dfcb4457ff2c5f804f70018ee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-sony-gobreaker-devel-0.5.0-10.el10_0.noarch.rpm;name=aarch64_golang-github-sony-gobreaker-devel;unpack=0"
SRC_URI[aarch64_golang-github-sony-gobreaker-devel.sha256sum] = "8409f214e55a577363fa8df872918cd2999bbe06c1a21ef18a6a99a83e13f41e"

RDEPENDS:golang-github-sony-gobreaker-devel = " \
 go-filesystem \
 "
