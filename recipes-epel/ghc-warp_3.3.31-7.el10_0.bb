# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-warp"
PV = "3.3.31"
PR = "7.el10_0"
PACKAGES = " \
 ghc-recv \
 ghc-recv-devel \
 ghc-recv-doc \
 ghc-recv-prof \
 ghc-warp \
 ghc-warp-devel \
 ghc-warp-doc \
 ghc-warp-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-warp-3.3.31-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a85a7b4c49cfefe49de91d8cd86295f06149cc5616bd5b059037feec7651831"

URI_x86_64_v2_ghc-recv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-recv-0.1.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-recv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-recv}"
SRC_URI[x86_64_v2_ghc-recv.sha256sum] = "23805853d3a4eef65bac7385be89811cfa094527636325ab4daf6ca0aff08f8c"

URI_x86_64_v2_ghc-recv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-recv-devel-0.1.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-recv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-recv-devel}"
SRC_URI[x86_64_v2_ghc-recv-devel.sha256sum] = "5a7af2d339453417030afa087c0b652da5b5adaface92247f3688652a8b54f41"

URI_x86_64_v2_ghc-recv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-recv-doc-0.1.0-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-recv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-recv-doc}"
SRC_URI[x86_64_v2_ghc-recv-doc.sha256sum] = "acaa8d41439b21f9dae6c0e313f41b173c99984ff17d875144fe79c4a1728314"

URI_x86_64_v2_ghc-recv-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-recv-prof-0.1.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-recv-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-recv-prof}"
SRC_URI[x86_64_v2_ghc-recv-prof.sha256sum] = "2d5b912e1d48fefffd4bf4055418cc434e2c1bd70755611463ae23a98b4abc79"

URI_x86_64_v2_ghc-warp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-warp-3.3.31-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-warp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-warp}"
SRC_URI[x86_64_v2_ghc-warp.sha256sum] = "cbb5f0a53035dee5f6f9982df3883cab6d2b6f4b8c3f4af2de0b8f940b3e18b9"

URI_x86_64_v2_ghc-warp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-warp-devel-3.3.31-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-warp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-warp-devel}"
SRC_URI[x86_64_v2_ghc-warp-devel.sha256sum] = "e2d97cd0e1a2972aab322e86878705a2cabeca5b6fc910c764fcdbb7065222f9"

URI_x86_64_v2_ghc-warp-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-warp-doc-3.3.31-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-warp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-warp-doc}"
SRC_URI[x86_64_v2_ghc-warp-doc.sha256sum] = "6ae9b2a2f5ecd3c56837ba317983ad195f12d8549f7fb135b01bba5bad3d729d"

URI_x86_64_v2_ghc-warp-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-warp-prof-3.3.31-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-warp-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-warp-prof}"
SRC_URI[x86_64_v2_ghc-warp-prof.sha256sum] = "0003864af83989674f972976e0ab4e32b12f83cc7320d8f93ed3e025961ea6b1"

URI_aarch64_ghc-recv = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-recv-0.1.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-recv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-recv}"
SRC_URI[aarch64_ghc-recv.sha256sum] = "818ed3c44b47e93e31fd1dcd691582b3742047b5cdeb60c6dfff33b033ab7fee"

URI_aarch64_ghc-recv-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-recv-devel-0.1.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-recv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-recv-devel}"
SRC_URI[aarch64_ghc-recv-devel.sha256sum] = "7c23d5da7c5d6ad67a0d5e822ca6a56096c4ecc352dd2d3bff5c1df5c239e33b"

URI_aarch64_ghc-recv-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-recv-doc-0.1.0-7.el10_0.noarch.rpm;name=aarch64_ghc-recv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-recv-doc}"
SRC_URI[aarch64_ghc-recv-doc.sha256sum] = "1dc1c2bbd6f2205cd95d356dadaa05c58617c5166c1ffa957b0efb46c588f6fa"

URI_aarch64_ghc-recv-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-recv-prof-0.1.0-7.el10_0.aarch64.rpm;name=aarch64_ghc-recv-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-recv-prof}"
SRC_URI[aarch64_ghc-recv-prof.sha256sum] = "b6d78e00af5d21b0688eacd521cb9d84141af37fa96be991fd1e9da1f027390b"

URI_aarch64_ghc-warp = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-warp-3.3.31-7.el10_0.aarch64.rpm;name=aarch64_ghc-warp;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-warp}"
SRC_URI[aarch64_ghc-warp.sha256sum] = "1988d8753f753121a5b86622a066157b0b7b2bce9bf6a9d4c13cd70f53cc51a8"

URI_aarch64_ghc-warp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-warp-devel-3.3.31-7.el10_0.aarch64.rpm;name=aarch64_ghc-warp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-warp-devel}"
SRC_URI[aarch64_ghc-warp-devel.sha256sum] = "7d17a2e124e67b769618491d46e0e4031b40c3590d93e67cdf1d933f9e80140a"

URI_aarch64_ghc-warp-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-warp-doc-3.3.31-7.el10_0.noarch.rpm;name=aarch64_ghc-warp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-warp-doc}"
SRC_URI[aarch64_ghc-warp-doc.sha256sum] = "bbffb0db82f655096703925c3332ab51f27204c44365cdb45b0426bd03dc9b60"

URI_aarch64_ghc-warp-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-warp-prof-3.3.31-7.el10_0.aarch64.rpm;name=aarch64_ghc-warp-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-warp-prof}"
SRC_URI[aarch64_ghc-warp-prof.sha256sum] = "baf5658bdb49aa21ea60bc95e9e03ee5e818acd8f4724923cfedb7b087f40ec3"

RDEPENDS:ghc-recv = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-network \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-recv-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-network-devel \
 ghc-recv \
 "
RDEPENDS:ghc-recv-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-recv-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-network-prof \
 ghc-recv-devel \
 "
RDEPENDS:ghc-warp = " \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-async \
 ghc-attoparsec \
 ghc-auto-update \
 ghc-base \
 ghc-basement \
 ghc-binary \
 ghc-bsb-http-chunked \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-containers \
 ghc-crypton \
 ghc-crypton-x509 \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-http-date \
 ghc-http-types \
 ghc-http2 \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-psqueues \
 ghc-random \
 ghc-recv \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-simple-sendfile \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-time-manager \
 ghc-transformers \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vault \
 ghc-wai \
 ghc-word8 \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-warp-devel = " \
 ghc-array-devel \
 ghc-auto-update-devel \
 ghc-base-devel \
 ghc-bsb-http-chunked-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-crypton-x509-devel \
 ghc-hashable-devel \
 ghc-http-date-devel \
 ghc-http-types-devel \
 ghc-http2-devel \
 ghc-iproute-devel \
 ghc-network-devel \
 ghc-recv-devel \
 ghc-simple-sendfile-devel \
 ghc-stm-devel \
 ghc-streaming-commons-devel \
 ghc-text-devel \
 ghc-time-manager-devel \
 ghc-unix-devel \
 ghc-unliftio-devel \
 ghc-vault-devel \
 ghc-wai-devel \
 ghc-warp \
 ghc-word8-devel \
 "
RDEPENDS:ghc-warp-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-warp-prof = " \
 ghc-array-prof \
 ghc-auto-update-prof \
 ghc-base-prof \
 ghc-bsb-http-chunked-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-containers-prof \
 ghc-crypton-x509-prof \
 ghc-hashable-prof \
 ghc-http-date-prof \
 ghc-http-types-prof \
 ghc-http2-prof \
 ghc-iproute-prof \
 ghc-network-prof \
 ghc-recv-prof \
 ghc-simple-sendfile-prof \
 ghc-stm-prof \
 ghc-streaming-commons-prof \
 ghc-text-prof \
 ghc-time-manager-prof \
 ghc-unix-prof \
 ghc-unliftio-prof \
 ghc-vault-prof \
 ghc-wai-prof \
 ghc-warp-devel \
 ghc-word8-prof \
 "
