# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "guestfs-tools"
PV = "1.52.2"
PR = "2.el10.alma.1"
PACKAGES = " \
 guestfs-tools \
 virt-win-reg \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/guestfs-tools-1.52.2-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "df2c13a73e27afe3deb770d64910d416e66650adb93dd106714cf1698c895f13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/guestfs-tools-1.52.2-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_guestfs-tools;unpack=0"
SRC_URI[x86_64_v2_guestfs-tools.sha256sum] = "19f39719058d4c6a507c7736f6e43e99dae6fd8eb59abda864b09d79996ae037"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/virt-win-reg-1.52.2-2.el10.alma.1.noarch.rpm;name=x86_64_v2_virt-win-reg;unpack=0"
SRC_URI[x86_64_v2_virt-win-reg.sha256sum] = "e2a4a6ea6d495048ed8cd7853ca67b9aea097e5d8126f9f03e57fc154348b5e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/guestfs-tools-1.52.2-2.el10.alma.1.aarch64.rpm;name=aarch64_guestfs-tools;unpack=0"
SRC_URI[aarch64_guestfs-tools.sha256sum] = "837e74251edc48d9d9ec37caa32c7929ffd6568e96047d9250412a7a2a48b4fa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/virt-win-reg-1.52.2-2.el10.alma.1.noarch.rpm;name=aarch64_virt-win-reg;unpack=0"
SRC_URI[aarch64_virt-win-reg.sha256sum] = "e2a4a6ea6d495048ed8cd7853ca67b9aea097e5d8126f9f03e57fc154348b5e1"

RDEPENDS:guestfs-tools = " \
 curl \
 glib2 \
 glibc \
 gnupg2 \
 json-c \
 libgcc \
 libguestfs \
 libosinfo \
 libvirt-libs \
 libxcrypt \
 libxml2 \
 ncurses-libs \
 pcre2 \
 qemu-img \
 xz \
 xz-libs \
 "
RDEPENDS:virt-win-reg = " \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Pod-Usage \
 perl-Sys-Guestfs \
 perl-hivex \
 perl-interpreter \
 perl-libintl-perl \
 perl-libs \
 "
