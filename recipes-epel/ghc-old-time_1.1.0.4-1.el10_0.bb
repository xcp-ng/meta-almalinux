# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-old-time"
PV = "1.1.0.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-old-time \
 ghc-old-time-devel \
 ghc-old-time-doc \
 ghc-old-time-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-old-time-1.1.0.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c92fab407beb8b39a413a547b0f462f70ed34d368c60192050d24a1f6117ee76"

URI_x86_64_v2_ghc-old-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-old-time-1.1.0.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-old-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-old-time}"
SRC_URI[x86_64_v2_ghc-old-time.sha256sum] = "5ee0be8e8363f222c43eb21c1726e6afc9ea5fb6170a18c9edfd5169173fbd56"

URI_x86_64_v2_ghc-old-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-old-time-devel-1.1.0.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-old-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-old-time-devel}"
SRC_URI[x86_64_v2_ghc-old-time-devel.sha256sum] = "3d68468dfb5b9a927a6ca796de746ac6a2a429263a71d1ff41e0bc91096605f5"

URI_x86_64_v2_ghc-old-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-old-time-doc-1.1.0.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-old-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-old-time-doc}"
SRC_URI[x86_64_v2_ghc-old-time-doc.sha256sum] = "35076e892913ac92dbeeb2a0df95fde2f462e4b2ef1647a6c326281d509e33e2"

URI_x86_64_v2_ghc-old-time-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-old-time-prof-1.1.0.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-old-time-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-old-time-prof}"
SRC_URI[x86_64_v2_ghc-old-time-prof.sha256sum] = "00d4dbb6a8348862d72c3198a3ab3df7bd26bbd9ddad2bdd691af5ff08427f11"

URI_aarch64_ghc-old-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-old-time-1.1.0.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-old-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-old-time}"
SRC_URI[aarch64_ghc-old-time.sha256sum] = "f9ae72a5ede45a3f0f017687d7d9576e66afdb6e4ffdf891e7da81bb109efd38"

URI_aarch64_ghc-old-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-old-time-devel-1.1.0.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-old-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-old-time-devel}"
SRC_URI[aarch64_ghc-old-time-devel.sha256sum] = "38f64aec551b7a69380e6a9b0986f09392de4387388a9b7e4a1952935741c469"

URI_aarch64_ghc-old-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-old-time-doc-1.1.0.4-1.el10_0.noarch.rpm;name=aarch64_ghc-old-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-old-time-doc}"
SRC_URI[aarch64_ghc-old-time-doc.sha256sum] = "3355fcc03506ee2538892eae7c7e03974b91684a8f455fdecad78d46dac339eb"

URI_aarch64_ghc-old-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-old-time-prof-1.1.0.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-old-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-old-time-prof}"
SRC_URI[aarch64_ghc-old-time-prof.sha256sum] = "3adbb254be9f9f27c6191f8df217af53fb92c9ded6b151f331db670ad3bcbc39"

RDEPENDS:ghc-old-time = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-old-locale \
 glibc \
 gmp \
 "
RDEPENDS:ghc-old-time-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-old-locale-devel \
 ghc-old-time \
 "
RDEPENDS:ghc-old-time-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-old-time-prof = " \
 ghc-base-prof \
 ghc-old-locale-prof \
 ghc-old-time-devel \
 "
