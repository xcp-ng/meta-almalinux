# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nss"
PV = "3.124.0"
PR = "5.el10_0"
PACKAGES = " \
 nspr \
 nspr-devel \
 nss \
 nss-devel \
 nss-softokn \
 nss-softokn-devel \
 nss-softokn-freebl \
 nss-softokn-freebl-devel \
 nss-sysinit \
 nss-tools \
 nss-util \
 nss-util-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nss-3.124.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f25c2ad7947e8f47e64e5b16cb4a9dd7d2c25c5dad9cb1b0149a2144a168f575"

URI_x86_64_v2_nspr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nspr-4.39.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nspr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nspr}"
SRC_URI[x86_64_v2_nspr.sha256sum] = "a46e1589396f1c2b4158895b8df8dab682e8403f63b5f6c1313d41e33bf3681d"

URI_x86_64_v2_nspr-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nspr-devel-4.39.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nspr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nspr-devel}"
SRC_URI[x86_64_v2_nspr-devel.sha256sum] = "561f407a89f2b8513d32959fb75334db8cc26f6d035bf45f67c5ce2b9d62ca9b"

URI_x86_64_v2_nss = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss}"
SRC_URI[x86_64_v2_nss.sha256sum] = "42b174d2af22cda06ef06152f99ad1aa84b9db6bd645afbe8161988902586997"

URI_x86_64_v2_nss-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-devel-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-devel}"
SRC_URI[x86_64_v2_nss-devel.sha256sum] = "3d8363642c7310ee858756f70128def9c34b3bba089006a999b2a62d85e7317d"

URI_x86_64_v2_nss-softokn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn}"
SRC_URI[x86_64_v2_nss-softokn.sha256sum] = "48cbddb9a2e14765ff8ba62f03a5309c1109bcc7f2c6d05f5b696df30298fc51"

URI_x86_64_v2_nss-softokn-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-devel-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn-devel}"
SRC_URI[x86_64_v2_nss-softokn-devel.sha256sum] = "184699b02a186c9725f77c8a8b0967b51c966ad1ab086f347cca2327c173a775"

URI_x86_64_v2_nss-softokn-freebl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-freebl-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn-freebl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn-freebl}"
SRC_URI[x86_64_v2_nss-softokn-freebl.sha256sum] = "71cc29653a25ac6c9f4ccb1c54ecf9461c2d60a652437e528a92b45e77167511"

URI_x86_64_v2_nss-softokn-freebl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-softokn-freebl-devel-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-softokn-freebl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-softokn-freebl-devel}"
SRC_URI[x86_64_v2_nss-softokn-freebl-devel.sha256sum] = "de330d74baaf2021f72f69f34276671ead3517735dc2760edce3e9f941c54f0d"

URI_x86_64_v2_nss-sysinit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-sysinit-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-sysinit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-sysinit}"
SRC_URI[x86_64_v2_nss-sysinit.sha256sum] = "e43424771a5e7a184b8a0f73e5bc114243e90759104d737d27246db7350a03e7"

URI_x86_64_v2_nss-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-tools-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-tools}"
SRC_URI[x86_64_v2_nss-tools.sha256sum] = "e2a8a86eb46fc4f0eea6819bbc0b240818b3f8e28ed1881a2a6826059a8b8f69"

URI_x86_64_v2_nss-util = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-util-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-util;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-util}"
SRC_URI[x86_64_v2_nss-util.sha256sum] = "517d1b4b87533d0bfee5d8350639ace38677c4dfed922de8c197a4aa0de13f45"

URI_x86_64_v2_nss-util-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nss-util-devel-3.124.0-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_nss-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss-util-devel}"
SRC_URI[x86_64_v2_nss-util-devel.sha256sum] = "216a12335951ee91424b18e0d64dc14bd0ffeb0268f77e23c8855d7ac1c3f371"

URI_aarch64_nspr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nspr-4.39.0-5.el10_0.aarch64.rpm;name=aarch64_nspr;unpack=0"
SRC_URI:append = " ${URI_aarch64_nspr}"
SRC_URI[aarch64_nspr.sha256sum] = "20900c35c07f1e9adb998149ea027219980cc6056f7b0de8cc1b5f8838778ebd"

URI_aarch64_nspr-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nspr-devel-4.39.0-5.el10_0.aarch64.rpm;name=aarch64_nspr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nspr-devel}"
SRC_URI[aarch64_nspr-devel.sha256sum] = "6fd439f950c953c2fc83320ce797626b7e1c76a4312e554f9eeceb97873e4e73"

URI_aarch64_nss = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss}"
SRC_URI[aarch64_nss.sha256sum] = "c8c64b17cfe3e4de364bea45f9f60ee0193ca50795b1edc8ac87e9e2ad30cc65"

URI_aarch64_nss-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-devel-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-devel}"
SRC_URI[aarch64_nss-devel.sha256sum] = "8072896482d0f9c9e08402b5aa3bc41e8a3a3af3d358bcc53fc7d51ab57f9028"

URI_aarch64_nss-softokn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss-softokn;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn}"
SRC_URI[aarch64_nss-softokn.sha256sum] = "a8c7ffbfe335a3ba23460ca80800836179619bc27f1eb4ef81ba7be16156b3c0"

URI_aarch64_nss-softokn-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-devel-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss-softokn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn-devel}"
SRC_URI[aarch64_nss-softokn-devel.sha256sum] = "72294f74e00447649a23ca674fec089cea57fc0893153837bf93972d0ab49139"

URI_aarch64_nss-softokn-freebl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-freebl-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss-softokn-freebl;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn-freebl}"
SRC_URI[aarch64_nss-softokn-freebl.sha256sum] = "443a4b063a726168a3535c340b6b203f3b327fcf738806589b99c4a25875ed23"

URI_aarch64_nss-softokn-freebl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-softokn-freebl-devel-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss-softokn-freebl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-softokn-freebl-devel}"
SRC_URI[aarch64_nss-softokn-freebl-devel.sha256sum] = "5a6ab5992f3167f194f71b84c05cb0b1e3837a2fba692298cff4a06cfcba923a"

URI_aarch64_nss-sysinit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-sysinit-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss-sysinit;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-sysinit}"
SRC_URI[aarch64_nss-sysinit.sha256sum] = "9b035c1dc666435a2092c3c7b85d54c1d8013965583136a31a2150b02681d299"

URI_aarch64_nss-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-tools-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-tools}"
SRC_URI[aarch64_nss-tools.sha256sum] = "110a5b58551c57d283d33b1bc2a32bda2bf24e84f98558426754fe2c7660491b"

URI_aarch64_nss-util = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-util-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss-util;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-util}"
SRC_URI[aarch64_nss-util.sha256sum] = "ed80c24fdf18b11b4c228174ac3b11b516686409d2781daf5f5a616f2403730b"

URI_aarch64_nss-util-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nss-util-devel-3.124.0-5.el10_0.aarch64.rpm;name=aarch64_nss-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss-util-devel}"
SRC_URI[aarch64_nss-util-devel.sha256sum] = "1eb0d84e878628333e2ebee99148cf3f05c7020e3c6a082f0184ecc6a2291e06"

RDEPENDS:nspr = " \
 glibc \
 "
RDEPENDS:nspr-devel = " \
 bash \
 nspr \
 pkgconf-pkg-config \
 "
RDEPENDS:nss = " \
 bash \
 crypto-policies \
 glibc \
 nspr \
 nss-softokn \
 nss-sysinit \
 nss-util \
 p11-kit-trust \
 "
RDEPENDS:nss-devel = " \
 bash \
 nspr-devel \
 nss \
 nss-softokn-devel \
 nss-util-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nss-softokn = " \
 glibc \
 nspr \
 nss-softokn-freebl \
 nss-util \
 sqlite-libs \
 "
RDEPENDS:nss-softokn-devel = " \
 bash \
 nspr-devel \
 nss-softokn \
 nss-softokn-freebl-devel \
 nss-util-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:nss-softokn-freebl = " \
 bash \
 glibc \
 nspr \
 nss-util \
 "
RDEPENDS:nss-softokn-freebl-devel = " \
 nss-softokn-freebl \
 "
RDEPENDS:nss-sysinit = " \
 bash \
 glibc \
 nspr \
 nss \
 nss-util \
 sed \
 virtual/coreutils \
 "
RDEPENDS:nss-tools = " \
 glibc \
 nspr \
 nss \
 nss-util \
 zlib-ng-compat \
 "
RDEPENDS:nss-util = " \
 glibc \
 nspr \
 "
RDEPENDS:nss-util-devel = " \
 bash \
 nspr-devel \
 nss-util \
 pkgconf-pkg-config \
 "
