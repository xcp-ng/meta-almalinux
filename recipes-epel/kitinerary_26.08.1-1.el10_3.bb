# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kitinerary"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kitinerary \
 kitinerary-devel \
 kitinerary-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kitinerary-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bd5387d4dda2ff472ec4952cc637eb8493f427d308636f1579d82f6b1916c2f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary;unpack=0"
SRC_URI[x86_64_v2_kitinerary.sha256sum] = "ac627710db1c9710b1ca343c01ec881a4245022b65efb8f29816426f4d3adfc7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitinerary-devel;unpack=0"
SRC_URI[x86_64_v2_kitinerary-devel.sha256sum] = "b01d2f754fe8b6b8f7a84e9693cc581d9f484844d3a901c3e914136a44963b80"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitinerary-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kitinerary-doc;unpack=0"
SRC_URI[x86_64_v2_kitinerary-doc.sha256sum] = "b4771919562075fb3df960c3379fd1dd02de510333112cb6aca669450bb4e1de"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kitinerary;unpack=0"
SRC_URI[aarch64_kitinerary.sha256sum] = "b53ac6ddb69246735430d8e5dcab5f1921aec197c4ec1ed5ab5cd691045cd7f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kitinerary-devel;unpack=0"
SRC_URI[aarch64_kitinerary-devel.sha256sum] = "758c4eb8d2e60ce73cbe2a9bda928b8a407346286b714984ac15a536e5668246"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kitinerary-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kitinerary-doc;unpack=0"
SRC_URI[aarch64_kitinerary-doc.sha256sum] = "cb94e56c143898ddcf088c0be93ab7410b77fd8074a28fd9538fd2ba7cf5d68f"

RDEPENDS:kitinerary = " \
 glibc \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcontacts \
 kf6-ki18n \
 kf6-kmime \
 kpkpass \
 libgcc \
 libstdc++ \
 libxml2 \
 openssl-libs \
 poppler \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 zxing-cpp \
 "
RDEPENDS:kitinerary-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kmime-devel \
 kitinerary \
 kpkpass-devel \
 "
RDEPENDS:kitinerary-doc = " \
 "
