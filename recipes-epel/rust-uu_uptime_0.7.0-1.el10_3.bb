# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_uptime"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_uptime+default-devel \
 rust-uu_uptime+feat_systemd_logind-devel \
 rust-uu_uptime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_uptime-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "023cde46cc49744b8880cd0e14c6ce9b7c4020f30c263f79291ac17ac37425e2"

URI_x86_64_v2_rust-uu_uptime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_uptime+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_uptime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_uptime+default-devel}"
SRC_URI[x86_64_v2_rust-uu_uptime+default-devel.sha256sum] = "cb2fa91e58ad7e1b582c8383365984195c9653efc17e9d5cb9882b2c5bbfee73"

URI_x86_64_v2_rust-uu_uptime+feat_systemd_logind-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_uptime+feat_systemd_logind-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_uptime+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_uptime+feat_systemd_logind-devel}"
SRC_URI[x86_64_v2_rust-uu_uptime+feat_systemd_logind-devel.sha256sum] = "2fe5eb7f64b99e11bd431c5c59693fa9b02bea7b0ce7f474c583968373bcd0ac"

URI_x86_64_v2_rust-uu_uptime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_uptime-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_uptime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_uptime-devel}"
SRC_URI[x86_64_v2_rust-uu_uptime-devel.sha256sum] = "006f557d21ada19145688c9d72399a78306c19f904e7ad6c2e56847dd456152d"

URI_aarch64_rust-uu_uptime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_uptime+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_uptime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_uptime+default-devel}"
SRC_URI[aarch64_rust-uu_uptime+default-devel.sha256sum] = "5afa62926db33b445a6e6bddd82cfa2f68d2e374a6e3ec530f8005d641cd4623"

URI_aarch64_rust-uu_uptime+feat_systemd_logind-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_uptime+feat_systemd_logind-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_uptime+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_uptime+feat_systemd_logind-devel}"
SRC_URI[aarch64_rust-uu_uptime+feat_systemd_logind-devel.sha256sum] = "32ed00d7c18e822ae9b7a293c274e40171195410f652d5fc105136182fcae4d2"

URI_aarch64_rust-uu_uptime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_uptime-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_uptime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_uptime-devel}"
SRC_URI[aarch64_rust-uu_uptime-devel.sha256sum] = "486c68ccb61991b849923a555f62a5ebc819c8e1d4291cae0763f803d3f58979"

RDEPENDS:rust-uu_uptime+default-devel = " \
 cargo \
 rust-uu_uptime-devel \
 "
RDEPENDS:rust-uu_uptime+feat_systemd_logind-devel = " \
 cargo \
 rust-uu_uptime-devel \
 rust-uucore+feat_systemd_logind-devel \
 "
RDEPENDS:rust-uu_uptime-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-jiff+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+libc-devel \
 rust-uucore+uptime-devel \
 rust-uucore+utmpx-devel \
 "
