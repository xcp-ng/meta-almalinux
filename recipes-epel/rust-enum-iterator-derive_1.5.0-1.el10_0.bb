# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-iterator-derive"
PV = "1.5.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-enum-iterator-derive+default-devel \
 rust-enum-iterator-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-iterator-derive-1.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91dab0bb640f4b53e77d8b809bdce24da7fb432f34bbf66edef3a80a4bd2ffa1"

URI_x86_64_v2_rust-enum-iterator-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator-derive+default-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator-derive+default-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator-derive+default-devel.sha256sum] = "4813dfa8e1e27d2b1790762fe9d8db5a616c808a671b0d4f514d9559a88442e0"

URI_x86_64_v2_rust-enum-iterator-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-iterator-derive-devel-1.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-iterator-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-iterator-derive-devel}"
SRC_URI[x86_64_v2_rust-enum-iterator-derive-devel.sha256sum] = "48cb3239ebfec64fe756ff6be8c6deaabc98f6073a2653cf84557c46e1ea2ef8"

URI_aarch64_rust-enum-iterator-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator-derive+default-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-enum-iterator-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator-derive+default-devel}"
SRC_URI[aarch64_rust-enum-iterator-derive+default-devel.sha256sum] = "3d46c7f06d9a65d332bc95404346e1908bcd592d8a3341a8b6acbcd35b464484"

URI_aarch64_rust-enum-iterator-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-iterator-derive-devel-1.5.0-1.el10_0.noarch.rpm;name=aarch64_rust-enum-iterator-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-iterator-derive-devel}"
SRC_URI[aarch64_rust-enum-iterator-derive-devel.sha256sum] = "7305495515efc97262a25b3c01e320210065b90f1dcdc65038de1c152530c113"

RDEPENDS:rust-enum-iterator-derive+default-devel = " \
 cargo \
 rust-enum-iterator-derive-devel \
 "
RDEPENDS:rust-enum-iterator-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 "
