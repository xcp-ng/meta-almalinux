# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest_meta"
PV = "2.8.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-pest_meta+default-devel \
 rust-pest_meta+grammar-extras-devel \
 rust-pest_meta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest_meta-2.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b6133dce9832e4132f310f1cc8b109a32606d86beed7a55ffad30a75f23c0c2"

URI_x86_64_v2_rust-pest_meta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta+default-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta+default-devel}"
SRC_URI[x86_64_v2_rust-pest_meta+default-devel.sha256sum] = "84f9094e62c6c01aa2e5d983cd2a6e18bff8b31016373d096b3ad083f41ec693"

URI_x86_64_v2_rust-pest_meta+grammar-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta+grammar-extras-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta+grammar-extras-devel}"
SRC_URI[x86_64_v2_rust-pest_meta+grammar-extras-devel.sha256sum] = "9e7affe3c9d058d499b8d7da48eb4832fa52a7cbe3ed455c89b16112ffbbbae3"

URI_x86_64_v2_rust-pest_meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest_meta-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest_meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest_meta-devel}"
SRC_URI[x86_64_v2_rust-pest_meta-devel.sha256sum] = "d7d9275cc6fc5c7356d7bc20e89f9b6061dabdf2ad412b5b38f1335bb28627a8"

URI_aarch64_rust-pest_meta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta+default-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta+default-devel}"
SRC_URI[aarch64_rust-pest_meta+default-devel.sha256sum] = "ccc8979d4ba9f44c5a4ad9622c9a89e2d4973227f68d3fa8dc179843fc26c3da"

URI_aarch64_rust-pest_meta+grammar-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta+grammar-extras-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_meta+grammar-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta+grammar-extras-devel}"
SRC_URI[aarch64_rust-pest_meta+grammar-extras-devel.sha256sum] = "16baa502b78c1fb7752a5c83bcad2bb9f610b7c4fcabc1296b3aab09b6469a15"

URI_aarch64_rust-pest_meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest_meta-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest_meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest_meta-devel}"
SRC_URI[aarch64_rust-pest_meta-devel.sha256sum] = "2213421436bd0015ee42dbae507267ac8ff83123745a57d7938318daad85ee86"

RDEPENDS:rust-pest_meta+default-devel = " \
 cargo \
 rust-pest_meta-devel \
 "
RDEPENDS:rust-pest_meta+grammar-extras-devel = " \
 cargo \
 rust-pest_meta-devel \
 "
RDEPENDS:rust-pest_meta-devel = " \
 cargo \
 rust \
 rust-pest+default-devel \
 rust-sha2-devel \
 "
