# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fb_procfs"
PV = "0.9.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-fb_procfs+default-devel \
 rust-fb_procfs-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fb_procfs-0.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27877664895e6770ef9fd707a68d72b1ba1c1ac91418d41749f025f553738784"

URI_x86_64_v2_rust-fb_procfs+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fb_procfs+default-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fb_procfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fb_procfs+default-devel}"
SRC_URI[x86_64_v2_rust-fb_procfs+default-devel.sha256sum] = "054caf93881800c570a957a0bb60ca0d3c23c7da7cc7060b57f9358dbd51365f"

URI_x86_64_v2_rust-fb_procfs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fb_procfs-devel-0.9.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fb_procfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fb_procfs-devel}"
SRC_URI[x86_64_v2_rust-fb_procfs-devel.sha256sum] = "11b376f48b9b268afae9a361c82afa1bafbed601beffc1f0ff2e70277419c706"

URI_aarch64_rust-fb_procfs+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fb_procfs+default-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-fb_procfs+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fb_procfs+default-devel}"
SRC_URI[aarch64_rust-fb_procfs+default-devel.sha256sum] = "5d3511117404ae061dcc100f7060c219584a679e5e3fe1eeda7e60e021349239"

URI_aarch64_rust-fb_procfs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fb_procfs-devel-0.9.0-1.el10_0.noarch.rpm;name=aarch64_rust-fb_procfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fb_procfs-devel}"
SRC_URI[aarch64_rust-fb_procfs-devel.sha256sum] = "dbc787b20e4992ca251c8aa2924be8c0b01be2d3d37347774975540691e34231"

RDEPENDS:rust-fb_procfs+default-devel = " \
 cargo \
 rust-fb_procfs-devel \
 "
RDEPENDS:rust-fb_procfs-devel = " \
 cargo \
 rust-below-common+default-devel \
 rust-lazy_static+default-devel \
 rust-libc+default-devel \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+event-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+net-devel \
 rust-nix+poll-devel \
 rust-nix+ptrace-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-openat+default-devel \
 rust-parking_lot+default-devel \
 rust-parking_lot+send_guard-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-slog+default-devel \
 rust-slog+max_level_trace-devel \
 rust-slog+nested-values-devel \
 rust-thiserror+default-devel \
 rust-threadpool+default-devel \
 "
