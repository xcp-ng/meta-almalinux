# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libb64"
PV = "1.2"
PR = "19.el10_2"
PACKAGES = " \
 libb64-devel \
 libb64-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libb64-1.2-19.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d81f9e918e0179dc5de52219bf13e7d1c0877e8677c1fe775c8b634f21daf785"

URI_x86_64_v2_libb64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libb64-devel-1.2-19.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libb64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libb64-devel}"
SRC_URI[x86_64_v2_libb64-devel.sha256sum] = "4417d664898581e4b5eee304d351dac17568ab6174e6f341a04aad1059a33fbe"

URI_x86_64_v2_libb64-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libb64-tools-1.2-19.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libb64-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libb64-tools}"
SRC_URI[x86_64_v2_libb64-tools.sha256sum] = "ce208c12cf8e9ba76e65d2fc2c6fe1853901fd56763a7c9805ae0a21df0f695a"

URI_aarch64_libb64-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libb64-devel-1.2-19.el10_2.aarch64.rpm;name=aarch64_libb64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libb64-devel}"
SRC_URI[aarch64_libb64-devel.sha256sum] = "172c6a0d9d2a3542690aabccba8d86742b7ba8a41115fc3688aa118fb2acb159"

URI_aarch64_libb64-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libb64-tools-1.2-19.el10_2.aarch64.rpm;name=aarch64_libb64-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libb64-tools}"
SRC_URI[aarch64_libb64-tools.sha256sum] = "4c621f59b1a1715363f33de1eff14eb0b756467a3780e1da81887b9acd95e746"

RDEPENDS:libb64-devel = " \
 "
RDEPENDS:libb64-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 "
