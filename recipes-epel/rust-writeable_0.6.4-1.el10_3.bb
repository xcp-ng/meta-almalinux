# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-writeable"
PV = "0.6.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-writeable+alloc-devel \
 rust-writeable+default-devel \
 rust-writeable+either-devel \
 rust-writeable-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-writeable-0.6.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "82980b01b2161a4155adc29a4ec05dcfe1bc8afdfb47ec72c651b22086569476"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+alloc-devel-0.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-writeable+alloc-devel.sha256sum] = "680eb94bd432d38c891670a364972faa38b7a68d7498aaa0f85948ffe66f6765"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+default-devel-0.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-writeable+default-devel.sha256sum] = "f8e0cb2a2c151b216a8e11c15a0b9b711f5706589ad6e864a9be8342f8c480d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable+either-devel-0.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable+either-devel;unpack=0"
SRC_URI[x86_64_v2_rust-writeable+either-devel.sha256sum] = "b4ccccd72a2958603ce96d9fd21a8ad100392591f977fc84faf92c34594a0cec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-writeable-devel-0.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-writeable-devel;unpack=0"
SRC_URI[x86_64_v2_rust-writeable-devel.sha256sum] = "6a825379f4e54ba6782dddce57af4c79136168cb547774556df5742d07443153"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+alloc-devel-0.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-writeable+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-writeable+alloc-devel.sha256sum] = "47f6d850c75ac4593cb365c67895be61e04367dcf07fcd3d8d4f8719d239a41d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+default-devel-0.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-writeable+default-devel;unpack=0"
SRC_URI[aarch64_rust-writeable+default-devel.sha256sum] = "a0ecffddc9bb99cee004c97a206761b9c646231bc76d5ff51e1757325e703861"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable+either-devel-0.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-writeable+either-devel;unpack=0"
SRC_URI[aarch64_rust-writeable+either-devel.sha256sum] = "0727ae6464857bd39e84dcd96c06ebf3d2f33bb704cb0ed37cfed1bb4df86095"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-writeable-devel-0.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-writeable-devel;unpack=0"
SRC_URI[aarch64_rust-writeable-devel.sha256sum] = "914153aba7a32d383523835e419c4a1c02ffd6a8e073966294d32915fc9226c5"

RDEPENDS:rust-writeable+alloc-devel = " \
 cargo \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable+default-devel = " \
 cargo \
 rust-writeable+alloc-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable+either-devel = " \
 cargo \
 rust-either-devel \
 rust-writeable-devel \
 "
RDEPENDS:rust-writeable-devel = " \
 cargo \
 rust \
 "
