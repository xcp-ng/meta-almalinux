# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-cd"
PV = "0.2.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-cd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-cd-0.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac93c1db5f5edbd4b92a5702498f632762369a49171e26e8f3d8a302c4b8aaf9"

URI_x86_64_v2_python3-colcon-cd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-cd-0.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-cd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-cd}"
SRC_URI[x86_64_v2_python3-colcon-cd.sha256sum] = "0cf45ccc6a89f2c610f7bbe2843a9292446c6f60e9ba3d80caa19de12d433f15"

URI_aarch64_python3-colcon-cd = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-cd-0.2.1-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-cd;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-cd}"
SRC_URI[aarch64_python3-colcon-cd.sha256sum] = "54e8e0c510e36e03062dcf8615d5dae88f80090d81742942d9bbe0d93fd57228"

RDEPENDS:python3-colcon-cd = " \
 python3 \
 python3-colcon-core \
 python3-colcon-package-information \
 "
