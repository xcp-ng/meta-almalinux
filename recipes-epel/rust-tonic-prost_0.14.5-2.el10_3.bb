# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tonic-prost"
PV = "0.14.5"
PR = "2.el10_3"
PACKAGES = " \
 rust-tonic-prost+default-devel \
 rust-tonic-prost-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tonic-prost-0.14.5-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edd073eb415df86e3a89010ea7e4d7449323824c5c125f700a9deb8d1bd07b30"

URI_x86_64_v2_rust-tonic-prost+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic-prost+default-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic-prost+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic-prost+default-devel}"
SRC_URI[x86_64_v2_rust-tonic-prost+default-devel.sha256sum] = "219af8cb0587b7fd8c651397621c7021a4fef55943e7ea3cf082102652ef2857"

URI_x86_64_v2_rust-tonic-prost-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic-prost-devel-0.14.5-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic-prost-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic-prost-devel}"
SRC_URI[x86_64_v2_rust-tonic-prost-devel.sha256sum] = "2fef05eaea7f4c823c3422ca3af210d48ec30d5c52641582173af2121e3e8c4c"

URI_aarch64_rust-tonic-prost+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic-prost+default-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic-prost+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic-prost+default-devel}"
SRC_URI[aarch64_rust-tonic-prost+default-devel.sha256sum] = "5d67fa475d6ab92ddd3134715e712524f19f7f9ba0d3483c5777f18059b25e88"

URI_aarch64_rust-tonic-prost-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic-prost-devel-0.14.5-2.el10_3.noarch.rpm;name=aarch64_rust-tonic-prost-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic-prost-devel}"
SRC_URI[aarch64_rust-tonic-prost-devel.sha256sum] = "904f92fe88f207e413614aa5f042e5f90fc809d3d664b46d7eccfe7bb3f790af"

RDEPENDS:rust-tonic-prost+default-devel = " \
 cargo \
 rust-tonic-prost-devel \
 "
RDEPENDS:rust-tonic-prost-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-prost+default-devel \
 rust-tonic-devel \
 "
