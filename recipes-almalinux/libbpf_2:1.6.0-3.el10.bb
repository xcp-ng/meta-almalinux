# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libbpf"
PE = "2"
PV = "1.6.0"
PR = "3.el10"
PACKAGES = " \
 libbpf \
 libbpf-devel \
 libbpf-static \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libbpf-1.6.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5689d98b6f7af4cd792041e84d58629a511ec67e3ec075cec4ad3b04e607a0b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libbpf-1.6.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf;unpack=0"
SRC_URI[x86_64_v2_libbpf.sha256sum] = "55cfe1be9cfb6b19ae548e3f02d0c610a4b634cd7cb3f885e81e6eeb3512095d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libbpf-devel-1.6.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf-devel;unpack=0"
SRC_URI[x86_64_v2_libbpf-devel.sha256sum] = "d1fc108fbf4691d6d3cec22496ff07a95ae45881559b8b27e7815cb62c62de58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libbpf-static-1.6.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf-static;unpack=0"
SRC_URI[x86_64_v2_libbpf-static.sha256sum] = "cf2f79dd32555071e14e27465f1956b0dea015c3a92e539c1813e427941d64ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libbpf-1.6.0-3.el10.aarch64.rpm;name=aarch64_libbpf;unpack=0"
SRC_URI[aarch64_libbpf.sha256sum] = "ae690885b211eca11bea111f77257515ca6ad07a0af1e2f7fb5bf49ccac97c9f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libbpf-devel-1.6.0-3.el10.aarch64.rpm;name=aarch64_libbpf-devel;unpack=0"
SRC_URI[aarch64_libbpf-devel.sha256sum] = "5f6745c0a3a0302e114d13227e0ea66e91d4767f065e789946a4dac9a555091c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libbpf-static-1.6.0-3.el10.aarch64.rpm;name=aarch64_libbpf-static;unpack=0"
SRC_URI[aarch64_libbpf-static.sha256sum] = "b1a6a8baa5f6844f1e962775f22c4b438355a8786342b89da2186e5b5c99ddd7"

RDEPENDS:libbpf = " \
 elfutils-libelf \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libbpf-devel = " \
 elfutils-libelf-devel \
 kernel-headers \
 libbpf \
 pkgconf-pkg-config \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:libbpf-static = " \
 libbpf-devel \
 "
