# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "alligator"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 alligator \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/alligator-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65d9dbc5d52b40476bac882693353e7e43fb7ee06ebfa4f86208262a492cdbac"

URI_x86_64_v2_alligator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/alligator-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_alligator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_alligator}"
SRC_URI[x86_64_v2_alligator.sha256sum] = "c5170af60698e92b648ffac035a28db57a65eda86d7ede48a5baa7f0acd4c113"

URI_aarch64_alligator = "${EPEL_MIRROR}/aarch64/Packages/a/alligator-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_alligator;unpack=0"
SRC_URI:append = " ${URI_aarch64_alligator}"
SRC_URI[aarch64_alligator.sha256sum] = "7fd27a1ebb580898dfa66bba786914ece96c596c01b087e1ebdceb78f4cc8cb4"

RDEPENDS:alligator = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-syndication \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
