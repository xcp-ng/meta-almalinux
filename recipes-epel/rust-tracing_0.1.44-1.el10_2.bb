# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing"
PV = "0.1.44"
PR = "1.el10_2"
PACKAGES = " \
 rust-tracing+async-await-devel \
 rust-tracing+attributes-devel \
 rust-tracing+default-devel \
 rust-tracing+log-always-devel \
 rust-tracing+log-devel \
 rust-tracing+max_level_debug-devel \
 rust-tracing+max_level_error-devel \
 rust-tracing+max_level_info-devel \
 rust-tracing+max_level_off-devel \
 rust-tracing+max_level_trace-devel \
 rust-tracing+max_level_warn-devel \
 rust-tracing+release_max_level_debug-devel \
 rust-tracing+release_max_level_error-devel \
 rust-tracing+release_max_level_info-devel \
 rust-tracing+release_max_level_off-devel \
 rust-tracing+release_max_level_trace-devel \
 rust-tracing+release_max_level_warn-devel \
 rust-tracing+std-devel \
 rust-tracing+tracing-attributes-devel \
 rust-tracing-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-0.1.44-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "049d3258358a5c77baf27350d2f49739b081a775c5fd27ebbd350fce81196684"

URI_x86_64_v2_rust-tracing+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+async-await-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+async-await-devel}"
SRC_URI[x86_64_v2_rust-tracing+async-await-devel.sha256sum] = "6ef7969c96fb0431ec42a9329aec6b2bfd6ae2081d242956ce354a3025e100ab"

URI_x86_64_v2_rust-tracing+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+attributes-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing+attributes-devel.sha256sum] = "df97871c0eb84e345e13cd14ca92abc8ec5ffae0761eac794571627ad5530c35"

URI_x86_64_v2_rust-tracing+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+default-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+default-devel}"
SRC_URI[x86_64_v2_rust-tracing+default-devel.sha256sum] = "0349811ce16dc0b47197ed9b897cf722c22eb7a88ae921672a63cf08cd0d8ee5"

URI_x86_64_v2_rust-tracing+log-always-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+log-always-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+log-always-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+log-always-devel}"
SRC_URI[x86_64_v2_rust-tracing+log-always-devel.sha256sum] = "5392ed636b66df8651cc6fdfcc67aeb963a9985ba2228a116809ecdf024972e8"

URI_x86_64_v2_rust-tracing+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+log-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+log-devel}"
SRC_URI[x86_64_v2_rust-tracing+log-devel.sha256sum] = "75c09b5218d51d3fe38fa61dc70fc2215c65f1cac2f4fa029f95d6a6150d6e17"

URI_x86_64_v2_rust-tracing+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_debug-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_debug-devel.sha256sum] = "38a6e7b12238c7d71c8b8a2019a1784569739ffde0b703d2433f1a8273326342"

URI_x86_64_v2_rust-tracing+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_error-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_error-devel.sha256sum] = "28244f1d20c92524a0ef00336e46be087a53b4fa7145e7cc09160b7246d3ba20"

URI_x86_64_v2_rust-tracing+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_info-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_info-devel.sha256sum] = "60918d6cdd44b2b9329842aa1e178070ab722a0b13149074992b0f49f42cec6e"

URI_x86_64_v2_rust-tracing+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_off-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_off-devel.sha256sum] = "a49fac51eafe17234eaba72ceb46e3d78301a6b5298359f7d8d7892c84bf4998"

URI_x86_64_v2_rust-tracing+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_trace-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_trace-devel.sha256sum] = "9cbd4ec8b12f36b4e627e32e6cf952065976ebf829ed2cdbab7ce363c50cd826"

URI_x86_64_v2_rust-tracing+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_warn-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_warn-devel.sha256sum] = "6ae4d1a66021b545e36587f50f80a426c4ceccd6ecbca741535494f60dc6e8ab"

URI_x86_64_v2_rust-tracing+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_debug-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_debug-devel.sha256sum] = "6b91f761d0823265db1e6fa75f01c28d3213f89455086b2939911ddc297099f4"

URI_x86_64_v2_rust-tracing+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_error-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_error-devel.sha256sum] = "be323413d2bb3c0df82efc3af3f9b61ff95ffa6692e32f5c9dcf1be792cef6ac"

URI_x86_64_v2_rust-tracing+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_info-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_info-devel.sha256sum] = "3e942d047f7beb0d8a24baa560cbe9fa360cf98d01ae05e9bb0805cdc0303e06"

URI_x86_64_v2_rust-tracing+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_off-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_off-devel.sha256sum] = "207109cfbfe353592348a6e7e9aa9e4c12dbc55147f20943684f72a55a54e9cb"

URI_x86_64_v2_rust-tracing+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_trace-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_trace-devel.sha256sum] = "6e61290c6be31f05bd752be8548b3a883972cf556933a4080b6da220f1fd8091"

URI_x86_64_v2_rust-tracing+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_warn-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_warn-devel.sha256sum] = "95085f4f343f60da48b3503c5bb559a4ba97de489be16bf9b67571718a9d014e"

URI_x86_64_v2_rust-tracing+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+std-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+std-devel}"
SRC_URI[x86_64_v2_rust-tracing+std-devel.sha256sum] = "92b4e8895e5c274444ff4abffab5642ba26fb6a46d2eae8447fffecf97e23c60"

URI_x86_64_v2_rust-tracing+tracing-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+tracing-attributes-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+tracing-attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing+tracing-attributes-devel.sha256sum] = "1cbc810e441cb62c6fa477b4fe97d29479a8a058aed71f104e46f75ffc1f6bc0"

URI_x86_64_v2_rust-tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-devel-0.1.44-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-devel}"
SRC_URI[x86_64_v2_rust-tracing-devel.sha256sum] = "7db5d99d95f45804c2d10ad679bb28e6e8312e88f72bd020c3fa22efe1dfc04a"

URI_aarch64_rust-tracing+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+async-await-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+async-await-devel}"
SRC_URI[aarch64_rust-tracing+async-await-devel.sha256sum] = "ab935e4712634efcfffd139a8647536e7297f779288bc917acea12b412df80e0"

URI_aarch64_rust-tracing+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+attributes-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+attributes-devel}"
SRC_URI[aarch64_rust-tracing+attributes-devel.sha256sum] = "fd66b5fd4e30c12a9c068ec8195f67bc9ea561ac6139989d1e3274e492f5cb1f"

URI_aarch64_rust-tracing+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+default-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+default-devel}"
SRC_URI[aarch64_rust-tracing+default-devel.sha256sum] = "b6bb1ae74ba4f2cd48d5bf2a64967bf0a524563049100ab4cdca9b8fe0fd28f9"

URI_aarch64_rust-tracing+log-always-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+log-always-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+log-always-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+log-always-devel}"
SRC_URI[aarch64_rust-tracing+log-always-devel.sha256sum] = "a73dee5e5b6cfe30d49ee47b747d9e456d0b20cf351e15e599077a902f4b7902"

URI_aarch64_rust-tracing+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+log-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+log-devel}"
SRC_URI[aarch64_rust-tracing+log-devel.sha256sum] = "9231d0aa5c8d9727f26668d2fe16b9e90585296b1805afdd50a6e4d8de18cb44"

URI_aarch64_rust-tracing+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_debug-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_debug-devel}"
SRC_URI[aarch64_rust-tracing+max_level_debug-devel.sha256sum] = "59cb225e2c803f4e923c39694a2a75752b2f78d5414a9764e6a069e15be88591"

URI_aarch64_rust-tracing+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_error-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_error-devel}"
SRC_URI[aarch64_rust-tracing+max_level_error-devel.sha256sum] = "878b57a22583f0e077bd98560dde36a16b8fcb331fcf099ebe475691f1af1634"

URI_aarch64_rust-tracing+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_info-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_info-devel}"
SRC_URI[aarch64_rust-tracing+max_level_info-devel.sha256sum] = "e7e409963b2c58d269ddda9718e0315cfe7b524e7c04ef3c03ce723dc1b31c3f"

URI_aarch64_rust-tracing+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_off-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_off-devel}"
SRC_URI[aarch64_rust-tracing+max_level_off-devel.sha256sum] = "806ca20564898b705fab6ba50ae3a3811e43c8d412f244b1fae630afdeb9aea5"

URI_aarch64_rust-tracing+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_trace-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_trace-devel}"
SRC_URI[aarch64_rust-tracing+max_level_trace-devel.sha256sum] = "490250f7b7bc1bacc68f30b61e84d8de827ad7a1e97c5cb574ce15e902264adb"

URI_aarch64_rust-tracing+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_warn-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_warn-devel}"
SRC_URI[aarch64_rust-tracing+max_level_warn-devel.sha256sum] = "de68bbef386e23f0b76b22188683b2f740fabde958f7ebcdd9e0692a9f852bc7"

URI_aarch64_rust-tracing+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_debug-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_debug-devel.sha256sum] = "e9c038527dd6f8f188cbeec74ab3fb7555813ef146123341fedd076fe143347f"

URI_aarch64_rust-tracing+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_error-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_error-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_error-devel.sha256sum] = "86131a8c798421702fc47b1a9050a5f498f90126f571a89ba8ff911cacbdb915"

URI_aarch64_rust-tracing+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_info-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_info-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_info-devel.sha256sum] = "fa5e34af754fe2af124a3a1c0580b963576f096f35b0f49baab118fff51e3b88"

URI_aarch64_rust-tracing+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_off-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_off-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_off-devel.sha256sum] = "3b139f6371b060d57901791e9e1a1e4037c3847c11d07f13e408498fdf3fdc46"

URI_aarch64_rust-tracing+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_trace-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_trace-devel.sha256sum] = "bcafa724fbe7dec3b73addd46d5b4f30cfe99d641ad2b8791b72687dd1c89b53"

URI_aarch64_rust-tracing+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_warn-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_warn-devel.sha256sum] = "930e072e8ddb12af557ca159960842b2aba4e83e6daa7f46738d68462ea70b53"

URI_aarch64_rust-tracing+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+std-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+std-devel}"
SRC_URI[aarch64_rust-tracing+std-devel.sha256sum] = "528d0a8a81370269e70fbfd301c87b92290f427ecd6cbfe75da5852e94c0781e"

URI_aarch64_rust-tracing+tracing-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+tracing-attributes-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing+tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+tracing-attributes-devel}"
SRC_URI[aarch64_rust-tracing+tracing-attributes-devel.sha256sum] = "2472f034b860efc7f4f9a520f3f1328a2c9141d192b802cca045bd3f0d42f204"

URI_aarch64_rust-tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-devel-0.1.44-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-devel}"
SRC_URI[aarch64_rust-tracing-devel.sha256sum] = "d8c090d7a6ca54e3cd5c3c7e4865512c23c7a141ebccfe800ef0a9533178dce1"

RDEPENDS:rust-tracing+async-await-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+attributes-devel = " \
 cargo \
 rust-tracing+tracing-attributes-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+default-devel = " \
 cargo \
 rust-tracing+attributes-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+log-always-devel = " \
 cargo \
 rust-tracing+log-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_debug-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_error-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_info-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_off-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_trace-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_warn-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_debug-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_error-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_info-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_off-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_trace-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_warn-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+std-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+tracing-attributes-devel = " \
 cargo \
 rust-tracing-attributes+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 rust-tracing-core-devel \
 "
