# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpmlint"
PV = "2.5.0"
PR = "11.el10_0"
PACKAGES = " \
 rpmlint \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rpmlint-2.5.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "512ea9370184151d542fa5eb7c9537c1081f42230227b9e5c2ef03bcdc099074"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmlint-2.5.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rpmlint;unpack=0"
SRC_URI[x86_64_v2_rpmlint.sha256sum] = "666b09147ef4f265bf131a8ce4d067e97843dd6aba92f9b88d6aa40107a1ff56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rpmlint-2.5.0-11.el10_0.noarch.rpm;name=aarch64_rpmlint;unpack=0"
SRC_URI[aarch64_rpmlint.sha256sum] = "5b24a37378cd5fb36d1c7423076e556847949c2f88c9c4dcd1e3808370338c0f"

RDEPENDS:rpmlint = " \
 desktop-file-utils \
 libappstream-glib \
 python3 \
 python3-enchant \
 python3-file-magic \
 python3-packaging \
 python3-pyxdg \
 python3-rpm \
 python3-tomli-w \
 python3-zstandard \
 rpm-build \
 rpmlint-fedora-license-data \
 "
