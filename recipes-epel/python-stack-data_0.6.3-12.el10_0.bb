# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-stack-data"
PV = "0.6.3"
PR = "12.el10_0"
PACKAGES = " \
 python3-stack-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-stack-data-0.6.3-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97408ad4bb07e6b4dda5adffae2fa58293c215fd448ec3d15e5c46c373d51cb4"

URI_x86_64_v2_python3-stack-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-stack-data-0.6.3-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-stack-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-stack-data}"
SRC_URI[x86_64_v2_python3-stack-data.sha256sum] = "e273c7b269799d454487bea5fcfc7d93b827cd5e7a6294ee5314a2070959433d"

URI_aarch64_python3-stack-data = "${EPEL_MIRROR}/aarch64/Packages/p/python3-stack-data-0.6.3-12.el10_0.noarch.rpm;name=aarch64_python3-stack-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-stack-data}"
SRC_URI[aarch64_python3-stack-data.sha256sum] = "f126265b10b860a59b446546992a0e629d9f752cac0cccc030ae44332a6c211f"

RDEPENDS:python3-stack-data = " \
 python3 \
 python3-asttokens \
 python3-executing \
 python3-pure-eval \
 "
