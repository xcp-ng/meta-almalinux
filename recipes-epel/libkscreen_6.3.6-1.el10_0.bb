# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkscreen"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 libkscreen \
 libkscreen-devel \
 libkscreen-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkscreen-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65f299ffd439990dc482ddec7d144a029f66dc8f2e805358aca367d9fdbc5643"

URI_x86_64_v2_libkscreen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen}"
SRC_URI[x86_64_v2_libkscreen.sha256sum] = "9eed76efd1947a3182b88536331e9a7629da937ae517d9bb9055709eb1816ce2"

URI_x86_64_v2_libkscreen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-devel-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkscreen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen-devel}"
SRC_URI[x86_64_v2_libkscreen-devel.sha256sum] = "26385d804ddc14f532caf093865199c9aefcfc328463491e03b71b613358695e"

URI_x86_64_v2_libkscreen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkscreen-doc-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libkscreen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkscreen-doc}"
SRC_URI[x86_64_v2_libkscreen-doc.sha256sum] = "08ed801c3b356c4f56a55eca907bc68d34d9a284923a062b6c48be70fb69c630"

URI_aarch64_libkscreen = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_libkscreen;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen}"
SRC_URI[aarch64_libkscreen.sha256sum] = "f04b4d513b0cf3c7187b46a3ed3d97f7966e1434394accee76726b641618f126"

URI_aarch64_libkscreen-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-devel-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_libkscreen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen-devel}"
SRC_URI[aarch64_libkscreen-devel.sha256sum] = "2a240e0263558a84839fc7605d31ed136a5631097980ed65fc9c7efa1e1ea9ea"

URI_aarch64_libkscreen-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkscreen-doc-6.3.6-1.el10_0.noarch.rpm;name=aarch64_libkscreen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkscreen-doc}"
SRC_URI[aarch64_libkscreen-doc.sha256sum] = "ea38eb351c4eea0a842f5ee4a6361aa14ae005ad4d92c2e1b3297c3332fa75b4"

RDEPENDS:libkscreen = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
RDEPENDS:libkscreen-devel = " \
 cmake-filesystem \
 libkscreen \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:libkscreen-doc = " \
 "
