# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-exr"
PV = "1.74.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-exr+default-devel \
 rust-exr+rayon-devel \
 rust-exr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-exr-1.74.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e77d742673b4f836f4ee7faab61c67732dd6792cd94204ccd978d87130620e8"

URI_x86_64_v2_rust-exr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exr+default-devel-1.74.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exr+default-devel}"
SRC_URI[x86_64_v2_rust-exr+default-devel.sha256sum] = "d99c87ebdedbed4c4e05d8f4c138148adcd9266c5ae5a6aeef1df266b8cd73d4"

URI_x86_64_v2_rust-exr+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exr+rayon-devel-1.74.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exr+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exr+rayon-devel}"
SRC_URI[x86_64_v2_rust-exr+rayon-devel.sha256sum] = "ecc831a2ed6ef71e2f1b658f3c77f334803f2b82416328733acce1af09d0f515"

URI_x86_64_v2_rust-exr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-exr-devel-1.74.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-exr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-exr-devel}"
SRC_URI[x86_64_v2_rust-exr-devel.sha256sum] = "21c96212a3736648e5ed0dcd9b910acccb478d47d6ebc3d2cf3f95adf9fc6c6e"

URI_aarch64_rust-exr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exr+default-devel-1.74.0-1.el10_2.noarch.rpm;name=aarch64_rust-exr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exr+default-devel}"
SRC_URI[aarch64_rust-exr+default-devel.sha256sum] = "3d825240579aa4834b5eaf284af4954df9b36c53e30394ae317e477c83bb9ead"

URI_aarch64_rust-exr+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exr+rayon-devel-1.74.0-1.el10_2.noarch.rpm;name=aarch64_rust-exr+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exr+rayon-devel}"
SRC_URI[aarch64_rust-exr+rayon-devel.sha256sum] = "194d9437f1f65989db32e45f4f58698a6803333c733966ae6f0047985921c495"

URI_aarch64_rust-exr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-exr-devel-1.74.0-1.el10_2.noarch.rpm;name=aarch64_rust-exr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-exr-devel}"
SRC_URI[aarch64_rust-exr-devel.sha256sum] = "5bbebbbcf4fc644ccd46082a60f180410c28823e91949fb2a027f2ef57ddc8fc"

RDEPENDS:rust-exr+default-devel = " \
 cargo \
 rust-exr+rayon-devel \
 rust-exr-devel \
 "
RDEPENDS:rust-exr+rayon-devel = " \
 cargo \
 rust-exr-devel \
 rust-rayon-core+default-devel \
 "
RDEPENDS:rust-exr-devel = " \
 cargo \
 rust \
 rust-bit_field+default-devel \
 rust-half+default-devel \
 rust-lebe+default-devel \
 rust-miniz_oxide+default-devel \
 rust-smallvec+default-devel \
 rust-zune-inflate+zlib-devel \
 rust-zune-inflate-devel \
 "
