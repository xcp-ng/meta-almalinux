# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "markdownpart"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 markdownpart \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/markdownpart-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4b318e281009111d0ba9c0d498efed21ee68e467e143fb5ff9ed86f71bd0b155"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/markdownpart-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_markdownpart;unpack=0"
SRC_URI[x86_64_v2_markdownpart.sha256sum] = "2412b527f8b605fbf3ea797cf9d8a4b270a2b89799a754cc9c8083b03291542c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/markdownpart-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_markdownpart;unpack=0"
SRC_URI[aarch64_markdownpart.sha256sum] = "692ea3b5b1a2b4b0f84e1f18dfa9643d5692a603728e8c60af19b0d3849e1ca6"

RDEPENDS:markdownpart = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
