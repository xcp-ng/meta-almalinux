# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openarm-can"
PV = "1.1.0^20251016git010ea25"
PR = "1.el10_2"
PACKAGES = " \
 openarm-can \
 openarm-can-devel \
 openarm-can-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openarm-can-1.1.0^20251016git010ea25-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae49130545c630a66c6583cdc297fc77e3f48ad33c58ced7daf79e10c70fb7b1"

URI_x86_64_v2_openarm-can = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openarm-can-1.1.0^20251016git010ea25-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openarm-can;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openarm-can}"
SRC_URI[x86_64_v2_openarm-can.sha256sum] = "078034aad3b1c0587b2c0690dfd149d190c94d2ec32402755d68df91c9f38639"

URI_x86_64_v2_openarm-can-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openarm-can-devel-1.1.0^20251016git010ea25-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openarm-can-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openarm-can-devel}"
SRC_URI[x86_64_v2_openarm-can-devel.sha256sum] = "8c64f6fc20e5d0e9c2653bca81df108c6ae6ac421778a74455b387993f6d03a1"

URI_x86_64_v2_openarm-can-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openarm-can-utils-1.1.0^20251016git010ea25-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openarm-can-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openarm-can-utils}"
SRC_URI[x86_64_v2_openarm-can-utils.sha256sum] = "400ab2d3b19e5e8af4affdcf2b27ae2eb5dba818bb402ea3ad9a480bb37b0874"

URI_aarch64_openarm-can = "${EPEL_MIRROR}/aarch64/Packages/o/openarm-can-1.1.0^20251016git010ea25-1.el10_2.aarch64.rpm;name=aarch64_openarm-can;unpack=0"
SRC_URI:append = " ${URI_aarch64_openarm-can}"
SRC_URI[aarch64_openarm-can.sha256sum] = "86e8a0f0b244419d54d1f14dea6258322e7c67f9c580503163bb3885449ff970"

URI_aarch64_openarm-can-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openarm-can-devel-1.1.0^20251016git010ea25-1.el10_2.aarch64.rpm;name=aarch64_openarm-can-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openarm-can-devel}"
SRC_URI[aarch64_openarm-can-devel.sha256sum] = "8980cc7074f2a9195582b51765f09b98a435050a1b886aaad7d29b37d7834f55"

URI_aarch64_openarm-can-utils = "${EPEL_MIRROR}/aarch64/Packages/o/openarm-can-utils-1.1.0^20251016git010ea25-1.el10_2.aarch64.rpm;name=aarch64_openarm-can-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_openarm-can-utils}"
SRC_URI[aarch64_openarm-can-utils.sha256sum] = "28f6884b79df3feb6fcc1fd6b2e4c2c45c0ded16072c0010e613156d4306d305"

RDEPENDS:openarm-can = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:openarm-can-devel = " \
 cmake-filesystem \
 openarm-can \
 pkgconf-pkg-config \
 "
RDEPENDS:openarm-can-utils = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openarm-can \
 python3 \
 "
