# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-SecretStorage"
PV = "3.3.3^20240314git3e5097c"
PR = "12.el10_1"
PACKAGES = " \
 python3-secretstorage \
 python3-secretstorage-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-SecretStorage-3.3.3^20240314git3e5097c-12.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1443e23ba35ef21af107ce63a744c7bcae79445fa436e123038a83dd6284afa1"

URI_x86_64_v2_python3-secretstorage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-secretstorage-3.3.3^20240314git3e5097c-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-secretstorage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-secretstorage}"
SRC_URI[x86_64_v2_python3-secretstorage.sha256sum] = "867bca8fc4400fab2c661b904ddf4e26dae78d3621ac8b0467521fed450ada1c"

URI_x86_64_v2_python3-secretstorage-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-secretstorage-doc-3.3.3^20240314git3e5097c-12.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-secretstorage-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-secretstorage-doc}"
SRC_URI[x86_64_v2_python3-secretstorage-doc.sha256sum] = "df8e21cd56501e350476de3f981388806b73441303bedd5e11273e9c24e742d7"

URI_aarch64_python3-secretstorage = "${EPEL_MIRROR}/aarch64/Packages/p/python3-secretstorage-3.3.3^20240314git3e5097c-12.el10_1.noarch.rpm;name=aarch64_python3-secretstorage;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-secretstorage}"
SRC_URI[aarch64_python3-secretstorage.sha256sum] = "7ca3d791508c33c9a61d2e8e41aa7929c12b1b4809b2bad853179d7a2043c697"

URI_aarch64_python3-secretstorage-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-secretstorage-doc-3.3.3^20240314git3e5097c-12.el10_1.noarch.rpm;name=aarch64_python3-secretstorage-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-secretstorage-doc}"
SRC_URI[aarch64_python3-secretstorage-doc.sha256sum] = "acd2af06787e06a7846453f6d3ad4803ebe2012f1efa5f574d92737cd684bd32"

RDEPENDS:python3-secretstorage = " \
 python3 \
 python3-cryptography \
 python3-jeepney \
 "
RDEPENDS:python3-secretstorage-doc = " \
 "
