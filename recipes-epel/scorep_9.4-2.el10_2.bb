# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scorep"
PV = "9.4"
PR = "2.el10_2"
PACKAGES = " \
 scorep \
 scorep-config \
 scorep-doc \
 scorep-libs \
 scorep-mpich \
 scorep-mpich-config \
 scorep-mpich-libs \
 scorep-openmpi \
 scorep-openmpi-config \
 scorep-openmpi-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scorep-9.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e6ea257728d63f97ea4eef05b621821317145c512c9b4b81efc917f9c155c21"

URI_x86_64_v2_scorep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-9.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep}"
SRC_URI[x86_64_v2_scorep.sha256sum] = "91fc4fe290847b579152c5570832fba588ff340a72aa3103a5d78b603cd561e2"

URI_x86_64_v2_scorep-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-config-9.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-config}"
SRC_URI[x86_64_v2_scorep-config.sha256sum] = "95229976b671390d4e48d09b5d57beb478741f4560e8fbb0920c5db37f0ba2bb"

URI_x86_64_v2_scorep-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-doc-9.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_scorep-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-doc}"
SRC_URI[x86_64_v2_scorep-doc.sha256sum] = "47c5e346dddacb6af5afdad6a7f19cfa464c11afcee89b1a29a1ea3768e9895b"

URI_x86_64_v2_scorep-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-libs-9.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-libs}"
SRC_URI[x86_64_v2_scorep-libs.sha256sum] = "e3ce61007259679697d3aa09b8d47f9b16e1ecb6aa1af4a04c6987dc5519e4dd"

URI_x86_64_v2_scorep-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-9.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich}"
SRC_URI[x86_64_v2_scorep-mpich.sha256sum] = "9e88d7f50e58fda6833cef47dd55cf75422b2763a6fd78d9fc670485d9d22de9"

URI_x86_64_v2_scorep-mpich-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-config-9.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich-config}"
SRC_URI[x86_64_v2_scorep-mpich-config.sha256sum] = "6d999a64463fb1de7b69af7530e49b83df2f77a668ac804f455760e727d5764d"

URI_x86_64_v2_scorep-mpich-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-mpich-libs-9.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-mpich-libs}"
SRC_URI[x86_64_v2_scorep-mpich-libs.sha256sum] = "1ededc94a8797896d770e95873397b27918587982da099e115faf0c7566fab12"

URI_x86_64_v2_scorep-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-9.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi}"
SRC_URI[x86_64_v2_scorep-openmpi.sha256sum] = "0733bbe942432b7233c4643afa939d4e9fba7b2a2dcdfe495a17f0f50ae0749d"

URI_x86_64_v2_scorep-openmpi-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-config-9.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi-config}"
SRC_URI[x86_64_v2_scorep-openmpi-config.sha256sum] = "66061ff2ae3c109dd46f75d24929a54ca238c222bdefb5170f6637a9ab7ec7eb"

URI_x86_64_v2_scorep-openmpi-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scorep-openmpi-libs-9.4-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scorep-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scorep-openmpi-libs}"
SRC_URI[x86_64_v2_scorep-openmpi-libs.sha256sum] = "c1f4e481addfb9896badb958ecaab593e06c1cad2f50e44f10487e28c698c69e"

URI_aarch64_scorep = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-9.4-2.el10_2.aarch64.rpm;name=aarch64_scorep;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep}"
SRC_URI[aarch64_scorep.sha256sum] = "7644d0c924913d7736ffe6587e53d7f5efdc04f512787da1ec403ab04e29b82c"

URI_aarch64_scorep-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-config-9.4-2.el10_2.aarch64.rpm;name=aarch64_scorep-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-config}"
SRC_URI[aarch64_scorep-config.sha256sum] = "3b328579012cd47029471d40aa70701c786aa9dd90609d0fdfc5d63197816dfe"

URI_aarch64_scorep-doc = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-doc-9.4-2.el10_2.noarch.rpm;name=aarch64_scorep-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-doc}"
SRC_URI[aarch64_scorep-doc.sha256sum] = "752d970fa65f8b754c0a4453187b231b298b6cacbae8a355bb203d9bed9c085d"

URI_aarch64_scorep-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-libs-9.4-2.el10_2.aarch64.rpm;name=aarch64_scorep-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-libs}"
SRC_URI[aarch64_scorep-libs.sha256sum] = "be60540cd693e96b9a2c1f2c0db3f487d0e9a1035885395648bb85cbd0d867a5"

URI_aarch64_scorep-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-9.4-2.el10_2.aarch64.rpm;name=aarch64_scorep-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich}"
SRC_URI[aarch64_scorep-mpich.sha256sum] = "355fc3cfd203b30a15909c1f4c7655e6b0dbfcb8a2d373d1f0b12ba5f6359f37"

URI_aarch64_scorep-mpich-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-config-9.4-2.el10_2.aarch64.rpm;name=aarch64_scorep-mpich-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich-config}"
SRC_URI[aarch64_scorep-mpich-config.sha256sum] = "f83c9392dd3c7be2a45c8cdd1e58f7915dae6e6df6004295735e645821585d7e"

URI_aarch64_scorep-mpich-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-mpich-libs-9.4-2.el10_2.aarch64.rpm;name=aarch64_scorep-mpich-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-mpich-libs}"
SRC_URI[aarch64_scorep-mpich-libs.sha256sum] = "1e62c4af2668a06867f87d8d050cd780dfc4b71374988798bd76b0b65d610e33"

URI_aarch64_scorep-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-9.4-2.el10_2.aarch64.rpm;name=aarch64_scorep-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi}"
SRC_URI[aarch64_scorep-openmpi.sha256sum] = "93647216c74d76df97d40bbe92ee1e2e6385f229e74c713aed692111725a22de"

URI_aarch64_scorep-openmpi-config = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-config-9.4-2.el10_2.aarch64.rpm;name=aarch64_scorep-openmpi-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi-config}"
SRC_URI[aarch64_scorep-openmpi-config.sha256sum] = "4b1545ea6f758b8d484e2b3cda168e3919443c20396b6b01447bcc5c07127b40"

URI_aarch64_scorep-openmpi-libs = "${EPEL_MIRROR}/aarch64/Packages/s/scorep-openmpi-libs-9.4-2.el10_2.aarch64.rpm;name=aarch64_scorep-openmpi-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_scorep-openmpi-libs}"
SRC_URI[aarch64_scorep-openmpi-libs.sha256sum] = "6193d4a1a15b2a92c0498b276819ae164ace9f2a35b3cc261ddd6458065783c5"

RDEPENDS:scorep = " \
 bash \
 binutils-devel \
 clang-libs \
 cube-libs \
 cube-libs-devel \
 glibc \
 gotcha-devel \
 libgcc \
 libstdc++ \
 libunwind-devel \
 ocl-icd-devel \
 opari2 \
 otf2-devel \
 papi-devel \
 scorep-libs \
 "
RDEPENDS:scorep-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-doc = " \
 "
RDEPENDS:scorep-libs = " \
 scorep-config \
 "
RDEPENDS:scorep-mpich = " \
 bash \
 cube-libs \
 cube-libs-devel \
 glibc \
 libgcc \
 libstdc++ \
 otf2-devel \
 papi-devel \
 scorep-mpich-libs \
 "
RDEPENDS:scorep-mpich-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-mpich-libs = " \
 scorep-mpich-config \
 "
RDEPENDS:scorep-openmpi = " \
 bash \
 cube-libs \
 cube-libs-devel \
 glibc \
 libgcc \
 libstdc++ \
 otf2-devel \
 papi-devel \
 scorep-openmpi-libs \
 "
RDEPENDS:scorep-openmpi-config = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:scorep-openmpi-libs = " \
 scorep-openmpi-config \
 "
