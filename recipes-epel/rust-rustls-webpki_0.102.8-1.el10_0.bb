# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-webpki"
PV = "0.102.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki+default-devel \
 rust-rustls-webpki+ring-devel \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-webpki-0.102.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07f2eb188446d17643e350c52a304a40f44b66df56ca5c85b47bac32ed0b61a3"

URI_x86_64_v2_rust-rustls-webpki+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+alloc-devel-0.102.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+alloc-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+alloc-devel.sha256sum] = "5b0888e446b11822616aca6d6b459f194c8fc7f4a362f0e803363b07ce879af1"

URI_x86_64_v2_rust-rustls-webpki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+default-devel-0.102.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+default-devel.sha256sum] = "23dde5e932ec913558451169a41c6dc00983f90516b64ebf5ce8655eb03190ad"

URI_x86_64_v2_rust-rustls-webpki+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+ring-devel-0.102.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+ring-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+ring-devel.sha256sum] = "a0973cbd38b9e3481eb1c93bce56c35e7a4a2d3710a8e354aba4187345f14bd7"

URI_x86_64_v2_rust-rustls-webpki+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+std-devel-0.102.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki+std-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki+std-devel.sha256sum] = "042a28b91bf17f67fd6f94e2a6a8e8b875be4939576db64c95b8ab8ef52e33b1"

URI_x86_64_v2_rust-rustls-webpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki-devel-0.102.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-webpki-devel}"
SRC_URI[x86_64_v2_rust-rustls-webpki-devel.sha256sum] = "6419f197e48daaf57bf44fb6cd07d60fd568f1d89f28bef88d54300715c6b4ff"

URI_aarch64_rust-rustls-webpki+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+alloc-devel-0.102.8-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+alloc-devel}"
SRC_URI[aarch64_rust-rustls-webpki+alloc-devel.sha256sum] = "3901a5ca98820c24bf5e683ed543dbb8bc85c54b163ac80032509983765e3a51"

URI_aarch64_rust-rustls-webpki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+default-devel-0.102.8-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+default-devel}"
SRC_URI[aarch64_rust-rustls-webpki+default-devel.sha256sum] = "a193a5ac688011bcf5d4e078b959ed7bf13af5a5c06f8ea5bb71301b33c648c2"

URI_aarch64_rust-rustls-webpki+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+ring-devel-0.102.8-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+ring-devel}"
SRC_URI[aarch64_rust-rustls-webpki+ring-devel.sha256sum] = "9703aed06803853697493e504ab62134d7c9da5561f3675fbfefde1463db22fc"

URI_aarch64_rust-rustls-webpki+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+std-devel-0.102.8-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki+std-devel}"
SRC_URI[aarch64_rust-rustls-webpki+std-devel.sha256sum] = "f33d6b6d4634e02581c6e182ef0ede0d1508c217e7a814d08fc3703e39633587"

URI_aarch64_rust-rustls-webpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki-devel-0.102.8-1.el10_0.noarch.rpm;name=aarch64_rust-rustls-webpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-webpki-devel}"
SRC_URI[aarch64_rust-rustls-webpki-devel.sha256sum] = "6d767737bdaf5db8ed124a753b0497fd01424f9029012a1e54f1bea39f41b9a5"

RDEPENDS:rust-rustls-webpki+alloc-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+default-devel = " \
 cargo \
 rust-rustls-webpki+ring-devel \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+ring-devel = " \
 cargo \
 rust-ring-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+std-devel = " \
 cargo \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 rust-untrusted+default-devel \
 "
