# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "seabios"
PV = "1.16.3"
PR = "7.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 seabios \
 seabios-bin \
 seavgabios-bin \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/seabios-1.16.3-7.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25075aad86875c9ff94bec680c010fc6530917fdaab0e965848e87021c97de9d"

URI_x86_64_v2_seabios = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/seabios-1.16.3-7.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_seabios;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seabios}"
SRC_URI[x86_64_v2_seabios.sha256sum] = "d01d7ec513845007580115eec55e5febd428595f3c86c0ee66dc47c1acc01409"

URI_x86_64_v2_seabios-bin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/seabios-bin-1.16.3-7.el10.alma.1.noarch.rpm;name=x86_64_v2_seabios-bin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seabios-bin}"
SRC_URI[x86_64_v2_seabios-bin.sha256sum] = "b78facffebfa7ef9c327953994c9e2738ff5ef682059d98e01cd911a0c68fa6f"

URI_x86_64_v2_seavgabios-bin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/seavgabios-bin-1.16.3-7.el10.alma.1.noarch.rpm;name=x86_64_v2_seavgabios-bin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seavgabios-bin}"
SRC_URI[x86_64_v2_seavgabios-bin.sha256sum] = "7a54039ac95efcb0b1008c67e71563d72403cf53583a84264a6a36f105da3c9d"

RDEPENDS:seabios = " \
 seabios-bin \
 seavgabios-bin \
 "
RDEPENDS:seabios-bin = " \
 "
RDEPENDS:seavgabios-bin = " \
 "
