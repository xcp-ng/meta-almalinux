# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_hostid"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_hostid+default-devel \
 rust-uu_hostid-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-uu_hostid-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0e53c34f242b673be0ae35c6403c261ac4414652441adc37c5dd11633fc25aaa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_hostid+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_hostid+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uu_hostid+default-devel.sha256sum] = "41416575a7da5e0c071cff6bcf014c1f98032ce845c931f56359d766bb9e131c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_hostid-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_hostid-devel;unpack=0"
SRC_URI[x86_64_v2_rust-uu_hostid-devel.sha256sum] = "2e66d09e9c24f468dec22cd721fcc089cc69f548ae829a210293ad41108d07fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_hostid+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_hostid+default-devel;unpack=0"
SRC_URI[aarch64_rust-uu_hostid+default-devel.sha256sum] = "ba6f267cc7a53494b6b724cc86991f2376f7f8ac41083b6d3982be07678822a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_hostid-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_hostid-devel;unpack=0"
SRC_URI[aarch64_rust-uu_hostid-devel.sha256sum] = "e8b249d81f24e3bb0903c9dd72d8458d6750f96dbe8e89f3ddc226f3dd0a2288"

RDEPENDS:rust-uu_hostid+default-devel = " \
 cargo \
 rust-uu_hostid-devel \
 "
RDEPENDS:rust-uu_hostid-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-uucore+default-devel \
 "
