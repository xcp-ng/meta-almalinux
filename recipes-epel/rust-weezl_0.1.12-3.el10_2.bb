# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-weezl"
PV = "0.1.12"
PR = "3.el10_2"
PACKAGES = " \
 rust-weezl+alloc-devel \
 rust-weezl+async-devel \
 rust-weezl+default-devel \
 rust-weezl+futures-devel \
 rust-weezl+std-devel \
 rust-weezl-devel \
 weezl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-weezl-0.1.12-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e02fc236af2de0c2c02e82e9b43a800cc2ecfbe8e0c330c1980c9d5af8d9ce2d"

URI_x86_64_v2_rust-weezl+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+alloc-devel-0.1.12-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+alloc-devel}"
SRC_URI[x86_64_v2_rust-weezl+alloc-devel.sha256sum] = "c88c7686ec9d77a88572717a2a589b8ffa57b0e6a8692b3def9cfa14b849146b"

URI_x86_64_v2_rust-weezl+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+async-devel-0.1.12-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+async-devel}"
SRC_URI[x86_64_v2_rust-weezl+async-devel.sha256sum] = "cce29918fc6c2ca942b27e4bc9eac5cbf17f8d638c81090d33d9046720cec069"

URI_x86_64_v2_rust-weezl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+default-devel-0.1.12-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+default-devel}"
SRC_URI[x86_64_v2_rust-weezl+default-devel.sha256sum] = "ffe4ad3d3b8c662a5de73ae30697ce1f3678eb778e10c5fe678dc3542bfee7ef"

URI_x86_64_v2_rust-weezl+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+futures-devel-0.1.12-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+futures-devel}"
SRC_URI[x86_64_v2_rust-weezl+futures-devel.sha256sum] = "6a2993cf84c3aa68c2679fbda4a3e1d6938eb903106631c373d601b10413d223"

URI_x86_64_v2_rust-weezl+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl+std-devel-0.1.12-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl+std-devel}"
SRC_URI[x86_64_v2_rust-weezl+std-devel.sha256sum] = "3285559b5676bedacca1b01204141bfea746a32eed747f8dc527536f7320de9c"

URI_x86_64_v2_rust-weezl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-weezl-devel-0.1.12-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-weezl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-weezl-devel}"
SRC_URI[x86_64_v2_rust-weezl-devel.sha256sum] = "b8fac49a9f44faf9590b90e21db7b5b52af51616b3da1845092e14bb8cee905f"

URI_x86_64_v2_weezl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/weezl-0.1.12-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_weezl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_weezl}"
SRC_URI[x86_64_v2_weezl.sha256sum] = "52487b1c95a783b53fb5aea5ad234be3b83fb16fd15d195e1a72afc309c115b8"

URI_aarch64_rust-weezl+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+alloc-devel-0.1.12-3.el10_2.noarch.rpm;name=aarch64_rust-weezl+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+alloc-devel}"
SRC_URI[aarch64_rust-weezl+alloc-devel.sha256sum] = "5b52906e19080c937c0c82d9960f822818de7c65894240f41a3be56302be46e0"

URI_aarch64_rust-weezl+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+async-devel-0.1.12-3.el10_2.noarch.rpm;name=aarch64_rust-weezl+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+async-devel}"
SRC_URI[aarch64_rust-weezl+async-devel.sha256sum] = "d5d7dab30c1237284656ca0ef7edf76a835daab3b8ae1e7c7784bf59d3a99903"

URI_aarch64_rust-weezl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+default-devel-0.1.12-3.el10_2.noarch.rpm;name=aarch64_rust-weezl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+default-devel}"
SRC_URI[aarch64_rust-weezl+default-devel.sha256sum] = "a6d7245fa345a73a588e08a52bc9ce0867e1d9dbb85fdb39d51e949f855b6430"

URI_aarch64_rust-weezl+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+futures-devel-0.1.12-3.el10_2.noarch.rpm;name=aarch64_rust-weezl+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+futures-devel}"
SRC_URI[aarch64_rust-weezl+futures-devel.sha256sum] = "e465c469fa7031707ee7431e12c325d6cb35f0c8569721deffe3a18be7dda2e5"

URI_aarch64_rust-weezl+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl+std-devel-0.1.12-3.el10_2.noarch.rpm;name=aarch64_rust-weezl+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl+std-devel}"
SRC_URI[aarch64_rust-weezl+std-devel.sha256sum] = "91be788e42ccb131d864b3c71bf5914242e0b45f6e4fd8103cb8d7be60befa69"

URI_aarch64_rust-weezl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-weezl-devel-0.1.12-3.el10_2.noarch.rpm;name=aarch64_rust-weezl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-weezl-devel}"
SRC_URI[aarch64_rust-weezl-devel.sha256sum] = "8ea4046080004ad750a5d49cf9d7ebc3234b1b97e6533d3cd9799b25d2f6bea1"

URI_aarch64_weezl = "${EPEL_MIRROR}/aarch64/Packages/w/weezl-0.1.12-3.el10_2.aarch64.rpm;name=aarch64_weezl;unpack=0"
SRC_URI:append = " ${URI_aarch64_weezl}"
SRC_URI[aarch64_weezl.sha256sum] = "9bd93c12515724c7e187c9ee19ee50a35d2ad657b98db60fe4a0017a714f8685"

RDEPENDS:rust-weezl+alloc-devel = " \
 cargo \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+async-devel = " \
 cargo \
 rust-weezl+futures-devel \
 rust-weezl+std-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+default-devel = " \
 cargo \
 rust-weezl+std-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+futures-devel = " \
 cargo \
 rust-futures+std-devel \
 rust-futures-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl+std-devel = " \
 cargo \
 rust-weezl+alloc-devel \
 rust-weezl-devel \
 "
RDEPENDS:rust-weezl-devel = " \
 cargo \
 "
RDEPENDS:weezl = " \
 glibc \
 libgcc \
 "
