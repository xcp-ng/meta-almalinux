# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-implib"
PV = "0.6.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-implib+default-devel \
 rust-implib+gnu-devel \
 rust-implib+msvc-devel \
 rust-implib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-implib-0.6.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9740edc704072610b53e7fd34e3d57bd0322522451cd9ab9ca52bc74e669e132"

URI_x86_64_v2_rust-implib+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib+default-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib+default-devel}"
SRC_URI[x86_64_v2_rust-implib+default-devel.sha256sum] = "83d10134e16ace052b932abf2e73903ab34b8837cbe7d81854d7ff57da383c70"

URI_x86_64_v2_rust-implib+gnu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib+gnu-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib+gnu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib+gnu-devel}"
SRC_URI[x86_64_v2_rust-implib+gnu-devel.sha256sum] = "0daa629b3ebd0567f4667bb0784b30ce5d8853c2a20fa02a65c8e1584bfed334"

URI_x86_64_v2_rust-implib+msvc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib+msvc-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib+msvc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib+msvc-devel}"
SRC_URI[x86_64_v2_rust-implib+msvc-devel.sha256sum] = "9d8792479b37ed48077e433698ed78dad436220e0d37b3ef66e990a67fdee902"

URI_x86_64_v2_rust-implib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib-devel-0.6.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib-devel}"
SRC_URI[x86_64_v2_rust-implib-devel.sha256sum] = "48639c1bde08d2bd14b5e4986066a4a0717c15d0618f74032e420ff4d0ff9654"

URI_aarch64_rust-implib+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib+default-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-implib+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib+default-devel}"
SRC_URI[aarch64_rust-implib+default-devel.sha256sum] = "996754be101d2cf1fe83a288c4235804acebcfd2b58736e11ef582e50ae5db7d"

URI_aarch64_rust-implib+gnu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib+gnu-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-implib+gnu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib+gnu-devel}"
SRC_URI[aarch64_rust-implib+gnu-devel.sha256sum] = "1a72dcd99dc6f49e45c0052217966a204ee4a7adbee811520d1b0bebaa6f7795"

URI_aarch64_rust-implib+msvc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib+msvc-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-implib+msvc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib+msvc-devel}"
SRC_URI[aarch64_rust-implib+msvc-devel.sha256sum] = "9b4318fbfea78321b3864c855d38e6e9daacc4ae24875e7305b13e2016d75341"

URI_aarch64_rust-implib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib-devel-0.6.0-1.el10_3.noarch.rpm;name=aarch64_rust-implib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib-devel}"
SRC_URI[aarch64_rust-implib-devel.sha256sum] = "363203cab8fd17ef8a80080df546a95b32d04e6986b7068e78b6bb8036991db2"

RDEPENDS:rust-implib+default-devel = " \
 cargo \
 rust-implib+gnu-devel \
 rust-implib+msvc-devel \
 rust-implib-devel \
 "
RDEPENDS:rust-implib+gnu-devel = " \
 cargo \
 rust-implib-devel \
 rust-object+write_std-devel \
 "
RDEPENDS:rust-implib+msvc-devel = " \
 cargo \
 rust-implib-devel \
 "
RDEPENDS:rust-implib-devel = " \
 cargo \
 rust-ar_archive_writer+default-devel \
 rust-memchr+default-devel \
 rust-memoffset+default-devel \
 rust-object+pe-devel \
 rust-object-devel \
 "
