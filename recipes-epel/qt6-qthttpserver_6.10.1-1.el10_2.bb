# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qthttpserver"
PV = "6.10.1"
PR = "1.el10_2"
PACKAGES = " \
 qt6-qthttpserver \
 qt6-qthttpserver-devel \
 qt6-qthttpserver-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qthttpserver-6.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f895187aac2ec956da4d6b5250dceba3a5996a26846d755d6312fc71bc4c8012"

URI_x86_64_v2_qt6-qthttpserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qthttpserver-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qthttpserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qthttpserver}"
SRC_URI[x86_64_v2_qt6-qthttpserver.sha256sum] = "fbe3c19e3cf222f3b956653019c9bab7ddc1cfbceb73f924ebf60919c5ecc898"

URI_x86_64_v2_qt6-qthttpserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qthttpserver-devel-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qthttpserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qthttpserver-devel}"
SRC_URI[x86_64_v2_qt6-qthttpserver-devel.sha256sum] = "01c89710ef374b8d0644acfdeb5f6a89a215b4726c1d4f1a619aefcc0ecfd951"

URI_x86_64_v2_qt6-qthttpserver-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qthttpserver-examples-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qthttpserver-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qthttpserver-examples}"
SRC_URI[x86_64_v2_qt6-qthttpserver-examples.sha256sum] = "59993008947ef868c152a697a759f481836a0ef30379d4c30b42b3301911c44b"

URI_aarch64_qt6-qthttpserver = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qthttpserver-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qthttpserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qthttpserver}"
SRC_URI[aarch64_qt6-qthttpserver.sha256sum] = "1fefed76c461a119b2a2bf74a3f7fc0cfffd9089feecd626dc24cee3cb8e3955"

URI_aarch64_qt6-qthttpserver-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qthttpserver-devel-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qthttpserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qthttpserver-devel}"
SRC_URI[aarch64_qt6-qthttpserver-devel.sha256sum] = "4903a1c2332acac6e5ee6845f6eeedefc33bd4901abc0dfc96cd2c05bfcc8c9c"

URI_aarch64_qt6-qthttpserver-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qthttpserver-examples-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qthttpserver-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qthttpserver-examples}"
SRC_URI[aarch64_qt6-qthttpserver-examples.sha256sum] = "2b8912328c54849cb9048681f0e3ae6dd701787b038f7260076ff6025b24c9a0"

RDEPENDS:qt6-qthttpserver = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtwebsockets \
 "
RDEPENDS:qt6-qthttpserver-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qthttpserver \
 qt6-qtwebsockets-devel \
 "
RDEPENDS:qt6-qthttpserver-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qthttpserver \
 qt6-qthttpserver-devel \
 "
