# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcodecs"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kcodecs \
 kf6-kcodecs-devel \
 kf6-kcodecs-doc \
 kf6-kcodecs-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcodecs-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "484e10907eb808c9fff8f88ec8f8d5b07ba39eec1c0e793e1eb475a189eaa77c"

URI_x86_64_v2_kf6-kcodecs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs}"
SRC_URI[x86_64_v2_kf6-kcodecs.sha256sum] = "e6697fd9b5a75d200d78a28df2508f69b575b469571f7793d05021f312345522"

URI_x86_64_v2_kf6-kcodecs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcodecs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-devel}"
SRC_URI[x86_64_v2_kf6-kcodecs-devel.sha256sum] = "69643f10decea8e60cd89302c1b0b045d31f9ffbece144b85f92d5dcb216ae9e"

URI_x86_64_v2_kf6-kcodecs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-doc}"
SRC_URI[x86_64_v2_kf6-kcodecs-doc.sha256sum] = "163754a7dc3647b97784bc304929a1519eede95a9f0f7faf312744d6166255f2"

URI_x86_64_v2_kf6-kcodecs-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcodecs-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcodecs-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcodecs-html}"
SRC_URI[x86_64_v2_kf6-kcodecs-html.sha256sum] = "2cdd3dcaf47eb2839f4b91f8bcb283124e9791da7d6520304f63ec6fbe5cd4bd"

URI_aarch64_kf6-kcodecs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcodecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs}"
SRC_URI[aarch64_kf6-kcodecs.sha256sum] = "7687f45c2c23f12cae9b4441bcbedf5846ada808cab63ca4d3bd81a570eace61"

URI_aarch64_kf6-kcodecs-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcodecs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-devel}"
SRC_URI[aarch64_kf6-kcodecs-devel.sha256sum] = "99bef15710939f167e35b6cc03128b1593da3e1be6e55c96b6246bbf9b3d3cf2"

URI_aarch64_kf6-kcodecs-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcodecs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-doc}"
SRC_URI[aarch64_kf6-kcodecs-doc.sha256sum] = "46a0146d56dbd034d5124772eb8e363e2d4296c4e65eb86eeb8799ae49e4eaa7"

URI_aarch64_kf6-kcodecs-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcodecs-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcodecs-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcodecs-html}"
SRC_URI[aarch64_kf6-kcodecs-html.sha256sum] = "075f86b43c970fc1a4ed3f2505bf6ae6a7d69cb02e048b6c3a39bd17c8e9675f"

RDEPENDS:kf6-kcodecs = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kcodecs-devel = " \
 cmake-filesystem \
 kf6-kcodecs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcodecs-doc = " \
 "
RDEPENDS:kf6-kcodecs-html = " \
 "
