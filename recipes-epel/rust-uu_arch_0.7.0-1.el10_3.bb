# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_arch"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_arch+default-devel \
 rust-uu_arch-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_arch-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d94160b7b2700d12b3f8d3e364adb4537d871993b5302fe967216ec731ea8c9d"

URI_x86_64_v2_rust-uu_arch+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_arch+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_arch+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_arch+default-devel}"
SRC_URI[x86_64_v2_rust-uu_arch+default-devel.sha256sum] = "7edf49db441e638e208b09e326f44d1574b4e1d853dacbc3076975b9d06b8735"

URI_x86_64_v2_rust-uu_arch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_arch-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_arch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_arch-devel}"
SRC_URI[x86_64_v2_rust-uu_arch-devel.sha256sum] = "dcf20a6cfaf0981b8dc76a432f75f17628876a3e4b1d6eeb8e7597f0692cbe83"

URI_aarch64_rust-uu_arch+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_arch+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_arch+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_arch+default-devel}"
SRC_URI[aarch64_rust-uu_arch+default-devel.sha256sum] = "c3bab267c44890cb361c528b03e96e871f4ad8b458e2e258bd2570c086991033"

URI_aarch64_rust-uu_arch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_arch-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_arch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_arch-devel}"
SRC_URI[aarch64_rust-uu_arch-devel.sha256sum] = "c04ddecfd891bee400a5f266674c72d2a45dbacf7e8de6897705f6115c1929d4"

RDEPENDS:rust-uu_arch+default-devel = " \
 cargo \
 rust-uu_arch-devel \
 "
RDEPENDS:rust-uu_arch-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-platform-info+default-devel \
 rust-uucore+default-devel \
 "
