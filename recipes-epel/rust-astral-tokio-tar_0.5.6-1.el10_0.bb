# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-tokio-tar"
PV = "0.5.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-astral-tokio-tar+default-devel \
 rust-astral-tokio-tar+xattr-devel \
 rust-astral-tokio-tar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral-tokio-tar-0.5.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "762c2165f72bf2afbd6e3107871e97969b0316d23e7a1e28131b76829e024766"

URI_x86_64_v2_rust-astral-tokio-tar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tokio-tar+default-devel-0.5.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tokio-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tokio-tar+default-devel}"
SRC_URI[x86_64_v2_rust-astral-tokio-tar+default-devel.sha256sum] = "d69039949adb8aad04ed7e7dd7508415e23731579c21488f00e6d2f34e64ee75"

URI_x86_64_v2_rust-astral-tokio-tar+xattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tokio-tar+xattr-devel-0.5.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tokio-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tokio-tar+xattr-devel}"
SRC_URI[x86_64_v2_rust-astral-tokio-tar+xattr-devel.sha256sum] = "06e530fd1cfe89adcd7df4e4ee87bd9b3e34b9f6d27be173bd1ff218e4cc92d6"

URI_x86_64_v2_rust-astral-tokio-tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tokio-tar-devel-0.5.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tokio-tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tokio-tar-devel}"
SRC_URI[x86_64_v2_rust-astral-tokio-tar-devel.sha256sum] = "e5bc566266b04d507d14eb58a913252e2d2aaaf60e0bb5e4ec8bcc27cb787706"

URI_aarch64_rust-astral-tokio-tar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tokio-tar+default-devel-0.5.6-1.el10_0.noarch.rpm;name=aarch64_rust-astral-tokio-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tokio-tar+default-devel}"
SRC_URI[aarch64_rust-astral-tokio-tar+default-devel.sha256sum] = "54b06af7333b2f209e366044892588d25675c223d0436b2e99b7645e831ec499"

URI_aarch64_rust-astral-tokio-tar+xattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tokio-tar+xattr-devel-0.5.6-1.el10_0.noarch.rpm;name=aarch64_rust-astral-tokio-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tokio-tar+xattr-devel}"
SRC_URI[aarch64_rust-astral-tokio-tar+xattr-devel.sha256sum] = "0dfab133075a4405d7e18469c06b8b27c99149f9fdaeee07ec8ed99450b88479"

URI_aarch64_rust-astral-tokio-tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tokio-tar-devel-0.5.6-1.el10_0.noarch.rpm;name=aarch64_rust-astral-tokio-tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tokio-tar-devel}"
SRC_URI[aarch64_rust-astral-tokio-tar-devel.sha256sum] = "c02eb595eda0242a447b3097d5d83d82a79869e2f15616aef9b4e05fc9726181"

RDEPENDS:rust-astral-tokio-tar+default-devel = " \
 cargo \
 rust-astral-tokio-tar+xattr-devel \
 rust-astral-tokio-tar-devel \
 "
RDEPENDS:rust-astral-tokio-tar+xattr-devel = " \
 cargo \
 rust-astral-tokio-tar-devel \
 rust-xattr+default-devel \
 "
RDEPENDS:rust-astral-tokio-tar-devel = " \
 bash \
 cargo \
 rust \
 rust-filetime+default-devel \
 rust-futures-core+default-devel \
 rust-libc+default-devel \
 rust-portable-atomic+default-devel \
 rust-rustc-hash+default-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+rt-devel \
 rust-tokio-stream+default-devel \
 "
