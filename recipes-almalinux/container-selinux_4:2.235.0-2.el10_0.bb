# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "container-selinux"
PE = "4"
PV = "2.235.0"
PR = "2.el10_0"
PACKAGES = " \
 container-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/container-selinux-2.235.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "807f238576348016fcc9c543e45305a59cc329fc5fd5943da42a792a075ab613"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/container-selinux-2.235.0-2.el10_0.noarch.rpm;name=x86_64_v2_container-selinux;unpack=0"
SRC_URI[x86_64_v2_container-selinux.sha256sum] = "985390d1e3f4090927b7433d1d975f2d3e388aff3ad41c2b9b2801c0d80d2c26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/container-selinux-2.235.0-2.el10_0.noarch.rpm;name=aarch64_container-selinux;unpack=0"
SRC_URI[aarch64_container-selinux.sha256sum] = "985390d1e3f4090927b7433d1d975f2d3e388aff3ad41c2b9b2801c0d80d2c26"

RDEPENDS:container-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 sed \
 selinux-policy \
 virtual/selinux-policy-any_ge_40.13.26 \
 "
