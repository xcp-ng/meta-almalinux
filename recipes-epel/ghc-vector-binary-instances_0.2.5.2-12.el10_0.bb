# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-vector-binary-instances"
PV = "0.2.5.2"
PR = "12.el10_0"
PACKAGES = " \
 ghc-vector-binary-instances \
 ghc-vector-binary-instances-devel \
 ghc-vector-binary-instances-doc \
 ghc-vector-binary-instances-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-vector-binary-instances-0.2.5.2-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9bd346fd571d4a9ab2c1c3dca0aac6fd84045d465d2d5a53a960d4caaf76633"

URI_x86_64_v2_ghc-vector-binary-instances = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-binary-instances-0.2.5.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-binary-instances;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-binary-instances}"
SRC_URI[x86_64_v2_ghc-vector-binary-instances.sha256sum] = "9d750b1a96646e2f6b08a2bd254016e31350da95126af031ff14445ad82124dd"

URI_x86_64_v2_ghc-vector-binary-instances-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-binary-instances-devel-0.2.5.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-binary-instances-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-binary-instances-devel}"
SRC_URI[x86_64_v2_ghc-vector-binary-instances-devel.sha256sum] = "348d0be40206caadb54028d93e8adc87f6db3dfd39b4e2693c23e7ebed67d1d5"

URI_x86_64_v2_ghc-vector-binary-instances-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-binary-instances-doc-0.2.5.2-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-vector-binary-instances-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-binary-instances-doc}"
SRC_URI[x86_64_v2_ghc-vector-binary-instances-doc.sha256sum] = "83e1a40e2d5c292c7a9bcc8d3072b5adf84d9e1400decb9a61365b958a0ac840"

URI_x86_64_v2_ghc-vector-binary-instances-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-vector-binary-instances-prof-0.2.5.2-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-vector-binary-instances-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-vector-binary-instances-prof}"
SRC_URI[x86_64_v2_ghc-vector-binary-instances-prof.sha256sum] = "34b4a4dbdddcaa5102a12546947b6b14757456f8c075a0dc95e6f84887beb368"

URI_aarch64_ghc-vector-binary-instances = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-binary-instances-0.2.5.2-12.el10_0.aarch64.rpm;name=aarch64_ghc-vector-binary-instances;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-binary-instances}"
SRC_URI[aarch64_ghc-vector-binary-instances.sha256sum] = "f036f5e7c8de926960bae38506f43d73748e3c62a2b8248524be9fb85133304d"

URI_aarch64_ghc-vector-binary-instances-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-binary-instances-devel-0.2.5.2-12.el10_0.aarch64.rpm;name=aarch64_ghc-vector-binary-instances-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-binary-instances-devel}"
SRC_URI[aarch64_ghc-vector-binary-instances-devel.sha256sum] = "81395abe94b1d6358cecf80e65e44a4929a22f9836b97fae7a28dccb7ec2f4f2"

URI_aarch64_ghc-vector-binary-instances-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-binary-instances-doc-0.2.5.2-12.el10_0.noarch.rpm;name=aarch64_ghc-vector-binary-instances-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-binary-instances-doc}"
SRC_URI[aarch64_ghc-vector-binary-instances-doc.sha256sum] = "ef1e9003a2854bb53b7e5a344de0ac101ee67a14c8512d8b9f19a9a608b176a5"

URI_aarch64_ghc-vector-binary-instances-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-vector-binary-instances-prof-0.2.5.2-12.el10_0.aarch64.rpm;name=aarch64_ghc-vector-binary-instances-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-vector-binary-instances-prof}"
SRC_URI[aarch64_ghc-vector-binary-instances-prof.sha256sum] = "b0b8f95fa591301f3594dae2c8f8e7d5822aaed7f80e502376b00e930643abb2"

RDEPENDS:ghc-vector-binary-instances = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-primitive \
 ghc-template-haskell \
 ghc-transformers \
 ghc-vector \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-vector-binary-instances-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-compiler \
 ghc-vector-binary-instances \
 ghc-vector-devel \
 "
RDEPENDS:ghc-vector-binary-instances-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-vector-binary-instances-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-vector-binary-instances-devel \
 ghc-vector-prof \
 "
