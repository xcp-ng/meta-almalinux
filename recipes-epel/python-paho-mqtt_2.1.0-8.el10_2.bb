# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-paho-mqtt"
PV = "2.1.0"
PR = "8.el10_2"
PACKAGES = " \
 python3-paho-mqtt \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-paho-mqtt-2.1.0-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f649fe5dbcd4ee36e47bbbf902680d6a1d3341b783611e9c370496e050bf058"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-paho-mqtt-2.1.0-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-paho-mqtt;unpack=0"
SRC_URI[x86_64_v2_python3-paho-mqtt.sha256sum] = "e7462a22c6d967f2f41ff4cb7cc1f047eb6ec76a997559a57bf773572b65f204"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-paho-mqtt-2.1.0-8.el10_2.noarch.rpm;name=aarch64_python3-paho-mqtt;unpack=0"
SRC_URI[aarch64_python3-paho-mqtt.sha256sum] = "6a0fcc21079f932e0c130a35c284f5b4d2a3c5b3452d1f5c6b4a39d7c2771139"

RDEPENDS:python3-paho-mqtt = " \
 python3 \
 "
