# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-dnaeon-vcr"
PV = "1.1.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-dnaeon-vcr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-dnaeon-vcr-1.1.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96f3806bd0a65ce930d49c40ee8ba3df4d47955c834eb306833cfe973e0330d5"

URI_x86_64_v2_golang-github-dnaeon-vcr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-dnaeon-vcr-devel-1.1.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-dnaeon-vcr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-dnaeon-vcr-devel}"
SRC_URI[x86_64_v2_golang-github-dnaeon-vcr-devel.sha256sum] = "2807124f2fc963cc6497a9da782cdfff86ab22b2982cb5dd57c87fc74396a43c"

URI_aarch64_golang-github-dnaeon-vcr-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-dnaeon-vcr-devel-1.1.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-dnaeon-vcr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-dnaeon-vcr-devel}"
SRC_URI[aarch64_golang-github-dnaeon-vcr-devel.sha256sum] = "ad62dd8e20bd88c3927257d0c29e5faba1295cdb851c90e7f86c440489a6ef85"

RDEPENDS:golang-github-dnaeon-vcr-devel = " \
 go-filesystem \
 golang-gopkg-yaml-2-devel \
 "
