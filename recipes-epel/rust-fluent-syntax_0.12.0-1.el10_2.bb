# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fluent-syntax"
PV = "0.12.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-fluent-syntax+default-devel \
 rust-fluent-syntax+json-devel \
 rust-fluent-syntax+serde-devel \
 rust-fluent-syntax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fluent-syntax-0.12.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c572da295a4e7b22656d6b88f1b428c825320790f214049ee6b9c2e8dce39774"

URI_x86_64_v2_rust-fluent-syntax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-syntax+default-devel-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-syntax+default-devel}"
SRC_URI[x86_64_v2_rust-fluent-syntax+default-devel.sha256sum] = "61c0bca7718fd8343ab7fa28739ab2e3d94a4c310769f0681a9bbdc67c28fe46"

URI_x86_64_v2_rust-fluent-syntax+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-syntax+json-devel-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-syntax+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-syntax+json-devel}"
SRC_URI[x86_64_v2_rust-fluent-syntax+json-devel.sha256sum] = "3d17cb28857c143098742aae0ef5e2478da8c5718e636d7f1abecb4a2d2c0782"

URI_x86_64_v2_rust-fluent-syntax+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-syntax+serde-devel-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-syntax+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-syntax+serde-devel}"
SRC_URI[x86_64_v2_rust-fluent-syntax+serde-devel.sha256sum] = "38e7ea83c4ee3c449c76885cd220ee53319afa6f195e1836a1f4a2085e6d6c50"

URI_x86_64_v2_rust-fluent-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fluent-syntax-devel-0.12.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fluent-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fluent-syntax-devel}"
SRC_URI[x86_64_v2_rust-fluent-syntax-devel.sha256sum] = "0574753203ee961b72f6236c791721c69aca5f75c84666281f6da12302c4f97b"

URI_aarch64_rust-fluent-syntax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-syntax+default-devel-0.12.0-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-syntax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-syntax+default-devel}"
SRC_URI[aarch64_rust-fluent-syntax+default-devel.sha256sum] = "292783cd59748e3b754e68478999ddbf625813eb25edc87600dd5014f9d86780"

URI_aarch64_rust-fluent-syntax+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-syntax+json-devel-0.12.0-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-syntax+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-syntax+json-devel}"
SRC_URI[aarch64_rust-fluent-syntax+json-devel.sha256sum] = "d92271415a63425c93897695ed41914b7ff565dc612f0b5a506cfd5d5b414f7c"

URI_aarch64_rust-fluent-syntax+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-syntax+serde-devel-0.12.0-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-syntax+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-syntax+serde-devel}"
SRC_URI[aarch64_rust-fluent-syntax+serde-devel.sha256sum] = "af883680ee16bb7e5574f41980baead251f5620826a23be9194c79bdc389eb55"

URI_aarch64_rust-fluent-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fluent-syntax-devel-0.12.0-1.el10_2.noarch.rpm;name=aarch64_rust-fluent-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fluent-syntax-devel}"
SRC_URI[aarch64_rust-fluent-syntax-devel.sha256sum] = "b719ce7555474cac664da04242d4e8b84bdf54fece2569a6154d936d2c56dc3a"

RDEPENDS:rust-fluent-syntax+default-devel = " \
 cargo \
 rust-fluent-syntax-devel \
 "
RDEPENDS:rust-fluent-syntax+json-devel = " \
 cargo \
 rust-fluent-syntax+serde-devel \
 rust-fluent-syntax-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-fluent-syntax+serde-devel = " \
 cargo \
 rust-fluent-syntax-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-fluent-syntax-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 rust-thiserror+default-devel \
 "
