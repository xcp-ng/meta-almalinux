# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pem"
PV = "3.0.6"
PR = "1.el10_2"
PACKAGES = " \
 rust-pem+default-devel \
 rust-pem+serde-devel \
 rust-pem+std-devel \
 rust-pem-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pem-3.0.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1bea79b15c9566e36fdbdaebee37b9ef288334338266faee0db5d4cd9fa4817"

URI_x86_64_v2_rust-pem+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+default-devel-3.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem+default-devel}"
SRC_URI[x86_64_v2_rust-pem+default-devel.sha256sum] = "1d785ef6f18955a29e019395899452f7b7ff63854b6f7dd5bdbaaf4a3710a83b"

URI_x86_64_v2_rust-pem+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+serde-devel-3.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem+serde-devel}"
SRC_URI[x86_64_v2_rust-pem+serde-devel.sha256sum] = "bbb9e8a1b86303ad57a1c16e898bd19707236c936d3f59ab9ae34406af5842ac"

URI_x86_64_v2_rust-pem+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem+std-devel-3.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem+std-devel}"
SRC_URI[x86_64_v2_rust-pem+std-devel.sha256sum] = "b9884143ebf1f8da337d8b99f945472531645af35c4bbb26615f27bd214e5f07"

URI_x86_64_v2_rust-pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pem-devel-3.0.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pem-devel}"
SRC_URI[x86_64_v2_rust-pem-devel.sha256sum] = "0288634ae7f21d3609254ed4de4770c8f467a41ee0e91a336bef8e1cfe0a1995"

URI_aarch64_rust-pem+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+default-devel-3.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-pem+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem+default-devel}"
SRC_URI[aarch64_rust-pem+default-devel.sha256sum] = "7204412121996c5a1a419c69dc7b124dcbec8a1d161d8ed518319369da2b1424"

URI_aarch64_rust-pem+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+serde-devel-3.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-pem+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem+serde-devel}"
SRC_URI[aarch64_rust-pem+serde-devel.sha256sum] = "030e40bb162774fafe96d27facb181190967e054cc34ced6bc9add844174ab1a"

URI_aarch64_rust-pem+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem+std-devel-3.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-pem+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem+std-devel}"
SRC_URI[aarch64_rust-pem+std-devel.sha256sum] = "a907d0ccdf158c9a9d54abc5640b36f42d58718a93f1297ecca3a632e96d0c96"

URI_aarch64_rust-pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pem-devel-3.0.6-1.el10_2.noarch.rpm;name=aarch64_rust-pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pem-devel}"
SRC_URI[aarch64_rust-pem-devel.sha256sum] = "df775b7a939ad03717bff5600b66caf2ff81e179418f8da67b015f2dff867e56"

RDEPENDS:rust-pem+default-devel = " \
 cargo \
 rust-pem+std-devel \
 rust-pem-devel \
 "
RDEPENDS:rust-pem+serde-devel = " \
 cargo \
 rust-pem-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem+std-devel = " \
 cargo \
 rust-base64+std-devel \
 rust-pem-devel \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-pem-devel = " \
 cargo \
 rust \
 rust-base64+alloc-devel \
 rust-base64-devel \
 "
