# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyflakes"
PV = "3.1.0"
PR = "8.el10_1"
PACKAGES = " \
 python3-pyflakes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pyflakes-3.1.0-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1457b9b3ccd30ed978405b33125ce55ae2dfded0261c53501ef966be5e9c3b1"

URI_x86_64_v2_python3-pyflakes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyflakes-3.1.0-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyflakes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyflakes}"
SRC_URI[x86_64_v2_python3-pyflakes.sha256sum] = "42c42533a7aa17f04ca8aa592e40e972c5b018b90d755370988b832bd6b04d3f"

URI_aarch64_python3-pyflakes = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyflakes-3.1.0-8.el10_1.noarch.rpm;name=aarch64_python3-pyflakes;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyflakes}"
SRC_URI[aarch64_python3-pyflakes.sha256sum] = "fdca2dd29872eaab5d447978b4b4bed0391eeefb5794aeddd72393249ef14998"

RDEPENDS:python3-pyflakes = " \
 python3 \
 "
