# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-get-size-derive2"
PV = "0.10.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-get-size-derive2+default-devel \
 rust-get-size-derive2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-get-size-derive2-0.10.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "866ecfc3a8f085d21bd07a4934d113ea37143b7168028244eb2bb08a392b7330"

URI_x86_64_v2_rust-get-size-derive2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size-derive2+default-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size-derive2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size-derive2+default-devel}"
SRC_URI[x86_64_v2_rust-get-size-derive2+default-devel.sha256sum] = "42c714806a4a155912eaa46a0c11b0812ae99645f577f6eae88c67a61577a2eb"

URI_x86_64_v2_rust-get-size-derive2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-get-size-derive2-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-get-size-derive2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-get-size-derive2-devel}"
SRC_URI[x86_64_v2_rust-get-size-derive2-devel.sha256sum] = "b4ff6aea6555f666e2dbdd139a0fd54e22d4800c478117421a4c16b24ad4c1d1"

URI_aarch64_rust-get-size-derive2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size-derive2+default-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size-derive2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size-derive2+default-devel}"
SRC_URI[aarch64_rust-get-size-derive2+default-devel.sha256sum] = "b54aa1892a5c0cbf20bb64ba133d3c3676037f38209406b66b0ba3fefe34cac4"

URI_aarch64_rust-get-size-derive2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-get-size-derive2-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-get-size-derive2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-get-size-derive2-devel}"
SRC_URI[aarch64_rust-get-size-derive2-devel.sha256sum] = "4cd1584ae3a84f7bd45d2a8b7983a6d335932e37b303004f8ae44d1f246809c6"

RDEPENDS:rust-get-size-derive2+default-devel = " \
 cargo \
 rust-get-size-derive2-devel \
 "
RDEPENDS:rust-get-size-derive2-devel = " \
 cargo \
 rust-attribute-derive+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+derive-devel \
 rust-syn2+parsing-devel \
 "
