# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isoimagewriter"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 isoimagewriter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/isoimagewriter-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "01a168f1cf27665f991dd660237672825c6fe8380e371334849bd0bcdd5f8911"

URI_x86_64_v2_isoimagewriter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/isoimagewriter-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_isoimagewriter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_isoimagewriter}"
SRC_URI[x86_64_v2_isoimagewriter.sha256sum] = "26d17ae7a2415eafb45bc19d15935c722470ffd49133ec78d2b9ecb708da4201"

URI_aarch64_isoimagewriter = "${EPEL_MIRROR}/aarch64/Packages/i/isoimagewriter-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_isoimagewriter;unpack=0"
SRC_URI:append = " ${URI_aarch64_isoimagewriter}"
SRC_URI[aarch64_isoimagewriter.sha256sum] = "5ba96dc38cd9ce0178cadc34506c8e6d5a6748c5abd9f3a3da81570823c9e180"

RDEPENDS:isoimagewriter = " \
 glibc \
 gpgmepp \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-solid \
 libgcc \
 libstdc++ \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
