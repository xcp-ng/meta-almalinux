# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtlocation"
PV = "5.15.17"
PR = "1.1.el10_1"
PACKAGES = " \
 qt5-qtlocation \
 qt5-qtlocation-devel \
 qt5-qtlocation-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtlocation-5.15.17-1.1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "54f4ef1b9c2dd96abba698c8db467dd7ae49604d22483a133e451453c291edad"

URI_x86_64_v2_qt5-qtlocation = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-5.15.17-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtlocation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation}"
SRC_URI[x86_64_v2_qt5-qtlocation.sha256sum] = "f4325444739ac2d4ef153d13f85013aa0c6fd94491f5d4551fea0e007357a920"

URI_x86_64_v2_qt5-qtlocation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-devel-5.15.17-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation-devel}"
SRC_URI[x86_64_v2_qt5-qtlocation-devel.sha256sum] = "1e5333ea4f8f824b7a48b45a43d53875bb2d316d561e34bd813b7b86d5e86a95"

URI_x86_64_v2_qt5-qtlocation-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtlocation-examples-5.15.17-1.1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtlocation-examples}"
SRC_URI[x86_64_v2_qt5-qtlocation-examples.sha256sum] = "d4d25501bf617c22c52c7675327cc168f511c725cb3256c327990bf2f87ef723"

URI_aarch64_qt5-qtlocation = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-5.15.17-1.1.el10_1.aarch64.rpm;name=aarch64_qt5-qtlocation;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation}"
SRC_URI[aarch64_qt5-qtlocation.sha256sum] = "c4c631eb3817cd0df0cd63839cc153d463bccc727012fe09cb6843a123b46132"

URI_aarch64_qt5-qtlocation-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-devel-5.15.17-1.1.el10_1.aarch64.rpm;name=aarch64_qt5-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation-devel}"
SRC_URI[aarch64_qt5-qtlocation-devel.sha256sum] = "0454dae893a4469eb898c997cfbd984483484fc6d5b5671f8939a6c9011f2312"

URI_aarch64_qt5-qtlocation-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtlocation-examples-5.15.17-1.1.el10_1.aarch64.rpm;name=aarch64_qt5-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtlocation-examples}"
SRC_URI[aarch64_qt5-qtlocation-examples.sha256sum] = "e31365913fb16249b687331c91357234f068f2ce9ef8800e257bebc4b715ef33"

RDEPENDS:qt5-qtlocation = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtlocation-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtlocation \
 qt5-qtlocation-devel \
 "
RDEPENDS:qt5-qtlocation-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtlocation \
 "
