# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rich-argparse"
PV = "1.7.2"
PR = "1.el10_1"
PACKAGES = " \
 python3-rich-argparse \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rich-argparse-1.7.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f30cc5c59835b671677aa33c36b09637f312367e3c6808d3605dd0fd5e957925"

URI_x86_64_v2_python3-rich-argparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rich-argparse-1.7.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rich-argparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rich-argparse}"
SRC_URI[x86_64_v2_python3-rich-argparse.sha256sum] = "c8e094edc23d16d134457ec9832c56d933b3c466ece63cd56436658e2a4a875f"

URI_aarch64_python3-rich-argparse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rich-argparse-1.7.2-1.el10_1.noarch.rpm;name=aarch64_python3-rich-argparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rich-argparse}"
SRC_URI[aarch64_python3-rich-argparse.sha256sum] = "245f5f9ad4e12cd73e8704e72a0043a85054ee01b24a569dabda61ea19bbf8c9"

RDEPENDS:python3-rich-argparse = " \
 python3 \
 python3-rich \
 "
