# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-constant-defer"
PV = "6"
PR = "32.el10_0"
PACKAGES = " \
 perl-constant-defer \
 perl-constant-defer-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-constant-defer-6-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fd7addd4fc2496b04807ce59ea9982e048a5e7297087ce89500bdfaed120021"

URI_x86_64_v2_perl-constant-defer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-constant-defer-6-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-constant-defer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-constant-defer}"
SRC_URI[x86_64_v2_perl-constant-defer.sha256sum] = "e93ae50f43650e79a849bec713175df566a29d92c792f13e9fc2c4dfa16bdbaf"

URI_x86_64_v2_perl-constant-defer-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-constant-defer-tests-6-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-constant-defer-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-constant-defer-tests}"
SRC_URI[x86_64_v2_perl-constant-defer-tests.sha256sum] = "f9602e07f8a961d6408ff8b8238a52325fb9b7891888a035fb86bfe282ca6a14"

URI_aarch64_perl-constant-defer = "${EPEL_MIRROR}/aarch64/Packages/p/perl-constant-defer-6-32.el10_0.noarch.rpm;name=aarch64_perl-constant-defer;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-constant-defer}"
SRC_URI[aarch64_perl-constant-defer.sha256sum] = "150aa7baf87b3c777e11ca9ae9b4d8f0f16e8740d8b71e1f8865c8aa584fc7e9"

URI_aarch64_perl-constant-defer-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-constant-defer-tests-6-32.el10_0.noarch.rpm;name=aarch64_perl-constant-defer-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-constant-defer-tests}"
SRC_URI[aarch64_perl-constant-defer-tests.sha256sum] = "59ecbb534eb1351b3b829144d6488eeb09123a4d97ece1d3e4b859ce0089b471"

RDEPENDS:perl-constant-defer = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-constant-defer-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-Test \
 perl-Test-Harness \
 perl-constant-defer \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 "
