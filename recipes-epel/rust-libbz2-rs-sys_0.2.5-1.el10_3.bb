# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbz2-rs-sys"
PV = "0.2.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-libbz2-rs-sys+c-allocator-devel \
 rust-libbz2-rs-sys+custom-prefix-devel \
 rust-libbz2-rs-sys+default-devel \
 rust-libbz2-rs-sys+export-symbols-devel \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys+semver-prefix-devel \
 rust-libbz2-rs-sys+std-devel \
 rust-libbz2-rs-sys+stdio-devel \
 rust-libbz2-rs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbz2-rs-sys-0.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7b127f260a33dc6d29f14bd1aa2ca55e37390b7dd3e7d77a4e47db914d39408"

URI_x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+c-allocator-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel.sha256sum] = "96ea0441c294437ec98cc0d1a4a33c45445cc81855d55c34590b387890ffa109"

URI_x86_64_v2_rust-libbz2-rs-sys+custom-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+custom-prefix-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+custom-prefix-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+custom-prefix-devel.sha256sum] = "b1e81e2226ad1c3e8689eb2b4de52a65666599c3813fecbbceef79495d82001c"

URI_x86_64_v2_rust-libbz2-rs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+default-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+default-devel.sha256sum] = "c989f63fc53515ea2faefec7fbc4da740745384de2072339a06183f6199726cf"

URI_x86_64_v2_rust-libbz2-rs-sys+export-symbols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+export-symbols-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+export-symbols-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+export-symbols-devel.sha256sum] = "2c5a4966a002f88d69c16224bed99dce7426d4912f10d39437131b7c8a52adf1"

URI_x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+rust-allocator-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel.sha256sum] = "12df02fc77607a3bc9af41292c01b261400cbe1f75e5a93aadd8795bde2f8b46"

URI_x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+semver-prefix-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel.sha256sum] = "c68e7cd55212556652273c28ccb729be6a757cc307320c29123a531ca65efe53"

URI_x86_64_v2_rust-libbz2-rs-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+std-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+std-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+std-devel.sha256sum] = "12eb5c5325a501bba78b5a884d841cfd08bb518802787c04cc7f4035db824eb9"

URI_x86_64_v2_rust-libbz2-rs-sys+stdio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+stdio-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+stdio-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+stdio-devel.sha256sum] = "016c27be544dce1920751d763256ac26caddb5a7253a87b8eb35fa0150658f51"

URI_x86_64_v2_rust-libbz2-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys-devel.sha256sum] = "4f8083a15fa1f1499b1a469990bb2c1f9695e8853a375fc528709b3eed94df0c"

URI_aarch64_rust-libbz2-rs-sys+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+c-allocator-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+c-allocator-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+c-allocator-devel.sha256sum] = "bc08460f5570a313d9b7f20972ceec9610432d82f89dfa968562a029853750ae"

URI_aarch64_rust-libbz2-rs-sys+custom-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+custom-prefix-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+custom-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+custom-prefix-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+custom-prefix-devel.sha256sum] = "6bed66ee327db042fbde9f245f621541a61e019066c7dbefe922aef8b65d1689"

URI_aarch64_rust-libbz2-rs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+default-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+default-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+default-devel.sha256sum] = "30925f1a06c133c261ceefa26d84aa41161100264c98ce70e425ebd8eef96b8a"

URI_aarch64_rust-libbz2-rs-sys+export-symbols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+export-symbols-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+export-symbols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+export-symbols-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+export-symbols-devel.sha256sum] = "7acd50c1b2c664451d5c0a1e8ba598060bc8e9f401c6c080f73f7cda02b2e7e4"

URI_aarch64_rust-libbz2-rs-sys+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+rust-allocator-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+rust-allocator-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+rust-allocator-devel.sha256sum] = "d795c2012e51d158334b7622a03d2ea99e20410b4fec4fabe64458a6e27d360a"

URI_aarch64_rust-libbz2-rs-sys+semver-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+semver-prefix-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+semver-prefix-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+semver-prefix-devel.sha256sum] = "960ea4ca39ad39abd3e4e894decf7c9a4e710dc6a12018f4f270550893e15613"

URI_aarch64_rust-libbz2-rs-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+std-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+std-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+std-devel.sha256sum] = "bc0615eb03b4a92e4868893f7e0c252d3701c3ae524d203ea52fb732b2ab4b67"

URI_aarch64_rust-libbz2-rs-sys+stdio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+stdio-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+stdio-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+stdio-devel.sha256sum] = "73c2007f5b7343dc04864f43a504cc1fddfda6565a899663fc96bb599e23253a"

URI_aarch64_rust-libbz2-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys-devel.sha256sum] = "82d231e74d07db24fc38ff15c537ed6b36314b6eec3a5636491d2b4998f3c982"

RDEPENDS:rust-libbz2-rs-sys+c-allocator-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+custom-prefix-devel = " \
 cargo \
 rust-libbz2-rs-sys+export-symbols-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+default-devel = " \
 cargo \
 rust-libbz2-rs-sys+std-devel \
 rust-libbz2-rs-sys+stdio-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+export-symbols-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+rust-allocator-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+semver-prefix-devel = " \
 cargo \
 rust-libbz2-rs-sys+export-symbols-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+std-devel = " \
 cargo \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+stdio-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-libbz2-rs-sys-devel = " \
 cargo \
 rust \
 "
