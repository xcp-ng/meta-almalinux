# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ca-certificates"
PV = "2026.2.90_v9.0.316"
PR = "100.0.el10"
PACKAGES = " \
 ca-certificates \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ca-certificates-2026.2.90_v9.0.316-100.0.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "27cdc412b4211df92e9f465a93368291770239c5ef31e2a9f40e3cc44ae6c32c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ca-certificates-2026.2.90_v9.0.316-100.0.el10.noarch.rpm;name=x86_64_v2_ca-certificates;unpack=0"
SRC_URI[x86_64_v2_ca-certificates.sha256sum] = "beaee4846a21490da4afd1299532f7e4e30fe32ad3771f6edcbe611a436315c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ca-certificates-2026.2.90_v9.0.316-100.0.el10.noarch.rpm;name=aarch64_ca-certificates;unpack=0"
SRC_URI[aarch64_ca-certificates.sha256sum] = "beaee4846a21490da4afd1299532f7e4e30fe32ad3771f6edcbe611a436315c7"

RDEPENDS:ca-certificates = " \
 bash \
 findutils \
 grep \
 libffi \
 p11-kit-trust \
 sed \
 virtual/coreutils \
 "
