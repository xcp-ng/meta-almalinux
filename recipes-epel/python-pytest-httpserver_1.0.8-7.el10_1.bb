# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-httpserver"
PV = "1.0.8"
PR = "7.el10_1"
PACKAGES = " \
 python3-pytest-httpserver \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-httpserver-1.0.8-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90fc331cc1b009c251c4c1533303cc5efc62620fd2561c7d6b6f1b3202ec1f74"

URI_x86_64_v2_python3-pytest-httpserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-httpserver-1.0.8-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-httpserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-httpserver}"
SRC_URI[x86_64_v2_python3-pytest-httpserver.sha256sum] = "76873965aedc41b2e710995b4bcd60440f5a640851a361e9a7b3ac359b8f7dc9"

URI_aarch64_python3-pytest-httpserver = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-httpserver-1.0.8-7.el10_1.noarch.rpm;name=aarch64_python3-pytest-httpserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-httpserver}"
SRC_URI[aarch64_python3-pytest-httpserver.sha256sum] = "84de4c03013f2bf570b770e8074e7ace5b7a5f04216660dcf63799ce3f2b830b"

RDEPENDS:python3-pytest-httpserver = " \
 python3 \
 python3-werkzeug \
 "
