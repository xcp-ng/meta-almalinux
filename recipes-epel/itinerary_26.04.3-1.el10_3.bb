# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "itinerary"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 itinerary \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/itinerary-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acb644b144ac4d89ff80307d4b32265850599e0f5cfe9bf73db7cde417291f5d"

URI_x86_64_v2_itinerary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/itinerary-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_itinerary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_itinerary}"
SRC_URI[x86_64_v2_itinerary.sha256sum] = "e975a73b1fe93e333f8943f9f6aa355fb6e835ed08055bb7aa4b5b2b32132c26"

URI_aarch64_itinerary = "${EPEL_MIRROR}/aarch64/Packages/i/itinerary-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_itinerary;unpack=0"
SRC_URI:append = " ${URI_aarch64_itinerary}"
SRC_URI[aarch64_itinerary.sha256sum] = "464d4b42ac0844c54bb259e3760752bf23f6d2f1102e6923070f9aad657e718d"

RDEPENDS:itinerary = " \
 glibc \
 hicolor-icon-theme \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kunitconversion \
 kf6-kwindowsystem \
 kf6-prison \
 kf6-qqc2-desktop-style \
 khealthcertificate \
 kitinerary \
 kosmindoormap \
 kpkpass \
 kpublictransport \
 libquotient-qt6 \
 libstdc++ \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qtkeychain-qt6 \
 zlib-ng-compat \
 "
