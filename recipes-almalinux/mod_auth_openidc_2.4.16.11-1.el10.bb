# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_auth_openidc"
PV = "2.4.16.11"
PR = "1.el10"
PACKAGES = " \
 mod_auth_openidc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_auth_openidc-2.4.16.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8c61140d522d4cd5cd692f6de9c2060dcbb757e3b9a9091c928b7d0156f02b6"

URI_x86_64_v2_mod_auth_openidc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_auth_openidc-2.4.16.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_mod_auth_openidc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_auth_openidc}"
SRC_URI[x86_64_v2_mod_auth_openidc.sha256sum] = "7d1ba14972dacad16fcb4c0dc96a12c5d9248c693d8ded4d5f7e1961df1ad17f"

URI_aarch64_mod_auth_openidc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_auth_openidc-2.4.16.11-1.el10.aarch64.rpm;name=aarch64_mod_auth_openidc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_auth_openidc}"
SRC_URI[aarch64_mod_auth_openidc.sha256sum] = "dcbcb51422a84a5e2dcb96e44d90d60826e45d7052acb7f2f189163083db03d7"

RDEPENDS:mod_auth_openidc = " \
 apr \
 apr-util \
 cjose \
 expat \
 glibc \
 httpd-core \
 jansson \
 jq \
 libxcrypt \
 openldap \
 openssl-libs \
 pcre2 \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
