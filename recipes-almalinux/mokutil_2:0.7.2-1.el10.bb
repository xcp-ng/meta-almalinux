# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mokutil"
PE = "2"
PV = "0.7.2"
PR = "1.el10"
PACKAGES = " \
 mokutil \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mokutil-0.7.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b15ecb1ba765ee395c7f2e435d028dae5f9168f9b95ed3939628edd8ed2335fc"

URI_x86_64_v2_mokutil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mokutil-0.7.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_mokutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mokutil}"
SRC_URI[x86_64_v2_mokutil.sha256sum] = "b4f71f6a0d13d920abff1adc206b1928620d6be99af38dfc960ecc25044ecd70"

URI_aarch64_mokutil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mokutil-0.7.2-1.el10.aarch64.rpm;name=aarch64_mokutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_mokutil}"
SRC_URI[aarch64_mokutil.sha256sum] = "4a302465933bf0808d31e3b4460ec7bc793ff6b31c664693135c2666a45843e8"

RDEPENDS:mokutil = " \
 efivar-libs \
 glibc \
 keyutils-libs \
 libxcrypt \
 openssl-libs \
 "
