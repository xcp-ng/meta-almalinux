# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sqlite"
PV = "3.46.1"
PR = "5.el10"
PACKAGES = " \
 sqlite \
 sqlite-devel \
 sqlite-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sqlite-3.46.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "498137458ee358f4a0edf65656327cc899ebf46a10c2230308a5b8b947027cc2"

URI_x86_64_v2_sqlite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-3.46.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlite}"
SRC_URI[x86_64_v2_sqlite.sha256sum] = "42cee9c4729d78679b64c99544c554785eae538a566b64138edf7523c2221d43"

URI_x86_64_v2_sqlite-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-devel-3.46.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlite-devel}"
SRC_URI[x86_64_v2_sqlite-devel.sha256sum] = "8cfb93f9246732ad9b2f737af59b6b13a28322acec87b996c80b54731446f43d"

URI_x86_64_v2_sqlite-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sqlite-libs-3.46.1-5.el10.x86_64_v2.rpm;name=x86_64_v2_sqlite-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlite-libs}"
SRC_URI[x86_64_v2_sqlite-libs.sha256sum] = "25a3358d77f79cdb4d34cbe59d97b5b47e1dac73f128bf3d4f824a6e377c55ce"

URI_aarch64_sqlite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-3.46.1-5.el10.aarch64.rpm;name=aarch64_sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlite}"
SRC_URI[aarch64_sqlite.sha256sum] = "3726a1e6426b8e6c1aa886863478582ba8f91f25557096ec714ad8099292814f"

URI_aarch64_sqlite-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-devel-3.46.1-5.el10.aarch64.rpm;name=aarch64_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlite-devel}"
SRC_URI[aarch64_sqlite-devel.sha256sum] = "720336714924a1dc2280577808d66b0aff067ffbb44179b86f2057837201f5c5"

URI_aarch64_sqlite-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sqlite-libs-3.46.1-5.el10.aarch64.rpm;name=aarch64_sqlite-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlite-libs}"
SRC_URI[aarch64_sqlite-libs.sha256sum] = "79ac4c39fc63be9f81c2d1e4c344e3d638a214eaa6a62f6f8b37e6f4a9090d80"

RDEPENDS:sqlite = " \
 glibc \
 readline \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:sqlite-devel = " \
 pkgconf-pkg-config \
 sqlite \
 sqlite-libs \
 "
RDEPENDS:sqlite-libs = " \
 glibc \
 zlib-ng-compat \
 "
