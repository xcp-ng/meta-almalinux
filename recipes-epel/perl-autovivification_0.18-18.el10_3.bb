# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-autovivification"
PV = "0.18"
PR = "18.el10_3"
PACKAGES = " \
 perl-autovivification \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-autovivification-0.18-18.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd41d898c7d2b4aeae95a3d9116a97f53d7b99617087b0a3d74e3f674c24bdd2"

URI_x86_64_v2_perl-autovivification = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-autovivification-0.18-18.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-autovivification;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-autovivification}"
SRC_URI[x86_64_v2_perl-autovivification.sha256sum] = "2f9ec83f3be3a60bff7d1e586b8da35a08d966d50349156176d1285ae55a8cd3"

URI_aarch64_perl-autovivification = "${EPEL_MIRROR}/aarch64/Packages/p/perl-autovivification-0.18-18.el10_3.aarch64.rpm;name=aarch64_perl-autovivification;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-autovivification}"
SRC_URI[aarch64_perl-autovivification.sha256sum] = "4cbbd175cba82f80dd0ac83c10b0241616602ca3264cefb9f8139352a4b038e4"

RDEPENDS:perl-autovivification = " \
 glibc \
 perl-libs \
 "
