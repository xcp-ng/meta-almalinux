# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setools"
PV = "4.5.1"
PR = "4.el10"
PACKAGES = " \
 python3-setools \
 setools \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/setools-4.5.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f6beb66c0c6e5fb91f4589c21bcd2b14367df6ce4b05e7b60e76c04360e4f8e"

URI_x86_64_v2_python3-setools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-setools-4.5.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3-setools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-setools}"
SRC_URI[x86_64_v2_python3-setools.sha256sum] = "5a64fc5b6983abf2cb32ec3d5e75590cd8dd1f854bfc492a7c254a95baa8fda1"

URI_x86_64_v2_setools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-4.5.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_setools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools}"
SRC_URI[x86_64_v2_setools.sha256sum] = "eccc36e4677cf1da9cf6825bc4580a8c0dd6a3a76b8ffcfcff5b9a3faa497476"

URI_x86_64_v2_setools-console = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/setools-console-4.5.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-console}"
SRC_URI[x86_64_v2_setools-console.sha256sum] = "e4ac9d7c936ad54524139e1550dbeef1325dd6e90a01d4bc273670b6b8289b7f"

URI_x86_64_v2_setools-console-analyses = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-console-analyses-4.5.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_setools-console-analyses;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-console-analyses}"
SRC_URI[x86_64_v2_setools-console-analyses.sha256sum] = "5792fabc2405f70b43fd54a84bae342cd0e24838c2ddf1f4e7a5564660c94331"

URI_x86_64_v2_setools-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setools-gui-4.5.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_setools-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setools-gui}"
SRC_URI[x86_64_v2_setools-gui.sha256sum] = "eedf7c6696c2f34dd49c1f6b3a2a73375b00307b33b782b7f986518a40229529"

URI_aarch64_python3-setools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-setools-4.5.1-4.el10.aarch64.rpm;name=aarch64_python3-setools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-setools}"
SRC_URI[aarch64_python3-setools.sha256sum] = "95a77066fce914ed0fec6beabb5c4f5c67ab4f0305e6a01102817cce93c9d88e"

URI_aarch64_setools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-4.5.1-4.el10.aarch64.rpm;name=aarch64_setools;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools}"
SRC_URI[aarch64_setools.sha256sum] = "dd8957bfc1d2b9741d9173b0632097f928599818ed7514053e437697f60bd949"

URI_aarch64_setools-console = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/setools-console-4.5.1-4.el10.aarch64.rpm;name=aarch64_setools-console;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-console}"
SRC_URI[aarch64_setools-console.sha256sum] = "875b0102d0b793beb941fc7afe7dc6780838320664ebe99391be1fd8abd58044"

URI_aarch64_setools-console-analyses = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-console-analyses-4.5.1-4.el10.aarch64.rpm;name=aarch64_setools-console-analyses;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-console-analyses}"
SRC_URI[aarch64_setools-console-analyses.sha256sum] = "6a0cd55df5677fc53c07c3d5ce385be85b9d624f2f6a349fedda98d4c6ed8a44"

URI_aarch64_setools-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setools-gui-4.5.1-4.el10.aarch64.rpm;name=aarch64_setools-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_setools-gui}"
SRC_URI[aarch64_setools-gui.sha256sum] = "fba8b4d922d7bd374222fe8163e25093866cb9970080ad394db1ab1f37e5943e"

RDEPENDS:python3-setools = " \
 glibc \
 libselinux \
 libsepol \
 python3 \
 python3-setuptools \
 "
RDEPENDS:setools = " \
 setools-console \
 setools-console-analyses \
 setools-gui \
 "
RDEPENDS:setools-console = " \
 libselinux \
 python3 \
 python3-setools \
 "
RDEPENDS:setools-console-analyses = " \
 libselinux \
 python3 \
 python3-networkx \
 python3-setools \
 "
RDEPENDS:setools-gui = " \
 python3 \
 python3-networkx \
 python3-pyqt6 \
 python3-pyqt6-sip \
 python3-setools \
 "
