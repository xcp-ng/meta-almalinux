# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tracer"
PV = "1.6"
PR = "1.el10_2"
PACKAGES = " \
 python3-tracer \
 tracer-common \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tracer-1.6-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "53c777dba5994aa10d83b0fd7611e0ff8af1bd3bf2f72bca614edf03b152f02e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tracer-1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tracer;unpack=0"
SRC_URI[x86_64_v2_python3-tracer.sha256sum] = "1edaa9c98f729fc6691c5f1ee9c67f8171eb080c2a4bc3e6c94279cb05334b08"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tracer-common-1.6-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_tracer-common;unpack=0"
SRC_URI[x86_64_v2_tracer-common.sha256sum] = "475d14a8be9774ebf7159101847932947308d80c3f98971b7af02b3995a0726b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-tracer-1.6-1.el10_2.noarch.rpm;name=aarch64_python3-tracer;unpack=0"
SRC_URI[aarch64_python3-tracer.sha256sum] = "97602ea632923b92ed6d55b6ea8545efa85f5eec189d27a88cbbfd3205ff28dd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tracer-common-1.6-1.el10_2.noarch.rpm;name=aarch64_tracer-common;unpack=0"
SRC_URI[aarch64_tracer-common.sha256sum] = "e5582c996f55821c6fa420cf3d9d159ee19a43aa1529351c261764cace50d33b"

RDEPENDS:python3-tracer = " \
 python3 \
 python3-dbus \
 python3-distro \
 python3-psutil \
 python3-rpm \
 python3-six \
 tracer-common \
 "
RDEPENDS:tracer-common = " \
 "
