# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnova"
PV = "0.16.0"
PR = "4.el10_2"
PACKAGES = " \
 libnova \
 libnova-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libnova-0.16.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e657156881c8ab251043d7d8fcfbc0b14b1a35684058111bd6ce9bcaf5c625fb"

URI_x86_64_v2_libnova = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnova-0.16.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnova;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnova}"
SRC_URI[x86_64_v2_libnova.sha256sum] = "0556fa73642efdc44a85e6ab45ce257d004174cad60316dc462dc0d8d0de7767"

URI_x86_64_v2_libnova-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libnova-devel-0.16.0-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libnova-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnova-devel}"
SRC_URI[x86_64_v2_libnova-devel.sha256sum] = "40fb18af2e7fa0b9c3324916d8cf2036284b523ff6b9e155e693bd843cb62aef"

URI_aarch64_libnova = "${EPEL_MIRROR}/aarch64/Packages/l/libnova-0.16.0-4.el10_2.aarch64.rpm;name=aarch64_libnova;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnova}"
SRC_URI[aarch64_libnova.sha256sum] = "34c0bce936114e818ffae973743247be450e7239d170881af69e5d9745a74fa0"

URI_aarch64_libnova-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libnova-devel-0.16.0-4.el10_2.aarch64.rpm;name=aarch64_libnova-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnova-devel}"
SRC_URI[aarch64_libnova-devel.sha256sum] = "51381c85a70fd10ed3a4f557da2e8e8d8fc9470cd5ee7679c798e4b95b133cfd"

RDEPENDS:libnova = " \
 glibc \
 "
RDEPENDS:libnova-devel = " \
 libnova \
 "
