# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-maybe-async"
PV = "0.2.10"
PR = "2.el10_0"
PACKAGES = " \
 rust-maybe-async+default-devel \
 rust-maybe-async+is_sync-devel \
 rust-maybe-async-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-maybe-async-0.2.10-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0997ccebef2ac3daad369535ded3edfe388e71af2bab252331903031909efd44"

URI_x86_64_v2_rust-maybe-async+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-async+default-devel-0.2.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-async+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-async+default-devel}"
SRC_URI[x86_64_v2_rust-maybe-async+default-devel.sha256sum] = "ae73c72f71ca822f5fb067f78f1b0495c1ec99806e7d5e047e9c9e42415d2716"

URI_x86_64_v2_rust-maybe-async+is_sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-async+is_sync-devel-0.2.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-async+is_sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-async+is_sync-devel}"
SRC_URI[x86_64_v2_rust-maybe-async+is_sync-devel.sha256sum] = "66ac548d7f66590fe5777df6b621cd841cc19a5750f1c864af6ccc138e75b460"

URI_x86_64_v2_rust-maybe-async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-async-devel-0.2.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-async-devel}"
SRC_URI[x86_64_v2_rust-maybe-async-devel.sha256sum] = "a3a783651b6c7558afbe6b272d2490511ac1668b8809c10fb78701dea318f7d1"

URI_aarch64_rust-maybe-async+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-async+default-devel-0.2.10-2.el10_0.noarch.rpm;name=aarch64_rust-maybe-async+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-async+default-devel}"
SRC_URI[aarch64_rust-maybe-async+default-devel.sha256sum] = "58fefefb6f208f9a6e83a5a72c65cfc1dddb1ee9ba8ef82951916c1f2dfee809"

URI_aarch64_rust-maybe-async+is_sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-async+is_sync-devel-0.2.10-2.el10_0.noarch.rpm;name=aarch64_rust-maybe-async+is_sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-async+is_sync-devel}"
SRC_URI[aarch64_rust-maybe-async+is_sync-devel.sha256sum] = "3f4f66669e66a81cf1f341bf3f957bf8074ecf3ea467e20f410bc1559eca05ff"

URI_aarch64_rust-maybe-async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-async-devel-0.2.10-2.el10_0.noarch.rpm;name=aarch64_rust-maybe-async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-async-devel}"
SRC_URI[aarch64_rust-maybe-async-devel.sha256sum] = "8b98287cdd19fdaab85023670e7d1e0b292b1abd8f17f023e0c48c1c19045da7"

RDEPENDS:rust-maybe-async+default-devel = " \
 cargo \
 rust-maybe-async-devel \
 "
RDEPENDS:rust-maybe-async+is_sync-devel = " \
 cargo \
 rust-maybe-async-devel \
 "
RDEPENDS:rust-maybe-async-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 rust-syn+visit-mut-devel \
 "
