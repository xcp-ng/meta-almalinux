# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "evolution"
PV = "3.52.4"
PR = "2.el10_0"
PACKAGES = " \
 evolution \
 evolution-bogofilter \
 evolution-devel \
 evolution-devel-docs \
 evolution-help \
 evolution-langpacks \
 evolution-pst \
 evolution-spamassassin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/evolution-3.52.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc30ff72e86c6007062573bbb295654bcd8f367e995cc97e816a760c05977eab"

URI_x86_64_v2_evolution = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-3.52.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution}"
SRC_URI[x86_64_v2_evolution.sha256sum] = "c8ad03247e20031deb2dcfb2aa11ea04dc68e384c9160140a30f64347c261ae3"

URI_x86_64_v2_evolution-bogofilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-bogofilter-3.52.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-bogofilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-bogofilter}"
SRC_URI[x86_64_v2_evolution-bogofilter.sha256sum] = "8e3507245f3d8b598fdeab6fe00eedb7fc476aec3e4e5fd2a8fa30797efb0baa"

URI_x86_64_v2_evolution-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-devel-3.52.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-devel}"
SRC_URI[x86_64_v2_evolution-devel.sha256sum] = "0884010cae6f8d396173bcc54ca01fcc4a0ab35cc45da785f086aba8f64aeea3"

URI_x86_64_v2_evolution-devel-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-devel-docs-3.52.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_evolution-devel-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-devel-docs}"
SRC_URI[x86_64_v2_evolution-devel-docs.sha256sum] = "dfa6ab8a75e4b4f6ac384c322cd8ce43875bf323db483c5e2e565c66e140ced0"

URI_x86_64_v2_evolution-help = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-help-3.52.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_evolution-help;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-help}"
SRC_URI[x86_64_v2_evolution-help.sha256sum] = "2cba3d2c7d18fb8ee72b508636a78b666921c5ba14922f9f3af4b2c674b2fe19"

URI_x86_64_v2_evolution-langpacks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-langpacks-3.52.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_evolution-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-langpacks}"
SRC_URI[x86_64_v2_evolution-langpacks.sha256sum] = "5f74452c85405b985d9f4336b4d5eb6da4dbb5636f6443476dd7cc8f1fa01bdb"

URI_x86_64_v2_evolution-pst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-pst-3.52.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-pst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-pst}"
SRC_URI[x86_64_v2_evolution-pst.sha256sum] = "f6b6b8fd851c82accb83e154d9c5c90910ddb7f4932e1d879314456d00b86aa1"

URI_x86_64_v2_evolution-spamassassin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/evolution-spamassassin-3.52.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_evolution-spamassassin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_evolution-spamassassin}"
SRC_URI[x86_64_v2_evolution-spamassassin.sha256sum] = "4fa2c7638146acb893f772334db69721df4a666973fbaf993ec8828723431edb"

URI_aarch64_evolution = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-3.52.4-2.el10_0.aarch64.rpm;name=aarch64_evolution;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution}"
SRC_URI[aarch64_evolution.sha256sum] = "2d02a4fe443729681dc275d1b63f2ed77c145fb27a584504ab36234288eededd"

URI_aarch64_evolution-bogofilter = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-bogofilter-3.52.4-2.el10_0.aarch64.rpm;name=aarch64_evolution-bogofilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-bogofilter}"
SRC_URI[aarch64_evolution-bogofilter.sha256sum] = "1e040d132fcf8af8010f657268a4fdfeedb93f396db0da09cfb50ea53c0a61ad"

URI_aarch64_evolution-devel = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-devel-3.52.4-2.el10_0.aarch64.rpm;name=aarch64_evolution-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-devel}"
SRC_URI[aarch64_evolution-devel.sha256sum] = "307b76dc2567893f97b65481592e0809a7e62280080b9c4167c8032d2b5d176b"

URI_aarch64_evolution-devel-docs = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-devel-docs-3.52.4-2.el10_0.noarch.rpm;name=aarch64_evolution-devel-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-devel-docs}"
SRC_URI[aarch64_evolution-devel-docs.sha256sum] = "bb52d265f1d248682885ad2b04a332924e5b8cc5da80a83379d212d96b19cf0c"

URI_aarch64_evolution-help = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-help-3.52.4-2.el10_0.noarch.rpm;name=aarch64_evolution-help;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-help}"
SRC_URI[aarch64_evolution-help.sha256sum] = "552db1c3f1447f8760a304e089bb7a78c22d4ef84f7c093863c2a4bb7c288063"

URI_aarch64_evolution-langpacks = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-langpacks-3.52.4-2.el10_0.noarch.rpm;name=aarch64_evolution-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-langpacks}"
SRC_URI[aarch64_evolution-langpacks.sha256sum] = "570beb184d00cffdf1da11436ee5d4a90e8622ff5ff587ad76586416af8d5353"

URI_aarch64_evolution-pst = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-pst-3.52.4-2.el10_0.aarch64.rpm;name=aarch64_evolution-pst;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-pst}"
SRC_URI[aarch64_evolution-pst.sha256sum] = "2c210520cb4b147836dc11625bb8f5947267772a799731285082fceebcb72714"

URI_aarch64_evolution-spamassassin = "${EPEL_MIRROR}/aarch64/Packages/e/evolution-spamassassin-3.52.4-2.el10_0.aarch64.rpm;name=aarch64_evolution-spamassassin;unpack=0"
SRC_URI:append = " ${URI_aarch64_evolution-spamassassin}"
SRC_URI[aarch64_evolution-spamassassin.sha256sum] = "f86d37b87a4dbcd7afe5cf6147ba37130bcd55bc8ab630f4af79bb817e965393"

RDEPENDS:evolution = " \
 atk \
 cairo \
 cairo-gobject \
 cmark-lib \
 enchant2 \
 evolution-data-server \
 evolution-langpacks \
 gdk-pixbuf2 \
 geocode-glib \
 glib2 \
 glibc \
 gnome-autoar \
 gnome-desktop3 \
 gspell \
 gtk3 \
 gvfs \
 highlight \
 javascriptcoregtk4.1 \
 libcanberra \
 libgweather \
 libical \
 libical-glib \
 libnotify \
 libsecret \
 libsoup3 \
 libxml2 \
 nspr \
 nss \
 openldap \
 pango \
 psmisc \
 sqlite-libs \
 webkit2gtk4.1 \
 "
RDEPENDS:evolution-bogofilter = " \
 bogofilter \
 evolution \
 evolution-data-server \
 glib2 \
 glibc \
 gtk3 \
 "
RDEPENDS:evolution-devel = " \
 enchant2-devel \
 evolution \
 evolution-data-server-devel \
 evolution-devel \
 glib2-devel \
 gnome-desktop3-devel \
 gspell-devel \
 gtk3-devel \
 libgweather-devel \
 libsoup3-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 webkit2gtk4.1-devel \
 "
RDEPENDS:evolution-devel-docs = " \
 devhelp \
 evolution-devel \
 "
RDEPENDS:evolution-help = " \
 evolution \
 yelp \
 "
RDEPENDS:evolution-langpacks = " \
 evolution \
 "
RDEPENDS:evolution-pst = " \
 evolution \
 evolution-data-server \
 glib2 \
 glibc \
 gtk3 \
 libical-glib \
 libpst-libs \
 "
RDEPENDS:evolution-spamassassin = " \
 evolution \
 evolution-data-server \
 glib2 \
 glibc \
 gtk3 \
 spamassassin \
 "
