# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-elazarl-goproxy"
PV = "1.1"
PR = "18.20210109git00ad82a.el10_0"
PACKAGES = " \
 golang-github-elazarl-goproxy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-elazarl-goproxy-1.1-18.20210109git00ad82a.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fd9aeff0217d6df5b477098fa7f7b311b57035db3018ed0dfbc4f6370cbdc80"

URI_aarch64_golang-github-elazarl-goproxy-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-elazarl-goproxy-devel-1.1-18.20210109git00ad82a.el10_0.noarch.rpm;name=aarch64_golang-github-elazarl-goproxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-elazarl-goproxy-devel}"
SRC_URI[aarch64_golang-github-elazarl-goproxy-devel.sha256sum] = "31c2d5eb44b6c6bdd47dfe27c7264703bc96695f150ad9bf882f97b79d4f6fd8"

RDEPENDS:golang-github-elazarl-goproxy-devel = " \
 go-filesystem \
 golang-github-rogpeppe-charset-devel \
 "
