# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-Base"
PV = "1.17"
PR = "29.el10_0"
PACKAGES = " \
 perl-Image-Base \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Image-Base-1.17-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3310934c6a9ce876a79c2b6ca10a861f9e8eb3a2b2995d5bffdc4b395d355318"

URI_x86_64_v2_perl-Image-Base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-Base-1.17-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-Base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-Base}"
SRC_URI[x86_64_v2_perl-Image-Base.sha256sum] = "a7b4acbc6bc70a48b4f3ab3d523582f5127e0d765f903b1a5bedd7613150df48"

URI_aarch64_perl-Image-Base = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-Base-1.17-29.el10_0.noarch.rpm;name=aarch64_perl-Image-Base;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-Base}"
SRC_URI[aarch64_perl-Image-Base.sha256sum] = "8c615b53e30119a08696c1a1dc856727e642fa946cc9a16c20f931f1c7ccc4a3"

RDEPENDS:perl-Image-Base = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
