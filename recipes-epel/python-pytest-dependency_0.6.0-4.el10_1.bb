# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-dependency"
PV = "0.6.0"
PR = "4.el10_1"
PACKAGES = " \
 python3-pytest-dependency \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-dependency-0.6.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "292176322f63cb95bc554df74397a6b011f7a65180d3afc6e8a4cb6a8b0eff82"

URI_x86_64_v2_python3-pytest-dependency = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-dependency-0.6.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-dependency;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-dependency}"
SRC_URI[x86_64_v2_python3-pytest-dependency.sha256sum] = "dbaa367e7e93d227e60860aaf9c4a46121677c8aa3abbbcc81d6995d1e1fee1a"

URI_aarch64_python3-pytest-dependency = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-dependency-0.6.0-4.el10_1.noarch.rpm;name=aarch64_python3-pytest-dependency;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-dependency}"
SRC_URI[aarch64_python3-pytest-dependency.sha256sum] = "2233705bb7081f685f98b2acc28571c4bb2cd1ff9678e58c45d60df38319e3a7"

RDEPENDS:python3-pytest-dependency = " \
 python3 \
 python3-pytest \
 python3-setuptools \
 "
