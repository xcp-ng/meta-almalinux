# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "packetdrill"
PV = "2.0~20220927gitc556afb"
PR = "10.el10_0"
PACKAGES = " \
 packetdrill \
 packetdrill-data \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/packetdrill-2.0~20220927gitc556afb-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "099988e2aff824a13b659487f300049803952df4bf6494524e0a28218ad568c9"

URI_x86_64_v2_packetdrill = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/packetdrill-2.0~20220927gitc556afb-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_packetdrill;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_packetdrill}"
SRC_URI[x86_64_v2_packetdrill.sha256sum] = "b9e2f02d0ed2eaf6a950c7371c5dc211fca1b568a780e8956a6ccdbde3cb4270"

URI_x86_64_v2_packetdrill-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/packetdrill-data-2.0~20220927gitc556afb-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_packetdrill-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_packetdrill-data}"
SRC_URI[x86_64_v2_packetdrill-data.sha256sum] = "fc5dbef8a54eef40172a1f1785df4d8202945239763c53a420a772edcca8b1e6"

URI_aarch64_packetdrill = "${EPEL_MIRROR}/aarch64/Packages/p/packetdrill-2.0~20220927gitc556afb-10.el10_0.aarch64.rpm;name=aarch64_packetdrill;unpack=0"
SRC_URI:append = " ${URI_aarch64_packetdrill}"
SRC_URI[aarch64_packetdrill.sha256sum] = "d6897e0190b84722008dc3739669619e54abdf1e55f5b753026a5d07ce7eec36"

URI_aarch64_packetdrill-data = "${EPEL_MIRROR}/aarch64/Packages/p/packetdrill-data-2.0~20220927gitc556afb-10.el10_0.noarch.rpm;name=aarch64_packetdrill-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_packetdrill-data}"
SRC_URI[aarch64_packetdrill-data.sha256sum] = "65b4667c94617fe9acc0be022cbeee9e58c114b2861d9a45ae92bbb28d8ba085"

RDEPENDS:packetdrill = " \
 glibc \
 "
RDEPENDS:packetdrill-data = " \
 bash \
 emacs-filesystem \
 iproute \
 procps-ng \
 python3 \
 vim-filesystem \
 virtual/coreutils \
 "
