# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-osc-lib"
PV = "4.4.0"
PR = "3.el10_3"
PACKAGES = " \
 python-osc-lib-doc \
 python3-osc-lib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-osc-lib-4.4.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f8bfd8dd741fdc2d16e2cdb72f3ef9019caf7e691070e14f86b968c081ec7fa"

URI_x86_64_v2_python-osc-lib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-osc-lib-doc-4.4.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-osc-lib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-osc-lib-doc}"
SRC_URI[x86_64_v2_python-osc-lib-doc.sha256sum] = "57f999d5b1c3441242ad483c7048425a976fed6c1122d42c7a4a0b2b62c53276"

URI_x86_64_v2_python3-osc-lib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-osc-lib-4.4.0-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-osc-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-osc-lib}"
SRC_URI[x86_64_v2_python3-osc-lib.sha256sum] = "4eed849a3f7bddd8792e91b37eeb01e588016163bf5215a70c83cbcdc8c8dfd5"

URI_aarch64_python-osc-lib-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-osc-lib-doc-4.4.0-3.el10_3.noarch.rpm;name=aarch64_python-osc-lib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-osc-lib-doc}"
SRC_URI[aarch64_python-osc-lib-doc.sha256sum] = "5a00e9afb34c9ffee189755ce8b07acfa799c83d18ef7c3d65d1a1ef7f07fa0c"

URI_aarch64_python3-osc-lib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-osc-lib-4.4.0-3.el10_3.noarch.rpm;name=aarch64_python3-osc-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-osc-lib}"
SRC_URI[aarch64_python3-osc-lib.sha256sum] = "b83cd29211767428fe8279c87b663848e9720cc626dbc228dc406adf9dc15402"

RDEPENDS:python-osc-lib-doc = " \
 "
RDEPENDS:python3-osc-lib = " \
 python3 \
 python3-cliff \
 python3-keystoneauth1 \
 python3-openstacksdk \
 python3-oslo-i18n \
 python3-oslo-utils \
 python3-pbr \
 python3-requests \
 python3-stevedore \
 "
