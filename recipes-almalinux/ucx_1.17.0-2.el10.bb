# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ucx"
PV = "1.17.0"
PR = "2.el10"
PACKAGES = " \
 ucx \
 ucx-cma \
 ucx-devel \
 ucx-ib \
 ucx-rdmacm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ucx-1.17.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9cefeba6722fca26c06a79cc86e45495c1389c84e843b869b968073c647e743"

URI_x86_64_v2_ucx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-1.17.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ucx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx}"
SRC_URI[x86_64_v2_ucx.sha256sum] = "7ed03b00f66c7738f5ef6014ee23f2a6a7085bf8e74e829f376b978932c88c0d"

URI_x86_64_v2_ucx-cma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-cma-1.17.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-cma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-cma}"
SRC_URI[x86_64_v2_ucx-cma.sha256sum] = "d61d09df9d67939b5c68cdfb3406dcc8b8facafe1e9423182bea2b56877ca0d0"

URI_x86_64_v2_ucx-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-devel-1.17.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-devel}"
SRC_URI[x86_64_v2_ucx-devel.sha256sum] = "5a41b9ede31b2f5eb55a7681bd3131145549c7368e2dbacb97adaa5b614a9f2d"

URI_x86_64_v2_ucx-ib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-ib-1.17.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-ib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-ib}"
SRC_URI[x86_64_v2_ucx-ib.sha256sum] = "cceb7e4170fd08a65501c7aa2d4436ef19f6e8c3f32bb9806855d7972ad52d0c"

URI_x86_64_v2_ucx-rdmacm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ucx-rdmacm-1.17.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ucx-rdmacm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ucx-rdmacm}"
SRC_URI[x86_64_v2_ucx-rdmacm.sha256sum] = "e1a13db8907988fc2de1736b062ffc967ce78969a7fcf1b96b3f52695062fa8b"

URI_aarch64_ucx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-1.17.0-2.el10.aarch64.rpm;name=aarch64_ucx;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx}"
SRC_URI[aarch64_ucx.sha256sum] = "39ac4033420d0ec632030799b9261fdf9abb48b0be49bd4db156cf8b0563ff05"

URI_aarch64_ucx-cma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-cma-1.17.0-2.el10.aarch64.rpm;name=aarch64_ucx-cma;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-cma}"
SRC_URI[aarch64_ucx-cma.sha256sum] = "629af955e3275ba6d9b6216b61e19986c98ec1a7559fd67f6947c7bb706de5eb"

URI_aarch64_ucx-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-devel-1.17.0-2.el10.aarch64.rpm;name=aarch64_ucx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-devel}"
SRC_URI[aarch64_ucx-devel.sha256sum] = "264eef13caa22b6928c6818c4fd3b6cce2897b18f9e579e4e2731ff9ee252ba2"

URI_aarch64_ucx-ib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-ib-1.17.0-2.el10.aarch64.rpm;name=aarch64_ucx-ib;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-ib}"
SRC_URI[aarch64_ucx-ib.sha256sum] = "593f171b0100c2dbfde1940ec702d48845fd8943208c25bfafdd4a0d4fe6c66a"

URI_aarch64_ucx-rdmacm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ucx-rdmacm-1.17.0-2.el10.aarch64.rpm;name=aarch64_ucx-rdmacm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ucx-rdmacm}"
SRC_URI[aarch64_ucx-rdmacm.sha256sum] = "db45a946db1340781fdd67936ed3c50bbfbc2255f44f4f1c4b1770697e5045a1"

RDEPENDS:ucx = " \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 "
RDEPENDS:ucx-cma = " \
 glibc \
 ucx \
 "
RDEPENDS:ucx-devel = " \
 pkgconf-pkg-config \
 rdma-core-devel \
 ucx \
 ucx-devel \
 "
RDEPENDS:ucx-ib = " \
 glibc \
 libibverbs \
 ucx \
 "
RDEPENDS:ucx-rdmacm = " \
 glibc \
 libibverbs \
 librdmacm \
 ucx \
 ucx-ib \
 "
