# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qt3d"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qt3d \
 qt5-qt3d-devel \
 qt5-qt3d-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qt3d-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "429eef2d560c6f7cafe46923090daa1e68c390a876299ec73f55b41c55494316"

URI_x86_64_v2_qt5-qt3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qt3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d}"
SRC_URI[x86_64_v2_qt5-qt3d.sha256sum] = "a06165dc52189575e3e66641be7ceab5fe1a6da939c7fed9065383023169800d"

URI_x86_64_v2_qt5-qt3d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d-devel}"
SRC_URI[x86_64_v2_qt5-qt3d-devel.sha256sum] = "e8b564bf6af0a4bb9ad631c6c96c91d90c7e7c93944b06f149b7b0b6711581c4"

URI_x86_64_v2_qt5-qt3d-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qt3d-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qt3d-examples}"
SRC_URI[x86_64_v2_qt5-qt3d-examples.sha256sum] = "d709aec155e1b159f6ea58fa99812a354da5a71f2fa823f911ce816324d71072"

URI_aarch64_qt5-qt3d = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qt3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d}"
SRC_URI[aarch64_qt5-qt3d.sha256sum] = "cb2e06886b25bb4553ad72500b64858cf571b9c36fb83cad7fb84649499167c2"

URI_aarch64_qt5-qt3d-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qt3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d-devel}"
SRC_URI[aarch64_qt5-qt3d-devel.sha256sum] = "3b2d8ac71177b438f292bc93a07045c35251c5dcbaf531c9db8f3040df3db3f3"

URI_aarch64_qt5-qt3d-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qt3d-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qt3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qt3d-examples}"
SRC_URI[aarch64_qt5-qt3d-examples.sha256sum] = "7b533d23a091a0cd377b4366286e73fc365454de24426c8fbfd22d693aecaf8c"

RDEPENDS:qt5-qt3d = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtimageformats \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qt3d-devel = " \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qt3d \
 qt5-qt3d-devel \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qt3d-examples = " \
 glibc \
 libstdc++ \
 qt5-qt3d \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
