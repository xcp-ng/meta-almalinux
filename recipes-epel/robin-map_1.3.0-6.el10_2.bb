# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "robin-map"
PV = "1.3.0"
PR = "6.el10_2"
PACKAGES = " \
 robin-map-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/robin-map-1.3.0-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "802290f7ac91fa98ea899a94ecf2f415426b2c3faf3f7a80e9c235c377213230"

URI_x86_64_v2_robin-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/robin-map-devel-1.3.0-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_robin-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_robin-map-devel}"
SRC_URI[x86_64_v2_robin-map-devel.sha256sum] = "84c61c1fe542865d3fdcd798acf045fe1a701ba94d8e9c4ae9b69c5901d74d1c"

URI_aarch64_robin-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/robin-map-devel-1.3.0-6.el10_2.noarch.rpm;name=aarch64_robin-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_robin-map-devel}"
SRC_URI[aarch64_robin-map-devel.sha256sum] = "157aceeb272cd26cd60d55d9b461f55b72eba84f4023b9f3e2541090f2e69561"

RDEPENDS:robin-map-devel = " \
 cmake-filesystem \
 "
