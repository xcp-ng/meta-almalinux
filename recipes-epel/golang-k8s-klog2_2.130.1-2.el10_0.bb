# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-k8s-klog2"
PV = "2.130.1"
PR = "2.el10_0"
PACKAGES = " \
 golang-k8s-klog2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-k8s-klog2-2.130.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c243ead24423bf0f8179720c8f54dfb2937131aeea3cbf451a3bc55a4cd38994"

URI_x86_64_v2_golang-k8s-klog2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-k8s-klog2-devel-2.130.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-k8s-klog2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-k8s-klog2-devel}"
SRC_URI[x86_64_v2_golang-k8s-klog2-devel.sha256sum] = "de369464453dccc718ca2bee9ca69953ebb06be3855f1d8292df0d59a3d71ce1"

URI_aarch64_golang-k8s-klog2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-k8s-klog2-devel-2.130.1-2.el10_0.noarch.rpm;name=aarch64_golang-k8s-klog2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-k8s-klog2-devel}"
SRC_URI[aarch64_golang-k8s-klog2-devel.sha256sum] = "9e30d5a434819d721a41797c26e16cf640c8978e681d045cd751bd2893c1f534"

RDEPENDS:golang-k8s-klog2-devel = " \
 go-filesystem \
 golang-github-logr-devel \
 "
