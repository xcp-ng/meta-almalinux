# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcpucycles"
PV = "20260105"
PR = "1.el10_2"
PACKAGES = " \
 libcpucycles \
 libcpucycles-devel \
 libcpucycles-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcpucycles-20260105-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e7afea829c0d0b650150b8e0229bb685ce0ee4660ddf10fe42595b673a38bce"

URI_x86_64_v2_libcpucycles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcpucycles-20260105-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcpucycles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcpucycles}"
SRC_URI[x86_64_v2_libcpucycles.sha256sum] = "46b6c09bbc7f4fdf1e5693d93a7855073c37b33ec1ac877ab998c65b1c856bf7"

URI_x86_64_v2_libcpucycles-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcpucycles-devel-20260105-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcpucycles-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcpucycles-devel}"
SRC_URI[x86_64_v2_libcpucycles-devel.sha256sum] = "f881dd647b69c637bc81fbf2871f86ec28d007c00849a0c766ec1397f4b37ba1"

URI_x86_64_v2_libcpucycles-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcpucycles-static-20260105-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcpucycles-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcpucycles-static}"
SRC_URI[x86_64_v2_libcpucycles-static.sha256sum] = "6892a855197defe7cb4f3ebb99e6b691fe8db279928e159359e6b256cd3e529b"

URI_aarch64_libcpucycles = "${EPEL_MIRROR}/aarch64/Packages/l/libcpucycles-20260105-1.el10_2.aarch64.rpm;name=aarch64_libcpucycles;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcpucycles}"
SRC_URI[aarch64_libcpucycles.sha256sum] = "58a0f9975a885b306b1c30b2a2ccefa10aede2fb79982333f42d9c1da9236d4c"

URI_aarch64_libcpucycles-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcpucycles-devel-20260105-1.el10_2.aarch64.rpm;name=aarch64_libcpucycles-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcpucycles-devel}"
SRC_URI[aarch64_libcpucycles-devel.sha256sum] = "49ee554800fc0d46d9f5dd9f04f9f7149abf16078276630a1571874662c46d25"

URI_aarch64_libcpucycles-static = "${EPEL_MIRROR}/aarch64/Packages/l/libcpucycles-static-20260105-1.el10_2.aarch64.rpm;name=aarch64_libcpucycles-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcpucycles-static}"
SRC_URI[aarch64_libcpucycles-static.sha256sum] = "b6e7992dfe9ba8d475abdd33febec2e7cc084e0d8efea240435273a58764436f"

RDEPENDS:libcpucycles = " \
 bash \
 glibc \
 "
RDEPENDS:libcpucycles-devel = " \
 libcpucycles \
 "
RDEPENDS:libcpucycles-static = " \
 libcpucycles-devel \
 "
