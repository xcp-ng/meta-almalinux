# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-range-header"
PV = "0.4.2"
PR = "2.el10_1"
PACKAGES = " \
 rust-http-range-header+default-devel \
 rust-http-range-header-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-range-header-0.4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0dea5bb696c1868a7cb4c6bbcf20d82442af80458e610a08036ce2c753b8443f"

URI_x86_64_v2_rust-http-range-header+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-range-header+default-devel-0.4.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-range-header+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-range-header+default-devel}"
SRC_URI[x86_64_v2_rust-http-range-header+default-devel.sha256sum] = "26a43a2270ea6f859ec8ae8053b57d271737998cf2cb17be62ee43c61922130f"

URI_x86_64_v2_rust-http-range-header-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-range-header-devel-0.4.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-range-header-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-range-header-devel}"
SRC_URI[x86_64_v2_rust-http-range-header-devel.sha256sum] = "6b63ce8ebbb31e1c5474dff596d71df22c3a90732c50b3e05fee31947eba2144"

URI_aarch64_rust-http-range-header+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-range-header+default-devel-0.4.2-2.el10_1.noarch.rpm;name=aarch64_rust-http-range-header+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-range-header+default-devel}"
SRC_URI[aarch64_rust-http-range-header+default-devel.sha256sum] = "4dcaef8e49f73aec911ed00d02010a1157ce8a4cec9fb1edfb0426161fe0bf83"

URI_aarch64_rust-http-range-header-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-range-header-devel-0.4.2-2.el10_1.noarch.rpm;name=aarch64_rust-http-range-header-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-range-header-devel}"
SRC_URI[aarch64_rust-http-range-header-devel.sha256sum] = "0e11f41ca0793594f7cc8a66ebc2be0da1c16dd73b91f7eb00fe73cc8648c808"

RDEPENDS:rust-http-range-header+default-devel = " \
 cargo \
 rust-http-range-header-devel \
 "
RDEPENDS:rust-http-range-header-devel = " \
 cargo \
 "
