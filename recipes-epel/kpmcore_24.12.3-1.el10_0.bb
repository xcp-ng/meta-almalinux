# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpmcore"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kpmcore \
 kpmcore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpmcore-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3da31451d0a757c3522292d52f03ba5f6cade30ca30935fd758127f0f9a13d67"

URI_x86_64_v2_kpmcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpmcore}"
SRC_URI[x86_64_v2_kpmcore.sha256sum] = "ad994c84d6abcaae14738cc82baabd0d0bee327aa63c7d676d50e459a2eb8fe2"

URI_x86_64_v2_kpmcore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpmcore-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpmcore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpmcore-devel}"
SRC_URI[x86_64_v2_kpmcore-devel.sha256sum] = "d8e9ae3aadae3824c2fb157bd90dd8fa577660347af141a1e3c0be18696e89d7"

URI_aarch64_kpmcore = "${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kpmcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpmcore}"
SRC_URI[aarch64_kpmcore.sha256sum] = "19c43e5c65374d0699e191a3e434db6cf0e4bc96009724ee3582fa9de8b1a2a8"

URI_aarch64_kpmcore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpmcore-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kpmcore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpmcore-devel}"
SRC_URI[aarch64_kpmcore-devel.sha256sum] = "2a80644aa5570db5db53140da921f6ae9f49d913f9f71b7c19e39129f5c4478f"

RDEPENDS:kpmcore = " \
 e2fsprogs \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libblkid \
 libgcc \
 libstdc++ \
 polkit-qt6-1 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kpmcore-devel = " \
 cmake-filesystem \
 kpmcore \
 qt6-qtbase-devel \
 "
