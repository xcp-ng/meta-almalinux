# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gwenview"
PE = "1"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 gwenview \
 gwenview-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gwenview-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62fca167cf3c2e483b7ebc8bd9a5e4839dfaaaa19ce8c263075d5942bd4f6d38"

URI_x86_64_v2_gwenview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gwenview}"
SRC_URI[x86_64_v2_gwenview.sha256sum] = "1eee37ec811290ac500c79c100cdd07aa1d959989a4c11419e24cb9d31ff100e"

URI_x86_64_v2_gwenview-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gwenview-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gwenview-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gwenview-libs}"
SRC_URI[x86_64_v2_gwenview-libs.sha256sum] = "db8143468081ea20cb5879ce714262d41e2d7c6209ffbb1a778f15fc0b072011"

URI_aarch64_gwenview = "${EPEL_MIRROR}/aarch64/Packages/g/gwenview-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_gwenview;unpack=0"
SRC_URI:append = " ${URI_aarch64_gwenview}"
SRC_URI[aarch64_gwenview.sha256sum] = "3b4cc412e05b88c3c799314733226e9e40dc4245c3ce8d4e692366ea95c0c027"

URI_aarch64_gwenview-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gwenview-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_gwenview-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gwenview-libs}"
SRC_URI[aarch64_gwenview-libs.sha256sum] = "efca27c619c43ee54d6d81f88c4de6c670d3055b93cf33078caa5f4076341a29"

RDEPENDS:gwenview = " \
 exiv2-libs \
 glibc \
 gwenview-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kf6-solid \
 kimageannotator-qt6 \
 libgcc \
 libstdc++ \
 libtiff \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:gwenview-libs = " \
 cfitsio \
 exiv2-libs \
 glibc \
 gwenview \
 kf6-baloo-libs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kimageannotator-qt6 \
 lcms2 \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libkdcraw \
 libpng \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
