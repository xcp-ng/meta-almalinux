# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-passlib"
PV = "1.7.4"
PR = "19.el10_1"
PACKAGES = " \
 python3-passlib \
 python3-passlib+argon2 \
 python3-passlib+bcrypt \
 python3-passlib+totp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-passlib-1.7.4-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ce172fa29a1e75acd8f43349cf334550cb7408e96580e5b246416b42af2db733"

URI_x86_64_v2_python3-passlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-passlib-1.7.4-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-passlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-passlib}"
SRC_URI[x86_64_v2_python3-passlib.sha256sum] = "6ea213e2663c906afe66b07372497c949e66719249e5e7a643f04fb6184f4e22"

URI_x86_64_v2_python3-passlib+argon2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-passlib+argon2-1.7.4-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-passlib+argon2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-passlib+argon2}"
SRC_URI[x86_64_v2_python3-passlib+argon2.sha256sum] = "cf831e61143feef486baab083b9ba2db8f39be034a0b791e97d96f20b5a4096c"

URI_x86_64_v2_python3-passlib+bcrypt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-passlib+bcrypt-1.7.4-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-passlib+bcrypt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-passlib+bcrypt}"
SRC_URI[x86_64_v2_python3-passlib+bcrypt.sha256sum] = "973126939ab9e275967bb012066803034ad913ccd02b2be21a1325aca686250e"

URI_x86_64_v2_python3-passlib+totp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-passlib+totp-1.7.4-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-passlib+totp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-passlib+totp}"
SRC_URI[x86_64_v2_python3-passlib+totp.sha256sum] = "0bf1abc7de74d8161e216f8e25a960104f309102627503b5199566930e6697a2"

URI_aarch64_python3-passlib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-passlib-1.7.4-19.el10_1.noarch.rpm;name=aarch64_python3-passlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-passlib}"
SRC_URI[aarch64_python3-passlib.sha256sum] = "03fee165e2eeccb67a5d1ed5fd9426af3e140d1d7f6a9143d9e0b4db6ee90b86"

URI_aarch64_python3-passlib+argon2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-passlib+argon2-1.7.4-19.el10_1.noarch.rpm;name=aarch64_python3-passlib+argon2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-passlib+argon2}"
SRC_URI[aarch64_python3-passlib+argon2.sha256sum] = "ae9e19e8ac8a0e5ce90f096dbba2c5c45ac71eff9c64a315f3c3a9b58430a143"

URI_aarch64_python3-passlib+bcrypt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-passlib+bcrypt-1.7.4-19.el10_1.noarch.rpm;name=aarch64_python3-passlib+bcrypt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-passlib+bcrypt}"
SRC_URI[aarch64_python3-passlib+bcrypt.sha256sum] = "6c692a4a58c9223b6b3b3ded15f0bb9bea3bc6c4ee3178a8fe1a6a06d2d00a0d"

URI_aarch64_python3-passlib+totp = "${EPEL_MIRROR}/aarch64/Packages/p/python3-passlib+totp-1.7.4-19.el10_1.noarch.rpm;name=aarch64_python3-passlib+totp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-passlib+totp}"
SRC_URI[aarch64_python3-passlib+totp.sha256sum] = "7b4dfbb71683c7aeafbbbc6770142059eb0c8347529a24abaf27c603c4861fb0"

RDEPENDS:python3-passlib = " \
 python3 \
 "
RDEPENDS:python3-passlib+argon2 = " \
 python3 \
 python3-argon2-cffi \
 python3-passlib \
 "
RDEPENDS:python3-passlib+bcrypt = " \
 python3 \
 python3-bcrypt \
 python3-passlib \
 "
RDEPENDS:python3-passlib+totp = " \
 python3 \
 python3-cryptography \
 python3-passlib \
 "
