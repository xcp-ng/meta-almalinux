# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kopeninghours"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kopeninghours \
 kopeninghours-devel \
 kopeninghours-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kopeninghours-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3b879f6d73617b8d46aaabab8beb9aaed8e2d529b92f984f45c131452d2fc671"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours;unpack=0"
SRC_URI[x86_64_v2_kopeninghours.sha256sum] = "bbca18a9dc9bd45765675b70aa6d328698291d4aa2c731411e8999111878c036"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kopeninghours-devel;unpack=0"
SRC_URI[x86_64_v2_kopeninghours-devel.sha256sum] = "788541a90f8ca3fba3a387fa2d040e34acb38e830e36b26f8290bc51fc758ef8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kopeninghours-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kopeninghours-doc;unpack=0"
SRC_URI[x86_64_v2_kopeninghours-doc.sha256sum] = "5ba7dd9022d8b594588663eacbbf6d13efc10ed49c78bc33d371ce13fd2df58e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kopeninghours;unpack=0"
SRC_URI[aarch64_kopeninghours.sha256sum] = "3d65393543959a9deb7322237d371a00663faedccb8ca090fd0cb7a5ef90ab21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kopeninghours-devel;unpack=0"
SRC_URI[aarch64_kopeninghours-devel.sha256sum] = "ff8dc15d8404677ed04d23b3b2943740f93d109c5c854396d3c12a66651b1899"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kopeninghours-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kopeninghours-doc;unpack=0"
SRC_URI[aarch64_kopeninghours-doc.sha256sum] = "208877563bee65a59b77332e012c49a3b80df8085861747f43c37caab4485b23"

RDEPENDS:kopeninghours = " \
 boost-python3 \
 glibc \
 kf6-filesystem \
 kf6-kholidays \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kopeninghours-devel = " \
 cmake-filesystem \
 kopeninghours \
 "
RDEPENDS:kopeninghours-doc = " \
 "
