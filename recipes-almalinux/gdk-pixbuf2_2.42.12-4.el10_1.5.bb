# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdk-pixbuf2"
PV = "2.42.12"
PR = "4.el10_1.5"
PACKAGES = " \
 gdk-pixbuf2 \
 gdk-pixbuf2-devel \
 gdk-pixbuf2-modules \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdk-pixbuf2-2.42.12-4.el10_1.5.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28a9d30be683daf207fb23297f9c120d35c28fce56779adf4e70d1d26b43547b"

URI_x86_64_v2_gdk-pixbuf2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-2.42.12-4.el10_1.5.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2}"
SRC_URI[x86_64_v2_gdk-pixbuf2.sha256sum] = "45dc5025f42c48efcc926829f42127c131940ef3c01c155eae7a004b7d516a1b"

URI_x86_64_v2_gdk-pixbuf2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-devel-2.42.12-4.el10_1.5.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2-devel}"
SRC_URI[x86_64_v2_gdk-pixbuf2-devel.sha256sum] = "5a140e4933ce04b0b7f2b818bfed3a0007891e36d3839edee9a497eed4b7599f"

URI_x86_64_v2_gdk-pixbuf2-modules = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdk-pixbuf2-modules-2.42.12-4.el10_1.5.x86_64_v2.rpm;name=x86_64_v2_gdk-pixbuf2-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdk-pixbuf2-modules}"
SRC_URI[x86_64_v2_gdk-pixbuf2-modules.sha256sum] = "df0c4b178f696157b57108c16c83869a8ea96a704b6803375a1474d6dceeade3"

URI_aarch64_gdk-pixbuf2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-2.42.12-4.el10_1.5.aarch64.rpm;name=aarch64_gdk-pixbuf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2}"
SRC_URI[aarch64_gdk-pixbuf2.sha256sum] = "791659d52930bb7095fa617ef2cfd13731f233aeed6643e8e88eb63587417638"

URI_aarch64_gdk-pixbuf2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-devel-2.42.12-4.el10_1.5.aarch64.rpm;name=aarch64_gdk-pixbuf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2-devel}"
SRC_URI[aarch64_gdk-pixbuf2-devel.sha256sum] = "ee7920b836e7d347a596afb84d1afe56d2d689560e884d50344823f194e46d5b"

URI_aarch64_gdk-pixbuf2-modules = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdk-pixbuf2-modules-2.42.12-4.el10_1.5.aarch64.rpm;name=aarch64_gdk-pixbuf2-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdk-pixbuf2-modules}"
SRC_URI[aarch64_gdk-pixbuf2-modules.sha256sum] = "2fb06c0717879c88d17f91ad0ddfee1de351ff18bad48c216cd7b6f607664186"

RDEPENDS:gdk-pixbuf2 = " \
 bash \
 glib2 \
 glibc \
 libjpeg-turbo \
 libpng \
 shared-mime-info \
 "
RDEPENDS:gdk-pixbuf2-devel = " \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 libjpeg-turbo-devel \
 libpng-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 shared-mime-info \
 "
RDEPENDS:gdk-pixbuf2-modules = " \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 libtiff \
 "
