# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "automake"
PV = "1.16.5"
PR = "20.el10"
PACKAGES = " \
 automake \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/automake-1.16.5-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80f107bb111a12b3d5e8e06c599571cb846bbd9e72a22984ab25934991e68dfe"

URI_x86_64_v2_automake = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/automake-1.16.5-20.el10.noarch.rpm;name=x86_64_v2_automake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_automake}"
SRC_URI[x86_64_v2_automake.sha256sum] = "0fbb3412d07c6fd8a763ec636e2902d52a592eb0e5f5f2b315375b214d370032"

URI_aarch64_automake = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/automake-1.16.5-20.el10.noarch.rpm;name=aarch64_automake;unpack=0"
SRC_URI:append = " ${URI_aarch64_automake}"
SRC_URI[aarch64_automake.sha256sum] = "0fbb3412d07c6fd8a763ec636e2902d52a592eb0e5f5f2b315375b214d370032"

RDEPENDS:automake = " \
 autoconf \
 bash \
 perl-Carp \
 perl-Class-Struct \
 perl-Errno \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Path \
 perl-File-stat \
 perl-Getopt-Long \
 perl-IO \
 perl-PathTools \
 perl-Thread-Queue \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-threads \
 "
