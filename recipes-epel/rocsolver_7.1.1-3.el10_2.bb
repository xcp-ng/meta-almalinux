# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocsolver"
PV = "7.1.1"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 rocsolver \
 rocsolver-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocsolver-7.1.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df729fde1903f95d2411944509fbee0bffb983adbefac87b497aec73444a580f"

URI_x86_64_v2_rocsolver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocsolver-7.1.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocsolver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocsolver}"
SRC_URI[x86_64_v2_rocsolver.sha256sum] = "451339f0929043eed8f8c39151e18487c41a3871c54471aec9f70241064be15f"

URI_x86_64_v2_rocsolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocsolver-devel-7.1.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocsolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocsolver-devel}"
SRC_URI[x86_64_v2_rocsolver-devel.sha256sum] = "64c9d77a2440999b15246c322f78d306965d2fe614ea2a0150bd8b604a104026"

RDEPENDS:rocsolver = " \
 glibc \
 libgcc \
 libstdc++ \
 rocblas \
 rocm-hip \
 "
RDEPENDS:rocsolver-devel = " \
 cmake-filesystem \
 rocsolver \
 "
