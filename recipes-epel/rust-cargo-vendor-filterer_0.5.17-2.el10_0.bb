# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-vendor-filterer"
PV = "0.5.17"
PR = "2.el10_0"
PACKAGES = " \
 cargo-vendor-filterer \
 rust-cargo-vendor-filterer+default-devel \
 rust-cargo-vendor-filterer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-vendor-filterer-0.5.17-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47a5efb0680e8ad49dd307d15b6c0c534d02cf1a6243206138bbef832f5382dc"

URI_x86_64_v2_cargo-vendor-filterer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-vendor-filterer-0.5.17-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-vendor-filterer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-vendor-filterer}"
SRC_URI[x86_64_v2_cargo-vendor-filterer.sha256sum] = "c1bcdc0522d222563e9162514d9b5d173fa134b3731c84b348aca2d4e2249221"

URI_x86_64_v2_rust-cargo-vendor-filterer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer+default-devel-0.5.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer+default-devel.sha256sum] = "1a536b85b9d2a1ec276b42853ee96a78fdc55c715bef442b5ed7da8fb8a3da12"

URI_x86_64_v2_rust-cargo-vendor-filterer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-vendor-filterer-devel-0.5.17-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-vendor-filterer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-vendor-filterer-devel}"
SRC_URI[x86_64_v2_rust-cargo-vendor-filterer-devel.sha256sum] = "b2fecf03cc4bff9859f5a7dbad3f4bfef0458490e7a52b7f2156a7b701e44c73"

URI_aarch64_cargo-vendor-filterer = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-vendor-filterer-0.5.17-2.el10_0.aarch64.rpm;name=aarch64_cargo-vendor-filterer;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-vendor-filterer}"
SRC_URI[aarch64_cargo-vendor-filterer.sha256sum] = "0160545a79b4eae054091647f3aa9f130e10352a2ed87ebe2110bf791265feca"

URI_aarch64_rust-cargo-vendor-filterer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer+default-devel-0.5.17-2.el10_0.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer+default-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer+default-devel.sha256sum] = "8048c3f5e18d0508144ba15d007b99e9769b543786846df7bda3d8f21959d583"

URI_aarch64_rust-cargo-vendor-filterer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-vendor-filterer-devel-0.5.17-2.el10_0.noarch.rpm;name=aarch64_rust-cargo-vendor-filterer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-vendor-filterer-devel}"
SRC_URI[aarch64_rust-cargo-vendor-filterer-devel.sha256sum] = "c394a2572e6eae1ae31c5f75b6fa7efde66aa6f07c490dc67e24b167f19d44c0"

RDEPENDS:cargo-vendor-filterer = " \
 glibc \
 libgcc \
 openssl-libs \
 "
RDEPENDS:rust-cargo-vendor-filterer+default-devel = " \
 cargo \
 rust-cargo-vendor-filterer-devel \
 "
RDEPENDS:rust-cargo-vendor-filterer-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-camino+default-devel \
 rust-cargo-lock+default-devel \
 rust-cargo_metadata0.18+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+wrap_help-devel \
 rust-either+default-devel \
 rust-flate2+default-devel \
 rust-hex+default-devel \
 rust-openssl+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_ignored+default-devel \
 rust-serde_json+default-devel \
 rust-smallvec+default-devel \
 rust-tar+default-devel \
 rust-tempfile+default-devel \
 rust-toml+default-devel \
 rust-walkdir+default-devel \
 "
