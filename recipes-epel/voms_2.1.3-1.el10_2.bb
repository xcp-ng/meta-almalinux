# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "voms"
PV = "2.1.3"
PR = "1.el10_2"
PACKAGES = " \
 voms \
 voms-clients-cpp \
 voms-devel \
 voms-doc \
 voms-server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/voms-2.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b18eb023e5606d5bccbf53fff9162ece49158cb2cb92e97e9f79031e7eb5e871"

URI_x86_64_v2_voms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms}"
SRC_URI[x86_64_v2_voms.sha256sum] = "d3604d16d236cb09be7f7eef78bc3d57ac300a15da397bb7b75b5d3edff235bf"

URI_x86_64_v2_voms-clients-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-clients-cpp-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-clients-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-clients-cpp}"
SRC_URI[x86_64_v2_voms-clients-cpp.sha256sum] = "982ba7791f8c129df722a93aa2120bbdd761586bc9d5531fbb6e844c61c4007e"
RPROVIDES:voms-clients-cpp:x86_64_v2 = "virtual/voms-clients"

URI_x86_64_v2_voms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-devel-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-devel}"
SRC_URI[x86_64_v2_voms-devel.sha256sum] = "35eb9f16ab7867a606945d449435fc9f2a654bded0ca14ee5626a1f845377184"

URI_x86_64_v2_voms-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-doc-2.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_voms-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-doc}"
SRC_URI[x86_64_v2_voms-doc.sha256sum] = "9eb87e8faab51d8322eddf97d720c22d6cd6389e91e415da8c9e58a45947a31d"

URI_x86_64_v2_voms-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/voms-server-2.1.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_voms-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_voms-server}"
SRC_URI[x86_64_v2_voms-server.sha256sum] = "18c6229fbd8473f46d9f48443e5c257b331024094da55f6043cc5905cc826f12"

URI_aarch64_voms = "${EPEL_MIRROR}/aarch64/Packages/v/voms-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_voms;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms}"
SRC_URI[aarch64_voms.sha256sum] = "a5b996a2a94929a8d3e3008fc37d95c0eb5ce2f50faf50a232fb05fe4b120fb1"

URI_aarch64_voms-clients-cpp = "${EPEL_MIRROR}/aarch64/Packages/v/voms-clients-cpp-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_voms-clients-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-clients-cpp}"
SRC_URI[aarch64_voms-clients-cpp.sha256sum] = "274d60f6d5c070805b7fba326055a2aa9d5ff87adfdad6c08bb30d3e998c7271"
RPROVIDES:voms-clients-cpp:aarch64 = "virtual/voms-clients"

URI_aarch64_voms-devel = "${EPEL_MIRROR}/aarch64/Packages/v/voms-devel-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_voms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-devel}"
SRC_URI[aarch64_voms-devel.sha256sum] = "820473dbe48663d07bccd2054c4f7467c6f3d0c63a726f06f3cd49b694122d90"

URI_aarch64_voms-doc = "${EPEL_MIRROR}/aarch64/Packages/v/voms-doc-2.1.3-1.el10_2.noarch.rpm;name=aarch64_voms-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-doc}"
SRC_URI[aarch64_voms-doc.sha256sum] = "2a2e20ec1b56a8835e7cc5daec0e05eec91815d8787f06127ada422dae4ee3d2"

URI_aarch64_voms-server = "${EPEL_MIRROR}/aarch64/Packages/v/voms-server-2.1.3-1.el10_2.aarch64.rpm;name=aarch64_voms-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_voms-server}"
SRC_URI[aarch64_voms-server.sha256sum] = "e782351164a327ff7b7aba022ea5f2d44a9e889530b449aadd436275d5780728"

RDEPENDS:voms = " \
 bash \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:voms-clients-cpp = " \
 alternatives \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 voms \
 "
RDEPENDS:voms-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 voms \
 "
RDEPENDS:voms-doc = " \
 "
RDEPENDS:voms-server = " \
 bash \
 expat \
 glibc \
 gsoap \
 libgcc \
 libstdc++ \
 openssl-libs \
 shadow-utils \
 systemd \
 voms \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/voms-clients"

PROVIDES:append:aarch64 = " rpm/virtual/voms-clients"
