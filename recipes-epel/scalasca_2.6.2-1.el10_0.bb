# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "scalasca"
PV = "2.6.2"
PR = "1.el10_0"
PACKAGES = " \
 scalasca \
 scalasca-doc \
 scalasca-mpich \
 scalasca-openmpi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/scalasca-2.6.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36479b529aad56042f6716caa3a47314b9e8e65ad7cfc061aca70ea857886138"

URI_x86_64_v2_scalasca = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalasca-2.6.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalasca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalasca}"
SRC_URI[x86_64_v2_scalasca.sha256sum] = "8b87cebc4ac2bbc8c307714fb21e2e5e54bc5563ca83ffdfe755cfefcd9a2ce1"

URI_x86_64_v2_scalasca-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalasca-doc-2.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_scalasca-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalasca-doc}"
SRC_URI[x86_64_v2_scalasca-doc.sha256sum] = "4469721923832819adda58d833c683336c51d41709c576973f93690e0e8932bb"

URI_x86_64_v2_scalasca-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalasca-mpich-2.6.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalasca-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalasca-mpich}"
SRC_URI[x86_64_v2_scalasca-mpich.sha256sum] = "ce3bf587688d16eb67a8b84184f05b9c275e2fe18092cd5275e0d8b68191b007"

URI_x86_64_v2_scalasca-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/scalasca-openmpi-2.6.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_scalasca-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_scalasca-openmpi}"
SRC_URI[x86_64_v2_scalasca-openmpi.sha256sum] = "1208c695495ca528809687b883a48bf5bab14f028bdb2a4fd6a4a540a2d3b370"

URI_aarch64_scalasca = "${EPEL_MIRROR}/aarch64/Packages/s/scalasca-2.6.2-1.el10_0.aarch64.rpm;name=aarch64_scalasca;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalasca}"
SRC_URI[aarch64_scalasca.sha256sum] = "8549805e0a9c5b216ba085df1cba0bfc349524b4c6e75b09e41b8d652662377f"

URI_aarch64_scalasca-doc = "${EPEL_MIRROR}/aarch64/Packages/s/scalasca-doc-2.6.2-1.el10_0.noarch.rpm;name=aarch64_scalasca-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalasca-doc}"
SRC_URI[aarch64_scalasca-doc.sha256sum] = "52ea652535c9c814f4a89206a78e1bac04028ff41b90d4b64247547301a8b13d"

URI_aarch64_scalasca-mpich = "${EPEL_MIRROR}/aarch64/Packages/s/scalasca-mpich-2.6.2-1.el10_0.aarch64.rpm;name=aarch64_scalasca-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalasca-mpich}"
SRC_URI[aarch64_scalasca-mpich.sha256sum] = "24f10403c0efcd2b5a5dc5b0528261e9e4a0eba8be2942d2a1fb7616ba8f09ce"

URI_aarch64_scalasca-openmpi = "${EPEL_MIRROR}/aarch64/Packages/s/scalasca-openmpi-2.6.2-1.el10_0.aarch64.rpm;name=aarch64_scalasca-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_scalasca-openmpi}"
SRC_URI[aarch64_scalasca-openmpi.sha256sum] = "3f9af23a9eb8a6466c1c9e5691f637903d70a85d238c2b56372e6ac5f18025dd"

RDEPENDS:scalasca = " \
 bash \
 cube-libs \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 otf2 \
 scorep-config \
 zlib-ng-compat \
 "
RDEPENDS:scalasca-doc = " \
 "
RDEPENDS:scalasca-mpich = " \
 bash \
 cube-libs \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 mpich \
 otf2 \
 scorep-mpich-config \
 zlib-ng-compat \
 "
RDEPENDS:scalasca-openmpi = " \
 bash \
 cube-libs \
 glibc \
 libgcc \
 libgomp \
 libstdc++ \
 openmpi \
 otf2 \
 scorep-openmpi-config \
 zlib-ng-compat \
 "
