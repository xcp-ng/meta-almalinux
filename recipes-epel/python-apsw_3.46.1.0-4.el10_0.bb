# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-apsw"
PV = "3.46.1.0"
PR = "4.el10_0"
PACKAGES = " \
 python3-apsw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-apsw-3.46.1.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e21ad11b1a88d9c1173024efe6a71125b4e4f4fe65f50c76c9861a61d7d3c005"

URI_x86_64_v2_python3-apsw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-apsw-3.46.1.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-apsw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-apsw}"
SRC_URI[x86_64_v2_python3-apsw.sha256sum] = "39305209f868a57ecad44d6a4e3b2976acf1c134ef5c3d3a75aecda956b11fec"

URI_aarch64_python3-apsw = "${EPEL_MIRROR}/aarch64/Packages/p/python3-apsw-3.46.1.0-4.el10_0.aarch64.rpm;name=aarch64_python3-apsw;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-apsw}"
SRC_URI[aarch64_python3-apsw.sha256sum] = "45fe09e04b641a3787d25083fe4655a6c28c9231c1d0b91ab4a244d7e9ea8f2a"

RDEPENDS:python3-apsw = " \
 glibc \
 python3 \
 sqlite-libs \
 "
