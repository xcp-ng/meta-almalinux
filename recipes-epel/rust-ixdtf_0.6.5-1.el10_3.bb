# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ixdtf"
PV = "0.6.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-ixdtf+default-devel \
 rust-ixdtf+duration-devel \
 rust-ixdtf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ixdtf-0.6.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e11c4a94b0949167195d38c655fbdbca5b6df1c8ad45b3e8acef75b7da0c7f1"

URI_x86_64_v2_rust-ixdtf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ixdtf+default-devel-0.6.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ixdtf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ixdtf+default-devel}"
SRC_URI[x86_64_v2_rust-ixdtf+default-devel.sha256sum] = "c279fb6e8f28c4ee66409521e5ab52e961b0f736450cb4966498303e9ed82a75"

URI_x86_64_v2_rust-ixdtf+duration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ixdtf+duration-devel-0.6.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ixdtf+duration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ixdtf+duration-devel}"
SRC_URI[x86_64_v2_rust-ixdtf+duration-devel.sha256sum] = "ed4a16de0a5ef0478c4d082a1e305c66a8ade10626f299c06af54b27c2c02f25"

URI_x86_64_v2_rust-ixdtf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ixdtf-devel-0.6.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ixdtf-devel}"
SRC_URI[x86_64_v2_rust-ixdtf-devel.sha256sum] = "c8506c3bb77874c009873dedf8bc917953ab1d82a20630b1e14bad2676baa53b"

URI_aarch64_rust-ixdtf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ixdtf+default-devel-0.6.5-1.el10_3.noarch.rpm;name=aarch64_rust-ixdtf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ixdtf+default-devel}"
SRC_URI[aarch64_rust-ixdtf+default-devel.sha256sum] = "4f8849978a5d7c6ba67b62399214e487957d0adf0cf61561d001f69c5eaae643"

URI_aarch64_rust-ixdtf+duration-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ixdtf+duration-devel-0.6.5-1.el10_3.noarch.rpm;name=aarch64_rust-ixdtf+duration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ixdtf+duration-devel}"
SRC_URI[aarch64_rust-ixdtf+duration-devel.sha256sum] = "d92001601d6d0d4e6db1632072b8cc8f2baf9007663e5fa0ff907fe8bc1b71b7"

URI_aarch64_rust-ixdtf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ixdtf-devel-0.6.5-1.el10_3.noarch.rpm;name=aarch64_rust-ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ixdtf-devel}"
SRC_URI[aarch64_rust-ixdtf-devel.sha256sum] = "d31096b70a0a2fe8f99bcca7ff360e84a109268bcf73adb9a2de9b3f5e97b2c7"

RDEPENDS:rust-ixdtf+default-devel = " \
 cargo \
 rust-ixdtf+duration-devel \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-ixdtf+duration-devel = " \
 cargo \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-ixdtf-devel = " \
 cargo \
 rust \
 "
