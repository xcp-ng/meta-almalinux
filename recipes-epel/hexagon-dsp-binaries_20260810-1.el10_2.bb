# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hexagon-dsp-binaries"
PV = "20260810"
PR = "1.el10_2"
PACKAGES = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-arduino-monza \
 hexagon-dsp-binaries-qualcomm-db410c \
 hexagon-dsp-binaries-qualcomm-db820c \
 hexagon-dsp-binaries-qualcomm-glymur-crd \
 hexagon-dsp-binaries-qualcomm-hamoa-iot-evk \
 hexagon-dsp-binaries-qualcomm-iq8275-evk \
 hexagon-dsp-binaries-qualcomm-iq9075-evk \
 hexagon-dsp-binaries-qualcomm-kaanapali-mtp \
 hexagon-dsp-binaries-qualcomm-purwa-iot-evk \
 hexagon-dsp-binaries-qualcomm-qcm6490-idp \
 hexagon-dsp-binaries-qualcomm-qcs615-ride \
 hexagon-dsp-binaries-qualcomm-qcs8300-ride \
 hexagon-dsp-binaries-qualcomm-sa8775p-ride \
 hexagon-dsp-binaries-qualcomm-sdm845-hdk \
 hexagon-dsp-binaries-qualcomm-shikra-cqm-evk \
 hexagon-dsp-binaries-qualcomm-shikra-cqs-evk \
 hexagon-dsp-binaries-qualcomm-shikra-iqs-evk \
 hexagon-dsp-binaries-qualcomm-sm8750-mtp \
 hexagon-dsp-binaries-radxa-dragon-q6a \
 hexagon-dsp-binaries-thundercomm-db845c \
 hexagon-dsp-binaries-thundercomm-rb1 \
 hexagon-dsp-binaries-thundercomm-rb2 \
 hexagon-dsp-binaries-thundercomm-rb3gen2 \
 hexagon-dsp-binaries-thundercomm-rb5 \
 hexagon-dsp-binaries-thundercomm-rubikpi3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hexagon-dsp-binaries-20260810-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bf7db93b2772bad1b06568b646d9cc327897c79f7a53ad68330bfc018eba947"

URI_aarch64_hexagon-dsp-binaries = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries}"
SRC_URI[aarch64_hexagon-dsp-binaries.sha256sum] = "bb9ce0b58d9d0b7f8a0645ee1d2edefae1294e29ba6de18be98af32dca4991d3"

URI_aarch64_hexagon-dsp-binaries-arduino-monza = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-arduino-monza-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-arduino-monza;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-arduino-monza}"
SRC_URI[aarch64_hexagon-dsp-binaries-arduino-monza.sha256sum] = "5061a34b6cc18a2f8a920a286f1bd42633e36acdf9d5e21dc2b4bff2fa818464"

URI_aarch64_hexagon-dsp-binaries-qualcomm-db410c = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-db410c-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-db410c;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-db410c}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-db410c.sha256sum] = "06e39d5528cc50e4f8ad450d0f7993a7b53a4e1e2610a23b3e3bed557996fcfd"

URI_aarch64_hexagon-dsp-binaries-qualcomm-db820c = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-db820c-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-db820c;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-db820c}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-db820c.sha256sum] = "bd39792bd4647b6b71e94be2e16188c9885a7bda88f828bb3ca91056d9c35775"

URI_aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-glymur-crd-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-glymur-crd.sha256sum] = "9657cbca81c7972863771e75dd07878b2c820d336c4017281c4deefa9763d3d9"

URI_aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-hamoa-iot-evk-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-hamoa-iot-evk.sha256sum] = "687b59373e8655107805d418626b6fd17595e790c3264aad85d06a41019e485a"

URI_aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-iq8275-evk-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-iq8275-evk.sha256sum] = "a6d954c8848867323c7f849647ce45eecf05b747db93d1d23157d683e0210418"

URI_aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-iq9075-evk-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-iq9075-evk.sha256sum] = "ad8d83897705e47df0d442216f6c904c3349c93a2e43c0b06a69b4f1b8917854"

URI_aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-kaanapali-mtp-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-kaanapali-mtp.sha256sum] = "f1dd0e123ccecfc2febdd2fd384d24b02f1c381747ad257008f422b9e2d28cf2"

URI_aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-purwa-iot-evk-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-purwa-iot-evk.sha256sum] = "94121e14cf0e464317abc0b645d5dc2c7f4837aae9e67c2391370975332104cf"

URI_aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-qcm6490-idp-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-qcm6490-idp.sha256sum] = "8def97d75a5a3d07dcd66222da5a7f2d952dba81a9d3ab1016c07f71ffa5d989"

URI_aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-qcs615-ride-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-qcs615-ride.sha256sum] = "2e9acbf8413d102915a2d7f569db3aa43b7eb4eebb13536758d80e4145074b95"

URI_aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-qcs8300-ride-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-qcs8300-ride.sha256sum] = "1df57871d258d0e4e11527d9c192875bdee436a541938214dee36a33f7a03c87"

URI_aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-sa8775p-ride-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-sa8775p-ride.sha256sum] = "6fdb7f28b3f1beed81b705d9ba6a14aa333032ededab6fd6f391df9c0898d8f4"

URI_aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-sdm845-hdk-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-sdm845-hdk.sha256sum] = "5966af4957299c9657b2400f32cfce9965b13256a3eb9083111be96936c9de63"

URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-shikra-cqm-evk-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqm-evk.sha256sum] = "95b749e8f16edbda7359b59c1ebb89cf0a94ae7bb2519a9b865e4223bd71dd2b"

URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-shikra-cqs-evk-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-shikra-cqs-evk.sha256sum] = "a2b43dae190e9034a71140436a321ceb370d0b80ea6eec26c16f87c726302bbf"

URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-shikra-iqs-evk-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-shikra-iqs-evk.sha256sum] = "b2afa6a50902c31906f7132ad849b93bb1aa807475253e3c4c647ac20828bbf4"

URI_aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-qualcomm-sm8750-mtp-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp}"
SRC_URI[aarch64_hexagon-dsp-binaries-qualcomm-sm8750-mtp.sha256sum] = "cd4595f8f84e1214194ac4457624a68cd1389ff8b40961ae59e122e6c8ad0d3c"

URI_aarch64_hexagon-dsp-binaries-radxa-dragon-q6a = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-radxa-dragon-q6a-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-radxa-dragon-q6a;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-radxa-dragon-q6a}"
SRC_URI[aarch64_hexagon-dsp-binaries-radxa-dragon-q6a.sha256sum] = "54735371ecf0b0177d6865e2e6febb28f09768c2ba427a64c02396dc339b9fbd"

URI_aarch64_hexagon-dsp-binaries-thundercomm-db845c = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-db845c-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-db845c;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-db845c}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-db845c.sha256sum] = "f33cf84f612ec858e866deb2912242fca2732e91fbc53a7ba608bde74d193d20"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rb1 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb1-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb1;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rb1}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb1.sha256sum] = "7b4014dd1b852cee82c95fc6d6c96866474a2330cab25cc188c0685cc90be61a"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rb2 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb2-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb2;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rb2}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb2.sha256sum] = "88cabcba99dbc859acc612a743f545c7d97b8e54ff2e02c9071981bdce692421"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb3gen2-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb3gen2.sha256sum] = "335b6ecaef6a0b6e33825c390fb85f0488749eaf4fab06c0e972b663a67d8d6b"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rb5 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rb5-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rb5;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rb5}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rb5.sha256sum] = "69eda9ce9f8455391d49bf85fb0f9d76ef1a67b0dfd798755a4b8b5f31fda120"

URI_aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3 = "${EPEL_MIRROR}/aarch64/Packages/h/hexagon-dsp-binaries-thundercomm-rubikpi3-20260810-1.el10_2.noarch.rpm;name=aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3;unpack=0"
SRC_URI:append = " ${URI_aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3}"
SRC_URI[aarch64_hexagon-dsp-binaries-thundercomm-rubikpi3.sha256sum] = "7b5f49493292f7e69a59092a24aa9d8fe9f88ada66d952f3d6d134cdd917640d"

RDEPENDS:hexagon-dsp-binaries = " \
 "
RDEPENDS:hexagon-dsp-binaries-arduino-monza = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-qcs8300-ride \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-db410c = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-db820c = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-glymur-crd = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-hamoa-iot-evk = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-iq8275-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-qcs8300-ride \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-iq9075-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-sa8775p-ride \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-kaanapali-mtp = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-purwa-iot-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-hamoa-iot-evk \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-qcm6490-idp = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-thundercomm-rb3gen2 \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-qcs615-ride = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-qcs8300-ride = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-sa8775p-ride = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-sdm845-hdk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-thundercomm-db845c \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-shikra-cqm-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-shikra-cqs-evk \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-shikra-cqs-evk = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-shikra-iqs-evk = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-qualcomm-shikra-cqs-evk \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-qualcomm-sm8750-mtp = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-radxa-dragon-q6a = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-db845c = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb1 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb2 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb3gen2 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rb5 = " \
 hexagon-dsp-binaries \
 qcom-firmware \
 "
RDEPENDS:hexagon-dsp-binaries-thundercomm-rubikpi3 = " \
 hexagon-dsp-binaries \
 hexagon-dsp-binaries-thundercomm-rb3gen2 \
 qcom-firmware \
 "
