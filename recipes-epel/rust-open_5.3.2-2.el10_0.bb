# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-open"
PV = "5.3.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-open+default-devel \
 rust-open-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-open-5.3.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bc6935b0aef590ca81a30b15df79824d0f62c9118a285943c01752b74200e8c6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open+default-devel-5.3.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-open+default-devel.sha256sum] = "6a5046abf7db2e9a43d995f5ea2ca441dfb467a6f15c470800fbfb2e6141ddd1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open-devel-5.3.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open-devel;unpack=0"
SRC_URI[x86_64_v2_rust-open-devel.sha256sum] = "b19a49311dd60038796563183c91dbdf77498c7c88bc1865d8ea45bedad1de6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-open+default-devel-5.3.2-2.el10_0.noarch.rpm;name=aarch64_rust-open+default-devel;unpack=0"
SRC_URI[aarch64_rust-open+default-devel.sha256sum] = "0c5c5487f16885e9eecc0de35a2f0ce29d266cdb1b6488c56aaa746109eb6290"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-open-devel-5.3.2-2.el10_0.noarch.rpm;name=aarch64_rust-open-devel;unpack=0"
SRC_URI[aarch64_rust-open-devel.sha256sum] = "a9d940b067518a084a57f7e81e5659462b633f79013225b4fed5415b039c172f"

RDEPENDS:rust-open+default-devel = " \
 cargo \
 rust-open-devel \
 "
RDEPENDS:rust-open-devel = " \
 cargo \
 rust \
 rust-is-wsl+default-devel \
 rust-libc+default-devel \
 rust-pathdiff+default-devel \
 "
