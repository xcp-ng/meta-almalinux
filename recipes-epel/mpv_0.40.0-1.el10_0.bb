# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mpv"
PV = "0.40.0"
PR = "1.el10_0"
PACKAGES = " \
 mpv \
 mpv-devel \
 mpv-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mpv-0.40.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2a067794e931873056c6c856efcd95f5ca3ea0fa16144827be099dd810e1745"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - mpv-devel: pkgconfig(libavcodec) >= 60.31.102
# - mpv-devel: pkgconfig(libavdevice) >= 60.3.100
# - mpv-devel: pkgconfig(libavfilter) >= 9.12.100
# - mpv-devel: pkgconfig(libavformat) >= 60.16.100
# - mpv-devel: pkgconfig(libavutil) >= 58.29.100
# - mpv-devel: pkgconfig(libswresample) >= 4.12.100
# - mpv-devel: pkgconfig(libswscale) >= 7.5.100
# - mpv-libs: libavcodec.so.61()(64bit)
# - mpv-libs: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - mpv-libs: libavdevice.so.61()(64bit)
# - mpv-libs: libavdevice.so.61(LIBAVDEVICE_61)(64bit)
# - mpv-libs: libavfilter.so.10()(64bit)
# - mpv-libs: libavfilter.so.10(LIBAVFILTER_10)(64bit)
# - mpv-libs: libavformat.so.61()(64bit)
# - mpv-libs: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - mpv-libs: libavutil.so.59()(64bit)
# - mpv-libs: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - mpv-libs: libswresample.so.5()(64bit)
# - mpv-libs: libswresample.so.5(LIBSWRESAMPLE_5)(64bit)
# - mpv-libs: libswscale.so.8()(64bit)
# - mpv-libs: libswscale.so.8(LIBSWSCALE_8)(64bit)
# - mpv: libavcodec.so.61()(64bit)
# - mpv: libavcodec.so.61(LIBAVCODEC_61)(64bit)
# - mpv: libavdevice.so.61()(64bit)
# - mpv: libavdevice.so.61(LIBAVDEVICE_61)(64bit)
# - mpv: libavfilter.so.10()(64bit)
# - mpv: libavfilter.so.10(LIBAVFILTER_10)(64bit)
# - mpv: libavformat.so.61()(64bit)
# - mpv: libavformat.so.61(LIBAVFORMAT_61)(64bit)
# - mpv: libavutil.so.59()(64bit)
# - mpv: libavutil.so.59(LIBAVUTIL_59)(64bit)
# - mpv: libswresample.so.5()(64bit)
# - mpv: libswresample.so.5(LIBSWRESAMPLE_5)(64bit)
# - mpv: libswscale.so.8()(64bit)
# - mpv: libswscale.so.8(LIBSWSCALE_8)(64bit)

URI_x86_64_v2_mpv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mpv-0.40.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mpv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpv}"
SRC_URI[x86_64_v2_mpv.sha256sum] = "d54e42a75dad0ed3d1529db335064e7a52153398658e57b660048d23bb5f0eca"

URI_x86_64_v2_mpv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mpv-devel-0.40.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mpv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpv-devel}"
SRC_URI[x86_64_v2_mpv-devel.sha256sum] = "74f4f067e107aa1405f91e7f0f6450ba37fa786b305c754c94b4594a59cb88e4"

URI_x86_64_v2_mpv-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mpv-libs-0.40.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mpv-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mpv-libs}"
SRC_URI[x86_64_v2_mpv-libs.sha256sum] = "f55796f4ea6ec7671a0a2904030335eb4dc5e3761c18e03d31c355c3570c285d"

URI_aarch64_mpv = "${EPEL_MIRROR}/aarch64/Packages/m/mpv-0.40.0-1.el10_0.aarch64.rpm;name=aarch64_mpv;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpv}"
SRC_URI[aarch64_mpv.sha256sum] = "25b81c332f3d39f6b1599312667b5b0ae84819ed78ffe29af5214430f67f06f4"

URI_aarch64_mpv-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mpv-devel-0.40.0-1.el10_0.aarch64.rpm;name=aarch64_mpv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpv-devel}"
SRC_URI[aarch64_mpv-devel.sha256sum] = "f476cde7be4ca6ecd027dc14151a550cca24c8e63a7520d420e2fbca70ed0985"

URI_aarch64_mpv-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mpv-libs-0.40.0-1.el10_0.aarch64.rpm;name=aarch64_mpv-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mpv-libs}"
SRC_URI[aarch64_mpv-libs.sha256sum] = "a2a0af800f131cd30d6113cb6530e568cb590490cd784590927171169b4441b5"

RDEPENDS:mpv:x86_64_v2 = " \
 alsa-lib \
 compat-lua-libs \
 glibc \
 hicolor-icon-theme \
 lcms2 \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcdio \
 libcdio-paranoia \
 libdisplay-info \
 libdrm \
 libdvdnav \
 libgcc \
 libglvnd-egl \
 libjpeg-turbo \
 libplacebo \
 libva \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 mesa-libgbm \
 mujs \
 openal-soft \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pulseaudio-libs \
 rubberband \
 uchardet \
 vapoursynth-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 vulkan-loader \
 zimg \
 zlib-ng-compat \
"
RDEPENDS:mpv:aarch64 = " \
 alsa-lib \
 compat-lua-libs \
 glibc \
 hicolor-icon-theme \
 lcms2 \
 libarchive \
 libass \
 libavcodec-free \
 libavdevice-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libbluray \
 libcaca \
 libcdio \
 libcdio-paranoia \
 libdisplay-info \
 libdrm \
 libdvdnav \
 libgcc \
 libglvnd-egl \
 libjpeg-turbo \
 libplacebo \
 libswresample-free \
 libswscale-free \
 libva \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 mesa-libgbm \
 mujs \
 openal-soft \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pulseaudio-libs \
 rubberband \
 uchardet \
 vapoursynth-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 vulkan-loader \
 zimg \
 zlib-ng-compat \
"
RDEPENDS:mpv-devel:x86_64_v2 = " \
 SDL2-devel \
 alsa-lib-devel \
 compat-lua-devel \
 lcms2-devel \
 libarchive-devel \
 libass-devel \
 libbluray-devel \
 libcaca-devel \
 libcdio-devel \
 libcdio-paranoia-devel \
 libdisplay-info-devel \
 libdrm-devel \
 libdvdnav-devel \
 libglvnd-devel \
 libjpeg-turbo-devel \
 libplacebo-devel \
 libva-devel \
 libxkbcommon-devel \
 mesa-libgbm-devel \
 mpv-libs \
 mujs-devel \
 nv-codec-headers \
 openal-soft-devel \
 pipewire-devel \
 pipewire-jack-audio-connection-kit-devel \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 rubberband-devel \
 uchardet-devel \
 vapoursynth-devel \
 vulkan-loader-devel \
 wayland-devel \
 wayland-protocols-devel \
 zimg-devel \
 zlib-ng-compat-devel \
"
RDEPENDS:mpv-devel:aarch64 = " \
 SDL2-devel \
 alsa-lib-devel \
 compat-lua-devel \
 lcms2-devel \
 libarchive-devel \
 libass-devel \
 libavcodec-free-devel \
 libavdevice-free-devel \
 libavfilter-free-devel \
 libavformat-free-devel \
 libavutil-free-devel \
 libbluray-devel \
 libcaca-devel \
 libcdio-devel \
 libcdio-paranoia-devel \
 libdisplay-info-devel \
 libdrm-devel \
 libdvdnav-devel \
 libglvnd-devel \
 libjpeg-turbo-devel \
 libplacebo-devel \
 libswresample-free-devel \
 libswscale-free-devel \
 libva-devel \
 libxkbcommon-devel \
 mesa-libgbm-devel \
 mpv-libs \
 mujs-devel \
 nv-codec-headers \
 openal-soft-devel \
 pipewire-devel \
 pipewire-jack-audio-connection-kit-devel \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 rubberband-devel \
 uchardet-devel \
 vapoursynth-devel \
 vulkan-loader-devel \
 wayland-devel \
 wayland-protocols-devel \
 zimg-devel \
 zlib-ng-compat-devel \
"
RDEPENDS:mpv-libs:x86_64_v2 = " \
 alsa-lib \
 compat-lua-libs \
 glibc \
 lcms2 \
 libarchive \
 libass \
 libbluray \
 libcaca \
 libcdio \
 libcdio-paranoia \
 libdisplay-info \
 libdrm \
 libdvdnav \
 libgcc \
 libglvnd-egl \
 libjpeg-turbo \
 libplacebo \
 libva \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 mesa-libgbm \
 mujs \
 openal-soft \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pulseaudio-libs \
 rubberband \
 uchardet \
 vapoursynth-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 vulkan-loader \
 zimg \
 zlib-ng-compat \
"
RDEPENDS:mpv-libs:aarch64 = " \
 alsa-lib \
 compat-lua-libs \
 glibc \
 lcms2 \
 libarchive \
 libass \
 libavcodec-free \
 libavdevice-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libbluray \
 libcaca \
 libcdio \
 libcdio-paranoia \
 libdisplay-info \
 libdrm \
 libdvdnav \
 libgcc \
 libglvnd-egl \
 libjpeg-turbo \
 libplacebo \
 libswresample-free \
 libswscale-free \
 libva \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxkbcommon \
 mesa-libgbm \
 mujs \
 openal-soft \
 pipewire-jack-audio-connection-kit-libs \
 pipewire-libs \
 pulseaudio-libs \
 rubberband \
 uchardet \
 vapoursynth-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 vulkan-loader \
 zimg \
 zlib-ng-compat \
"
