# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-urfave-negroni"
PV = "2.0.2"
PR = "15.el10_0"
PACKAGES = " \
 compat-golang-github-codegangsta-negroni-devel \
 golang-github-urfave-negroni-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-urfave-negroni-2.0.2-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d67aa4be863e5438e3951033e07a5fc0d7efb44c86449a81da68a16a849c8ae"

URI_x86_64_v2_compat-golang-github-codegangsta-negroni-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-codegangsta-negroni-devel-2.0.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-codegangsta-negroni-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-codegangsta-negroni-devel}"
SRC_URI[x86_64_v2_compat-golang-github-codegangsta-negroni-devel.sha256sum] = "0544515830150c0b3ed736672f67d620b88b9e9871e326451c896505d1ae3482"

URI_x86_64_v2_golang-github-urfave-negroni-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-urfave-negroni-devel-2.0.2-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-urfave-negroni-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-urfave-negroni-devel}"
SRC_URI[x86_64_v2_golang-github-urfave-negroni-devel.sha256sum] = "083c9e3efb03286db0ab516805803af0ec32d8c64aa2644cf3035c13fc57142d"

URI_aarch64_compat-golang-github-codegangsta-negroni-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-codegangsta-negroni-devel-2.0.2-15.el10_0.noarch.rpm;name=aarch64_compat-golang-github-codegangsta-negroni-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-codegangsta-negroni-devel}"
SRC_URI[aarch64_compat-golang-github-codegangsta-negroni-devel.sha256sum] = "27b224219f82083074b399163000d24a9c0c8dbc9d6450d34816d18204b114ea"

URI_aarch64_golang-github-urfave-negroni-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-urfave-negroni-devel-2.0.2-15.el10_0.noarch.rpm;name=aarch64_golang-github-urfave-negroni-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-urfave-negroni-devel}"
SRC_URI[aarch64_golang-github-urfave-negroni-devel.sha256sum] = "19b282bffd7818ecc4b6748cbbcf724b151f0d9a0b311c7c6a4c89ecc45b9992"

RDEPENDS:compat-golang-github-codegangsta-negroni-devel = " \
 go-filesystem \
 golang-github-urfave-negroni-devel \
 "
RDEPENDS:golang-github-urfave-negroni-devel = " \
 go-filesystem \
 "
