# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvma"
PV = "9.8.84"
PR = "2.el10"
PACKAGES = " \
 libvma \
 libvma-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvma-9.8.84-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1c41be7695f292f13543a585b09fb86d46976a905d8fe9b2eadea4f032c67611"

URI_x86_64_v2_libvma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvma-9.8.84-2.el10.x86_64_v2.rpm;name=x86_64_v2_libvma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvma}"
SRC_URI[x86_64_v2_libvma.sha256sum] = "e9b57c00f01a91db86af53cce7f1e86806a55efd655d20369ae658bea8ebd60e"

URI_x86_64_v2_libvma-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvma-utils-9.8.84-2.el10.x86_64_v2.rpm;name=x86_64_v2_libvma-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvma-utils}"
SRC_URI[x86_64_v2_libvma-utils.sha256sum] = "d22a00199fe0f60f55573d6654272c1496f74484f667ffba0f81594cfafaf60a"

URI_aarch64_libvma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvma-9.8.84-2.el10.aarch64.rpm;name=aarch64_libvma;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvma}"
SRC_URI[aarch64_libvma.sha256sum] = "6cf5a5917f647d57a0d4b8a156c16284886ef5d4f25c21a61a8d5a7cfe2e750d"

URI_aarch64_libvma-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvma-utils-9.8.84-2.el10.aarch64.rpm;name=aarch64_libvma-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvma-utils}"
SRC_URI[aarch64_libvma-utils.sha256sum] = "8d8fddbea6d1a975be8bae0a6e72eb80d5e67b1c47bfcfbcdc326ef2a942b149"

RDEPENDS:libvma = " \
 bash \
 glibc \
 libgcc \
 libibverbs \
 libnl3 \
 librdmacm \
 libstdc++ \
 "
RDEPENDS:libvma-utils = " \
 glibc \
 libgcc \
 libstdc++ \
 libvma \
 "
