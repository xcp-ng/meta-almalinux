# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-base"
PV = "1.26.7"
PR = "4.el10"
PACKAGES = " \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 gstreamer1-plugins-base-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-base-1.26.7-4.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a8d86a61e590f5663130db87aa1cfb5323472c1540a8d98e532d1d80432bc496"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-1.26.7-4.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-base.sha256sum] = "b33dfa3c3db4fa5b77a80fa5c08f12dfff930ed419f6ec16d850919d0816947e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-devel-1.26.7-4.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-devel.sha256sum] = "5498b9bbcc65cc76c3217a656b2eaf8683e2f0fcb5c683f4e1327ce3cf205cde"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-base-tools-1.26.7-4.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-base-tools.sha256sum] = "2af9f75d1262a63bd8e66548afb2b8284472ae838825d187d2d41473291e6775"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-1.26.7-4.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-base;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-base.sha256sum] = "e27f72e5526c00c138e4231dff53a1cc34a119ee28c488d17533e5d8de1c3365"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-devel-1.26.7-4.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-devel;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-base-devel.sha256sum] = "be44e01fe037005e7a620619db6f8b0465fe1b921e5c9f8cce75f8697c5225b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-base-tools-1.26.7-4.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-base-tools;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-base-tools.sha256sum] = "61bc715c08d3fcc2f7e19387d2aeefb0839cea43e3d1095f9de34fa96bedce6a"

RDEPENDS:gstreamer1-plugins-base = " \
 alsa-lib \
 cairo \
 glib2 \
 glibc \
 graphene \
 gstreamer1 \
 iso-codes \
 libX11 \
 libX11-xcb \
 libXext \
 libXi \
 libXv \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libgudev \
 libjpeg-turbo \
 libogg \
 libpng \
 libtheora \
 libvorbis \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libxcb \
 mesa-libgbm \
 opus \
 orc \
 pango \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-base-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-base \
 gstreamer1-plugins-base-devel \
 libX11-devel \
 libdrm-devel \
 libglvnd-devel \
 libgudev-devel \
 mesa-libgbm-devel \
 orc-devel \
 pkgconf-pkg-config \
 wayland-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:gstreamer1-plugins-base-tools = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 "
