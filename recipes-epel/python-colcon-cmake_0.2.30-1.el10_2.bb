# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-cmake"
PV = "0.2.30"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-cmake \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-cmake-0.2.30-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e64e611c6c7f9e99d246207dcd1867b4c8966d5889f47c24c2a46cf8ede4ee3b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-cmake-0.2.30-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-cmake;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-cmake.sha256sum] = "b4baf4e75ab871af0f80e47cee6f356410bc92f6ee65997e951c7f0250e95395"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-cmake-0.2.30-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-cmake;unpack=0"
SRC_URI[aarch64_python3-colcon-cmake.sha256sum] = "48b5ea65e75f7396e8936c6bafe2bcbf12c299465fff4914fee7cfe27c752bd3"

RDEPENDS:python3-colcon-cmake = " \
 python3 \
 python3-colcon-core \
 python3-colcon-library-path \
 python3-colcon-test-result \
 python3-packaging \
 "
