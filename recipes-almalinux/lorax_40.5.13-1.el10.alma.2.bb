# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lorax"
PV = "40.5.13"
PR = "1.el10.alma.2"
PACKAGES = " \
 lorax \
 lorax-docs \
 lorax-lmc-novirt \
 lorax-lmc-virt \
 lorax-templates-generic \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/lorax-40.5.13-1.el10.alma.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9de439e71bbd9454ffed926928fbea9252f6333853a78362e3d4f9550f678b5f"

URI_x86_64_v2_lorax = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-40.5.13-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_lorax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax}"
SRC_URI[x86_64_v2_lorax.sha256sum] = "930d72241d5f9f4c707fcaa8d402752a4d23f85cbb3f597e7ccc9d5b6cfb47d5"

URI_x86_64_v2_lorax-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-docs-40.5.13-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_lorax-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-docs}"
SRC_URI[x86_64_v2_lorax-docs.sha256sum] = "a53ec218e6d3ff3ec79566b9370965bed07d113f92e8ebc06b582fa00eb4abeb"

URI_x86_64_v2_lorax-lmc-novirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-novirt-40.5.13-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-novirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-lmc-novirt}"
SRC_URI[x86_64_v2_lorax-lmc-novirt.sha256sum] = "cf6a5ec74887a1162d143a932b6f8bae50478abd627a8437a6762b43e5e271fb"

URI_x86_64_v2_lorax-lmc-virt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-lmc-virt-40.5.13-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_lorax-lmc-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-lmc-virt}"
SRC_URI[x86_64_v2_lorax-lmc-virt.sha256sum] = "daff5777940f2c5c86ec5a2bf10913293d7a859a695225d7b505e0d64c72bf36"

URI_x86_64_v2_lorax-templates-generic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lorax-templates-generic-40.5.13-1.el10.alma.2.x86_64_v2.rpm;name=x86_64_v2_lorax-templates-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lorax-templates-generic}"
SRC_URI[x86_64_v2_lorax-templates-generic.sha256sum] = "529b0a14092e679fe9214c875f90f76ec32a4c9f74c249946169c44b58c23408"
RPROVIDES:lorax-templates-generic:x86_64_v2 = "virtual/lorax-templates"

URI_aarch64_lorax = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-40.5.13-1.el10.alma.2.aarch64.rpm;name=aarch64_lorax;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax}"
SRC_URI[aarch64_lorax.sha256sum] = "393d3658566ce6a273d05289ad6d2d44c9bcdfeea9f9985c27cb6087c78da42c"

URI_aarch64_lorax-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-docs-40.5.13-1.el10.alma.2.aarch64.rpm;name=aarch64_lorax-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-docs}"
SRC_URI[aarch64_lorax-docs.sha256sum] = "b8d41ced61aced50ff73db13ddf154e3712235cf8c94a23802118c82d65766da"

URI_aarch64_lorax-lmc-novirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-novirt-40.5.13-1.el10.alma.2.aarch64.rpm;name=aarch64_lorax-lmc-novirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-lmc-novirt}"
SRC_URI[aarch64_lorax-lmc-novirt.sha256sum] = "1f7d823a02d429bb377e8d7d77404fcadcdcb39315196e8fc6155d9e4fe10ba2"

URI_aarch64_lorax-lmc-virt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-lmc-virt-40.5.13-1.el10.alma.2.aarch64.rpm;name=aarch64_lorax-lmc-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-lmc-virt}"
SRC_URI[aarch64_lorax-lmc-virt.sha256sum] = "3b55840104376a6de9fc4929cdc0bc446143c98f299cc6ff6ce898b151984284"

URI_aarch64_lorax-templates-generic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lorax-templates-generic-40.5.13-1.el10.alma.2.aarch64.rpm;name=aarch64_lorax-templates-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_lorax-templates-generic}"
SRC_URI[aarch64_lorax-templates-generic.sha256sum] = "dbf9c61db87af5c515d96bc275b4a740b573226b20c502e31c3a3d5da974300c"
RPROVIDES:lorax-templates-generic:aarch64 = "virtual/lorax-templates"

RDEPENDS:lorax:x86_64_v2 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 grub2-pc \
 grub2-tools \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax:aarch64 = " \
 cpio \
 device-mapper \
 dosfstools \
 dracut \
 e2fsprogs \
 erofs-utils \
 findutils \
 gawk \
 glib2 \
 glibc \
 glibc-common \
 gzip \
 isomd5sum \
 kmod \
 kpartx \
 lorax-templates-rhel \
 parted \
 pbzip2 \
 pigz \
 psmisc \
 python3 \
 python3-dnf \
 python3-kickstart \
 python3-librepo \
 python3-libselinux \
 python3-mako \
 python3-pycdio \
 squashfs-tools \
 util-linux \
 virtual/lorax-templates \
 xorriso \
 xz \
 xz-lzma-compat \
"
RDEPENDS:lorax-docs = " \
 lorax \
 "
RDEPENDS:lorax-lmc-novirt = " \
 almalinux-logos \
 anaconda-core \
 anaconda-install-env-deps \
 anaconda-tui \
 lorax \
 python3-psutil \
 tar \
 "
RDEPENDS:lorax-lmc-virt:x86_64_v2 = " \
 edk2-ovmf \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-lmc-virt:aarch64 = " \
 edk2-aarch64 \
 lorax \
 qemu-kvm \
 tar \
"
RDEPENDS:lorax-templates-generic = " \
 lorax \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/lorax-templates"

PROVIDES:append:aarch64 = " rpm/virtual/lorax-templates"
