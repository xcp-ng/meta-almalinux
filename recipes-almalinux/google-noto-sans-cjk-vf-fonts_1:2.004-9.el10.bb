# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-noto-sans-cjk-vf-fonts"
PE = "1"
PV = "2.004"
PR = "9.el10"
PACKAGES = " \
 google-noto-sans-cjk-vf-fonts \
 google-noto-sans-mono-cjk-vf-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/google-noto-sans-cjk-vf-fonts-2.004-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90fe1ba8725be673caedda87120acbf721ac80f8343ff0e240b03e7e05083b3f"

URI_x86_64_v2_google-noto-sans-cjk-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-noto-sans-cjk-vf-fonts-2.004-9.el10.noarch.rpm;name=x86_64_v2_google-noto-sans-cjk-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-noto-sans-cjk-vf-fonts}"
SRC_URI[x86_64_v2_google-noto-sans-cjk-vf-fonts.sha256sum] = "cd7bfa59806126fa6a4bede5c7eb2e19d6494dcbf4164cd64a2a9698c825b6f9"

URI_x86_64_v2_google-noto-sans-mono-cjk-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-noto-sans-mono-cjk-vf-fonts-2.004-9.el10.noarch.rpm;name=x86_64_v2_google-noto-sans-mono-cjk-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_google-noto-sans-mono-cjk-vf-fonts}"
SRC_URI[x86_64_v2_google-noto-sans-mono-cjk-vf-fonts.sha256sum] = "18b319d454963085f25e92528738a66d2c5ba0c291cb9b4e035f5f8dcfb07aa0"

URI_aarch64_google-noto-sans-cjk-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-noto-sans-cjk-vf-fonts-2.004-9.el10.noarch.rpm;name=aarch64_google-noto-sans-cjk-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-noto-sans-cjk-vf-fonts}"
SRC_URI[aarch64_google-noto-sans-cjk-vf-fonts.sha256sum] = "cd7bfa59806126fa6a4bede5c7eb2e19d6494dcbf4164cd64a2a9698c825b6f9"

URI_aarch64_google-noto-sans-mono-cjk-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-noto-sans-mono-cjk-vf-fonts-2.004-9.el10.noarch.rpm;name=aarch64_google-noto-sans-mono-cjk-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_google-noto-sans-mono-cjk-vf-fonts}"
SRC_URI[aarch64_google-noto-sans-mono-cjk-vf-fonts.sha256sum] = "18b319d454963085f25e92528738a66d2c5ba0c291cb9b4e035f5f8dcfb07aa0"

RDEPENDS:google-noto-sans-cjk-vf-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:google-noto-sans-mono-cjk-vf-fonts = " \
 fonts-filesystem \
 "
