# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdnssd"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kdnssd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdnssd-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b2d601bafb7a9bc9f661663f4717dad701c5054074f66ee18c527f360ddf46d"

URI_x86_64_v2_kdnssd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdnssd-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdnssd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdnssd}"
SRC_URI[x86_64_v2_kdnssd.sha256sum] = "48b332e00e9fd402227405750efa43918fc5464b0bb3ca1db265cf21ec53f008"

URI_aarch64_kdnssd = "${EPEL_MIRROR}/aarch64/Packages/k/kdnssd-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kdnssd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdnssd}"
SRC_URI[aarch64_kdnssd.sha256sum] = "59b3afaab8b9f5e9d401a1557d79e8bdc2f3ef740a1322ad032011cbab80a093"

RDEPENDS:kdnssd = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
