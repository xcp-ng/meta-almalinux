# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sm3"
PV = "0.4.2"
PR = "7.el10_3"
PACKAGES = " \
 rust-sm3+default-devel \
 rust-sm3+std-devel \
 rust-sm3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sm3-0.4.2-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "709944dbd2a30b7170d229389eae795816c2c1fe9570f3f528678e87b608ad11"

URI_x86_64_v2_rust-sm3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sm3+default-devel-0.4.2-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sm3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sm3+default-devel}"
SRC_URI[x86_64_v2_rust-sm3+default-devel.sha256sum] = "eca6fc4d232971b4eeb1c7df31189ed7ae6529851a31b574dcd4224cce2f45d2"

URI_x86_64_v2_rust-sm3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sm3+std-devel-0.4.2-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sm3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sm3+std-devel}"
SRC_URI[x86_64_v2_rust-sm3+std-devel.sha256sum] = "11beb4b078e55990e991db70df3378e598a08f07b88672acae7391ec44d188b0"

URI_x86_64_v2_rust-sm3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sm3-devel-0.4.2-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sm3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sm3-devel}"
SRC_URI[x86_64_v2_rust-sm3-devel.sha256sum] = "577e8fee2177f2f464c095b80bfd4b135be1b786895e86ad429f879f20175d0a"

URI_aarch64_rust-sm3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sm3+default-devel-0.4.2-7.el10_3.noarch.rpm;name=aarch64_rust-sm3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sm3+default-devel}"
SRC_URI[aarch64_rust-sm3+default-devel.sha256sum] = "55eb7dcc46f9f32c59b9fe3a75058752bcf3754ab72678f52dfb0f113d0d7318"

URI_aarch64_rust-sm3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sm3+std-devel-0.4.2-7.el10_3.noarch.rpm;name=aarch64_rust-sm3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sm3+std-devel}"
SRC_URI[aarch64_rust-sm3+std-devel.sha256sum] = "8d1560e6fc729a6a6ad5775a8b78697a1649a3df174e6d0b340ae6f6f999b833"

URI_aarch64_rust-sm3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sm3-devel-0.4.2-7.el10_3.noarch.rpm;name=aarch64_rust-sm3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sm3-devel}"
SRC_URI[aarch64_rust-sm3-devel.sha256sum] = "3bc4da710bed725d65244a6c8724081c2d46af14dd101553cf8abbb813e8d46f"

RDEPENDS:rust-sm3+default-devel = " \
 cargo \
 rust-sm3+std-devel \
 rust-sm3-devel \
 "
RDEPENDS:rust-sm3+std-devel = " \
 cargo \
 rust-digest0.10+std-devel \
 rust-sm3-devel \
 "
RDEPENDS:rust-sm3-devel = " \
 cargo \
 rust-digest0.10+default-devel \
 "
