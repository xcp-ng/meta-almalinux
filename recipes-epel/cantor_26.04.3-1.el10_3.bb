# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cantor"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 cantor \
 cantor-devel \
 cantor-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cantor-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "043068f24953ee068ea38148b87ece3e9339806ce6603ef337e1bdfffec56b13"

URI_x86_64_v2_cantor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cantor-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cantor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cantor}"
SRC_URI[x86_64_v2_cantor.sha256sum] = "f0f865f10a71a80d67cc104e56bc2a6e8bbcebd03e0c75ab4a36d903ac2d0481"

URI_x86_64_v2_cantor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cantor-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cantor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cantor-devel}"
SRC_URI[x86_64_v2_cantor-devel.sha256sum] = "83663283f42fb2e85606a4a1a8362f657e0995c8f99a6ed3f3bedefabd0ddeb3"

URI_x86_64_v2_cantor-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cantor-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cantor-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cantor-libs}"
SRC_URI[x86_64_v2_cantor-libs.sha256sum] = "b374a630efd264c0695361ee2fc5354d7bebf7d053263873b8156df958e2e345"

URI_aarch64_cantor = "${EPEL_MIRROR}/aarch64/Packages/c/cantor-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_cantor;unpack=0"
SRC_URI:append = " ${URI_aarch64_cantor}"
SRC_URI[aarch64_cantor.sha256sum] = "5ef2a3ffe3c0c1571ddc5958355e83467a27f40ae6da7f44d60740a7c7b9a921"

URI_aarch64_cantor-devel = "${EPEL_MIRROR}/aarch64/Packages/c/cantor-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_cantor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cantor-devel}"
SRC_URI[aarch64_cantor-devel.sha256sum] = "472565ca3607d7f35005f6498b90e2efc1d9fe318364d80546c65e41406e976a"

URI_aarch64_cantor-libs = "${EPEL_MIRROR}/aarch64/Packages/c/cantor-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_cantor-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cantor-libs}"
SRC_URI[aarch64_cantor-libs.sha256sum] = "a5193ebe95167bf1653bcdc8d3f9002c1c410ffe522536560917197443308760"

RDEPENDS:cantor = " \
 cantor-libs \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libgcc \
 libstdc++ \
 python3-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:cantor-devel = " \
 cantor-libs \
 cmake-filesystem \
 "
RDEPENDS:cantor-libs = " \
 analitza \
 cantor \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knewstuff \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libgcc \
 libqalculate \
 libspectre \
 libstdc++ \
 libxml2 \
 libxslt \
 luajit \
 poppler-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 qt6-qttools-libs-help \
 qt6-qtwebengine \
 "
