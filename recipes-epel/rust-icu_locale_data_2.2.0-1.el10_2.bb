# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_locale_data"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_locale_data+default-devel \
 rust-icu_locale_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_locale_data-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1a20875e63ceab55c5afff42a1929f345a901707a9ed39c5f3250f0657c10d82"

URI_x86_64_v2_rust-icu_locale_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_data+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_data+default-devel.sha256sum] = "a9129b45b8c322be238dfeb4daf1d54347e537e34c9ae0404d66bfeaa15202ee"

URI_x86_64_v2_rust-icu_locale_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_locale_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_locale_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_locale_data-devel}"
SRC_URI[x86_64_v2_rust-icu_locale_data-devel.sha256sum] = "768f32026bc45d94af85faadd0c99db0ed21602c2444a0477d6debc3e2d3e65f"

URI_aarch64_rust-icu_locale_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_data+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_data+default-devel}"
SRC_URI[aarch64_rust-icu_locale_data+default-devel.sha256sum] = "c2055dc5ad07255f1cde154ab7f20e2ded2d5f8fd2cd384f38c3cae4e47e15c2"

URI_aarch64_rust-icu_locale_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_locale_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_locale_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_locale_data-devel}"
SRC_URI[aarch64_rust-icu_locale_data-devel.sha256sum] = "4fa6045a8b7554075237fe8f4b046aa1b4afaab30424a77d94f3d9dc614626a8"

RDEPENDS:rust-icu_locale_data+default-devel = " \
 cargo \
 rust-icu_locale_data-devel \
 "
RDEPENDS:rust-icu_locale_data-devel = " \
 cargo \
 rust \
 "
