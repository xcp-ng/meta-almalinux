# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nextcloud"
PV = "34.0.4"
PR = "1.el10_2"
PACKAGES = " \
 nextcloud \
 nextcloud-httpd \
 nextcloud-mysql \
 nextcloud-nginx \
 nextcloud-postgresql \
 nextcloud-sqlite \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nextcloud-34.0.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0093dfd1f01bcfb95e74ede5c6162dad1fbd1e3e1a381b9441b34c6ddf33faef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-34.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud;unpack=0"
SRC_URI[x86_64_v2_nextcloud.sha256sum] = "b9ab035474b4c74fa9fd0a06ffad78b90167ff4df35a5e4d36ec053b775faac4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-httpd-34.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-httpd;unpack=0"
SRC_URI[x86_64_v2_nextcloud-httpd.sha256sum] = "7d14f6257bb36c911aeffb32462c6f68a67b296b04e1442dbf14b17f632a7cc4"
RPROVIDES:nextcloud-httpd:append:x86_64_v2 = " virtual/nextcloud-webserver_eq_34.0.4-1.el10_2.alma_altarch"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-mysql-34.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-mysql;unpack=0"
SRC_URI[x86_64_v2_nextcloud-mysql.sha256sum] = "eb14ecd30b1bd6fe004981025a3d4c0246a0fd9e982e8337e79888f6fb03cdae"
RPROVIDES:nextcloud-mysql:append:x86_64_v2 = " virtual/nextcloud-database_eq_34.0.4-1.el10_2.alma_altarch"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-nginx-34.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-nginx;unpack=0"
SRC_URI[x86_64_v2_nextcloud-nginx.sha256sum] = "77c2eefae2909bc392a924276470ebd4c0c7874dae62760bd3c0aa38f4393697"
RPROVIDES:nextcloud-nginx:append:x86_64_v2 = " virtual/nextcloud-webserver_eq_34.0.4-1.el10_2.alma_altarch"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-postgresql-34.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-postgresql;unpack=0"
SRC_URI[x86_64_v2_nextcloud-postgresql.sha256sum] = "82b6deb8f68d4e4f28296f421035a8a9046f6c714a878d55f8e7b81787e253d6"
RPROVIDES:nextcloud-postgresql:append:x86_64_v2 = " virtual/nextcloud-database_eq_34.0.4-1.el10_2.alma_altarch"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-sqlite-34.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-sqlite;unpack=0"
SRC_URI[x86_64_v2_nextcloud-sqlite.sha256sum] = "50731ea3d8ec4dfea156b10e0880fa76dc11232f9173f1582ef0c81e0c0601c7"
RPROVIDES:nextcloud-sqlite:append:x86_64_v2 = " virtual/nextcloud-database_eq_34.0.4-1.el10_2.alma_altarch"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-34.0.4-1.el10_2.noarch.rpm;name=aarch64_nextcloud;unpack=0"
SRC_URI[aarch64_nextcloud.sha256sum] = "ad74e1e7a4720a0c0670c10e033700beecbbe747b0c649eef8a980db0902f5b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-httpd-34.0.4-1.el10_2.noarch.rpm;name=aarch64_nextcloud-httpd;unpack=0"
SRC_URI[aarch64_nextcloud-httpd.sha256sum] = "0f1c7ccf872f33157ef671261ad135b70c013f16a96625206f720bab52482da3"
RPROVIDES:nextcloud-httpd:append:aarch64 = " virtual/nextcloud-webserver_eq_34.0.4-1.el10_2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-mysql-34.0.4-1.el10_2.noarch.rpm;name=aarch64_nextcloud-mysql;unpack=0"
SRC_URI[aarch64_nextcloud-mysql.sha256sum] = "8701012a579f9988213dfb4b3e69736f1b3c87a9343fe4339429f0b287d5b3c0"
RPROVIDES:nextcloud-mysql:append:aarch64 = " virtual/nextcloud-database_eq_34.0.4-1.el10_2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-nginx-34.0.4-1.el10_2.noarch.rpm;name=aarch64_nextcloud-nginx;unpack=0"
SRC_URI[aarch64_nextcloud-nginx.sha256sum] = "c4a13536c75b0cf06e20ba2ecd4c305ca0f31eb083af95ee40bf330abf8a23e8"
RPROVIDES:nextcloud-nginx:append:aarch64 = " virtual/nextcloud-webserver_eq_34.0.4-1.el10_2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-postgresql-34.0.4-1.el10_2.noarch.rpm;name=aarch64_nextcloud-postgresql;unpack=0"
SRC_URI[aarch64_nextcloud-postgresql.sha256sum] = "f160d45202bbf4a8a05e0deffbc235848aa28f29b2a3e8db7441b70737636bbf"
RPROVIDES:nextcloud-postgresql:append:aarch64 = " virtual/nextcloud-database_eq_34.0.4-1.el10_2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-sqlite-34.0.4-1.el10_2.noarch.rpm;name=aarch64_nextcloud-sqlite;unpack=0"
SRC_URI[aarch64_nextcloud-sqlite.sha256sum] = "6ba793690a299f13015ce5637bea895a9e344de5594b0b9aab37ccf1ee1535e4"
RPROVIDES:nextcloud-sqlite:append:aarch64 = " virtual/nextcloud-database_eq_34.0.4-1.el10_2"

RDEPENDS:nextcloud:x86_64_v2 = " \
 bash \
 ca-certificates \
 php-pecl-imagick \
 php-pecl-memcached \
 php-smbclient \
 systemd \
 virtual//usr/bin/php \
 virtual/nextcloud-database_eq_34.0.4-1.el10_2.alma_altarch \
 virtual/nextcloud-webserver_eq_34.0.4-1.el10_2.alma_altarch \
 virtual/php-bcmath \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gmp \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-opcache \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-pecl-apcu \
 virtual/php-pecl-redis6_or_php-pecl-redis5 \
 virtual/php-process \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-spl \
 virtual/php-xmlwriter \
 virtual/php-zip \
"
RDEPENDS:nextcloud:aarch64 = " \
 bash \
 ca-certificates \
 php-pecl-imagick \
 php-pecl-memcached \
 php-smbclient \
 systemd \
 virtual//usr/bin/php \
 virtual/nextcloud-database_eq_34.0.4-1.el10_2 \
 virtual/nextcloud-webserver_eq_34.0.4-1.el10_2 \
 virtual/php-bcmath \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gmp \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-opcache \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-pecl-apcu \
 virtual/php-pecl-redis6_or_php-pecl-redis5 \
 virtual/php-process \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-spl \
 virtual/php-xmlwriter \
 virtual/php-zip \
"
RDEPENDS:nextcloud-httpd = " \
 bash \
 httpd \
 nextcloud \
 virtual/php-fpm \
 "
RDEPENDS:nextcloud-mysql = " \
 nextcloud \
 virtual/php-mysqlnd \
 "
RDEPENDS:nextcloud-nginx = " \
 bash \
 nextcloud \
 nginx \
 virtual/php-fpm \
 "
RDEPENDS:nextcloud-postgresql = " \
 nextcloud \
 virtual/php-pgsql \
 "
RDEPENDS:nextcloud-sqlite = " \
 nextcloud \
 "
