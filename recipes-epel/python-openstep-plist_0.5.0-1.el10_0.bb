# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstep-plist"
PV = "0.5.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-openstep-plist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openstep-plist-0.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06029f7fb383de2923b394bc7d153b0a4cdec8f46e370db3cd0221f9f46d197a"

URI_x86_64_v2_python3-openstep-plist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstep-plist-0.5.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-openstep-plist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstep-plist}"
SRC_URI[x86_64_v2_python3-openstep-plist.sha256sum] = "f73bd36854ff9872010ae27e40b723f0aa922bdcb3b1b88f72b139f050b3615b"

URI_aarch64_python3-openstep-plist = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstep-plist-0.5.0-1.el10_0.aarch64.rpm;name=aarch64_python3-openstep-plist;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstep-plist}"
SRC_URI[aarch64_python3-openstep-plist.sha256sum] = "3e0f48b7745283e20095cde669f0dcff072e60862f622bc121e2eeef901db409"

RDEPENDS:python3-openstep-plist = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
