# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpl"
PE = "1"
PV = "2.16.0"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 libvpl \
 libvpl-devel \
 libvpl-samples \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libvpl-2.16.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "32fea3f8cb245436aaee5ee0d42b6ea6269959f0e8de2e700817e249d1c2e5f4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-2.16.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl;unpack=0"
SRC_URI[x86_64_v2_libvpl.sha256sum] = "49623835cc2e8e3301b54b92726e9a77c1f402a2a21726f758fc16a3dfabb046"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-devel-2.16.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-devel;unpack=0"
SRC_URI[x86_64_v2_libvpl-devel.sha256sum] = "d57eab1ada636910a6b33d2736397aa76d740aee3982bbd40049d3b188850d34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvpl-samples-2.16.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvpl-samples;unpack=0"
SRC_URI[x86_64_v2_libvpl-samples.sha256sum] = "a9de6ca425187a610b232abdde0e6dc8836aaf718259c2fde09dbc3369a6d07c"

RDEPENDS:libvpl = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libvpl-devel = " \
 cmake-filesystem \
 libvpl \
 pkgconf-pkg-config \
 "
RDEPENDS:libvpl-samples = " \
 libvpl-devel \
 "
