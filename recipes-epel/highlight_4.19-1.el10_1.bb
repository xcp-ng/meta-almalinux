# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "highlight"
PV = "4.19"
PR = "1.el10_1"
PACKAGES = " \
 highlight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/highlight-4.19-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9a64aa67a330fbc40b87657ce5b858e1bba27b852d84c0ec5ac56a314533344"

URI_x86_64_v2_highlight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/highlight-4.19-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_highlight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_highlight}"
SRC_URI[x86_64_v2_highlight.sha256sum] = "b23ae48deea0db513b5bbe087d6156ce75595d481bcfdd5ed534e88ee2aa0c21"

URI_aarch64_highlight = "${EPEL_MIRROR}/aarch64/Packages/h/highlight-4.19-1.el10_1.aarch64.rpm;name=aarch64_highlight;unpack=0"
SRC_URI:append = " ${URI_aarch64_highlight}"
SRC_URI[aarch64_highlight.sha256sum] = "a527c4a433a47a3ba351f9ad2a0bbe1be8822bdfe1229721ed59cd596413be10"

RDEPENDS:highlight = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 lua-libs \
 "
