# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nano"
PV = "8.1"
PR = "3.el10"
PACKAGES = " \
 nano \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nano-8.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36930f887460adf2d85853b27d107eb1753804d08d05812389da4ba603f66cbc"

URI_x86_64_v2_nano = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nano-8.1-3.el10.x86_64_v2.rpm;name=x86_64_v2_nano;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nano}"
SRC_URI[x86_64_v2_nano.sha256sum] = "9d88f7c8c63102e1608303ebda4f824fff0a01cb877bb937840082c1e7763d93"

URI_aarch64_nano = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nano-8.1-3.el10.aarch64.rpm;name=aarch64_nano;unpack=0"
SRC_URI:append = " ${URI_aarch64_nano}"
SRC_URI[aarch64_nano.sha256sum] = "3c4d2328a3cbdc1f7856ffb749486f78028d7b3309627a64b64e91cdb61109c3"

RDEPENDS:nano = " \
 file-libs \
 glibc \
 ncurses-libs \
 "
