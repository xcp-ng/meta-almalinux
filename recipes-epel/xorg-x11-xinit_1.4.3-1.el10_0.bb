# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-xinit"
PV = "1.4.3"
PR = "1.el10_0"
PACKAGES = " \
 xorg-x11-xinit \
 xorg-x11-xinit-session \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xorg-x11-xinit-1.4.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8753c61a68e1f29444e064643dada0dc08b6732b3821d42de8000735227a37e"

URI_x86_64_v2_xorg-x11-xinit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xorg-x11-xinit-1.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-xinit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-xinit}"
SRC_URI[x86_64_v2_xorg-x11-xinit.sha256sum] = "fe17be751e4f707db931bd182816ba9988a2ff8df05e385d241bf48eb7240e06"

URI_x86_64_v2_xorg-x11-xinit-session = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xorg-x11-xinit-session-1.4.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-xinit-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-xinit-session}"
SRC_URI[x86_64_v2_xorg-x11-xinit-session.sha256sum] = "88721f12ab79054ad5fde355a14e45c9d7f87ec2a980cd061aa691dc9dfce0f2"

URI_aarch64_xorg-x11-xinit = "${EPEL_MIRROR}/aarch64/Packages/x/xorg-x11-xinit-1.4.3-1.el10_0.aarch64.rpm;name=aarch64_xorg-x11-xinit;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-xinit}"
SRC_URI[aarch64_xorg-x11-xinit.sha256sum] = "7814b48c7052a30cbdaa4000b952472edcc017ed38c434dfb4ddb8f97950154d"

URI_aarch64_xorg-x11-xinit-session = "${EPEL_MIRROR}/aarch64/Packages/x/xorg-x11-xinit-session-1.4.3-1.el10_0.aarch64.rpm;name=aarch64_xorg-x11-xinit-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-xinit-session}"
SRC_URI[aarch64_xorg-x11-xinit-session.sha256sum] = "a5c3ca292c9d85fcddcb7c04e5c7ebf040bb030d7e58e3b24a0725cdc8abe1f1"

RDEPENDS:xorg-x11-xinit = " \
 bash \
 glibc \
 libX11 \
 setxkbmap \
 virtual/coreutils \
 xhost \
 xmodmap \
 xorg-x11-xauth \
 xrdb \
 "
RDEPENDS:xorg-x11-xinit-session = " \
 bash \
 "
