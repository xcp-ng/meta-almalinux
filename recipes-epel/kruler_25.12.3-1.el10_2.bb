# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kruler"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kruler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kruler-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cff24f0d246020db0988af179689be9133d092e5f92e75b7f6602baba064c922"

URI_x86_64_v2_kruler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kruler-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kruler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kruler}"
SRC_URI[x86_64_v2_kruler.sha256sum] = "989b15dfe02ace3c05d6c5e913c4474927f6ff9d7ca438402805d20e78684eca"

URI_aarch64_kruler = "${EPEL_MIRROR}/aarch64/Packages/k/kruler-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kruler;unpack=0"
SRC_URI:append = " ${URI_aarch64_kruler}"
SRC_URI[aarch64_kruler.sha256sum] = "b8cdb57246f5c154a449ad1eeb1048e075197dbff1eade13ef707da555c29c0b"

RDEPENDS:kruler = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
