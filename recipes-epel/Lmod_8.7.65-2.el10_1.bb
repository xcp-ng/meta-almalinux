# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "Lmod"
PV = "8.7.65"
PR = "2.el10_1"
PACKAGES = " \
 Lmod \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/Lmod-8.7.65-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "064884d62bb98eeb060369c99ef471304cb7061813fb93746970537097053c98"

URI_x86_64_v2_Lmod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/Lmod-8.7.65-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_Lmod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_Lmod}"
SRC_URI[x86_64_v2_Lmod.sha256sum] = "593560832e3a430e83846f69333569618fa0a9ed9214b1f82f30a7c7869c7ecf"
RPROVIDES:Lmod:x86_64_v2 = "virtual/environment_modules_"

URI_aarch64_Lmod = "${EPEL_MIRROR}/aarch64/Packages/l/Lmod-8.7.65-2.el10_1.aarch64.rpm;name=aarch64_Lmod;unpack=0"
SRC_URI:append = " ${URI_aarch64_Lmod}"
SRC_URI[aarch64_Lmod.sha256sum] = "d05ce50ceb32258059fca5f5a6838599fb547b7299941eb8f33122513f9dd998"
RPROVIDES:Lmod:aarch64 = "virtual/environment_modules_"

RDEPENDS:Lmod = " \
 alternatives \
 bash \
 glibc \
 lua-filesystem \
 lua-json \
 lua-posix \
 lua-term \
 procps-ng \
 tcl \
 virtual/coreutils \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/environment_modules_"

PROVIDES:append:aarch64 = " rpm/virtual/environment_modules_"
