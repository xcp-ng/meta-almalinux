# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-signal"
PV = "0.2.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-signal+default-devel \
 rust-async-signal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-signal-0.2.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edea34451058d0ca71c40c488e64a420eeca9231f4ae2a97c7644b48bd37a45e"

URI_x86_64_v2_rust-async-signal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-signal+default-devel-0.2.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-signal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-signal+default-devel}"
SRC_URI[x86_64_v2_rust-async-signal+default-devel.sha256sum] = "09492d0638ad36081f70a4f33ad4e3972e6e350a6b073d6bb4e1952d998a3937"

URI_x86_64_v2_rust-async-signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-signal-devel-0.2.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-signal-devel}"
SRC_URI[x86_64_v2_rust-async-signal-devel.sha256sum] = "122104dc31b03e7b6c4bcf02e6238851fa03ad3833c00592ad2486ec5879e9c6"

URI_aarch64_rust-async-signal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-signal+default-devel-0.2.10-1.el10_0.noarch.rpm;name=aarch64_rust-async-signal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-signal+default-devel}"
SRC_URI[aarch64_rust-async-signal+default-devel.sha256sum] = "6ebc76a76fc652781fab55f4f0d7c632c6eb9da6ab20f99e84c11eaa85a99a08"

URI_aarch64_rust-async-signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-signal-devel-0.2.10-1.el10_0.noarch.rpm;name=aarch64_rust-async-signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-signal-devel}"
SRC_URI[aarch64_rust-async-signal-devel.sha256sum] = "11f5199a6a8e82bcf4f417e9f2c87e9900fa4e3d18828e4d7c13c469966f05f8"

RDEPENDS:rust-async-signal+default-devel = " \
 cargo \
 rust-async-signal-devel \
 "
RDEPENDS:rust-async-signal-devel = " \
 cargo \
 rust \
 rust-async-io+default-devel \
 rust-cfg-if+default-devel \
 rust-futures-core+default-devel \
 rust-futures-io+default-devel \
 rust-rustix+process-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-signal-hook-registry+default-devel \
 "
