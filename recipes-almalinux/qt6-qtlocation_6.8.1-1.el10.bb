# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtlocation"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtlocation \
 qt6-qtlocation-devel \
 qt6-qtlocation-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtlocation-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d1b8777b5fd71f3f56dc4e5b5f9fe00ff6aa5698190b3c5565fdd763c3a3f98"

URI_x86_64_v2_qt6-qtlocation = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlocation-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlocation;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlocation}"
SRC_URI[x86_64_v2_qt6-qtlocation.sha256sum] = "5327125f332aa0b1f624606c232cf8064d92f10345713f1b6fea224b5be6730d"

URI_x86_64_v2_qt6-qtlocation-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtlocation-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlocation-devel}"
SRC_URI[x86_64_v2_qt6-qtlocation-devel.sha256sum] = "d3c9b69c5df8486c965cc4d919108ae2c1dce39fdb9b67a0cc19fa01cccf9b9f"

URI_x86_64_v2_qt6-qtlocation-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtlocation-examples-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtlocation-examples}"
SRC_URI[x86_64_v2_qt6-qtlocation-examples.sha256sum] = "4f919d7a8cc27d3ff02d0c1f1ece324ef6e05fc95b414f5b002bb75a02de2005"

URI_aarch64_qt6-qtlocation = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlocation-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlocation;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlocation}"
SRC_URI[aarch64_qt6-qtlocation.sha256sum] = "7f3adfec3dbbfabf7b579b1da0cdcc279e0b0767cce5b53abadd97f0d801c805"

URI_aarch64_qt6-qtlocation-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtlocation-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlocation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlocation-devel}"
SRC_URI[aarch64_qt6-qtlocation-devel.sha256sum] = "c7f343781ed6b3638134d6b2e5afe6913974a5515270899f3e3cd41a0c188d35"

URI_aarch64_qt6-qtlocation-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtlocation-examples-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtlocation-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtlocation-examples}"
SRC_URI[aarch64_qt6-qtlocation-examples.sha256sum] = "4974f3136dbd212a6aaeacc5ff10be7c97023f61b561a399fd00f5c324b8f848"

RDEPENDS:qt6-qtlocation = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 "
RDEPENDS:qt6-qtlocation-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtlocation \
 qt6-qtpositioning-devel \
 "
RDEPENDS:qt6-qtlocation-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtlocation \
 qt6-qtpositioning \
 "
