# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grantleetheme"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 grantleetheme \
 grantleetheme-devel \
 grantleetheme-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grantleetheme-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdd4608ac9150edbcaab402d9145e4f4800f69e30e3d09b1039159c828bbefa9"

URI_x86_64_v2_grantleetheme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme}"
SRC_URI[x86_64_v2_grantleetheme.sha256sum] = "2c7fb80e0fcd3e7104c10798f19e843a2795d394e7a0f9cd89f32bf5f21ed70f"

URI_x86_64_v2_grantleetheme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grantleetheme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme-devel}"
SRC_URI[x86_64_v2_grantleetheme-devel.sha256sum] = "8624f0e51fe78db543292d6eea5925d0de5e0c82b5dee7f528d0e01212ad4dad"

URI_x86_64_v2_grantleetheme-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grantleetheme-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_grantleetheme-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grantleetheme-doc}"
SRC_URI[x86_64_v2_grantleetheme-doc.sha256sum] = "022bd96caa345dcaf5a207111e9371487fa0851c3ac002202312591631391d6a"

URI_aarch64_grantleetheme = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_grantleetheme;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme}"
SRC_URI[aarch64_grantleetheme.sha256sum] = "db22bfa67a6b188af3cee5715e1a6fd0435288dcd164ca49ac08ba15c3dc8351"

URI_aarch64_grantleetheme-devel = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_grantleetheme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme-devel}"
SRC_URI[aarch64_grantleetheme-devel.sha256sum] = "31c6db6f15cf99179f295fa8cde2cb5656603a9f4215926d45df0e9d2d0d8556"

URI_aarch64_grantleetheme-doc = "${EPEL_MIRROR}/aarch64/Packages/g/grantleetheme-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_grantleetheme-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_grantleetheme-doc}"
SRC_URI[aarch64_grantleetheme-doc.sha256sum] = "a6fb33e0c106c088e9780e7ebf24dd62bbab8dbead241fbd33639154960c233e"

RDEPENDS:grantleetheme = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knewstuff \
 kf6-ktexttemplate \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:grantleetheme-devel = " \
 cmake-filesystem \
 grantleetheme \
 kf6-ktexttemplate-devel \
 "
RDEPENDS:grantleetheme-doc = " \
 "
