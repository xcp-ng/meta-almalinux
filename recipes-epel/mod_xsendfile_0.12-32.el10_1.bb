# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_xsendfile"
PV = "0.12"
PR = "32.el10_1"
PACKAGES = " \
 mod_xsendfile \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mod_xsendfile-0.12-32.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a3fd26090a2df1249d3d0d39eafbc2c8b65f61b6bb13f52b2b5ab44a0bfe0fc"

URI_x86_64_v2_mod_xsendfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mod_xsendfile-0.12-32.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mod_xsendfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_xsendfile}"
SRC_URI[x86_64_v2_mod_xsendfile.sha256sum] = "cc234e27d3619127f033f600b61b416495125a198e94746409e4e2b7b655f833"

URI_aarch64_mod_xsendfile = "${EPEL_MIRROR}/aarch64/Packages/m/mod_xsendfile-0.12-32.el10_1.aarch64.rpm;name=aarch64_mod_xsendfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_xsendfile}"
SRC_URI[aarch64_mod_xsendfile.sha256sum] = "244cf16f88bea2e43b3f1238ee9ae9783a2f135e78475edc267d76a624b6d233"

RDEPENDS:mod_xsendfile = " \
 glibc \
 httpd-core \
 "
