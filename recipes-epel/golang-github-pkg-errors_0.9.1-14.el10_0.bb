# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pkg-errors"
PV = "0.9.1"
PR = "14.el10_0"
PACKAGES = " \
 golang-github-pkg-errors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pkg-errors-0.9.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "945172be0c1c5307feb9133d772e5452a201c9244ab79b4216d53668aedf7716"

URI_x86_64_v2_golang-github-pkg-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pkg-errors-devel-0.9.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pkg-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pkg-errors-devel}"
SRC_URI[x86_64_v2_golang-github-pkg-errors-devel.sha256sum] = "21ab06ef3ffede983719920851119e97bf728b26ee754ee53ca6d0a046b29e70"

URI_aarch64_golang-github-pkg-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pkg-errors-devel-0.9.1-14.el10_0.noarch.rpm;name=aarch64_golang-github-pkg-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pkg-errors-devel}"
SRC_URI[aarch64_golang-github-pkg-errors-devel.sha256sum] = "cdddec83d4820719e6a0534712d3919b3087bcfa956c1f4f3e3ada6ff6fa3d5f"

RDEPENDS:golang-github-pkg-errors-devel = " \
 go-filesystem \
 "
