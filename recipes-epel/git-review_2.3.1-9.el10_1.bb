# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-review"
PV = "2.3.1"
PR = "9.el10_1"
PACKAGES = " \
 git-review \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/git-review-2.3.1-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b29b184dc511c395de2bef9f75f504e3b4f574847e80e5446ffb263877836341"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-review-2.3.1-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_git-review;unpack=0"
SRC_URI[x86_64_v2_git-review.sha256sum] = "288e3b598be3229c0ff35afe157f8829a6ed2483616f6317571d795efa38fdad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/git-review-2.3.1-9.el10_1.noarch.rpm;name=aarch64_git-review;unpack=0"
SRC_URI[aarch64_git-review.sha256sum] = "f614fd246d68f79174bd94385d32630fc1d20447975bfe216db4a9d5eb35076e"

RDEPENDS:git-review = " \
 git-core \
 python3 \
 python3-requests \
 python3-setuptools \
 "
