# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bcc"
PV = "0.34.0"
PR = "2.el10"
PACKAGES = " \
 bcc \
 bcc-devel \
 bcc-doc \
 bcc-tools \
 libbpf-tools \
 python3-bcc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/bcc-0.34.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31502f3be45b0e23f195193fa626ee05cfa98c0faa0834f35eb1814397f745b3"

URI_x86_64_v2_bcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bcc-0.34.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_bcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc}"
SRC_URI[x86_64_v2_bcc.sha256sum] = "086b061e0c241e0aced3ca30e6ab9f27fc04f635e2a1628f9e873753015e331d"

URI_x86_64_v2_bcc-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bcc-devel-0.34.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_bcc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc-devel}"
SRC_URI[x86_64_v2_bcc-devel.sha256sum] = "b93322b613e3673edefcb8ee3b4cbd1f222049298d0b380d27d9f14893e76157"

URI_x86_64_v2_bcc-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/bcc-doc-0.34.0-2.el10.noarch.rpm;name=x86_64_v2_bcc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc-doc}"
SRC_URI[x86_64_v2_bcc-doc.sha256sum] = "99d704cd70b0e4ef7c9305494603b6d9e263344615a1a87793ff684fc9762e6a"

URI_x86_64_v2_bcc-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/bcc-tools-0.34.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_bcc-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bcc-tools}"
SRC_URI[x86_64_v2_bcc-tools.sha256sum] = "77eefbcacb735f3805f8c6f50bfea27b4bdeef44dc68e89fa81cb29749e48b9b"

URI_x86_64_v2_libbpf-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libbpf-tools-0.34.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libbpf-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbpf-tools}"
SRC_URI[x86_64_v2_libbpf-tools.sha256sum] = "007022f24f632c9e401a21a67bfaa09a9f8d45557669b7eb7f42123841e061b9"

URI_x86_64_v2_python3-bcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-bcc-0.34.0-2.el10.noarch.rpm;name=x86_64_v2_python3-bcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bcc}"
SRC_URI[x86_64_v2_python3-bcc.sha256sum] = "e1d07d00da3dfcda947a879cc37a4ea9c3d9800e25113ed68139738caa031013"

URI_aarch64_bcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bcc-0.34.0-2.el10.aarch64.rpm;name=aarch64_bcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc}"
SRC_URI[aarch64_bcc.sha256sum] = "62a4c5c2ac4f3c152961bfe86f38dfbc8233eba219d84b9cd719cf80cfaff120"

URI_aarch64_bcc-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bcc-devel-0.34.0-2.el10.aarch64.rpm;name=aarch64_bcc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc-devel}"
SRC_URI[aarch64_bcc-devel.sha256sum] = "f1d4874435e25639b817e89ad1cdcfeb51c7835a35f0e5a188ec162f893886af"

URI_aarch64_bcc-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/bcc-doc-0.34.0-2.el10.noarch.rpm;name=aarch64_bcc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc-doc}"
SRC_URI[aarch64_bcc-doc.sha256sum] = "99d704cd70b0e4ef7c9305494603b6d9e263344615a1a87793ff684fc9762e6a"

URI_aarch64_bcc-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/bcc-tools-0.34.0-2.el10.aarch64.rpm;name=aarch64_bcc-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_bcc-tools}"
SRC_URI[aarch64_bcc-tools.sha256sum] = "b837c888313a4bf90137746a23142fafafac3a91b4f6d1767671a162af1629e4"

URI_aarch64_libbpf-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libbpf-tools-0.34.0-2.el10.aarch64.rpm;name=aarch64_libbpf-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbpf-tools}"
SRC_URI[aarch64_libbpf-tools.sha256sum] = "eedcf9ccfca7513ff95e9c9deb55c48b61f83348b8715d09537eac6bd60d62e0"

URI_aarch64_python3-bcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-bcc-0.34.0-2.el10.noarch.rpm;name=aarch64_python3-bcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bcc}"
SRC_URI[aarch64_python3-bcc.sha256sum] = "e1d07d00da3dfcda947a879cc37a4ea9c3d9800e25113ed68139738caa031013"

RDEPENDS:bcc = " \
 clang-libs \
 elfutils-debuginfod-client \
 elfutils-libelf \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 llvm-libs \
 tar \
 xz-libs \
 "
RDEPENDS:bcc-devel = " \
 bcc \
 pkgconf-pkg-config \
 "
RDEPENDS:bcc-doc = " \
 "
RDEPENDS:bcc-tools = " \
 bash \
 bcc \
 glibc \
 libbpf \
 python3 \
 python3-bcc \
 python3-netaddr \
 "
RDEPENDS:libbpf-tools = " \
 elfutils-libelf \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:python3-bcc = " \
 bcc \
 python3 \
 "
