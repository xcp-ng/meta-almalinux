# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dialoguer"
PV = "0.11.0"
PR = "6.el10_1"
PACKAGES = " \
 rust-dialoguer+completion-devel \
 rust-dialoguer+default-devel \
 rust-dialoguer+editor-devel \
 rust-dialoguer+fuzzy-matcher-devel \
 rust-dialoguer+fuzzy-select-devel \
 rust-dialoguer+history-devel \
 rust-dialoguer+password-devel \
 rust-dialoguer+tempfile-devel \
 rust-dialoguer+zeroize-devel \
 rust-dialoguer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dialoguer-0.11.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cfc2c61b09b584c8a8621e981b63e49ad1cdac28b8b3b964c85224e9b96c2d5"

URI_x86_64_v2_rust-dialoguer+completion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+completion-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+completion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+completion-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+completion-devel.sha256sum] = "e8bea910870629c4d4dfd439dce424081e11bbe75794d1e000b0787842d83e57"

URI_x86_64_v2_rust-dialoguer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+default-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+default-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+default-devel.sha256sum] = "2a410231f0f579ee2a950425a9f813437761645d68fcf14d69087df386d20030"

URI_x86_64_v2_rust-dialoguer+editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+editor-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+editor-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+editor-devel.sha256sum] = "00660cbb045fce7ada661a3774cac92791e2d40fc9e59b92c5c4b66975e7b8ea"

URI_x86_64_v2_rust-dialoguer+fuzzy-matcher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+fuzzy-matcher-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+fuzzy-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+fuzzy-matcher-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+fuzzy-matcher-devel.sha256sum] = "65040c8850299ae33265176004e0169d4abeb62192139357e67b259fffe1d309"

URI_x86_64_v2_rust-dialoguer+fuzzy-select-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+fuzzy-select-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+fuzzy-select-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+fuzzy-select-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+fuzzy-select-devel.sha256sum] = "54da5b2188c6f8ca0f06edfba9257fa886a3a46779ae28b7e8761936ef7e6916"

URI_x86_64_v2_rust-dialoguer+history-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+history-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+history-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+history-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+history-devel.sha256sum] = "b457cba29c8afac8d0e1c5200765acc85140d9c4b57cfcff8a3285c2a0b3ccd9"

URI_x86_64_v2_rust-dialoguer+password-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+password-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+password-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+password-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+password-devel.sha256sum] = "bf5e4999cd06cc2ded4d651b792ab90d73411d5417b7e1f60db2871b41d02ad2"

URI_x86_64_v2_rust-dialoguer+tempfile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+tempfile-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+tempfile-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+tempfile-devel.sha256sum] = "96b9eb37ade7b1f6bb2cdb179bf4bbc89595027ec40c3557f96d6132022c80a9"

URI_x86_64_v2_rust-dialoguer+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer+zeroize-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer+zeroize-devel}"
SRC_URI[x86_64_v2_rust-dialoguer+zeroize-devel.sha256sum] = "524c1dfeb7d1ff5d7d1664f842331ab5e0cd0c1dde6eeab4477d639d7282cf23"

URI_x86_64_v2_rust-dialoguer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dialoguer-devel-0.11.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dialoguer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dialoguer-devel}"
SRC_URI[x86_64_v2_rust-dialoguer-devel.sha256sum] = "55b47ac458eb99437671d0e476087d6a963b1a940a70496f91b9d8164c107d25"

URI_aarch64_rust-dialoguer+completion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+completion-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer+completion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+completion-devel}"
SRC_URI[aarch64_rust-dialoguer+completion-devel.sha256sum] = "cfcaa7c01f0c60d9f2fb6ef34179046e73063acf20141cc8a2af86c772373394"

URI_aarch64_rust-dialoguer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+default-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+default-devel}"
SRC_URI[aarch64_rust-dialoguer+default-devel.sha256sum] = "9b25831b1f4e0f17e809648d18d9d94950d8039193df2975e44305935f90fa0e"

URI_aarch64_rust-dialoguer+editor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+editor-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer+editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+editor-devel}"
SRC_URI[aarch64_rust-dialoguer+editor-devel.sha256sum] = "15517ecbf6dbf49979cb5f1f9032677a42382c6773972342660d740846081b3e"

URI_aarch64_rust-dialoguer+fuzzy-matcher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+fuzzy-matcher-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer+fuzzy-matcher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+fuzzy-matcher-devel}"
SRC_URI[aarch64_rust-dialoguer+fuzzy-matcher-devel.sha256sum] = "210013ac29175715dc41715b48187e483934725a5668981934b0a5c603a316ec"

URI_aarch64_rust-dialoguer+fuzzy-select-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+fuzzy-select-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer+fuzzy-select-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+fuzzy-select-devel}"
SRC_URI[aarch64_rust-dialoguer+fuzzy-select-devel.sha256sum] = "ccf0bc22a41dbe8490f5894fff42bd8c6ddf58e7fa2c8b2cf41d0550806a6d73"

URI_aarch64_rust-dialoguer+history-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+history-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer+history-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+history-devel}"
SRC_URI[aarch64_rust-dialoguer+history-devel.sha256sum] = "34e3b8a223cd3dd18a09bfcd88138f488bdb9592b0d58b55e866ffd0f7bcf9e4"

URI_aarch64_rust-dialoguer+password-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+password-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer+password-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+password-devel}"
SRC_URI[aarch64_rust-dialoguer+password-devel.sha256sum] = "5e1a07395303d83384e0cb9750e00a4663d120d4e81834e331ddff9d09f015c6"

URI_aarch64_rust-dialoguer+tempfile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+tempfile-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer+tempfile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+tempfile-devel}"
SRC_URI[aarch64_rust-dialoguer+tempfile-devel.sha256sum] = "235564ad3c7b201f426ce48960851099e51ef2908e999a5a6af08f2639db835b"

URI_aarch64_rust-dialoguer+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer+zeroize-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer+zeroize-devel}"
SRC_URI[aarch64_rust-dialoguer+zeroize-devel.sha256sum] = "03c49d345399f8d948277365e9b0be0138e3e45c3403ea0981ef23fd09c321e7"

URI_aarch64_rust-dialoguer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dialoguer-devel-0.11.0-6.el10_1.noarch.rpm;name=aarch64_rust-dialoguer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dialoguer-devel}"
SRC_URI[aarch64_rust-dialoguer-devel.sha256sum] = "7f93112089ccdae597562273141e6f278803ebbf5eba55c23c9499d51d5a1d30"

RDEPENDS:rust-dialoguer+completion-devel = " \
 cargo \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+default-devel = " \
 cargo \
 rust-dialoguer+editor-devel \
 rust-dialoguer+password-devel \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+editor-devel = " \
 cargo \
 rust-dialoguer+tempfile-devel \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+fuzzy-matcher-devel = " \
 cargo \
 rust-dialoguer-devel \
 rust-fuzzy-matcher+default-devel \
 "
RDEPENDS:rust-dialoguer+fuzzy-select-devel = " \
 cargo \
 rust-dialoguer+fuzzy-matcher-devel \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+history-devel = " \
 cargo \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+password-devel = " \
 cargo \
 rust-dialoguer+zeroize-devel \
 rust-dialoguer-devel \
 "
RDEPENDS:rust-dialoguer+tempfile-devel = " \
 cargo \
 rust-dialoguer-devel \
 rust-tempfile+default-devel \
 "
RDEPENDS:rust-dialoguer+zeroize-devel = " \
 cargo \
 rust-dialoguer-devel \
 rust-zeroize+default-devel \
 "
RDEPENDS:rust-dialoguer-devel = " \
 cargo \
 rust \
 rust-console+default-devel \
 rust-shell-words+default-devel \
 rust-thiserror1+default-devel \
 "
