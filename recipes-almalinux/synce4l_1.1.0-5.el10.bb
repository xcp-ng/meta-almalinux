# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "synce4l"
PV = "1.1.0"
PR = "5.el10"
PACKAGES = " \
 synce4l \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/synce4l-1.1.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2225733b8450121e809bf4d2d9988bdae0849838a02c962b69830cc0a57a12f8"

URI_x86_64_v2_synce4l = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/synce4l-1.1.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_synce4l;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_synce4l}"
SRC_URI[x86_64_v2_synce4l.sha256sum] = "216c09027acade9e973e776903ed1cab1b73ac73a7fa5bd1b9d809ca6ceddf4b"

URI_aarch64_synce4l = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/synce4l-1.1.0-5.el10.aarch64.rpm;name=aarch64_synce4l;unpack=0"
SRC_URI:append = " ${URI_aarch64_synce4l}"
SRC_URI[aarch64_synce4l.sha256sum] = "f57be74b783cfc507b1976359343232046d762f88d4b9dd282daf945308c9f22"

RDEPENDS:synce4l = " \
 bash \
 glibc \
 libnl3 \
 systemd \
 "
