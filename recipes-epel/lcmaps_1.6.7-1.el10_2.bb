# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lcmaps"
PV = "1.6.7"
PR = "1.el10_2"
PACKAGES = " \
 lcmaps \
 lcmaps-common-devel \
 lcmaps-devel \
 lcmaps-without-gsi \
 lcmaps-without-gsi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lcmaps-1.6.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78189f3ad2fb75760fcfdca33d4016a744dd2e56ddafda759836317576e88fd1"

URI_x86_64_v2_lcmaps = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-1.6.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps}"
SRC_URI[x86_64_v2_lcmaps.sha256sum] = "07f05b654ac97cd2ae9e0c41b0b8f4a746a6403921c17197a94aac50c33cbf2b"

URI_x86_64_v2_lcmaps-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-common-devel-1.6.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps-common-devel}"
SRC_URI[x86_64_v2_lcmaps-common-devel.sha256sum] = "8a815b669400a9cadb27c3edbb26f637c0c7e3f70d0ec91936a29a36605180c6"

URI_x86_64_v2_lcmaps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-devel-1.6.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps-devel}"
SRC_URI[x86_64_v2_lcmaps-devel.sha256sum] = "cd644539038661ecc57fc53355e6ac766b782de922185212828e43ee5adca0fb"

URI_x86_64_v2_lcmaps-without-gsi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-without-gsi-1.6.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps-without-gsi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps-without-gsi}"
SRC_URI[x86_64_v2_lcmaps-without-gsi.sha256sum] = "2c8cf3fcb822d8a3ac2a8a3451234c1c202f2f808059888e25e81942a9c52c9c"

URI_x86_64_v2_lcmaps-without-gsi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lcmaps-without-gsi-devel-1.6.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lcmaps-without-gsi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lcmaps-without-gsi-devel}"
SRC_URI[x86_64_v2_lcmaps-without-gsi-devel.sha256sum] = "2d0c622906687560de65d064b8ea9d00f0c7f809e765c62e864f6b09b549a4c9"

URI_aarch64_lcmaps = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-1.6.7-1.el10_2.aarch64.rpm;name=aarch64_lcmaps;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps}"
SRC_URI[aarch64_lcmaps.sha256sum] = "2f8de5144286b0fa3edf0869fe16c6512110b1d14936dc76e77839e0dd0f4369"

URI_aarch64_lcmaps-common-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-common-devel-1.6.7-1.el10_2.aarch64.rpm;name=aarch64_lcmaps-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps-common-devel}"
SRC_URI[aarch64_lcmaps-common-devel.sha256sum] = "4076410e757328107b96478d0ab1c5886fbe75816ed6fe3cdaa164448423c104"

URI_aarch64_lcmaps-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-devel-1.6.7-1.el10_2.aarch64.rpm;name=aarch64_lcmaps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps-devel}"
SRC_URI[aarch64_lcmaps-devel.sha256sum] = "4cc1a1a322f67da2c18cacb073e33ab33c9c0f18b41f427ba6b6c50add5900e5"

URI_aarch64_lcmaps-without-gsi = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-without-gsi-1.6.7-1.el10_2.aarch64.rpm;name=aarch64_lcmaps-without-gsi;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps-without-gsi}"
SRC_URI[aarch64_lcmaps-without-gsi.sha256sum] = "d59dcfe0b22cf04b625ca4d599a22a7ebd3f21c1208e4e5133780efd20490abe"

URI_aarch64_lcmaps-without-gsi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lcmaps-without-gsi-devel-1.6.7-1.el10_2.aarch64.rpm;name=aarch64_lcmaps-without-gsi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lcmaps-without-gsi-devel}"
SRC_URI[aarch64_lcmaps-without-gsi-devel.sha256sum] = "1fe0be3f29ffd2096c03ce07f6e26d6fb01e007d82bd969eeda8e6c67f4942cf"

RDEPENDS:lcmaps = " \
 glibc \
 globus-common \
 globus-gsi-credential \
 globus-gss-assist \
 globus-gssapi-gsi \
 openssl-libs \
 voms \
 "
RDEPENDS:lcmaps-common-devel = " \
 pkgconf-pkg-config \
 "
RDEPENDS:lcmaps-devel = " \
 globus-gsi-cert-utils-devel \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 lcmaps \
 lcmaps-common-devel \
 lcmaps-devel \
 openssl-devel \
 pkgconf-pkg-config \
 voms-devel \
 "
RDEPENDS:lcmaps-without-gsi = " \
 glibc \
 "
RDEPENDS:lcmaps-without-gsi-devel = " \
 lcmaps-common-devel \
 lcmaps-without-gsi \
 lcmaps-without-gsi-devel \
 pkgconf-pkg-config \
 "
