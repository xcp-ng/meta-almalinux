# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust_decimal_macros"
PV = "1.39.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rust_decimal_macros+default-devel \
 rust-rust_decimal_macros+reexportable-devel \
 rust-rust_decimal_macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust_decimal_macros-1.39.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a8421441fed6b473d16e91de8ddc7c1383b1c2586d973f4b90cad4fb24f7643"

URI_x86_64_v2_rust-rust_decimal_macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros+default-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal_macros+default-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal_macros+default-devel.sha256sum] = "c4f10c091dfa47d1692416c1953e3f96dfefbb7c520fa74259023f726a4f1c92"

URI_x86_64_v2_rust-rust_decimal_macros+reexportable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros+reexportable-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros+reexportable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal_macros+reexportable-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal_macros+reexportable-devel.sha256sum] = "c79e7c6e98aa778c051a0a985d929209323c61d5db490364d413c0a5fe4a9c5e"

URI_x86_64_v2_rust-rust_decimal_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust_decimal_macros-devel-1.39.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust_decimal_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust_decimal_macros-devel}"
SRC_URI[x86_64_v2_rust-rust_decimal_macros-devel.sha256sum] = "290ff9613270c628c2392c06ccd77fcfa925c683e23e04c805377e8338bf9458"

URI_aarch64_rust-rust_decimal_macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros+default-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal_macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal_macros+default-devel}"
SRC_URI[aarch64_rust-rust_decimal_macros+default-devel.sha256sum] = "55f2bdfbbe6c32e00a900343bfd8895412393b9dccd793de0271fc4dd04df18c"

URI_aarch64_rust-rust_decimal_macros+reexportable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros+reexportable-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal_macros+reexportable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal_macros+reexportable-devel}"
SRC_URI[aarch64_rust-rust_decimal_macros+reexportable-devel.sha256sum] = "f3d5d29b56aeb431029b15f29bd9b16cc892ebcdad1f44c7e900e36af8404ddc"

URI_aarch64_rust-rust_decimal_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust_decimal_macros-devel-1.39.0-1.el10_1.noarch.rpm;name=aarch64_rust-rust_decimal_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust_decimal_macros-devel}"
SRC_URI[aarch64_rust-rust_decimal_macros-devel.sha256sum] = "ff13215ea6739b556c8e8442c40e97fd752a03316daaf9d69e52878af8eab823"

RDEPENDS:rust-rust_decimal_macros+default-devel = " \
 cargo \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal_macros+reexportable-devel = " \
 cargo \
 rust-rust_decimal_macros-devel \
 "
RDEPENDS:rust-rust_decimal_macros-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
