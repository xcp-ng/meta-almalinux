# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-haddock-library"
PV = "1.11.0"
PR = "6.el10_0"
PACKAGES = " \
 ghc-haddock-library \
 ghc-haddock-library-devel \
 ghc-haddock-library-doc \
 ghc-haddock-library-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-haddock-library-1.11.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e6789558d19b89adf4538be113d8cbed25665870e503d8404ac8201dd457c89"

URI_x86_64_v2_ghc-haddock-library = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haddock-library-1.11.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haddock-library;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haddock-library}"
SRC_URI[x86_64_v2_ghc-haddock-library.sha256sum] = "db96ffb1e2ba11bf42dd77d1d255e198bfcd28d8a26a134ea8277bdda57c3a36"

URI_x86_64_v2_ghc-haddock-library-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haddock-library-devel-1.11.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haddock-library-devel}"
SRC_URI[x86_64_v2_ghc-haddock-library-devel.sha256sum] = "524d9d96c7a85518009b430f733d6d19fcfb470106b575bdd05caed2e398d288"

URI_x86_64_v2_ghc-haddock-library-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haddock-library-doc-1.11.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haddock-library-doc}"
SRC_URI[x86_64_v2_ghc-haddock-library-doc.sha256sum] = "b3db045f9c9742dffc3ff09d1986e70bfd280ea43896131cc0785a991ff8ee86"

URI_x86_64_v2_ghc-haddock-library-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-haddock-library-prof-1.11.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-haddock-library-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-haddock-library-prof}"
SRC_URI[x86_64_v2_ghc-haddock-library-prof.sha256sum] = "1f33b4074e0bc2dd509f76593c5923c2656244e2575b247f7b06d3463c10abd4"

URI_aarch64_ghc-haddock-library = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haddock-library-1.11.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-haddock-library;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haddock-library}"
SRC_URI[aarch64_ghc-haddock-library.sha256sum] = "d79e042f3ca5aeb41c08c6f1965a903e8d9a2637e98cc2d6604702f86b441da0"

URI_aarch64_ghc-haddock-library-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haddock-library-devel-1.11.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-haddock-library-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haddock-library-devel}"
SRC_URI[aarch64_ghc-haddock-library-devel.sha256sum] = "8f05732f6030b390b8bffa5a93cdafaf139b6035a239bddabee1ff5ebe42cc3c"

URI_aarch64_ghc-haddock-library-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haddock-library-doc-1.11.0-6.el10_0.noarch.rpm;name=aarch64_ghc-haddock-library-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haddock-library-doc}"
SRC_URI[aarch64_ghc-haddock-library-doc.sha256sum] = "49b73c937e62a2ed4f6dbcbc8be3bd9e378c3bc56b44d51df25c32c68098d0f5"

URI_aarch64_ghc-haddock-library-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-haddock-library-prof-1.11.0-6.el10_0.aarch64.rpm;name=aarch64_ghc-haddock-library-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-haddock-library-prof}"
SRC_URI[aarch64_ghc-haddock-library-prof.sha256sum] = "4736015f07e6baf4007c65c16b6b87c3b547ab04ab5a6fb7ec19f5f73074723b"

RDEPENDS:ghc-haddock-library = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-parsec \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-haddock-library-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-haddock-library \
 ghc-parsec-devel \
 ghc-text-devel \
 "
RDEPENDS:ghc-haddock-library-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-haddock-library-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-haddock-library-devel \
 ghc-parsec-prof \
 ghc-text-prof \
 "
