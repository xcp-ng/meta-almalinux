# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yubihsm-shell"
PV = "2.7.0"
PR = "3.el10_3"
PACKAGES = " \
 yubihsm-shell \
 yubihsm-shell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yubihsm-shell-2.7.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "562369e418ae03907cbcf3e492eaddaa03e98c426dac970cb024429283d9bff5"

URI_x86_64_v2_yubihsm-shell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yubihsm-shell-2.7.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yubihsm-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yubihsm-shell}"
SRC_URI[x86_64_v2_yubihsm-shell.sha256sum] = "cb623ab55ddefc10c0074cf352b305bf8227db9d8020c14f8fe1fff40c4208c3"

URI_x86_64_v2_yubihsm-shell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yubihsm-shell-devel-2.7.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yubihsm-shell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yubihsm-shell-devel}"
SRC_URI[x86_64_v2_yubihsm-shell-devel.sha256sum] = "6f399b0fd758999ec4b5e1765eaa57485ff472e71228ddb8d7243dc54c1d187a"

URI_aarch64_yubihsm-shell = "${EPEL_MIRROR}/aarch64/Packages/y/yubihsm-shell-2.7.0-3.el10_3.aarch64.rpm;name=aarch64_yubihsm-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_yubihsm-shell}"
SRC_URI[aarch64_yubihsm-shell.sha256sum] = "8c28f9d2d97262f9af939935bf06a9a598c983ea05a80981b8803b2788c75ef9"

URI_aarch64_yubihsm-shell-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yubihsm-shell-devel-2.7.0-3.el10_3.aarch64.rpm;name=aarch64_yubihsm-shell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yubihsm-shell-devel}"
SRC_URI[aarch64_yubihsm-shell-devel.sha256sum] = "d8e4f055ad1c58f9b6db0ae758c8d61813d409a0c61671fa5d863fb0f3bd09f7"

RDEPENDS:yubihsm-shell = " \
 glibc \
 libedit \
 libusb1 \
 openssl-libs \
 pcsc-lite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:yubihsm-shell-devel = " \
 libcurl-devel \
 openssl-devel \
 pcsc-lite-devel \
 pkgconf-pkg-config \
 yubihsm-shell \
 "
