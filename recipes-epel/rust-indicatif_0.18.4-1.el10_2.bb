# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-indicatif"
PV = "0.18.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-indicatif+default-devel \
 rust-indicatif+futures-devel \
 rust-indicatif+improved_unicode-devel \
 rust-indicatif+in_memory-devel \
 rust-indicatif+rayon-devel \
 rust-indicatif+tokio-devel \
 rust-indicatif+unicode-segmentation-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif+vt100-devel \
 rust-indicatif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-indicatif-0.18.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2261787a37e9f300856b17a4e08111e76972500835723bfed1254518a5a3d604"

URI_x86_64_v2_rust-indicatif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+default-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+default-devel}"
SRC_URI[x86_64_v2_rust-indicatif+default-devel.sha256sum] = "b7be160293e4797c1671629bd07a0d46abce549c32e80df21de44017797c6286"

URI_x86_64_v2_rust-indicatif+futures-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+futures-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+futures-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+futures-devel}"
SRC_URI[x86_64_v2_rust-indicatif+futures-devel.sha256sum] = "0dc7fd1d9efd532d1184bc38175f7fdd79bef41fb4b6faf2baf868d0f60c1a1f"

URI_x86_64_v2_rust-indicatif+improved_unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+improved_unicode-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+improved_unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+improved_unicode-devel}"
SRC_URI[x86_64_v2_rust-indicatif+improved_unicode-devel.sha256sum] = "abc3d9ffc67a3f58226b958fb55ffe5f60882cd0f2278104aa51907ed9945f3e"

URI_x86_64_v2_rust-indicatif+in_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+in_memory-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+in_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+in_memory-devel}"
SRC_URI[x86_64_v2_rust-indicatif+in_memory-devel.sha256sum] = "1a060866b51cfc02337450f97b776a16002dea5c15a6c320ec8056f73b2a998d"

URI_x86_64_v2_rust-indicatif+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+rayon-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+rayon-devel}"
SRC_URI[x86_64_v2_rust-indicatif+rayon-devel.sha256sum] = "99e16907f1df51f5e5b46377a8a762e360137b630439980271fa6924566f1e52"

URI_x86_64_v2_rust-indicatif+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+tokio-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+tokio-devel}"
SRC_URI[x86_64_v2_rust-indicatif+tokio-devel.sha256sum] = "6b56e8daf69e6a89b3113d4144d14edc93b79d2fca400402201d42592a54c425"

URI_x86_64_v2_rust-indicatif+unicode-segmentation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+unicode-segmentation-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+unicode-segmentation-devel}"
SRC_URI[x86_64_v2_rust-indicatif+unicode-segmentation-devel.sha256sum] = "329c91e89516c43eebd3ffa2680d92520fb9849c15590c4bdfe1c7e7464aebf8"

URI_x86_64_v2_rust-indicatif+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+unicode-width-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-indicatif+unicode-width-devel.sha256sum] = "68ca6e52da4c14b2d6dae5657d2d393ba1c79fc2edc01813744b9552c169a169"

URI_x86_64_v2_rust-indicatif+vt100-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif+vt100-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif+vt100-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif+vt100-devel}"
SRC_URI[x86_64_v2_rust-indicatif+vt100-devel.sha256sum] = "6af84928d1a11e3eeb2ae31551b4215f4f37cd2bf435d3e356802ccfbe0a8e01"

URI_x86_64_v2_rust-indicatif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-indicatif-devel-0.18.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-indicatif-devel}"
SRC_URI[x86_64_v2_rust-indicatif-devel.sha256sum] = "3649333aa541ba8ec0a6d620fbb4a6d5f8eb3fb5c0586dd1d6cb86e7d588d7cf"

URI_aarch64_rust-indicatif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+default-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+default-devel}"
SRC_URI[aarch64_rust-indicatif+default-devel.sha256sum] = "c55ed760986f351021592d4eeb6f0e8587d81605d4ede25ded1a06a65186b91e"

URI_aarch64_rust-indicatif+futures-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+futures-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif+futures-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+futures-devel}"
SRC_URI[aarch64_rust-indicatif+futures-devel.sha256sum] = "f359dcd95d6677c8a8e03226e5a23ea67956f2c4bb15d3322e970cbffdaf2834"

URI_aarch64_rust-indicatif+improved_unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+improved_unicode-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif+improved_unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+improved_unicode-devel}"
SRC_URI[aarch64_rust-indicatif+improved_unicode-devel.sha256sum] = "ca955ce5957e9461a242139652fd192e652512314e5f0fbe7fe7113a486efaba"

URI_aarch64_rust-indicatif+in_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+in_memory-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif+in_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+in_memory-devel}"
SRC_URI[aarch64_rust-indicatif+in_memory-devel.sha256sum] = "4608c36478242ea833f728c45f735c090f9791f60ec985f3eab58613171030dd"

URI_aarch64_rust-indicatif+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+rayon-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+rayon-devel}"
SRC_URI[aarch64_rust-indicatif+rayon-devel.sha256sum] = "7db75111f8f1ae6eb386e93d88c59eec9d8bd4a684c96cf0e512e987fed25858"

URI_aarch64_rust-indicatif+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+tokio-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+tokio-devel}"
SRC_URI[aarch64_rust-indicatif+tokio-devel.sha256sum] = "6d9c2f0639072bd1f2d06cd1b0511e15eb967a3dc08c4beb73ff71c0746a4b22"

URI_aarch64_rust-indicatif+unicode-segmentation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+unicode-segmentation-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif+unicode-segmentation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+unicode-segmentation-devel}"
SRC_URI[aarch64_rust-indicatif+unicode-segmentation-devel.sha256sum] = "07f5b93d28351282f2f58f4d5e85064705e881440a0e06eff7569549bf4815b5"

URI_aarch64_rust-indicatif+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+unicode-width-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+unicode-width-devel}"
SRC_URI[aarch64_rust-indicatif+unicode-width-devel.sha256sum] = "0ba798476a7c3a851558f92010b3fc5c50a4346163675746e7b7f2ab30ffd837"

URI_aarch64_rust-indicatif+vt100-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif+vt100-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif+vt100-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif+vt100-devel}"
SRC_URI[aarch64_rust-indicatif+vt100-devel.sha256sum] = "92846e2af6aa07f779181e57af29d08c8a7e2dd11286d1c3840961bbfd022a3a"

URI_aarch64_rust-indicatif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-indicatif-devel-0.18.4-1.el10_2.noarch.rpm;name=aarch64_rust-indicatif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-indicatif-devel}"
SRC_URI[aarch64_rust-indicatif-devel.sha256sum] = "fb8bb75bd9a209a121fb404fbcd158a01b2b0d6a3d3372945e88d606b90ffd29"

RDEPENDS:rust-indicatif+default-devel = " \
 cargo \
 rust-indicatif+unicode-width-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+futures-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+improved_unicode-devel = " \
 cargo \
 rust-indicatif+unicode-segmentation-devel \
 rust-indicatif+unicode-width-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+in_memory-devel = " \
 cargo \
 rust-indicatif+vt100-devel \
 rust-indicatif-devel \
 "
RDEPENDS:rust-indicatif+rayon-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-indicatif+tokio-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-indicatif+unicode-segmentation-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-unicode-segmentation+default-devel \
 "
RDEPENDS:rust-indicatif+unicode-width-devel = " \
 cargo \
 rust-console+unicode-width-devel \
 rust-indicatif-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-indicatif+vt100-devel = " \
 cargo \
 rust-indicatif-devel \
 rust-vt100+default-devel \
 "
RDEPENDS:rust-indicatif-devel = " \
 cargo \
 rust \
 rust-console+ansi-parsing-devel \
 rust-console+std-devel \
 rust-console-devel \
 rust-portable-atomic+default-devel \
 rust-unit-prefix+default-devel \
 "
