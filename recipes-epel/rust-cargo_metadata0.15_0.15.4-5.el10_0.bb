# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_metadata0.15"
PV = "0.15.4"
PR = "5.el10_0"
PACKAGES = " \
 rust-cargo_metadata0.15+builder-devel \
 rust-cargo_metadata0.15+default-devel \
 rust-cargo_metadata0.15+derive_builder-devel \
 rust-cargo_metadata0.15-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_metadata0.15-0.15.4-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f8795fac3e44919d4721c9f1a0f8e856b9a281f2c15c7fba1573dd58564f425"

URI_x86_64_v2_rust-cargo_metadata0.15+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15+builder-devel-0.15.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15+builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15+builder-devel.sha256sum] = "c16ed87e37791e7b0fafde0c4c7c4db1351c6ce76fc38c432274bfdb1b1cbc5c"

URI_x86_64_v2_rust-cargo_metadata0.15+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15+default-devel-0.15.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15+default-devel.sha256sum] = "b14ba622cac559af45ba46d0a84bb0dd16c34d0d52bfdf488d1affabb7e60414"

URI_x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15+derive_builder-devel-0.15.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15+derive_builder-devel.sha256sum] = "3974fedf14b6cdbfda3b21be6e0aa803133a38f2f035a26e8233596aeef1b9b9"

URI_x86_64_v2_rust-cargo_metadata0.15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_metadata0.15-devel-0.15.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_metadata0.15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_metadata0.15-devel}"
SRC_URI[x86_64_v2_rust-cargo_metadata0.15-devel.sha256sum] = "3628d5beb7b92b4c282e56aa630999502c83c2f3b3f2d8b10f07f687e77f0baa"

URI_aarch64_rust-cargo_metadata0.15+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15+builder-devel-0.15.4-5.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata0.15+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15+builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15+builder-devel.sha256sum] = "458d44d49d30da9a46a7a3a904e06d625d148d960ea41f87c0cbc2b3925ca1ec"

URI_aarch64_rust-cargo_metadata0.15+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15+default-devel-0.15.4-5.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata0.15+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15+default-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15+default-devel.sha256sum] = "4dde2d57370fb909c6c55b930268af9d859b9ea675b1694273a629a6197d6b2c"

URI_aarch64_rust-cargo_metadata0.15+derive_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15+derive_builder-devel-0.15.4-5.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata0.15+derive_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15+derive_builder-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15+derive_builder-devel.sha256sum] = "3f8c1dce51d7226a91b7b5f36b4fba0ac81d136de26b9b21d7bbc4ca0dc8370c"

URI_aarch64_rust-cargo_metadata0.15-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_metadata0.15-devel-0.15.4-5.el10_0.noarch.rpm;name=aarch64_rust-cargo_metadata0.15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_metadata0.15-devel}"
SRC_URI[aarch64_rust-cargo_metadata0.15-devel.sha256sum] = "5e1ca8440d64de35ee8cecc40c5f0fe7a383b22011b8be3c3e18e6e8f262f662"

RDEPENDS:rust-cargo_metadata0.15+builder-devel = " \
 cargo \
 rust-cargo_metadata0.15+derive_builder-devel \
 rust-cargo_metadata0.15-devel \
 "
RDEPENDS:rust-cargo_metadata0.15+default-devel = " \
 cargo \
 rust-cargo_metadata0.15-devel \
 "
RDEPENDS:rust-cargo_metadata0.15+derive_builder-devel = " \
 cargo \
 rust-cargo_metadata0.15-devel \
 rust-derive_builder+default-devel \
 "
RDEPENDS:rust-cargo_metadata0.15-devel = " \
 cargo \
 rust \
 rust-camino+default-devel \
 rust-camino+serde1-devel \
 rust-cargo-platform+default-devel \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+unbounded_depth-devel \
 rust-thiserror1+default-devel \
 "
