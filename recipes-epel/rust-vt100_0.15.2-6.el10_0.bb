# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vt100"
PV = "0.15.2"
PR = "6.el10_0"
PACKAGES = " \
 rust-vt100+default-devel \
 rust-vt100-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vt100-0.15.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19b52fe462315d2b668deff8964cce801a19030611ba195d5edc75f701f72ec5"

URI_x86_64_v2_rust-vt100+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vt100+default-devel-0.15.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vt100+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vt100+default-devel}"
SRC_URI[x86_64_v2_rust-vt100+default-devel.sha256sum] = "dc39d9620986a4c02f266e6953ce694be4cb7340b6895594dac39dc0d5ea7155"

URI_x86_64_v2_rust-vt100-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vt100-devel-0.15.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vt100-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vt100-devel}"
SRC_URI[x86_64_v2_rust-vt100-devel.sha256sum] = "c6610ac7dd16afbba13735813ca5bb71e763e2580c41bf7535944d026a5c0c2a"

URI_aarch64_rust-vt100+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vt100+default-devel-0.15.2-6.el10_0.noarch.rpm;name=aarch64_rust-vt100+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vt100+default-devel}"
SRC_URI[aarch64_rust-vt100+default-devel.sha256sum] = "f13b35273951b8531e030e3aec4c2aed7b9254d5201f488ec37a695211afcc4f"

URI_aarch64_rust-vt100-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vt100-devel-0.15.2-6.el10_0.noarch.rpm;name=aarch64_rust-vt100-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vt100-devel}"
SRC_URI[aarch64_rust-vt100-devel.sha256sum] = "64700b8db096172e78579acb78b55d8ec90c030faac91e374b6912e498f3de46"

RDEPENDS:rust-vt100+default-devel = " \
 cargo \
 rust-vt100-devel \
 "
RDEPENDS:rust-vt100-devel = " \
 cargo \
 rust-itoa+default-devel \
 rust-log+default-devel \
 rust-unicode-width0.1+default-devel \
 rust-vte+default-devel \
 "
