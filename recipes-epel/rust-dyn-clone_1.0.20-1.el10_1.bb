# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dyn-clone"
PV = "1.0.20"
PR = "1.el10_1"
PACKAGES = " \
 rust-dyn-clone+default-devel \
 rust-dyn-clone-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dyn-clone-1.0.20-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a53066cf49c11b4c04b99d7a56c0264bfac9cda54ca4ff43c18f9f642e41b8c9"

URI_x86_64_v2_rust-dyn-clone+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dyn-clone+default-devel-1.0.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dyn-clone+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dyn-clone+default-devel}"
SRC_URI[x86_64_v2_rust-dyn-clone+default-devel.sha256sum] = "c237f821b63bf66e6e4498c54bd3d8d51414065c6fe1b814b11a9b910fc0c811"

URI_x86_64_v2_rust-dyn-clone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dyn-clone-devel-1.0.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dyn-clone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dyn-clone-devel}"
SRC_URI[x86_64_v2_rust-dyn-clone-devel.sha256sum] = "3f272e78f19b918e17e56978ee52f3303d9c7ea46fb9c517f712c49110e9ab70"

URI_aarch64_rust-dyn-clone+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dyn-clone+default-devel-1.0.20-1.el10_1.noarch.rpm;name=aarch64_rust-dyn-clone+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dyn-clone+default-devel}"
SRC_URI[aarch64_rust-dyn-clone+default-devel.sha256sum] = "c1e42dafe96c024f76b5858bab1b2c422fb91fa539d29a7fee26debb3b21f224"

URI_aarch64_rust-dyn-clone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dyn-clone-devel-1.0.20-1.el10_1.noarch.rpm;name=aarch64_rust-dyn-clone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dyn-clone-devel}"
SRC_URI[aarch64_rust-dyn-clone-devel.sha256sum] = "826c005f777b15d50aaaea6965f596f96f96ee9e783242cd9609f3a035ce7bb6"

RDEPENDS:rust-dyn-clone+default-devel = " \
 cargo \
 rust-dyn-clone-devel \
 "
RDEPENDS:rust-dyn-clone-devel = " \
 cargo \
 rust \
 "
