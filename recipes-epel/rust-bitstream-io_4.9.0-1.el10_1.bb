# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitstream-io"
PV = "4.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-bitstream-io+alloc-devel \
 rust-bitstream-io+default-devel \
 rust-bitstream-io+std-devel \
 rust-bitstream-io-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitstream-io-4.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c3b9a384508dcefaae36757bbe5a131f401c2cb2261fe613b726029a11b2201"

URI_x86_64_v2_rust-bitstream-io+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+alloc-devel-4.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+alloc-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+alloc-devel.sha256sum] = "40739dfc58f1a0407dd79d9db859d3246b4151bd823dc83c1ac4a3981fdbc44f"

URI_x86_64_v2_rust-bitstream-io+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+default-devel-4.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+default-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+default-devel.sha256sum] = "bba77c33d6e645314f474678ec9909d3a3d1ca9b4d1da5cd240a476696432cbe"

URI_x86_64_v2_rust-bitstream-io+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io+std-devel-4.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io+std-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io+std-devel.sha256sum] = "5ccbac9ba1ac5cf96bb8519fd400addff8cdea7923e7d8820fce8eab78c4e2fc"

URI_x86_64_v2_rust-bitstream-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitstream-io-devel-4.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitstream-io-devel}"
SRC_URI[x86_64_v2_rust-bitstream-io-devel.sha256sum] = "28959d8736505557d506d7090f80ccde6d50abb33f5a90de0836e306c905b6f4"

URI_aarch64_rust-bitstream-io+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+alloc-devel-4.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitstream-io+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+alloc-devel}"
SRC_URI[aarch64_rust-bitstream-io+alloc-devel.sha256sum] = "375a3ba65d70078d45b7dad640921c23a151c7e5ee849cda84adad7d433b30fa"

URI_aarch64_rust-bitstream-io+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+default-devel-4.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitstream-io+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+default-devel}"
SRC_URI[aarch64_rust-bitstream-io+default-devel.sha256sum] = "a9476316d28a6638629d98d19c412b7255f9a648e9af6faf85f383d4afade164"

URI_aarch64_rust-bitstream-io+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io+std-devel-4.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitstream-io+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io+std-devel}"
SRC_URI[aarch64_rust-bitstream-io+std-devel.sha256sum] = "8ab0e50d0907bb82689d5a032c2881ed99c1b2eb7a0976afd04d5c0ea623475b"

URI_aarch64_rust-bitstream-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitstream-io-devel-4.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitstream-io-devel}"
SRC_URI[aarch64_rust-bitstream-io-devel.sha256sum] = "3e8b982b70c99409cca7c752aca73d944e7d3cc10bebd9831037b864cf56d045"

RDEPENDS:rust-bitstream-io+alloc-devel = " \
 cargo \
 rust-bitstream-io-devel \
 rust-core2+alloc-devel \
 "
RDEPENDS:rust-bitstream-io+default-devel = " \
 cargo \
 rust-bitstream-io+std-devel \
 rust-bitstream-io-devel \
 "
RDEPENDS:rust-bitstream-io+std-devel = " \
 cargo \
 rust-bitstream-io+alloc-devel \
 rust-bitstream-io-devel \
 rust-core2+std-devel \
 "
RDEPENDS:rust-bitstream-io-devel = " \
 cargo \
 rust \
 rust-core2-devel \
 "
