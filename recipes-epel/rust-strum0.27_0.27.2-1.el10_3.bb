# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-strum0.27"
PV = "0.27.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-strum0.27+default-devel \
 rust-strum0.27+derive-devel \
 rust-strum0.27+phf-devel \
 rust-strum0.27+std-devel \
 rust-strum0.27+strum_macros-devel \
 rust-strum0.27-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-strum0.27-0.27.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19606304f3046e5254be1878a0bb869f19e10554fe536561196c058654ad8d9f"

URI_x86_64_v2_rust-strum0.27+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.27+default-devel-0.27.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.27+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.27+default-devel}"
SRC_URI[x86_64_v2_rust-strum0.27+default-devel.sha256sum] = "255b36fa246389c6f0a45af4405e43dee4875fb2406ad71386474842ae0d586f"

URI_x86_64_v2_rust-strum0.27+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.27+derive-devel-0.27.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.27+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.27+derive-devel}"
SRC_URI[x86_64_v2_rust-strum0.27+derive-devel.sha256sum] = "8c840022df3c077dfa040c16a2edb9b4ac2e50ee4e2b8fc7afa5c25083420176"

URI_x86_64_v2_rust-strum0.27+phf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.27+phf-devel-0.27.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.27+phf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.27+phf-devel}"
SRC_URI[x86_64_v2_rust-strum0.27+phf-devel.sha256sum] = "ff51038f1fe65eca9ce31df7307b34301a3177ac3ed89891914846978f125fd4"

URI_x86_64_v2_rust-strum0.27+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.27+std-devel-0.27.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.27+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.27+std-devel}"
SRC_URI[x86_64_v2_rust-strum0.27+std-devel.sha256sum] = "86102cdc623b82a9408452d7a9bce14e264585f382c4b63257b632befbfe8bf3"

URI_x86_64_v2_rust-strum0.27+strum_macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.27+strum_macros-devel-0.27.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.27+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.27+strum_macros-devel}"
SRC_URI[x86_64_v2_rust-strum0.27+strum_macros-devel.sha256sum] = "eb58df4360f5e28e94345d8eeae9d0e46f8d6b751ce9e251a7800c392882407c"

URI_x86_64_v2_rust-strum0.27-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-strum0.27-devel-0.27.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-strum0.27-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-strum0.27-devel}"
SRC_URI[x86_64_v2_rust-strum0.27-devel.sha256sum] = "b98a4332be4cddcb6a65db39c02cfe4ea5984454a57260743d544a2985cab5ba"

URI_aarch64_rust-strum0.27+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.27+default-devel-0.27.2-1.el10_3.noarch.rpm;name=aarch64_rust-strum0.27+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.27+default-devel}"
SRC_URI[aarch64_rust-strum0.27+default-devel.sha256sum] = "ff2e25042736e8d2f44c2a41dc3b52bf5e3ce9e4c1c95b7e59f9d2821773d766"

URI_aarch64_rust-strum0.27+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.27+derive-devel-0.27.2-1.el10_3.noarch.rpm;name=aarch64_rust-strum0.27+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.27+derive-devel}"
SRC_URI[aarch64_rust-strum0.27+derive-devel.sha256sum] = "82eb6674c604829ddefd8cee57655225e0217df7381ac181ecc0205ee19630cf"

URI_aarch64_rust-strum0.27+phf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.27+phf-devel-0.27.2-1.el10_3.noarch.rpm;name=aarch64_rust-strum0.27+phf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.27+phf-devel}"
SRC_URI[aarch64_rust-strum0.27+phf-devel.sha256sum] = "f0555fab410e29f9eaa876a9dfcce0d71cdde3c615d778c7e9f076655a56f77d"

URI_aarch64_rust-strum0.27+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.27+std-devel-0.27.2-1.el10_3.noarch.rpm;name=aarch64_rust-strum0.27+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.27+std-devel}"
SRC_URI[aarch64_rust-strum0.27+std-devel.sha256sum] = "21783cce5b9e8e20fbe33626497e1c79b74cd03564f7a64b0133d581fad5c4ef"

URI_aarch64_rust-strum0.27+strum_macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.27+strum_macros-devel-0.27.2-1.el10_3.noarch.rpm;name=aarch64_rust-strum0.27+strum_macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.27+strum_macros-devel}"
SRC_URI[aarch64_rust-strum0.27+strum_macros-devel.sha256sum] = "5afe5d8c31aa9ae07f107c9bd52c579806e063f61cd45e9f41b729b217628c7f"

URI_aarch64_rust-strum0.27-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-strum0.27-devel-0.27.2-1.el10_3.noarch.rpm;name=aarch64_rust-strum0.27-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-strum0.27-devel}"
SRC_URI[aarch64_rust-strum0.27-devel.sha256sum] = "7cd3e52e7374608ef96221a6b96b14954b6e962b6078672de01076170a77e85d"

RDEPENDS:rust-strum0.27+default-devel = " \
 cargo \
 rust-strum0.27+std-devel \
 rust-strum0.27-devel \
 "
RDEPENDS:rust-strum0.27+derive-devel = " \
 cargo \
 rust-strum0.27+strum_macros-devel \
 rust-strum0.27-devel \
 "
RDEPENDS:rust-strum0.27+phf-devel = " \
 cargo \
 rust-phf+default-devel \
 rust-phf+macros-devel \
 rust-strum0.27-devel \
 "
RDEPENDS:rust-strum0.27+std-devel = " \
 cargo \
 rust-strum0.27-devel \
 "
RDEPENDS:rust-strum0.27+strum_macros-devel = " \
 cargo \
 rust-strum0.27-devel \
 rust-strum_macros0.27+default-devel \
 "
RDEPENDS:rust-strum0.27-devel = " \
 cargo \
 rust \
 "
