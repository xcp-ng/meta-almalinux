# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khangman"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 khangman \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/khangman-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ebfa384877600e15997492a29d656c9a21763341e1c391384e25fd98adac533c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khangman-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khangman;unpack=0"
SRC_URI[x86_64_v2_khangman.sha256sum] = "0e1b3391ced557265f203f3b71caf83c9ca1865602be6dcae03931c3f9ffe1d9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/khangman-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_khangman;unpack=0"
SRC_URI[aarch64_khangman.sha256sum] = "4380f534445c2fe46667e3685ca380a588e03bed65b7a7ef54d0fed0ab444f8a"

RDEPENDS:khangman = " \
 dustin-domestic-manners-fonts \
 dustin-dustismo-roman-fonts \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 libkeduvocdocument \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
