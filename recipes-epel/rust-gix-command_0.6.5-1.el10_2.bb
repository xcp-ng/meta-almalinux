# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-command"
PV = "0.6.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-command+default-devel \
 rust-gix-command-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-command-0.6.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbe4f539ed40bbcfd78096425799174f817688f98e1f99d838bd0f3b136fdb31"

URI_x86_64_v2_rust-gix-command+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-command+default-devel-0.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-command+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-command+default-devel}"
SRC_URI[x86_64_v2_rust-gix-command+default-devel.sha256sum] = "802f046e4a786ad4400a71bba941cecbe82a1db6ea49ec164f81d7a314dce91b"

URI_x86_64_v2_rust-gix-command-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-command-devel-0.6.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-command-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-command-devel}"
SRC_URI[x86_64_v2_rust-gix-command-devel.sha256sum] = "5f7c09202f853f74ee72f8e0c35a5b06db442ef7dc932264066c966ba0029391"

URI_aarch64_rust-gix-command+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-command+default-devel-0.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-gix-command+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-command+default-devel}"
SRC_URI[aarch64_rust-gix-command+default-devel.sha256sum] = "c1d6379fc9745b23c81fa6a69cbc8862aca09ef535c312e2b49a071bb1e10379"

URI_aarch64_rust-gix-command-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-command-devel-0.6.5-1.el10_2.noarch.rpm;name=aarch64_rust-gix-command-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-command-devel}"
SRC_URI[aarch64_rust-gix-command-devel.sha256sum] = "5b513f2d1217f144af36713ca57632339273e468a127f868cdf2ba569a3ddc09"

RDEPENDS:rust-gix-command+default-devel = " \
 cargo \
 rust-gix-command-devel \
 "
RDEPENDS:rust-gix-command-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-path+default-devel \
 rust-gix-quote+default-devel \
 rust-gix-trace+default-devel \
 rust-shell-words+default-devel \
 "
