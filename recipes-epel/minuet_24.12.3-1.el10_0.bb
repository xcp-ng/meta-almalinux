# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "minuet"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 minuet \
 minuet-data \
 minuet-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/minuet-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a188f6437afaad69ed1ac9c825364eec7c8b7219e0547f71e4d34f117dbc0db3"

URI_x86_64_v2_minuet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minuet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minuet}"
SRC_URI[x86_64_v2_minuet.sha256sum] = "7fe3746c916fe54b0dd3128146773bd9e9a20839b6ca14f2e4638130e4f42fc9"

URI_x86_64_v2_minuet-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-data-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_minuet-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minuet-data}"
SRC_URI[x86_64_v2_minuet-data.sha256sum] = "da850f10416c7cc7bd27438508a0957ccf9ac7592bd182768278ccc3627fa691"

URI_x86_64_v2_minuet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/minuet-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_minuet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_minuet-devel}"
SRC_URI[x86_64_v2_minuet-devel.sha256sum] = "d9d2d537db370be34895e434a7d43b895c0cbe41f51d56cc4b51286eb6185e0e"

URI_aarch64_minuet = "${EPEL_MIRROR}/aarch64/Packages/m/minuet-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_minuet;unpack=0"
SRC_URI:append = " ${URI_aarch64_minuet}"
SRC_URI[aarch64_minuet.sha256sum] = "b4be30982adf8b7ce97536ed34f11f65c4d6211495e2ff4cf08a53507bb1c8d7"

URI_aarch64_minuet-data = "${EPEL_MIRROR}/aarch64/Packages/m/minuet-data-24.12.3-1.el10_0.noarch.rpm;name=aarch64_minuet-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_minuet-data}"
SRC_URI[aarch64_minuet-data.sha256sum] = "b17c7ee0306ef16b05538c5fc2c7f7a8159e23f2625b06d7dc5b541933623d18"

URI_aarch64_minuet-devel = "${EPEL_MIRROR}/aarch64/Packages/m/minuet-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_minuet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_minuet-devel}"
SRC_URI[aarch64_minuet-devel.sha256sum] = "73522ed36cdf628d1225d5e937534a450c3b4559a597a147fcc8b7a32cff1482"

RDEPENDS:minuet = " \
 fluidsynth-libs \
 glibc \
 hicolor-icon-theme \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 minuet-data \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:minuet-data = " \
 minuet \
 "
RDEPENDS:minuet-devel = " \
 minuet \
 "
