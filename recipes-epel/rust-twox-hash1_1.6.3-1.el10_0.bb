# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-twox-hash1"
PV = "1.6.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-twox-hash1+default-devel \
 rust-twox-hash1+digest_0_10-devel \
 rust-twox-hash1+digest_0_9-devel \
 rust-twox-hash1+rand-devel \
 rust-twox-hash1+serde-devel \
 rust-twox-hash1+serialize-devel \
 rust-twox-hash1+std-devel \
 rust-twox-hash1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-twox-hash1-1.6.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7dc53c0b53a0ff10b8e4a36009e2c644eb30d43820f3959a79e072d912c1a139"

URI_x86_64_v2_rust-twox-hash1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash1+default-devel-1.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash1+default-devel}"
SRC_URI[x86_64_v2_rust-twox-hash1+default-devel.sha256sum] = "841047baed21194558e40fe1420031670ea088e58e7747402bfe5f3b609cef59"

URI_x86_64_v2_rust-twox-hash1+digest_0_10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash1+digest_0_10-devel-1.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash1+digest_0_10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash1+digest_0_10-devel}"
SRC_URI[x86_64_v2_rust-twox-hash1+digest_0_10-devel.sha256sum] = "6d183ae567a927f4dc998872de68442bcd40c4f17d2564d490035df5eef4d531"

URI_x86_64_v2_rust-twox-hash1+digest_0_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash1+digest_0_9-devel-1.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash1+digest_0_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash1+digest_0_9-devel}"
SRC_URI[x86_64_v2_rust-twox-hash1+digest_0_9-devel.sha256sum] = "cedfeb10b75b0d89618fda4a7bfbe437487a2e97fbfd265429cbd1a68f29ba03"

URI_x86_64_v2_rust-twox-hash1+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash1+rand-devel-1.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash1+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash1+rand-devel}"
SRC_URI[x86_64_v2_rust-twox-hash1+rand-devel.sha256sum] = "6f3e9afea276e5663a047d4cb7be1ee76664b5dd6693e00d49e53015f74ec766"

URI_x86_64_v2_rust-twox-hash1+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash1+serde-devel-1.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash1+serde-devel}"
SRC_URI[x86_64_v2_rust-twox-hash1+serde-devel.sha256sum] = "ba223cfcd680270a74e162cc08780a88dd7c6a4c75c805529280e22f8a652060"

URI_x86_64_v2_rust-twox-hash1+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash1+serialize-devel-1.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash1+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash1+serialize-devel}"
SRC_URI[x86_64_v2_rust-twox-hash1+serialize-devel.sha256sum] = "bd109e1e07b119a325c851e8af200800a2a1913ebafa623f15356d728130af5e"

URI_x86_64_v2_rust-twox-hash1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash1+std-devel-1.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash1+std-devel}"
SRC_URI[x86_64_v2_rust-twox-hash1+std-devel.sha256sum] = "2946a843d4f0d5a0b93b9be259f11e6872cb1d01c57820eac32d6163c3d34c02"

URI_x86_64_v2_rust-twox-hash1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash1-devel-1.6.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twox-hash1-devel}"
SRC_URI[x86_64_v2_rust-twox-hash1-devel.sha256sum] = "a78f8ab03e045f16aa7400a3d6e3f06cb1f1696b33eef38a94fb4433355b2700"

URI_aarch64_rust-twox-hash1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash1+default-devel-1.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-twox-hash1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash1+default-devel}"
SRC_URI[aarch64_rust-twox-hash1+default-devel.sha256sum] = "d6a1079b6632765be81993eb88cbb4450c64058e087f5a772b13642b40b30116"

URI_aarch64_rust-twox-hash1+digest_0_10-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash1+digest_0_10-devel-1.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-twox-hash1+digest_0_10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash1+digest_0_10-devel}"
SRC_URI[aarch64_rust-twox-hash1+digest_0_10-devel.sha256sum] = "b4d07a6afa3ac3785189d1d6ec129bf9d641e92648c6df9ffd235e3543f8105f"

URI_aarch64_rust-twox-hash1+digest_0_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash1+digest_0_9-devel-1.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-twox-hash1+digest_0_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash1+digest_0_9-devel}"
SRC_URI[aarch64_rust-twox-hash1+digest_0_9-devel.sha256sum] = "8692a797316f70d96a639a0da260622c2089d4ebbcaea87f110aafa6d620479f"

URI_aarch64_rust-twox-hash1+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash1+rand-devel-1.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-twox-hash1+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash1+rand-devel}"
SRC_URI[aarch64_rust-twox-hash1+rand-devel.sha256sum] = "f746990d381db6ab34ee44294f168e7ad6ce43b068a197c0d9900d8f82e8b1ea"

URI_aarch64_rust-twox-hash1+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash1+serde-devel-1.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-twox-hash1+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash1+serde-devel}"
SRC_URI[aarch64_rust-twox-hash1+serde-devel.sha256sum] = "a60d15cda687a7bb7b2a8bf76412e48d0409f18ea5c2cee5ef296a434a2d36ad"

URI_aarch64_rust-twox-hash1+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash1+serialize-devel-1.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-twox-hash1+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash1+serialize-devel}"
SRC_URI[aarch64_rust-twox-hash1+serialize-devel.sha256sum] = "9fa6fd2bd6fabd175393b2da5a10cf3979e5866ad07c02933d77258260eb0182"

URI_aarch64_rust-twox-hash1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash1+std-devel-1.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-twox-hash1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash1+std-devel}"
SRC_URI[aarch64_rust-twox-hash1+std-devel.sha256sum] = "f9f7a4d23f68b52406080a9932c7dbc816b310cb5fe51f72817ee680e0914fae"

URI_aarch64_rust-twox-hash1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash1-devel-1.6.3-1.el10_0.noarch.rpm;name=aarch64_rust-twox-hash1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twox-hash1-devel}"
SRC_URI[aarch64_rust-twox-hash1-devel.sha256sum] = "deedfed0f6fb4ba6446621f782ac832b04d703df97ac92ebc25fe1f64ca6efe7"

RDEPENDS:rust-twox-hash1+default-devel = " \
 cargo \
 rust-twox-hash1+std-devel \
 rust-twox-hash1-devel \
 "
RDEPENDS:rust-twox-hash1+digest_0_10-devel = " \
 cargo \
 rust-digest-devel \
 rust-twox-hash1-devel \
 "
RDEPENDS:rust-twox-hash1+digest_0_9-devel = " \
 cargo \
 rust-digest0.9-devel \
 rust-twox-hash1-devel \
 "
RDEPENDS:rust-twox-hash1+rand-devel = " \
 cargo \
 rust-twox-hash1-devel \
 virtual/crate_rand/default__ge_0.3.10_with_crate_rand/default__lt_0.9.0~ \
 "
RDEPENDS:rust-twox-hash1+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-twox-hash1-devel \
 "
RDEPENDS:rust-twox-hash1+serialize-devel = " \
 cargo \
 rust-twox-hash1+serde-devel \
 rust-twox-hash1-devel \
 "
RDEPENDS:rust-twox-hash1+std-devel = " \
 cargo \
 rust-twox-hash1+rand-devel \
 rust-twox-hash1-devel \
 "
RDEPENDS:rust-twox-hash1-devel = " \
 cargo \
 rust-cfg-if-devel \
 rust-static_assertions-devel \
 "
