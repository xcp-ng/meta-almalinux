# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dropbear"
PV = "2025.89"
PR = "1.el10_2"
PACKAGES = " \
 dropbear \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dropbear-2025.89-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cad49dc004c664a5824bac3e9356c8beb8b156316616ea0d6fe33d3ab0e74b1"

URI_x86_64_v2_dropbear = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dropbear-2025.89-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dropbear;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dropbear}"
SRC_URI[x86_64_v2_dropbear.sha256sum] = "39847349b6851a5171e6c158e0af894813c49575f0be4af7a6b045e18dd3ed21"

URI_aarch64_dropbear = "${EPEL_MIRROR}/aarch64/Packages/d/dropbear-2025.89-1.el10_2.aarch64.rpm;name=aarch64_dropbear;unpack=0"
SRC_URI:append = " ${URI_aarch64_dropbear}"
SRC_URI[aarch64_dropbear.sha256sum] = "96b3995ddbdc17c23b727b5735a69b37036dd46348d2660166a1cc47ca3b6c89"

RDEPENDS:dropbear = " \
 bash \
 glibc \
 libtomcrypt \
 libtommath \
 libxcrypt \
 systemd \
 zlib-ng-compat \
 "
