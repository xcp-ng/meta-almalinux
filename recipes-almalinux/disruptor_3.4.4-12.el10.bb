# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "disruptor"
PV = "3.4.4"
PR = "12.el10"
PACKAGES = " \
 disruptor \
 disruptor-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/disruptor-3.4.4-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3923b0ec9accbcbfc71277e5d875903a0566a32affda365007cf4c428713d39f"

URI_x86_64_v2_disruptor = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/disruptor-3.4.4-12.el10.noarch.rpm;name=x86_64_v2_disruptor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_disruptor}"
SRC_URI[x86_64_v2_disruptor.sha256sum] = "05a74e2070a8c9eecfefbf49dae062a8e6fcae6e31cdc6e66620fe86c40bd491"

URI_x86_64_v2_disruptor-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/disruptor-javadoc-3.4.4-12.el10.noarch.rpm;name=x86_64_v2_disruptor-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_disruptor-javadoc}"
SRC_URI[x86_64_v2_disruptor-javadoc.sha256sum] = "336abfbc7c2d627b9ef0ada6b6cc42dcece02d7b66c5dde912614bcdd527ed62"

URI_aarch64_disruptor = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/disruptor-3.4.4-12.el10.noarch.rpm;name=aarch64_disruptor;unpack=0"
SRC_URI:append = " ${URI_aarch64_disruptor}"
SRC_URI[aarch64_disruptor.sha256sum] = "05a74e2070a8c9eecfefbf49dae062a8e6fcae6e31cdc6e66620fe86c40bd491"

URI_aarch64_disruptor-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/disruptor-javadoc-3.4.4-12.el10.noarch.rpm;name=aarch64_disruptor-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_disruptor-javadoc}"
SRC_URI[aarch64_disruptor-javadoc.sha256sum] = "336abfbc7c2d627b9ef0ada6b6cc42dcece02d7b66c5dde912614bcdd527ed62"

RDEPENDS:disruptor = " \
 javapackages-filesystem \
 "
RDEPENDS:disruptor-javadoc = " \
 javapackages-filesystem \
 "
