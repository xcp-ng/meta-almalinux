# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordered-stream"
PV = "0.2.0"
PR = "6.el10_1"
PACKAGES = " \
 rust-ordered-stream+default-devel \
 rust-ordered-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordered-stream-0.2.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3caea912e6ef0ec242ebca5f140552d185bfdd8559b2bfa94ad56241c1e42236"

URI_x86_64_v2_rust-ordered-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-stream+default-devel-0.2.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-stream+default-devel}"
SRC_URI[x86_64_v2_rust-ordered-stream+default-devel.sha256sum] = "6618e7fb1cac98759e14cb817163eefda7dd3580ce88effe2971d49fd73242dc"

URI_x86_64_v2_rust-ordered-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-stream-devel-0.2.0-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-stream-devel}"
SRC_URI[x86_64_v2_rust-ordered-stream-devel.sha256sum] = "85d23df2796a87e9b0349c30835e8f9adeffb905791c53ace2deaa16d2fbb0b5"

URI_aarch64_rust-ordered-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-stream+default-devel-0.2.0-6.el10_1.noarch.rpm;name=aarch64_rust-ordered-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-stream+default-devel}"
SRC_URI[aarch64_rust-ordered-stream+default-devel.sha256sum] = "c82e26b5d27bee7a74bd511360440856a3987dce75b787a5ab17711d78dee839"

URI_aarch64_rust-ordered-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-stream-devel-0.2.0-6.el10_1.noarch.rpm;name=aarch64_rust-ordered-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-stream-devel}"
SRC_URI[aarch64_rust-ordered-stream-devel.sha256sum] = "0bc7ee21149676e0944b13e9bcc93bec4ad9d2e1cc05ccee4c833a0306be4297"

RDEPENDS:rust-ordered-stream+default-devel = " \
 cargo \
 rust-ordered-stream-devel \
 "
RDEPENDS:rust-ordered-stream-devel = " \
 cargo \
 rust-futures-core+default-devel \
 rust-pin-project-lite+default-devel \
 "
