# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thread-id"
PV = "4.2.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-thread-id+default-devel \
 rust-thread-id-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thread-id-4.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "182517a396748bda2a93c0f29d755605cb736e49bacdc12fa1967563c457c930"

URI_x86_64_v2_rust-thread-id+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread-id+default-devel-4.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread-id+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread-id+default-devel}"
SRC_URI[x86_64_v2_rust-thread-id+default-devel.sha256sum] = "530b240ec3bdd0f5cf7f32d11ca43dc152cbd2bfe640f5eeff173ea34494fddb"

URI_x86_64_v2_rust-thread-id-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread-id-devel-4.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread-id-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread-id-devel}"
SRC_URI[x86_64_v2_rust-thread-id-devel.sha256sum] = "6001ccb3ed2fc76337b865a3b8c6c91516287e5b0903e8e37067ca17874c566e"

URI_aarch64_rust-thread-id+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread-id+default-devel-4.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-thread-id+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread-id+default-devel}"
SRC_URI[aarch64_rust-thread-id+default-devel.sha256sum] = "959839a0a46c64e92c961bebf9d446cc17115b3130d822859729f2de837034d7"

URI_aarch64_rust-thread-id-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread-id-devel-4.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-thread-id-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread-id-devel}"
SRC_URI[aarch64_rust-thread-id-devel.sha256sum] = "714a89728c6373dccce587a52c7e08c9ddf3e220647073416339ade7871bdfbc"

RDEPENDS:rust-thread-id+default-devel = " \
 cargo \
 rust-thread-id-devel \
 "
RDEPENDS:rust-thread-id-devel = " \
 cargo \
 rust-libc+default-devel \
 "
