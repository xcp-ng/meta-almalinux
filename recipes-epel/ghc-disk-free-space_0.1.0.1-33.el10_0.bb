# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-disk-free-space"
PV = "0.1.0.1"
PR = "33.el10_0"
PACKAGES = " \
 ghc-disk-free-space \
 ghc-disk-free-space-devel \
 ghc-disk-free-space-doc \
 ghc-disk-free-space-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-disk-free-space-0.1.0.1-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2098ec194337a71b7128128deb8537444ef11479b73526dfd8e731456e581cdb"

URI_x86_64_v2_ghc-disk-free-space = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-disk-free-space-0.1.0.1-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-disk-free-space;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-disk-free-space}"
SRC_URI[x86_64_v2_ghc-disk-free-space.sha256sum] = "8f0cc2179cc9329b7e7c22261ab59e84dac92787af49edb8b50dafeb695d1d7e"

URI_x86_64_v2_ghc-disk-free-space-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-disk-free-space-devel-0.1.0.1-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-disk-free-space-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-disk-free-space-devel}"
SRC_URI[x86_64_v2_ghc-disk-free-space-devel.sha256sum] = "dc5ad2ef10915625fc316d5e3f58c3c5067f3f9c09e3f874a8472a801f04ab36"

URI_x86_64_v2_ghc-disk-free-space-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-disk-free-space-doc-0.1.0.1-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-disk-free-space-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-disk-free-space-doc}"
SRC_URI[x86_64_v2_ghc-disk-free-space-doc.sha256sum] = "8b330ea1fc58ade34387439a338c3e25c04f63d124c51bba979960b6e5f74741"

URI_x86_64_v2_ghc-disk-free-space-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-disk-free-space-prof-0.1.0.1-33.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-disk-free-space-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-disk-free-space-prof}"
SRC_URI[x86_64_v2_ghc-disk-free-space-prof.sha256sum] = "77266f65de6218ffc91346a637bfb77f9450e07628445b56c1c59596112da497"

URI_aarch64_ghc-disk-free-space = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-disk-free-space-0.1.0.1-33.el10_0.aarch64.rpm;name=aarch64_ghc-disk-free-space;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-disk-free-space}"
SRC_URI[aarch64_ghc-disk-free-space.sha256sum] = "d3db62817ceeba0c556929a60f19929cfd199328a6cb721e73759e7c54d01d78"

URI_aarch64_ghc-disk-free-space-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-disk-free-space-devel-0.1.0.1-33.el10_0.aarch64.rpm;name=aarch64_ghc-disk-free-space-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-disk-free-space-devel}"
SRC_URI[aarch64_ghc-disk-free-space-devel.sha256sum] = "11e4d74f8f7821afdb032343d88ece1da792f318ae5193c9740645c9a0627dd3"

URI_aarch64_ghc-disk-free-space-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-disk-free-space-doc-0.1.0.1-33.el10_0.noarch.rpm;name=aarch64_ghc-disk-free-space-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-disk-free-space-doc}"
SRC_URI[aarch64_ghc-disk-free-space-doc.sha256sum] = "1cedab7467804b845f83150256bed8ab0be5925ccb7cea125814729625b289f8"

URI_aarch64_ghc-disk-free-space-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-disk-free-space-prof-0.1.0.1-33.el10_0.aarch64.rpm;name=aarch64_ghc-disk-free-space-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-disk-free-space-prof}"
SRC_URI[aarch64_ghc-disk-free-space-prof.sha256sum] = "fe24248670a577fa60c3ce6466092d65d26aa342de1455f5c4a0848f98dca66a"

RDEPENDS:ghc-disk-free-space = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-disk-free-space-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-disk-free-space \
 "
RDEPENDS:ghc-disk-free-space-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-disk-free-space-prof = " \
 ghc-base-prof \
 ghc-disk-free-space-devel \
 "
