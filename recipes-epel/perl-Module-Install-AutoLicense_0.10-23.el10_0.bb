# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Module-Install-AutoLicense"
PV = "0.10"
PR = "23.el10_0"
PACKAGES = " \
 perl-Module-Install-AutoLicense \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Module-Install-AutoLicense-0.10-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aae08b82cb4ab7e14434569cb65c56c7ae187c437b28e1642aa00c27ef78b0f3"

URI_x86_64_v2_perl-Module-Install-AutoLicense = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Module-Install-AutoLicense-0.10-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Module-Install-AutoLicense;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Module-Install-AutoLicense}"
SRC_URI[x86_64_v2_perl-Module-Install-AutoLicense.sha256sum] = "9ff4fe8ab08d3611560077df6623782bf9b18471d5dbef11a50a5f8717a4c28e"

URI_aarch64_perl-Module-Install-AutoLicense = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Module-Install-AutoLicense-0.10-23.el10_0.noarch.rpm;name=aarch64_perl-Module-Install-AutoLicense;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Module-Install-AutoLicense}"
SRC_URI[aarch64_perl-Module-Install-AutoLicense.sha256sum] = "51b56bdbb1f7427908d906204cdf3e6ee13ecb40691eb6e36cf2066ea4bad196"

RDEPENDS:perl-Module-Install-AutoLicense = " \
 perl-Module-Install \
 perl-Software-License \
 perl-base \
 perl-libs \
 perl-vars \
 "
