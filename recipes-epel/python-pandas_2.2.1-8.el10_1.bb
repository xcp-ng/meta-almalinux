# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pandas"
PV = "2.2.1"
PR = "8.el10_1"
PACKAGES = " \
 python3-pandas \
 python3-pandas+test \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pandas-2.2.1-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24fd10be9db8ef3a5c8434052446dee8a7f792872504bbd7433d351fa237f3e0"

URI_x86_64_v2_python3-pandas = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pandas-2.2.1-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pandas;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pandas}"
SRC_URI[x86_64_v2_python3-pandas.sha256sum] = "c89ef1cc76fecf92b29a2ca72ba6592a6be8a69626c31505b1e063974ba93f09"

URI_x86_64_v2_python3-pandas+test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pandas+test-2.2.1-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pandas+test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pandas+test}"
SRC_URI[x86_64_v2_python3-pandas+test.sha256sum] = "23824aedda2a9e805db2eaf66443e1206897ad9a3831548f741c826253f0f23f"

URI_aarch64_python3-pandas = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pandas-2.2.1-8.el10_1.aarch64.rpm;name=aarch64_python3-pandas;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pandas}"
SRC_URI[aarch64_python3-pandas.sha256sum] = "9a7ba4ffda0edaef7aaada2efb3dea4346021ddd7d491eee1db108600f6bab01"

URI_aarch64_python3-pandas+test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pandas+test-2.2.1-8.el10_1.aarch64.rpm;name=aarch64_python3-pandas+test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pandas+test}"
SRC_URI[aarch64_python3-pandas+test.sha256sum] = "425a18a7abf58052a12e891c3e117a2ca50cf56908e26f2844e555be0f8017a7"

RDEPENDS:python3-pandas = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-Bottleneck \
 python3-dateutil \
 python3-numexpr \
 python3-numpy \
 python3-pytz \
 "
RDEPENDS:python3-pandas+test = " \
 python3 \
 python3-hypothesis \
 python3-pandas \
 python3-pytest \
 python3-pytest-xdist \
 "
