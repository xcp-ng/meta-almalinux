# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-uv-build"
PV = "0.12.7"
PR = "1.el10_3"
PACKAGES = " \
 python3-uv-build \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-uv-build-0.12.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1fff564b5221c851f060988dc287efd65ed642779c3b6866aa503a1f7c90af06"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-uv-build-0.12.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-uv-build;unpack=0"
SRC_URI[x86_64_v2_python3-uv-build.sha256sum] = "19ac4d15460c9ad0bc0c19a6091f3499dcc9ccda36d5cc40fd3cf5f303970018"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-uv-build-0.12.7-1.el10_3.aarch64.rpm;name=aarch64_python3-uv-build;unpack=0"
SRC_URI[aarch64_python3-uv-build.sha256sum] = "85556230f3fc17b98a13861c3ed0372f6c2749cb4e01b67171519ab48bc80a0b"

RDEPENDS:python3-uv-build = " \
 glibc \
 libgcc \
 libzstd \
 python3 \
 "
