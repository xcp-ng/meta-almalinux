# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-event-listener"
PV = "5.4.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-event-listener+critical-section-devel \
 rust-event-listener+default-devel \
 rust-event-listener+parking-devel \
 rust-event-listener+portable-atomic-devel \
 rust-event-listener+portable-atomic-util-devel \
 rust-event-listener+portable_atomic_crate-devel \
 rust-event-listener+std-devel \
 rust-event-listener-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-event-listener-5.4.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5dada551a3c383cf17a712e3d7d59b68300190acff90e1deb64717983270f6b9"

URI_x86_64_v2_rust-event-listener+critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+critical-section-devel-5.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+critical-section-devel}"
SRC_URI[x86_64_v2_rust-event-listener+critical-section-devel.sha256sum] = "875ea44bea007d0aac47988e65142dcbafb7e401b4d772b45bcc7c035455225b"

URI_x86_64_v2_rust-event-listener+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+default-devel-5.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+default-devel}"
SRC_URI[x86_64_v2_rust-event-listener+default-devel.sha256sum] = "cb991ea98fc40beb14ec36eb955cb4507e82371b73e4221ac21d4a0cb9e71bab"

URI_x86_64_v2_rust-event-listener+parking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+parking-devel-5.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+parking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+parking-devel}"
SRC_URI[x86_64_v2_rust-event-listener+parking-devel.sha256sum] = "a02d82a2f861cb925db1189e02a2330a99ab3f1d80d79824aa7cd0bcd1a24d02"

URI_x86_64_v2_rust-event-listener+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable-atomic-devel-5.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable-atomic-devel.sha256sum] = "802d32e4de63891d466beee1205bba7bf71b245edcbd5abc01559f3f38c8cd5c"

URI_x86_64_v2_rust-event-listener+portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable-atomic-util-devel-5.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable-atomic-util-devel.sha256sum] = "8b48f438beff69d67772af6c02f0ec5d4087e32ba3956956b27a4b8546087c59"

URI_x86_64_v2_rust-event-listener+portable_atomic_crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+portable_atomic_crate-devel-5.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+portable_atomic_crate-devel}"
SRC_URI[x86_64_v2_rust-event-listener+portable_atomic_crate-devel.sha256sum] = "6037d49eb3672eddca618cef82e805b1b1889d6ffb9dde8091ba9966eeeda0a9"

URI_x86_64_v2_rust-event-listener+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener+std-devel-5.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener+std-devel}"
SRC_URI[x86_64_v2_rust-event-listener+std-devel.sha256sum] = "c7e41e984069d141e6535d73f2fc3eff446fce8e52aabb35399704bc3b5488ea"

URI_x86_64_v2_rust-event-listener-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-devel-5.4.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-devel}"
SRC_URI[x86_64_v2_rust-event-listener-devel.sha256sum] = "5cefbc999f495a63c511b5915acddd0fef9cdbde0cdf4ca0c841e4151246c80d"

URI_aarch64_rust-event-listener+critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+critical-section-devel-5.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-event-listener+critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+critical-section-devel}"
SRC_URI[aarch64_rust-event-listener+critical-section-devel.sha256sum] = "12c98892099a5bcd44e5d673ef69173754c07db4d3e6f023f4c10f2257fc7e46"

URI_aarch64_rust-event-listener+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+default-devel-5.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-event-listener+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+default-devel}"
SRC_URI[aarch64_rust-event-listener+default-devel.sha256sum] = "18424b14c8a01696a948825fb6936cc9d4de66a063e2243201f094aff0b1d7f0"

URI_aarch64_rust-event-listener+parking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+parking-devel-5.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-event-listener+parking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+parking-devel}"
SRC_URI[aarch64_rust-event-listener+parking-devel.sha256sum] = "d8fe47e8d4fb81cf859f60ae853268b173028be9ac5a9378cde15c87277d308f"

URI_aarch64_rust-event-listener+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable-atomic-devel-5.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-event-listener+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable-atomic-devel}"
SRC_URI[aarch64_rust-event-listener+portable-atomic-devel.sha256sum] = "d3b4dd7007df69cfa5aa0bc6d4c406024439ac5e32b8a67d08e9db05e888a357"

URI_aarch64_rust-event-listener+portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable-atomic-util-devel-5.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-event-listener+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable-atomic-util-devel}"
SRC_URI[aarch64_rust-event-listener+portable-atomic-util-devel.sha256sum] = "0088f2cc14086caf3bb03acc525aa0ecef59e70b599d94abbc3bef274352eb21"

URI_aarch64_rust-event-listener+portable_atomic_crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+portable_atomic_crate-devel-5.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-event-listener+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+portable_atomic_crate-devel}"
SRC_URI[aarch64_rust-event-listener+portable_atomic_crate-devel.sha256sum] = "5dfe1cf6bf9ab0b1b9f08949d432b93705f85e945b5217bd25fac906660d12b6"

URI_aarch64_rust-event-listener+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener+std-devel-5.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-event-listener+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener+std-devel}"
SRC_URI[aarch64_rust-event-listener+std-devel.sha256sum] = "6d475996015e245f8ab744bdeceb67154494376b079a211b876e65b99808e9f2"

URI_aarch64_rust-event-listener-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-devel-5.4.2-1.el10_2.noarch.rpm;name=aarch64_rust-event-listener-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-devel}"
SRC_URI[aarch64_rust-event-listener-devel.sha256sum] = "b755d4c76e3e95165c0c13e8bbf7f0298f1cf11b5c0b22f9b8350953ecb3e5f1"

RDEPENDS:rust-event-listener+critical-section-devel = " \
 cargo \
 rust-critical-section-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+default-devel = " \
 cargo \
 rust-event-listener+std-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+parking-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-parking+default-devel \
 "
RDEPENDS:rust-event-listener+portable-atomic-devel = " \
 cargo \
 rust-event-listener+portable-atomic-util-devel \
 rust-event-listener+portable_atomic_crate-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener+portable-atomic-util-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 "
RDEPENDS:rust-event-listener+portable_atomic_crate-devel = " \
 cargo \
 rust-event-listener-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-event-listener+std-devel = " \
 cargo \
 rust-event-listener+parking-devel \
 rust-event-listener-devel \
 "
RDEPENDS:rust-event-listener-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 "
