# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-grc"
PV = "2.1.5"
PR = "33.el10"
PACKAGES = " \
 hunspell-grc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-grc-2.1.5-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe24c0aabdd4a765abf8ee87b064a5e6feeb45eccdeddbc7f142d7ccfe9c1b2e"

URI_x86_64_v2_hunspell-grc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-grc-2.1.5-33.el10.noarch.rpm;name=x86_64_v2_hunspell-grc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-grc}"
SRC_URI[x86_64_v2_hunspell-grc.sha256sum] = "72f7718ffac6afbc2125009ea29e89c4baf58517c5b57c5eae402a833959658f"

URI_aarch64_hunspell-grc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-grc-2.1.5-33.el10.noarch.rpm;name=aarch64_hunspell-grc;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-grc}"
SRC_URI[aarch64_hunspell-grc.sha256sum] = "72f7718ffac6afbc2125009ea29e89c4baf58517c5b57c5eae402a833959658f"

RDEPENDS:hunspell-grc = " \
 hunspell-filesystem \
 "
