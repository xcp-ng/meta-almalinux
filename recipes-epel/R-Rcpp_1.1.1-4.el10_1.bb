# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-Rcpp"
PV = "1.1.1"
PR = "4.el10_1"
PACKAGES = " \
 R-Rcpp \
 R-Rcpp-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-Rcpp-1.1.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "090c3bd1d0d0d672f102dc9597644295128f26132b698605eb7a104ebe37716b"

URI_x86_64_v2_R-Rcpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-Rcpp-1.1.1-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-Rcpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-Rcpp}"
SRC_URI[x86_64_v2_R-Rcpp.sha256sum] = "08d14c38f4e5fe3bd7628ef76ddf9b96a33e90cc0bbd34ee28fbef344f8432e3"

URI_x86_64_v2_R-Rcpp-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-Rcpp-examples-1.1.1-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-Rcpp-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-Rcpp-examples}"
SRC_URI[x86_64_v2_R-Rcpp-examples.sha256sum] = "e5b3ab24a3ea6d7b01a65f7eba386a7f732e3277b16c6877e233be587b17b9bc"

URI_aarch64_R-Rcpp = "${EPEL_MIRROR}/aarch64/Packages/r/R-Rcpp-1.1.1-4.el10_1.aarch64.rpm;name=aarch64_R-Rcpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-Rcpp}"
SRC_URI[aarch64_R-Rcpp.sha256sum] = "1d7c120c185dbf65da7785a2bb6a1b48013dc07369bd474b5ab31c10bcfd205f"

URI_aarch64_R-Rcpp-examples = "${EPEL_MIRROR}/aarch64/Packages/r/R-Rcpp-examples-1.1.1-4.el10_1.aarch64.rpm;name=aarch64_R-Rcpp-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-Rcpp-examples}"
SRC_URI[aarch64_R-Rcpp-examples.sha256sum] = "32ae782afc399d56c824dbb8e78fad92c61763ca4e5dc1cc82956ed55a7b5883"

RDEPENDS:R-Rcpp = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:R-Rcpp-examples = " \
 R-Rcpp \
 R-littler \
 bash \
 "
