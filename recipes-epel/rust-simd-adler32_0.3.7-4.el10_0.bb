# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simd-adler32"
PV = "0.3.7"
PR = "4.el10_0"
PACKAGES = " \
 rust-simd-adler32+const-generics-devel \
 rust-simd-adler32+default-devel \
 rust-simd-adler32+nightly-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simd-adler32-0.3.7-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc66189f46d6df0d345d5ec556e88c29394f53363d5436837f5dd8e59ef23ec8"

URI_x86_64_v2_rust-simd-adler32+const-generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+const-generics-devel-0.3.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+const-generics-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+const-generics-devel.sha256sum] = "dbc590fe7b6700123b4964bb4244ffd95e2066ce9f22122cc068bbd7ab01da53"

URI_x86_64_v2_rust-simd-adler32+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+default-devel-0.3.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+default-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+default-devel.sha256sum] = "c47b0fcf803f1601a2b4db1fed4a8260da48b57094ac8c836fc1bd05c1ff86b6"

URI_x86_64_v2_rust-simd-adler32+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+nightly-devel-0.3.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+nightly-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+nightly-devel.sha256sum] = "717b41047fd9c14c7192dcab3a4a5b78f2ef18f8db580691d6b4295ed4e4ea79"

URI_x86_64_v2_rust-simd-adler32+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32+std-devel-0.3.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32+std-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32+std-devel.sha256sum] = "f1ea41f712b993e19b5b2f4a1e5390d74d1a100a9d70f23afe5fe25de90463bf"

URI_x86_64_v2_rust-simd-adler32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd-adler32-devel-0.3.7-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd-adler32-devel}"
SRC_URI[x86_64_v2_rust-simd-adler32-devel.sha256sum] = "3fdb60e63629829d72fdd24e016cda8e46d30c015cf0506b6f5133f4d55b241e"

URI_aarch64_rust-simd-adler32+const-generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+const-generics-devel-0.3.7-4.el10_0.noarch.rpm;name=aarch64_rust-simd-adler32+const-generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+const-generics-devel}"
SRC_URI[aarch64_rust-simd-adler32+const-generics-devel.sha256sum] = "2f8651ca12cfb0c6949a910763f7a2769c02bc8c43887bc63bd370a704f58957"

URI_aarch64_rust-simd-adler32+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+default-devel-0.3.7-4.el10_0.noarch.rpm;name=aarch64_rust-simd-adler32+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+default-devel}"
SRC_URI[aarch64_rust-simd-adler32+default-devel.sha256sum] = "c3221d8e6e99da303aa2ffbe52271f8c9aaa96215495add9a5d25eeee0a02718"

URI_aarch64_rust-simd-adler32+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+nightly-devel-0.3.7-4.el10_0.noarch.rpm;name=aarch64_rust-simd-adler32+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+nightly-devel}"
SRC_URI[aarch64_rust-simd-adler32+nightly-devel.sha256sum] = "0cf4f07f9854fdf4a9049d38e5cb441fd6b9b6c78fe9878600bd97aaeb638c36"

URI_aarch64_rust-simd-adler32+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32+std-devel-0.3.7-4.el10_0.noarch.rpm;name=aarch64_rust-simd-adler32+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32+std-devel}"
SRC_URI[aarch64_rust-simd-adler32+std-devel.sha256sum] = "5f377a7bc0097124f33826a435cd57893bd6d3565ccff2b322cd93be28f4c1df"

URI_aarch64_rust-simd-adler32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd-adler32-devel-0.3.7-4.el10_0.noarch.rpm;name=aarch64_rust-simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd-adler32-devel}"
SRC_URI[aarch64_rust-simd-adler32-devel.sha256sum] = "16e2cca45efd9f1b61fe721daa012e135413601d63a4fe7d6cd23f1ae79ca2c8"

RDEPENDS:rust-simd-adler32+const-generics-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+default-devel = " \
 cargo \
 rust-simd-adler32+const-generics-devel \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+nightly-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32+std-devel = " \
 cargo \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-simd-adler32-devel = " \
 cargo \
 "
