# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httptools"
PV = "0.6.4"
PR = "2.el10_1"
PACKAGES = " \
 python3-httptools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httptools-0.6.4-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd03260910c6ed5db78c90faa4bb74d2fd941ba7f6aa6b68e1c723d61d083a0f"

URI_x86_64_v2_python3-httptools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httptools-0.6.4-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-httptools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httptools}"
SRC_URI[x86_64_v2_python3-httptools.sha256sum] = "6a639a7d5d1eec2171cc05b1133decb9a46a49d49fcf23b3a23557c9096c7b7c"

URI_aarch64_python3-httptools = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httptools-0.6.4-2.el10_1.aarch64.rpm;name=aarch64_python3-httptools;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httptools}"
SRC_URI[aarch64_python3-httptools.sha256sum] = "a5186cc42dfc6f45f575daef82f48c8faaade064c09ad7e85af9085c632b6d36"

RDEPENDS:python3-httptools = " \
 glibc \
 python3 \
 "
