# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hashbrown"
PV = "0.16.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown+rayon-devel \
 rust-hashbrown+serde-devel \
 rust-hashbrown-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hashbrown-0.16.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "321d46070893fe81899cdaf797e6199badf1967bbb384ee4dde5149f52a5fcb9"

URI_x86_64_v2_rust-hashbrown+allocator-api2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+allocator-api2-devel-0.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+allocator-api2-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+allocator-api2-devel.sha256sum] = "e34ec7eedb0bd81b66686fd3ff3d49263225bd8d73bf5e4f334d7783ed60416a"

URI_x86_64_v2_rust-hashbrown+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-devel-0.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+default-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+default-devel.sha256sum] = "612b1e977f2ca1b12c6c0316af6d85488345d9b420b7af99b8b74e96d0af868e"

URI_x86_64_v2_rust-hashbrown+default-hasher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+default-hasher-devel-0.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+default-hasher-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+default-hasher-devel.sha256sum] = "75bd7fe67ae13afc1cd1c44ae73756177f1170d81eccea936ff6a2bdd1be943f"

URI_x86_64_v2_rust-hashbrown+equivalent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+equivalent-devel-0.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+equivalent-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+equivalent-devel.sha256sum] = "48e6298fb4c4ecfa0fb91f672eb169f3f76c73674d44e86832de25b86233b202"

URI_x86_64_v2_rust-hashbrown+inline-more-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+inline-more-devel-0.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+inline-more-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+inline-more-devel.sha256sum] = "46210ce6af1ddb1de4eda5dfe0f349d79dbef3526e9fe98d35a2bf88f36a7251"

URI_x86_64_v2_rust-hashbrown+raw-entry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+raw-entry-devel-0.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+raw-entry-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+raw-entry-devel.sha256sum] = "d6a1e90fa84e71c986a30c524be29fd60ce745557b4dc8521f82f642a3890b67"

URI_x86_64_v2_rust-hashbrown+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+rayon-devel-0.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+rayon-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+rayon-devel.sha256sum] = "0652f4667bb9b680675f157793aa595175c1e16f5f69fb315b19fa4a8505eb45"

URI_x86_64_v2_rust-hashbrown+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown+serde-devel-0.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown+serde-devel}"
SRC_URI[x86_64_v2_rust-hashbrown+serde-devel.sha256sum] = "1d44f3f5377ccc8e52f06b62a2d9c5640e56fecf715d07d1cb3ee24f758ae4ef"

URI_x86_64_v2_rust-hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hashbrown-devel-0.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hashbrown-devel}"
SRC_URI[x86_64_v2_rust-hashbrown-devel.sha256sum] = "d534d0c517a9661c75a94b7a674bc21d450558f39215066e843eeb15e87dae4a"
RPROVIDES:rust-hashbrown-devel:x86_64_v2 = "virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~"

URI_aarch64_rust-hashbrown+allocator-api2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+allocator-api2-devel-0.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown+allocator-api2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+allocator-api2-devel}"
SRC_URI[aarch64_rust-hashbrown+allocator-api2-devel.sha256sum] = "0f3af1f9e9ad24387a2f23c829cbd8e6aee2b455f3917583e15d5a55911bf6e0"

URI_aarch64_rust-hashbrown+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-devel-0.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+default-devel}"
SRC_URI[aarch64_rust-hashbrown+default-devel.sha256sum] = "0bf3e702d8a6e2f6dbe2fe505ad712ad1d4240584c7032d42221dd9bf1f8b455"

URI_aarch64_rust-hashbrown+default-hasher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+default-hasher-devel-0.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown+default-hasher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+default-hasher-devel}"
SRC_URI[aarch64_rust-hashbrown+default-hasher-devel.sha256sum] = "a517f7f3aa93cab671715c308c7bfb04a0f1248c5d6be19cb220f82b752b006a"

URI_aarch64_rust-hashbrown+equivalent-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+equivalent-devel-0.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown+equivalent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+equivalent-devel}"
SRC_URI[aarch64_rust-hashbrown+equivalent-devel.sha256sum] = "d3d357fad85bef5245dbc6cb8dd3216826e45c6bb25daaf14736ebcdcc97a668"

URI_aarch64_rust-hashbrown+inline-more-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+inline-more-devel-0.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown+inline-more-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+inline-more-devel}"
SRC_URI[aarch64_rust-hashbrown+inline-more-devel.sha256sum] = "991424b325a7a41891d55b3038a5bc1c24bf1536d4cce66e51a62fd4916041d3"

URI_aarch64_rust-hashbrown+raw-entry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+raw-entry-devel-0.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown+raw-entry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+raw-entry-devel}"
SRC_URI[aarch64_rust-hashbrown+raw-entry-devel.sha256sum] = "b883853852536f8edb5ea191bc78194f9802c5deefce739c1d5de49865a44384"

URI_aarch64_rust-hashbrown+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+rayon-devel-0.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+rayon-devel}"
SRC_URI[aarch64_rust-hashbrown+rayon-devel.sha256sum] = "66fecba53a10904186ccd299faf50edcb18dd3e96b36567409f99cb9b589949b"

URI_aarch64_rust-hashbrown+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown+serde-devel-0.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown+serde-devel}"
SRC_URI[aarch64_rust-hashbrown+serde-devel.sha256sum] = "173aa28a945c7ccebbf086d1b8696697923e1f6faa85a2a19ef2d8cd0e35dd63"

URI_aarch64_rust-hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hashbrown-devel-0.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hashbrown-devel}"
SRC_URI[aarch64_rust-hashbrown-devel.sha256sum] = "d4e333a0acaaa345419b681f37e1613fdffdeb46521734b03fe25992819d7d61"
RPROVIDES:rust-hashbrown-devel:aarch64 = "virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~"

RDEPENDS:rust-hashbrown+allocator-api2-devel = " \
 cargo \
 rust-allocator-api2+alloc-devel \
 rust-allocator-api2-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-devel = " \
 cargo \
 rust-hashbrown+allocator-api2-devel \
 rust-hashbrown+default-hasher-devel \
 rust-hashbrown+equivalent-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown+raw-entry-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+default-hasher-devel = " \
 cargo \
 rust-foldhash-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+equivalent-devel = " \
 cargo \
 rust-equivalent-devel \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+inline-more-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+raw-entry-devel = " \
 cargo \
 rust-hashbrown-devel \
 "
RDEPENDS:rust-hashbrown+rayon-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-hashbrown+serde-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-serde-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-hashbrown-devel = " \
 cargo \
 rust \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_hashbrown__ge_0.15.0_with_crate_hashbrown__lt_0.17.0~"
