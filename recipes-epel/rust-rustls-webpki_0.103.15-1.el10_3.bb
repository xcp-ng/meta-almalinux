# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-webpki"
PV = "0.103.15"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki+default-devel \
 rust-rustls-webpki+ring-devel \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-webpki-0.103.15-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bf5ed1ab4fd121679ecc12007abd1d9f8f89aabe1bc4ceb16b2aad7df24d0456"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+alloc-devel-0.103.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki+alloc-devel.sha256sum] = "13c39305b23d923c31d1bbf3664ab0b070e609c9868c1dfea894b51cb9fe34c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+default-devel-0.103.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki+default-devel.sha256sum] = "4db66f3a96d3501114b45a1de966189c47ac082d89e61f7e26e0c15defb187e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+ring-devel-0.103.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki+ring-devel.sha256sum] = "5b757b1f34312377e4442578646aef4c38e26b15fc0c102895d733a830e1179b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki+std-devel-0.103.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki+std-devel.sha256sum] = "045de4fb3bee505a9da77d1f28d4e3180a4134e856ddde7ea4cdc08cde21b53c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-webpki-devel-0.103.15-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-webpki-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustls-webpki-devel.sha256sum] = "fb5839045bc3750a3af56fad5a8c795fe2db6830b0ec077696bde4d986c94abe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+alloc-devel-0.103.15-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki+alloc-devel.sha256sum] = "7fd54ba954fc14a9bbcfec7dd57acc370f309d30727f0a6df297f542812ae579"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+default-devel-0.103.15-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki+default-devel.sha256sum] = "1e94df15a40b0fa52753f54143de56386d22270c293e66a6603382ad9d80ecb8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+ring-devel-0.103.15-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki+ring-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki+ring-devel.sha256sum] = "f85907a2a7726bce99a1b1d0fc4662765eef7bad6468222e28327d09d5cced0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki+std-devel-0.103.15-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki+std-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki+std-devel.sha256sum] = "3ed43a9cd0f98832e82983f10e3c02ae1b9c6a15dfb1db3a6b6248543dacbc4a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-webpki-devel-0.103.15-1.el10_3.noarch.rpm;name=aarch64_rust-rustls-webpki-devel;unpack=0"
SRC_URI[aarch64_rust-rustls-webpki-devel.sha256sum] = "222a4f62b23b27ccf1a7e76bd31dcf981873728f68bf2904373a4841242cfd10"

RDEPENDS:rust-rustls-webpki+alloc-devel = " \
 cargo \
 rust-ring+alloc-devel \
 rust-ring-devel \
 rust-rustls-pki-types+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+default-devel = " \
 cargo \
 rust-rustls-webpki+std-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+ring-devel = " \
 cargo \
 rust-ring-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki+std-devel = " \
 cargo \
 rust-rustls-pki-types+std-devel \
 rust-rustls-webpki+alloc-devel \
 rust-rustls-webpki-devel \
 "
RDEPENDS:rust-rustls-webpki-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 rust-untrusted+default-devel \
 "
