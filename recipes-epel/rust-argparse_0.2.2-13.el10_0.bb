# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-argparse"
PV = "0.2.2"
PR = "13.el10_0"
PACKAGES = " \
 rust-argparse+default-devel \
 rust-argparse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-argparse-0.2.2-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "38761544ac0c2bb8d0a8185f36f61b6930be6367b78c3a33e1db239e209059c0"

URI_x86_64_v2_rust-argparse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argparse+default-devel-0.2.2-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argparse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argparse+default-devel}"
SRC_URI[x86_64_v2_rust-argparse+default-devel.sha256sum] = "993c038d85af287b9dcdac9f9691db98f48186bed888db10d7d9f8aa9a5b5b35"

URI_x86_64_v2_rust-argparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-argparse-devel-0.2.2-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-argparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-argparse-devel}"
SRC_URI[x86_64_v2_rust-argparse-devel.sha256sum] = "73c07c8bd2cf977989c08ec799ac95ee426158791843e7cb15c8bd86f65d6c29"

URI_aarch64_rust-argparse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argparse+default-devel-0.2.2-13.el10_0.noarch.rpm;name=aarch64_rust-argparse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argparse+default-devel}"
SRC_URI[aarch64_rust-argparse+default-devel.sha256sum] = "dbd9c6457706dc93e1f432d966b210c80cffcd5a1c265a122cd241ce5eac5988"

URI_aarch64_rust-argparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-argparse-devel-0.2.2-13.el10_0.noarch.rpm;name=aarch64_rust-argparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-argparse-devel}"
SRC_URI[aarch64_rust-argparse-devel.sha256sum] = "74694b265742402c2e4443d5ac5c39e68f9a8d6d704f333ef040d18a34be90f2"

RDEPENDS:rust-argparse+default-devel = " \
 cargo \
 rust-argparse-devel \
 "
RDEPENDS:rust-argparse-devel = " \
 cargo \
 "
