# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "llvm19"
PV = "19.1.7"
PR = "15.el10_1"
PACKAGES = " \
 clang19 \
 clang19-analyzer \
 clang19-devel \
 clang19-libs \
 clang19-resource-filesystem \
 clang19-tools-extra \
 clang19-tools-extra-devel \
 compiler-rt19 \
 git-clang-format19 \
 libomp19 \
 libomp19-devel \
 lld19 \
 lld19-devel \
 lld19-libs \
 lldb19 \
 lldb19-devel \
 llvm19 \
 llvm19-cmake-utils \
 llvm19-devel \
 llvm19-doc \
 llvm19-filesystem \
 llvm19-googletest \
 llvm19-libs \
 llvm19-static \
 llvm19-test \
 llvm19-toolset \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/llvm19-19.1.7-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f75882262c1ec6fe50a937c3b18b037eefe5076bbbc6412b43ec0a71c950c791"

URI_x86_64_v2_clang19 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang19-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang19;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang19}"
SRC_URI[x86_64_v2_clang19.sha256sum] = "58bebb35751538c230121006f54b40167457d1945b77ed1195f1497f2f1718c5"

URI_x86_64_v2_clang19-analyzer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang19-analyzer-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang19-analyzer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang19-analyzer}"
SRC_URI[x86_64_v2_clang19-analyzer.sha256sum] = "c796882b2dbd40f1e6f050ed014f8ca75e318fa6fdb8a49bb859bb5eca6d5b1b"

URI_x86_64_v2_clang19-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang19-devel-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang19-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang19-devel}"
SRC_URI[x86_64_v2_clang19-devel.sha256sum] = "bef0fe8f0d2660204db6800f53c05aebbd0f4bf523f2b3b45358633f1068c28a"

URI_x86_64_v2_clang19-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang19-libs-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang19-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang19-libs}"
SRC_URI[x86_64_v2_clang19-libs.sha256sum] = "9bb359d8cd37e048d432d3e5db7cdc8e54ccb3ab377e7e8e702adc8e9c850ceb"

URI_x86_64_v2_clang19-resource-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang19-resource-filesystem-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang19-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang19-resource-filesystem}"
SRC_URI[x86_64_v2_clang19-resource-filesystem.sha256sum] = "156a3444414cf144b125c44b1268847ad9122af68b3d94377d2b8ad98457a72c"

URI_x86_64_v2_clang19-tools-extra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang19-tools-extra-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang19-tools-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang19-tools-extra}"
SRC_URI[x86_64_v2_clang19-tools-extra.sha256sum] = "5ddb4ebf1cbf86314114b614d7e0fad5b5f2e46b309e53eaebb6694d6dd8849c"

URI_x86_64_v2_clang19-tools-extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/clang19-tools-extra-devel-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_clang19-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_clang19-tools-extra-devel}"
SRC_URI[x86_64_v2_clang19-tools-extra-devel.sha256sum] = "c910b590bfb1360fd8d1842f15b132bf955e67136ae09afee4cb3a397d3977fd"

URI_x86_64_v2_compiler-rt19 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compiler-rt19-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_compiler-rt19;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compiler-rt19}"
SRC_URI[x86_64_v2_compiler-rt19.sha256sum] = "c1b4a843711a38d7574085bd24ba6f3e1c21d6c5e63956aa506b8f34ce05e14d"

URI_x86_64_v2_git-clang-format19 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-clang-format19-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-clang-format19;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-clang-format19}"
SRC_URI[x86_64_v2_git-clang-format19.sha256sum] = "1e15c5db3783482d92129de8ae11b8fb8c3cca37846c25adafaa6824d5978753"

URI_x86_64_v2_libomp19 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libomp19-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libomp19;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp19}"
SRC_URI[x86_64_v2_libomp19.sha256sum] = "69d0f5edc2a0f921c73427e4b586214ec68e0aad9693d4a3118d8cb78b41d56b"
RPROVIDES:libomp19:x86_64_v2 = "virtual/libomp.so_VERSION__64bit_ virtual/libomp.so___64bit_"

URI_x86_64_v2_libomp19-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libomp19-devel-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libomp19-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libomp19-devel}"
SRC_URI[x86_64_v2_libomp19-devel.sha256sum] = "caf2a7a5bdafb302ee002dd8ee46c1e197e4e9eeb6d2f8a4e22f373749edd027"

URI_x86_64_v2_lld19 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld19-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld19;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld19}"
SRC_URI[x86_64_v2_lld19.sha256sum] = "91541505a7955afa41df0bee5055bbf7d5f85c5b05a0d172d8c1700e92d7732d"

URI_x86_64_v2_lld19-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld19-devel-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld19-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld19-devel}"
SRC_URI[x86_64_v2_lld19-devel.sha256sum] = "edcc05acd0f0df6f447a8ff443930bc80fe0cd12f78af4bc199037d62af985a8"

URI_x86_64_v2_lld19-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld19-libs-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld19-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld19-libs}"
SRC_URI[x86_64_v2_lld19-libs.sha256sum] = "5e592c494e62c32ae48e0a88937852241fbbed7625ad34804e6dffbf73174490"

URI_x86_64_v2_lldb19 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lldb19-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lldb19;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb19}"
SRC_URI[x86_64_v2_lldb19.sha256sum] = "d6f16044f8b639a7687e7c4aff92afa85e5c27cde9d6875199d806acfe43eb01"

URI_x86_64_v2_lldb19-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lldb19-devel-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lldb19-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lldb19-devel}"
SRC_URI[x86_64_v2_lldb19-devel.sha256sum] = "b4a51c79e6a192a8ca31af63f4647ea08515aab03909e62434016f9643093594"

URI_x86_64_v2_llvm19 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm19;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19}"
SRC_URI[x86_64_v2_llvm19.sha256sum] = "c9b21c8649901cb961d646002bc31b7d149fda95cef7fb439721998d256d5a0c"

URI_x86_64_v2_llvm19-cmake-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-cmake-utils-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm19-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19-cmake-utils}"
SRC_URI[x86_64_v2_llvm19-cmake-utils.sha256sum] = "dc25959a37f9bcfbbfb82d63666a11d1ecf224c42926ecc165d3bf49aff50b9c"

URI_x86_64_v2_llvm19-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-devel-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm19-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19-devel}"
SRC_URI[x86_64_v2_llvm19-devel.sha256sum] = "4a02d5873940cb1ebe468feb7a98c07689099bc171c23027173e9d6393d2c152"

URI_x86_64_v2_llvm19-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-doc-19.1.7-15.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_llvm19-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19-doc}"
SRC_URI[x86_64_v2_llvm19-doc.sha256sum] = "2e223ad420eb3247cf9245821dda8bc49f92d5b179e3aa002bccbaa87f65520d"

URI_x86_64_v2_llvm19-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-filesystem-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm19-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19-filesystem}"
SRC_URI[x86_64_v2_llvm19-filesystem.sha256sum] = "02af32a50a7d709e7a4ae201cbd1a0a7f9605db29ff15952cf0c033d986ec0f8"

URI_x86_64_v2_llvm19-googletest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-googletest-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm19-googletest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19-googletest}"
SRC_URI[x86_64_v2_llvm19-googletest.sha256sum] = "19e4343837d9f6fee0c4174fbdd9a7e348a8d060ef87ef293f59756a0f5cb5be"

URI_x86_64_v2_llvm19-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-libs-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm19-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19-libs}"
SRC_URI[x86_64_v2_llvm19-libs.sha256sum] = "0fff1b778163b09f5a7f0c7c45b662acdbd022231eb987422157a9d9b068a3c3"

URI_x86_64_v2_llvm19-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-static-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm19-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19-static}"
SRC_URI[x86_64_v2_llvm19-static.sha256sum] = "087178bfb1076835474f463f4690d2e75cad161ddd262124218131238d8f0a69"

URI_x86_64_v2_llvm19-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-test-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm19-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19-test}"
SRC_URI[x86_64_v2_llvm19-test.sha256sum] = "25b5fee79b1080cc81f538e53c449e67a402fb9fb4a8d7dd85e6b4b1fb4d36d2"

URI_x86_64_v2_llvm19-toolset = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/llvm19-toolset-19.1.7-15.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_llvm19-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_llvm19-toolset}"
SRC_URI[x86_64_v2_llvm19-toolset.sha256sum] = "2bff16778ae32d6a3de24933b85af5afe7c9ee035a027becaa3d887f7afaf119"

URI_aarch64_clang19 = "${EPEL_MIRROR}/aarch64/Packages/c/clang19-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_clang19;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang19}"
SRC_URI[aarch64_clang19.sha256sum] = "f5c2473d976c3e1281081dafc0cd31d86129719086e13ba596415430b5565b29"

URI_aarch64_clang19-analyzer = "${EPEL_MIRROR}/aarch64/Packages/c/clang19-analyzer-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_clang19-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang19-analyzer}"
SRC_URI[aarch64_clang19-analyzer.sha256sum] = "3e52f43d07b4f3d4876efab361f517918c4e8efdd27eeb7a78a5b3dd1a1f1558"

URI_aarch64_clang19-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang19-devel-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_clang19-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang19-devel}"
SRC_URI[aarch64_clang19-devel.sha256sum] = "97d056d36dc09dc400ba5648876f56ab505008a08c4bf8aae54aea75566e56b5"

URI_aarch64_clang19-libs = "${EPEL_MIRROR}/aarch64/Packages/c/clang19-libs-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_clang19-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang19-libs}"
SRC_URI[aarch64_clang19-libs.sha256sum] = "b66e509cfba71bf530675797872f2711e750b83667b287149ba5643c46f11bdc"

URI_aarch64_clang19-resource-filesystem = "${EPEL_MIRROR}/aarch64/Packages/c/clang19-resource-filesystem-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_clang19-resource-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang19-resource-filesystem}"
SRC_URI[aarch64_clang19-resource-filesystem.sha256sum] = "c17f1465ccc764fd6385145437ed7ae1db080494e1297da2b512eeeb5819f276"

URI_aarch64_clang19-tools-extra = "${EPEL_MIRROR}/aarch64/Packages/c/clang19-tools-extra-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_clang19-tools-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang19-tools-extra}"
SRC_URI[aarch64_clang19-tools-extra.sha256sum] = "4669e8cc623309ccf972bbc54d3c31bc9436ec11e5044bb1e1dd94d34c421ff6"

URI_aarch64_clang19-tools-extra-devel = "${EPEL_MIRROR}/aarch64/Packages/c/clang19-tools-extra-devel-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_clang19-tools-extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_clang19-tools-extra-devel}"
SRC_URI[aarch64_clang19-tools-extra-devel.sha256sum] = "e78cea47a453e96b2d0544e5a0634625801f01fdfc74c60a59fb6be977f5e8b7"

URI_aarch64_compiler-rt19 = "${EPEL_MIRROR}/aarch64/Packages/c/compiler-rt19-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_compiler-rt19;unpack=0"
SRC_URI:append = " ${URI_aarch64_compiler-rt19}"
SRC_URI[aarch64_compiler-rt19.sha256sum] = "48f0ed306a25141e06a106293ed46f3798ebe977ee2c1e7fae73afb5ff712df6"

URI_aarch64_git-clang-format19 = "${EPEL_MIRROR}/aarch64/Packages/g/git-clang-format19-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_git-clang-format19;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-clang-format19}"
SRC_URI[aarch64_git-clang-format19.sha256sum] = "02b2a02e9ffbdedcda9eea03851744381e257446d4b8b373456be210233965f8"

URI_aarch64_libomp19 = "${EPEL_MIRROR}/aarch64/Packages/l/libomp19-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_libomp19;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp19}"
SRC_URI[aarch64_libomp19.sha256sum] = "337042f8938b26f6d6e0d09fe88b22d27dc1c044769a3a6c20c1e4b9cba85f00"

URI_aarch64_libomp19-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libomp19-devel-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_libomp19-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libomp19-devel}"
SRC_URI[aarch64_libomp19-devel.sha256sum] = "ff88e2dbdcd90239ec64988e4ca2fda945c92c2e280a55e58cf2272ef7d7464b"

URI_aarch64_lld19 = "${EPEL_MIRROR}/aarch64/Packages/l/lld19-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_lld19;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld19}"
SRC_URI[aarch64_lld19.sha256sum] = "c969603de4fd79b1d19a6b61288afee93234dff5721e27afab38e62a70b228e1"

URI_aarch64_lld19-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lld19-devel-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_lld19-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld19-devel}"
SRC_URI[aarch64_lld19-devel.sha256sum] = "3c284dc15f044bed55b1a6ddb5547a6ef3f658e581008050a44c5fdae9dd04ef"

URI_aarch64_lld19-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lld19-libs-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_lld19-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld19-libs}"
SRC_URI[aarch64_lld19-libs.sha256sum] = "6af391b79566aca5ad57673735b4cfbc42bf6d61be4ce46ded18f66a3f8ce9ab"

URI_aarch64_lldb19 = "${EPEL_MIRROR}/aarch64/Packages/l/lldb19-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_lldb19;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb19}"
SRC_URI[aarch64_lldb19.sha256sum] = "71de3ae67c6cda46b7ec919850140d55b9c1a9d1c6aceacbfe74614bde158e44"

URI_aarch64_lldb19-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lldb19-devel-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_lldb19-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lldb19-devel}"
SRC_URI[aarch64_lldb19-devel.sha256sum] = "d5ca6939db11c336fd1807c65eee62c54a905ad272f7f6e7b32a55922cb9e306"

URI_aarch64_llvm19 = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_llvm19;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19}"
SRC_URI[aarch64_llvm19.sha256sum] = "65fa927dd5e5bacd91cda24b072e79a99f7bc044bf8652cf7714a12604356f41"

URI_aarch64_llvm19-cmake-utils = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-cmake-utils-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_llvm19-cmake-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19-cmake-utils}"
SRC_URI[aarch64_llvm19-cmake-utils.sha256sum] = "bccbc76c6083d8a780ad061ad582fc2ba8fb01cdab309bad075b349dcbf48eea"

URI_aarch64_llvm19-devel = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-devel-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_llvm19-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19-devel}"
SRC_URI[aarch64_llvm19-devel.sha256sum] = "3e92d1f924300bc7063a661fb92ae7b5862246f93f17d47afd50f7e536038d4c"

URI_aarch64_llvm19-doc = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-doc-19.1.7-15.el10_1.noarch.rpm;name=aarch64_llvm19-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19-doc}"
SRC_URI[aarch64_llvm19-doc.sha256sum] = "a76697019a82f3e4462b2152f41061b7c1f33e5afa7b874c0bbb96a842002d00"

URI_aarch64_llvm19-filesystem = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-filesystem-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_llvm19-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19-filesystem}"
SRC_URI[aarch64_llvm19-filesystem.sha256sum] = "3301821b67685f44d35963ce8ffd5bf0eb706c1cdb0e2141a850d29afe0a2363"

URI_aarch64_llvm19-googletest = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-googletest-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_llvm19-googletest;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19-googletest}"
SRC_URI[aarch64_llvm19-googletest.sha256sum] = "146e846ffeee2a62cc6df5b072c3cf57bc35175761e49384f4973e45a2e22915"

URI_aarch64_llvm19-libs = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-libs-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_llvm19-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19-libs}"
SRC_URI[aarch64_llvm19-libs.sha256sum] = "3a25090399a18f842c30e3cba5003f636453df0d8d805ce3b7015d797e42a149"

URI_aarch64_llvm19-static = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-static-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_llvm19-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19-static}"
SRC_URI[aarch64_llvm19-static.sha256sum] = "f1818251158c5de131e48ea514606741456e716edac59bd302e835b30167a78c"

URI_aarch64_llvm19-test = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-test-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_llvm19-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19-test}"
SRC_URI[aarch64_llvm19-test.sha256sum] = "e3ffed141d284b2dd2e7ac372b93538e7d7181afd417a1923d2a97e1084e79f5"

URI_aarch64_llvm19-toolset = "${EPEL_MIRROR}/aarch64/Packages/l/llvm19-toolset-19.1.7-15.el10_1.aarch64.rpm;name=aarch64_llvm19-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_llvm19-toolset}"
SRC_URI[aarch64_llvm19-toolset.sha256sum] = "cca4ae3321fa77484154c29671d85625e699130baaf32a7adfb8c980ab7f55a6"

RDEPENDS:clang19 = " \
 clang19-libs \
 gcc-c++ \
 glibc \
 libgcc \
 libstdc++ \
 libstdc++-devel \
 llvm19-libs \
 "
RDEPENDS:clang19-analyzer = " \
 clang19 \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-File-Temp \
 perl-FindBin \
 perl-Hash-Util \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Text-ParseWords \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3 \
 "
RDEPENDS:clang19-devel = " \
 clang19 \
 clang19-libs \
 clang19-tools-extra \
 glibc \
 libgcc \
 libstdc++ \
 llvm19-devel \
 "
RDEPENDS:clang19-libs = " \
 clang19-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 llvm19-libs \
 "
RDEPENDS:clang19-resource-filesystem = " \
 "
RDEPENDS:clang19-tools-extra = " \
 clang19-libs \
 emacs-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm19-libs \
 python3 \
 "
RDEPENDS:clang19-tools-extra-devel = " \
 clang19-tools-extra \
 "
RDEPENDS:compiler-rt19 = " \
 clang19-resource-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:git-clang-format19 = " \
 clang19-tools-extra \
 git \
 python3 \
 "
RDEPENDS:libomp19 = " \
 elfutils-libelf \
 glibc \
 libffi \
 libgcc \
 libstdc++ \
 llvm19-libs \
 "
RDEPENDS:libomp19-devel = " \
 clang19-resource-filesystem \
 libomp19 \
 "
RDEPENDS:lld19 = " \
 alternatives \
 glibc \
 libgcc \
 libstdc++ \
 lld19-libs \
 llvm19-libs \
 "
RDEPENDS:lld19-devel = " \
 lld19-libs \
 "
RDEPENDS:lld19-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm19-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb19 = " \
 clang19-libs \
 glibc \
 libedit \
 libgcc \
 libstdc++ \
 libxml2 \
 llvm19-libs \
 ncurses-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:lldb19-devel = " \
 lldb19 \
 "
RDEPENDS:llvm19 = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 llvm19-libs \
 python3 \
 zlib-ng-compat \
 "
RDEPENDS:llvm19-cmake-utils = " \
 llvm19-filesystem \
 "
RDEPENDS:llvm19-devel = " \
 alternatives \
 bash \
 glibc \
 libedit-devel \
 libgcc \
 libstdc++ \
 libzstd-devel \
 llvm19 \
 llvm19-googletest \
 llvm19-libs \
 llvm19-static \
 llvm19-test \
 "
RDEPENDS:llvm19-doc = " \
 llvm19 \
 "
RDEPENDS:llvm19-filesystem = " \
 "
RDEPENDS:llvm19-googletest = " \
 llvm19-filesystem \
 "
RDEPENDS:llvm19-libs = " \
 glibc \
 libedit \
 libffi \
 libgcc \
 libstdc++ \
 libxml2 \
 libzstd \
 llvm19-filesystem \
 zlib-ng-compat \
 "
RDEPENDS:llvm19-static = " \
 llvm19-filesystem \
 "
RDEPENDS:llvm19-test = " \
 glibc \
 libgcc \
 libstdc++ \
 llvm19 \
 llvm19-libs \
 "
RDEPENDS:llvm19-toolset = " \
 clang19 \
 lld19 \
 llvm19 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libomp.so_VERSION__64bit_ rpm/virtual/libomp.so___64bit_"
