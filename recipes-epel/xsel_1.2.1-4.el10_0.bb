# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xsel"
PV = "1.2.1"
PR = "4.el10_0"
PACKAGES = " \
 xsel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xsel-1.2.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fdde22ac366f3eee24217666034dcae97b2358d4d1f510b9ad2ce794600b2b9"

URI_x86_64_v2_xsel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xsel-1.2.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xsel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xsel}"
SRC_URI[x86_64_v2_xsel.sha256sum] = "dd6354a4ae2d268181529eedff9419c3426ca591ede9a3e3ae024183b186a9c3"

URI_aarch64_xsel = "${EPEL_MIRROR}/aarch64/Packages/x/xsel-1.2.1-4.el10_0.aarch64.rpm;name=aarch64_xsel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xsel}"
SRC_URI[aarch64_xsel.sha256sum] = "61df110e8cf844770da6d54f02cfab3ff15717f329a5d99beaa9ce994255f3ab"

RDEPENDS:xsel = " \
 glibc \
 libX11 \
 "
