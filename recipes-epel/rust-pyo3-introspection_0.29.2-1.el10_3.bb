# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-introspection"
PV = "0.29.2"
PR = "1.el10_3"
PACKAGES = " \
 pyo3-introspection \
 rust-pyo3-introspection+default-devel \
 rust-pyo3-introspection-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-introspection-0.29.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "07dabd00ba05a2aadb52bb239f003e7f39089e1169e8c064a8619cfcf0b83aa9"

URI_x86_64_v2_pyo3-introspection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyo3-introspection-0.29.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pyo3-introspection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyo3-introspection}"
SRC_URI[x86_64_v2_pyo3-introspection.sha256sum] = "8c019ce98e79bce8ea2b738bf7a22b9fee4aaa655c72ac7a7a9ce41b3e41b4e1"

URI_x86_64_v2_rust-pyo3-introspection+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-introspection+default-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-introspection+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-introspection+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-introspection+default-devel.sha256sum] = "09608fc7de8db40e9a36828dae4deec6fb83d40c4440994d3723ffef55672d7a"

URI_x86_64_v2_rust-pyo3-introspection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-introspection-devel-0.29.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-introspection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-introspection-devel}"
SRC_URI[x86_64_v2_rust-pyo3-introspection-devel.sha256sum] = "de2bedd811ee03095c658f27b86ba56c3643f830a7313bc74ec091414bbf14a9"

URI_aarch64_pyo3-introspection = "${EPEL_MIRROR}/aarch64/Packages/p/pyo3-introspection-0.29.2-1.el10_3.aarch64.rpm;name=aarch64_pyo3-introspection;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyo3-introspection}"
SRC_URI[aarch64_pyo3-introspection.sha256sum] = "936e26e53b5f747cd3830be6e4e51d180ef74728bda6bbbcb7f7c0c62b9a8bdd"

URI_aarch64_rust-pyo3-introspection+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-introspection+default-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-introspection+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-introspection+default-devel}"
SRC_URI[aarch64_rust-pyo3-introspection+default-devel.sha256sum] = "3a3a75ac1f5f3b07af98fb65da6be4f04bfb2e4174e4b28c4f1d650e3199b490"

URI_aarch64_rust-pyo3-introspection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-introspection-devel-0.29.2-1.el10_3.noarch.rpm;name=aarch64_rust-pyo3-introspection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-introspection-devel}"
SRC_URI[aarch64_rust-pyo3-introspection-devel.sha256sum] = "9a4383ca4f782935176884f687e6e29d5e16c7caa9a6642abe921da056077ef0"

RDEPENDS:pyo3-introspection = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-pyo3-introspection+default-devel = " \
 cargo \
 rust-pyo3-introspection-devel \
 "
RDEPENDS:rust-pyo3-introspection-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 virtual/crate_goblin/default__ge_0.9.0_with_crate_goblin/default__lt_0.11.0~ \
 "
