# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat9"
PE = "1"
PV = "9.0.117"
PR = "2.el10_2.alma.1"
PACKAGES = " \
 tomcat9 \
 tomcat9-admin-webapps \
 tomcat9-docs-webapp \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-lib \
 tomcat9-servlet-4.0-api \
 tomcat9-webapps \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat9-9.0.117-2.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d8e83000fa8fab82e85368feb0b2b9d9784352f6de794e3d91890b09273c8de"

URI_x86_64_v2_tomcat9 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-9.0.117-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9}"
SRC_URI[x86_64_v2_tomcat9.sha256sum] = "7b18a53d3580ad05f99f8ee76bc0a5408bc9f0a2ca45465fd3446184546c2cb9"

URI_x86_64_v2_tomcat9-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-admin-webapps-9.0.117-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-admin-webapps}"
SRC_URI[x86_64_v2_tomcat9-admin-webapps.sha256sum] = "35f74b44de15b3b04a6bc454a111d3dfb26dfee6c7ad16644fb1a88130dce735"

URI_x86_64_v2_tomcat9-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-docs-webapp-9.0.117-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-docs-webapp}"
SRC_URI[x86_64_v2_tomcat9-docs-webapp.sha256sum] = "a59f4bad7f545f5287804da402c7f5be36cbae0c74cf7b8b5f691c3473fe68b6"

URI_x86_64_v2_tomcat9-el-3.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-el-3.0-api-9.0.117-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-el-3.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-el-3.0-api}"
SRC_URI[x86_64_v2_tomcat9-el-3.0-api.sha256sum] = "1e7a1f290d83d33dca1568da1d68c956d2ff9d703a7b398d2955f8f881f6c51c"

URI_x86_64_v2_tomcat9-jsp-2.3-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-jsp-2.3-api-9.0.117-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-jsp-2.3-api}"
SRC_URI[x86_64_v2_tomcat9-jsp-2.3-api.sha256sum] = "ac4d0fe0045a2723cfb5b6f43bdf719a027a0d7e5f26985bc08e3b4c1c91feb3"

URI_x86_64_v2_tomcat9-lib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-lib-9.0.117-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-lib}"
SRC_URI[x86_64_v2_tomcat9-lib.sha256sum] = "3a1e23335ca4fc1ca27006743516d5c74f7da734dc74dcdc72f5a4bed710668b"
RPROVIDES:tomcat9-lib:x86_64_v2 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_x86_64_v2_tomcat9-servlet-4.0-api = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-servlet-4.0-api-9.0.117-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-servlet-4.0-api}"
SRC_URI[x86_64_v2_tomcat9-servlet-4.0-api.sha256sum] = "42f01e89a5d4c20d96e5212710be93238f72ce04851d86ae714c53b925109a88"

URI_x86_64_v2_tomcat9-webapps = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-webapps-9.0.117-2.el10_2.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-webapps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tomcat9-webapps}"
SRC_URI[x86_64_v2_tomcat9-webapps.sha256sum] = "3682120341af35136b188a86d60de457c2c5936026aea99b5a7b1317d71f90f2"

URI_aarch64_tomcat9 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-9.0.117-2.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9}"
SRC_URI[aarch64_tomcat9.sha256sum] = "7b18a53d3580ad05f99f8ee76bc0a5408bc9f0a2ca45465fd3446184546c2cb9"

URI_aarch64_tomcat9-admin-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-admin-webapps-9.0.117-2.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-admin-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-admin-webapps}"
SRC_URI[aarch64_tomcat9-admin-webapps.sha256sum] = "35f74b44de15b3b04a6bc454a111d3dfb26dfee6c7ad16644fb1a88130dce735"

URI_aarch64_tomcat9-docs-webapp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-docs-webapp-9.0.117-2.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-docs-webapp;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-docs-webapp}"
SRC_URI[aarch64_tomcat9-docs-webapp.sha256sum] = "a59f4bad7f545f5287804da402c7f5be36cbae0c74cf7b8b5f691c3473fe68b6"

URI_aarch64_tomcat9-el-3.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-el-3.0-api-9.0.117-2.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-el-3.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-el-3.0-api}"
SRC_URI[aarch64_tomcat9-el-3.0-api.sha256sum] = "1e7a1f290d83d33dca1568da1d68c956d2ff9d703a7b398d2955f8f881f6c51c"

URI_aarch64_tomcat9-jsp-2.3-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-jsp-2.3-api-9.0.117-2.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-jsp-2.3-api}"
SRC_URI[aarch64_tomcat9-jsp-2.3-api.sha256sum] = "ac4d0fe0045a2723cfb5b6f43bdf719a027a0d7e5f26985bc08e3b4c1c91feb3"

URI_aarch64_tomcat9-lib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-lib-9.0.117-2.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-lib}"
SRC_URI[aarch64_tomcat9-lib.sha256sum] = "3a1e23335ca4fc1ca27006743516d5c74f7da734dc74dcdc72f5a4bed710668b"
RPROVIDES:tomcat9-lib:aarch64 = "virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 virtual/mvn_org.apache.tomcat_tomcat-juli_ virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

URI_aarch64_tomcat9-servlet-4.0-api = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-servlet-4.0-api-9.0.117-2.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-servlet-4.0-api}"
SRC_URI[aarch64_tomcat9-servlet-4.0-api.sha256sum] = "42f01e89a5d4c20d96e5212710be93238f72ce04851d86ae714c53b925109a88"

URI_aarch64_tomcat9-webapps = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-webapps-9.0.117-2.el10_2.alma.1.noarch.rpm;name=aarch64_tomcat9-webapps;unpack=0"
SRC_URI:append = " ${URI_aarch64_tomcat9-webapps}"
SRC_URI[aarch64_tomcat9-webapps.sha256sum] = "3682120341af35136b188a86d60de457c2c5936026aea99b5a7b1317d71f90f2"

RDEPENDS:tomcat9 = " \
 bash \
 javapackages-tools \
 shadow-utils \
 systemd \
 tomcat9-lib \
 virtual/java-headless_or_java-25-headless \
 "
RDEPENDS:tomcat9-admin-webapps = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-docs-webapp = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-el-3.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-jsp-2.3-api = " \
 bash \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-servlet-4.0-api \
 "
RDEPENDS:tomcat9-lib = " \
 ecj \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-servlet-4.0-api \
 virtual/coreutils \
 "
RDEPENDS:tomcat9-servlet-4.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-webapps = " \
 tomcat9 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"

PROVIDES:append:aarch64 = " rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina_ rpm/virtual/mvn_org.apache.tomcat_tomcat-catalina__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote_ rpm/virtual/mvn_org.apache.tomcat_tomcat-coyote__ge_9.0.62 rpm/virtual/mvn_org.apache.tomcat_tomcat-juli_ rpm/virtual/mvn_org.apache.tomcat_tomcat-juli__ge_9.0.62"
