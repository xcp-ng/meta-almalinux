# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "staticcheck"
PV = "2026.1"
PR = "1.el10_3"
PACKAGES = " \
 staticcheck \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/staticcheck-2026.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa730be9c2c966bf914c198d1c208775e4f3a0b95b80e190175c113218108807"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/staticcheck-2026.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_staticcheck;unpack=0"
SRC_URI[x86_64_v2_staticcheck.sha256sum] = "ef7a7b1814cc08c5b0af22473e56881a470a079c04af1db9b5c56a4b370731df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/staticcheck-2026.1-1.el10_3.aarch64.rpm;name=aarch64_staticcheck;unpack=0"
SRC_URI[aarch64_staticcheck.sha256sum] = "c3b9b06f4aab0ef91d8eebbba5bf1a8c658a55792deb7f151e0925ae379f71b8"

RDEPENDS:staticcheck = " \
 glibc \
 "
