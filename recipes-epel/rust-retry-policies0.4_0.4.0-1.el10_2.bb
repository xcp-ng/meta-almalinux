# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-retry-policies0.4"
PV = "0.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-retry-policies0.4+default-devel \
 rust-retry-policies0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-retry-policies0.4-0.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05f141eeace26701ceed6baf92e2d6f7fe4d6dd9c7e1eff438a62f6daa1edd40"

URI_x86_64_v2_rust-retry-policies0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-retry-policies0.4+default-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-retry-policies0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-retry-policies0.4+default-devel}"
SRC_URI[x86_64_v2_rust-retry-policies0.4+default-devel.sha256sum] = "5b80ee3bd3dd87209f7dd41ebe6bbe337ed5a3494312e1914d526a776e8b5261"

URI_x86_64_v2_rust-retry-policies0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-retry-policies0.4-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-retry-policies0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-retry-policies0.4-devel}"
SRC_URI[x86_64_v2_rust-retry-policies0.4-devel.sha256sum] = "1328c808f0d1fd812dd39c7cc1037f6585a0b328f4a863eaa2aa52bc5e924fe5"

URI_aarch64_rust-retry-policies0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-retry-policies0.4+default-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-retry-policies0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-retry-policies0.4+default-devel}"
SRC_URI[aarch64_rust-retry-policies0.4+default-devel.sha256sum] = "af57f47b1f668417cc6344020c790d20f40f4159623987fca0ea4cd5b322b64c"

URI_aarch64_rust-retry-policies0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-retry-policies0.4-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-retry-policies0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-retry-policies0.4-devel}"
SRC_URI[aarch64_rust-retry-policies0.4-devel.sha256sum] = "416946413290f55a0953e76023ecd04faf9aa25f51cfc8289d2a7eca7f638430"

RDEPENDS:rust-retry-policies0.4+default-devel = " \
 cargo \
 rust-retry-policies0.4-devel \
 "
RDEPENDS:rust-retry-policies0.4-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 "
