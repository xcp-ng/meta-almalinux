# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-http-directory"
PV = "0.1.12"
PR = "1.el10_2"
PACKAGES:x86_64_v2 = " \
 ghc-http-directory \
 ghc-http-directory-devel \
 ghc-http-directory-doc \
"
PACKAGES:aarch64 = " \
 ghc-http-directory \
 ghc-http-directory-devel \
 ghc-http-directory-doc \
 ghc-http-directory-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-http-directory-0.1.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab357b7c97d10dbf9a889aaa1b6b962146165174736f9e2666a8f74f9cbafbd6"

URI_x86_64_v2_ghc-http-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-directory-0.1.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-directory}"
SRC_URI[x86_64_v2_ghc-http-directory.sha256sum] = "8a1ceb6a1ff386af0663a2700f4075fb3d69983433f3821b97a2142c79e07784"

URI_x86_64_v2_ghc-http-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-directory-devel-0.1.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-directory-devel}"
SRC_URI[x86_64_v2_ghc-http-directory-devel.sha256sum] = "48581f688fe8b61fe161a78c89e18287f882de6704ce20bea2056b018a9cbba3"

URI_x86_64_v2_ghc-http-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http-directory-doc-0.1.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-http-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http-directory-doc}"
SRC_URI[x86_64_v2_ghc-http-directory-doc.sha256sum] = "ef749968ec82228019ac21c792302d1fb2fffff80dcad4612094d2d58ef2ce6a"

URI_aarch64_ghc-http-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-directory-0.1.12-1.el10_2.aarch64.rpm;name=aarch64_ghc-http-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-directory}"
SRC_URI[aarch64_ghc-http-directory.sha256sum] = "e5491bb3c2af6ce7d9d4e2a9f42b5cb2bfd3165fae351eb6e881f832ddb121b9"

URI_aarch64_ghc-http-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-directory-devel-0.1.12-1.el10_2.aarch64.rpm;name=aarch64_ghc-http-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-directory-devel}"
SRC_URI[aarch64_ghc-http-directory-devel.sha256sum] = "caf3a8a88b7cac76dbda88e3435fd009c8a0cc6fbc0d42717d164a050a7dfd5b"

URI_aarch64_ghc-http-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-directory-doc-0.1.12-1.el10_2.noarch.rpm;name=aarch64_ghc-http-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-directory-doc}"
SRC_URI[aarch64_ghc-http-directory-doc.sha256sum] = "9cd923b18f3fd5237399421200d45591d6e8c4186c09287ba12dba56a21b5aaa"

URI_aarch64_ghc-http-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http-directory-prof-0.1.12-1.el10_2.aarch64.rpm;name=aarch64_ghc-http-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http-directory-prof}"
SRC_URI[aarch64_ghc-http-directory-prof.sha256sum] = "ad703199449ea61c914a6cca22b09221045bddff7ac239c76b11437e85695359"

RDEPENDS:ghc-http-directory = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-appar \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-base64-bytestring \
 ghc-basement \
 ghc-bifunctors \
 ghc-binary \
 ghc-bitvec \
 ghc-blaze-builder \
 ghc-blaze-html \
 ghc-blaze-markup \
 ghc-byteorder \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-cereal \
 ghc-comonad \
 ghc-conduit \
 ghc-conduit-extra \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-crypton \
 ghc-crypton-connection \
 ghc-crypton-x509 \
 ghc-crypton-x509-store \
 ghc-crypton-x509-system \
 ghc-crypton-x509-validation \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-deepseq \
 ghc-directory \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-hourglass \
 ghc-html-conduit \
 ghc-http-client \
 ghc-http-client-tls \
 ghc-http-conduit \
 ghc-http-date \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-iproute \
 ghc-memory \
 ghc-mime-types \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-network \
 ghc-network-uri \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-parsec \
 ghc-pem \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-random \
 ghc-resourcet \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-socks \
 ghc-split \
 ghc-splitmix \
 ghc-stm \
 ghc-streaming-commons \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-tls \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-typed-process \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-uuid-types \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 ghc-witherable \
 ghc-xml-conduit \
 ghc-xml-types \
 ghc-zlib \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-http-directory-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-html-conduit-devel \
 ghc-http-client-devel \
 ghc-http-client-tls-devel \
 ghc-http-conduit-devel \
 ghc-http-date-devel \
 ghc-http-directory \
 ghc-http-types-devel \
 ghc-network-uri-devel \
 ghc-text-devel \
 ghc-time-devel \
 ghc-xml-conduit-devel \
 "
RDEPENDS:ghc-http-directory-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-http-directory-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-html-conduit-prof \
 ghc-http-client-prof \
 ghc-http-client-tls-prof \
 ghc-http-conduit-prof \
 ghc-http-date-prof \
 ghc-http-directory-devel \
 ghc-http-types-prof \
 ghc-network-uri-prof \
 ghc-text-prof \
 ghc-time-prof \
 ghc-xml-conduit-prof \
 "
