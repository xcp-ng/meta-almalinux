# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-Fatal"
PV = "0.017"
PR = "8.el10"
PACKAGES = " \
 perl-Test-Fatal \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-Test-Fatal-0.017-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10fadfc9d2f8297ae398bc76d51476f4e573ed1f94d923efd55d1e2e9794735a"

URI_x86_64_v2_perl-Test-Fatal = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-Test-Fatal-0.017-8.el10.noarch.rpm;name=x86_64_v2_perl-Test-Fatal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Fatal}"
SRC_URI[x86_64_v2_perl-Test-Fatal.sha256sum] = "8e41753989dcfc369b2fce467a73dda0b70f7607bb74d6ee6a88ff373ac2539e"

URI_aarch64_perl-Test-Fatal = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-Test-Fatal-0.017-8.el10.noarch.rpm;name=aarch64_perl-Test-Fatal;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Fatal}"
SRC_URI[aarch64_perl-Test-Fatal.sha256sum] = "8e41753989dcfc369b2fce467a73dda0b70f7607bb74d6ee6a88ff373ac2539e"

RDEPENDS:perl-Test-Fatal = " \
 perl-Carp \
 perl-Exporter \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-libs \
 "
