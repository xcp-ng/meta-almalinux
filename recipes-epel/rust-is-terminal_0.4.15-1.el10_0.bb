# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-is-terminal"
PV = "0.4.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-is-terminal+default-devel \
 rust-is-terminal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-is-terminal-0.4.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af2b348049f0c37cc4913f5397c6f29f0241c81d2ffdd2b0d4776251135fdec8"

URI_x86_64_v2_rust-is-terminal+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-terminal+default-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-terminal+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-terminal+default-devel}"
SRC_URI[x86_64_v2_rust-is-terminal+default-devel.sha256sum] = "4d7f67e8546def7c414db9646432a4bbc83a50446897139bca5ea2a02699e8e6"

URI_x86_64_v2_rust-is-terminal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-is-terminal-devel-0.4.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-is-terminal-devel}"
SRC_URI[x86_64_v2_rust-is-terminal-devel.sha256sum] = "67dced0b9d659a280ba3fe6c5a4b791a0bd1ca1455e3613c93e3a1f915cccd92"

URI_aarch64_rust-is-terminal+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-terminal+default-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-is-terminal+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-terminal+default-devel}"
SRC_URI[aarch64_rust-is-terminal+default-devel.sha256sum] = "1b21884fa77b7f1b779882eeac969631f3181cc9df1f3eb5c24bf90d3ed6fbbd"

URI_aarch64_rust-is-terminal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-is-terminal-devel-0.4.15-1.el10_0.noarch.rpm;name=aarch64_rust-is-terminal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-is-terminal-devel}"
SRC_URI[aarch64_rust-is-terminal-devel.sha256sum] = "2fdf9cdfa394c96c98044798fbad575fc76bf8279b876546acf3b5d263406208"

RDEPENDS:rust-is-terminal+default-devel = " \
 cargo \
 rust-is-terminal-devel \
 "
RDEPENDS:rust-is-terminal-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
