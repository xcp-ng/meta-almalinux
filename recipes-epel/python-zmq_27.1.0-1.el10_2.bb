# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zmq"
PV = "27.1.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-pyzmq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-zmq-27.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bbbf78018923cebbf4487930d1aff7ed2f92e543a2e3b05c8342a39afd93582"

URI_x86_64_v2_python3-pyzmq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyzmq-27.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyzmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyzmq}"
SRC_URI[x86_64_v2_python3-pyzmq.sha256sum] = "ce3bb842f768ced6d1c31b42f11e93a958730e7ef9d0128744f4504062841a98"

URI_aarch64_python3-pyzmq = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyzmq-27.1.0-1.el10_2.aarch64.rpm;name=aarch64_python3-pyzmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyzmq}"
SRC_URI[aarch64_python3-pyzmq.sha256sum] = "17e3239573a853217a67d103c2a2e8ddde0bbc7d2498ccefc0b66333048ed5ac"

RDEPENDS:python3-pyzmq = " \
 glibc \
 python3 \
 zeromq \
 "
