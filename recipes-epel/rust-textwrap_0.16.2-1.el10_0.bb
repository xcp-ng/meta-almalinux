# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-textwrap"
PV = "0.16.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-textwrap+default-devel \
 rust-textwrap+smawk-devel \
 rust-textwrap+terminal_size-devel \
 rust-textwrap+unicode-linebreak-devel \
 rust-textwrap+unicode-width-devel \
 rust-textwrap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-textwrap-0.16.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b08b56f38d1565e451a5429eb1198f3d5b1a9688eae362c69560d5291ac708d"

URI_x86_64_v2_rust-textwrap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+default-devel-0.16.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+default-devel}"
SRC_URI[x86_64_v2_rust-textwrap+default-devel.sha256sum] = "7217d14b42eaa6f5f5368e2124718fbc90db24209c85dab42f2dbe3f8c751937"

URI_x86_64_v2_rust-textwrap+smawk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+smawk-devel-0.16.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+smawk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+smawk-devel}"
SRC_URI[x86_64_v2_rust-textwrap+smawk-devel.sha256sum] = "91bcf46745385005e1f757ed4dcc4e5f865ebe16d8b2471a75e36228200b86e8"

URI_x86_64_v2_rust-textwrap+terminal_size-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+terminal_size-devel-0.16.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+terminal_size-devel}"
SRC_URI[x86_64_v2_rust-textwrap+terminal_size-devel.sha256sum] = "807c8d1a8a28502b42ed79d1f9349a0a60f09a565a1e88296aa66dbedf2e63ce"

URI_x86_64_v2_rust-textwrap+unicode-linebreak-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+unicode-linebreak-devel-0.16.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+unicode-linebreak-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+unicode-linebreak-devel}"
SRC_URI[x86_64_v2_rust-textwrap+unicode-linebreak-devel.sha256sum] = "d5ff97a68fbabd91563324c60bb725f7280fdb2791088170e925540b37d81d91"

URI_x86_64_v2_rust-textwrap+unicode-width-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap+unicode-width-devel-0.16.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap+unicode-width-devel}"
SRC_URI[x86_64_v2_rust-textwrap+unicode-width-devel.sha256sum] = "1770d10d87e9a2cccc7afbc20c1c2720e86bfca6191007fd3bdecb1760c62b3a"

URI_x86_64_v2_rust-textwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-textwrap-devel-0.16.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-textwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-textwrap-devel}"
SRC_URI[x86_64_v2_rust-textwrap-devel.sha256sum] = "034238c591e180eff949a3c7e643e96c8066d2db523c691d12448e0ba4f51c00"

URI_aarch64_rust-textwrap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+default-devel-0.16.2-1.el10_0.noarch.rpm;name=aarch64_rust-textwrap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+default-devel}"
SRC_URI[aarch64_rust-textwrap+default-devel.sha256sum] = "de58f9bcf38fa99aa91687ae6d2bef2710079bd22436f0312763b1b99bb62e8a"

URI_aarch64_rust-textwrap+smawk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+smawk-devel-0.16.2-1.el10_0.noarch.rpm;name=aarch64_rust-textwrap+smawk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+smawk-devel}"
SRC_URI[aarch64_rust-textwrap+smawk-devel.sha256sum] = "a914ca3206adb0dd77d47deed7650cf182d074403b9fe948b5b4aa7e27557f9f"

URI_aarch64_rust-textwrap+terminal_size-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+terminal_size-devel-0.16.2-1.el10_0.noarch.rpm;name=aarch64_rust-textwrap+terminal_size-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+terminal_size-devel}"
SRC_URI[aarch64_rust-textwrap+terminal_size-devel.sha256sum] = "aa9010f688b1e9efdefd7c8b1e0d88630f58655e74172a9eb66a0a993503aec5"

URI_aarch64_rust-textwrap+unicode-linebreak-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+unicode-linebreak-devel-0.16.2-1.el10_0.noarch.rpm;name=aarch64_rust-textwrap+unicode-linebreak-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+unicode-linebreak-devel}"
SRC_URI[aarch64_rust-textwrap+unicode-linebreak-devel.sha256sum] = "c9de7732a47901441f201245aa60ba0fa00226ae6fb8793cf098df931ad6c38f"

URI_aarch64_rust-textwrap+unicode-width-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap+unicode-width-devel-0.16.2-1.el10_0.noarch.rpm;name=aarch64_rust-textwrap+unicode-width-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap+unicode-width-devel}"
SRC_URI[aarch64_rust-textwrap+unicode-width-devel.sha256sum] = "43dfcdafb03bdf632c4a6c610dfa55ce93878c626dd56fe0b137b40836dfdde0"

URI_aarch64_rust-textwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-textwrap-devel-0.16.2-1.el10_0.noarch.rpm;name=aarch64_rust-textwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-textwrap-devel}"
SRC_URI[aarch64_rust-textwrap-devel.sha256sum] = "df940b828332de45a3da29678a876d603081e4d7dd8ac1d0f9d6ed0b0c2590e2"

RDEPENDS:rust-textwrap+default-devel = " \
 cargo \
 rust-textwrap+smawk-devel \
 rust-textwrap+unicode-linebreak-devel \
 rust-textwrap+unicode-width-devel \
 rust-textwrap-devel \
 "
RDEPENDS:rust-textwrap+smawk-devel = " \
 cargo \
 rust-smawk+default-devel \
 rust-textwrap-devel \
 "
RDEPENDS:rust-textwrap+terminal_size-devel = " \
 cargo \
 rust-terminal_size+default-devel \
 rust-textwrap-devel \
 "
RDEPENDS:rust-textwrap+unicode-linebreak-devel = " \
 cargo \
 rust-textwrap-devel \
 rust-unicode-linebreak+default-devel \
 "
RDEPENDS:rust-textwrap+unicode-width-devel = " \
 cargo \
 rust-textwrap-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-textwrap-devel = " \
 cargo \
 rust \
 "
