# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lebe"
PV = "0.5.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-lebe+default-devel \
 rust-lebe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lebe-0.5.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac41ba0b881d08982a1779ff78ac813ef86ffd3818f44c777a3acc6be52f090a"

URI_x86_64_v2_rust-lebe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lebe+default-devel-0.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lebe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lebe+default-devel}"
SRC_URI[x86_64_v2_rust-lebe+default-devel.sha256sum] = "e300034f64ca0129c3e4faab59da6810a981eede00cb624193ab6af82abda0c6"

URI_x86_64_v2_rust-lebe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lebe-devel-0.5.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lebe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lebe-devel}"
SRC_URI[x86_64_v2_rust-lebe-devel.sha256sum] = "64b5ff8f9f465a577036b65ceca78d17cb430c7297569f3485c046ddfa5c3b8b"

URI_aarch64_rust-lebe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lebe+default-devel-0.5.3-1.el10_0.noarch.rpm;name=aarch64_rust-lebe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lebe+default-devel}"
SRC_URI[aarch64_rust-lebe+default-devel.sha256sum] = "4e2796f28ea996423151d302e08e3cda8818d881978d928ad6b6e8c2ec7b07f8"

URI_aarch64_rust-lebe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lebe-devel-0.5.3-1.el10_0.noarch.rpm;name=aarch64_rust-lebe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lebe-devel}"
SRC_URI[aarch64_rust-lebe-devel.sha256sum] = "32ba227bdb39454e220e5d037753c4e63ec957fdf5b4c4ea8c20ee9f0537214f"

RDEPENDS:rust-lebe+default-devel = " \
 cargo \
 rust-lebe-devel \
 "
RDEPENDS:rust-lebe-devel = " \
 cargo \
 rust \
 "
