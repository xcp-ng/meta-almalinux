# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iml"
PV = "1.0.5"
PR = "48.el10_0"
PACKAGES = " \
 iml \
 iml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/iml-1.0.5-48.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e31b006d2449965e51b3b47f2ebecc5a2b6ad52194ec07eb20b5de86189bb7bc"

URI_x86_64_v2_iml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iml-1.0.5-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iml}"
SRC_URI[x86_64_v2_iml.sha256sum] = "82fd406866ee08f6ea0c48e835aafd99d6acb86091a92f6e565890690f00cd3a"

URI_x86_64_v2_iml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iml-devel-1.0.5-48.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iml-devel}"
SRC_URI[x86_64_v2_iml-devel.sha256sum] = "fb1d9efd1a780908b695218bb49f452157bf909051c053290d1ec809d3659b79"

URI_aarch64_iml = "${EPEL_MIRROR}/aarch64/Packages/i/iml-1.0.5-48.el10_0.aarch64.rpm;name=aarch64_iml;unpack=0"
SRC_URI:append = " ${URI_aarch64_iml}"
SRC_URI[aarch64_iml.sha256sum] = "c801afd95c8334f6685ac722330e31802fa38ce9d886d7068f48f1b42f86a6a5"

URI_aarch64_iml-devel = "${EPEL_MIRROR}/aarch64/Packages/i/iml-devel-1.0.5-48.el10_0.aarch64.rpm;name=aarch64_iml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iml-devel}"
SRC_URI[aarch64_iml-devel.sha256sum] = "41ebd69b4ab1ab8d425c32720f1938df9be4b6ddcdce55a5d35ac484bedde458"

RDEPENDS:iml = " \
 flexiblas-netlib \
 glibc \
 gmp \
 "
RDEPENDS:iml-devel = " \
 flexiblas-devel \
 gmp-devel \
 iml \
 "
