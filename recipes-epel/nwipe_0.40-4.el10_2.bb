# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nwipe"
PV = "0.40"
PR = "4.el10_2"
PACKAGES = " \
 nwipe \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nwipe-0.40-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3eeaa8330c8dcf842e81c60a0d72a2e94ea1b1a3240b4125a76b60c389d354b9"

URI_x86_64_v2_nwipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nwipe-0.40-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nwipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nwipe}"
SRC_URI[x86_64_v2_nwipe.sha256sum] = "0f7b7e936b8e2a4b30fd693b718c13daf83aabecea2afcbfef7e176cd91d83ce"

URI_aarch64_nwipe = "${EPEL_MIRROR}/aarch64/Packages/n/nwipe-0.40-4.el10_2.aarch64.rpm;name=aarch64_nwipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_nwipe}"
SRC_URI[aarch64_nwipe.sha256sum] = "5da06f3051626d28652abf41d9f60493dab2a68aa4b651cd1cf1a32032c439ed"

RDEPENDS:nwipe = " \
 dmidecode \
 glibc \
 hdparm \
 kmod \
 libconfig \
 ncurses-libs \
 parted \
 smartmontools \
 virtual//usr/bin/readlink \
 "
