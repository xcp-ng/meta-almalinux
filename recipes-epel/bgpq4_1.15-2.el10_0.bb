# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bgpq4"
PV = "1.15"
PR = "2.el10_0"
PACKAGES = " \
 bgpq4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bgpq4-1.15-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9fdbefc9c9d0559846a69aa1fe4e4e6c8a2cc70478e131a6db89e28393b4073"

URI_x86_64_v2_bgpq4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bgpq4-1.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bgpq4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bgpq4}"
SRC_URI[x86_64_v2_bgpq4.sha256sum] = "b9af297e5e020c0336e4b82a8c5f22ecaf5f54454b2a1efaa4593c3d1348be4e"

URI_aarch64_bgpq4 = "${EPEL_MIRROR}/aarch64/Packages/b/bgpq4-1.15-2.el10_0.aarch64.rpm;name=aarch64_bgpq4;unpack=0"
SRC_URI:append = " ${URI_aarch64_bgpq4}"
SRC_URI[aarch64_bgpq4.sha256sum] = "695e9a3a414fe4091f6c630bd4ea664517c567fe12290daec3d17d4829e3de94"

RDEPENDS:bgpq4 = " \
 glibc \
 "
