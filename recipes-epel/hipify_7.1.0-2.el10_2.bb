# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipify"
PV = "7.1.0"
PR = "2.el10_2"
PACKAGES:x86_64_v2 = " \
 hipify \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipify-7.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52dd171d7a5ff74918d4ca30349fdd1ac3acfb3cb5ae4847dbbe12721857533e"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - hipify: libLLVM.so.20.0git()(64bit)
# - hipify: libLLVM.so.20.0git(LLVM_20.0)(64bit)
# - hipify: libclang-cpp.so.20.0git()(64bit)
# - hipify: libclang-cpp.so.20.0git(LLVM_20.0)(64bit)

URI_x86_64_v2_hipify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipify-7.1.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipify}"
SRC_URI[x86_64_v2_hipify.sha256sum] = "e5d4f73786243ab35403c71221e59bb8d963b2c130e0845c591de2dd707e0cda"

RDEPENDS:hipify = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 perl \
 perl-interpreter \
 "
