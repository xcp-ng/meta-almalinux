# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdaemon"
PV = "0.14"
PR = "31.el10"
PACKAGES = " \
 libdaemon \
 libdaemon-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libdaemon-0.14-31.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e32a37cf79138b527e3397e0e9aa6153b2dd81bdf0dcfe0e6629541a7af6688c"

URI_x86_64_v2_libdaemon = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdaemon-0.14-31.el10.x86_64_v2.rpm;name=x86_64_v2_libdaemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdaemon}"
SRC_URI[x86_64_v2_libdaemon.sha256sum] = "27ec2574b78eed27bd9a6c383db67f4446d523d17ba76c4be967b2657243fbfd"

URI_x86_64_v2_libdaemon-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libdaemon-devel-0.14-31.el10.x86_64_v2.rpm;name=x86_64_v2_libdaemon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdaemon-devel}"
SRC_URI[x86_64_v2_libdaemon-devel.sha256sum] = "6c186190fe9adabadc0a0b731b0cede897e4db68301e67d49de228194750ae62"

URI_aarch64_libdaemon = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdaemon-0.14-31.el10.aarch64.rpm;name=aarch64_libdaemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdaemon}"
SRC_URI[aarch64_libdaemon.sha256sum] = "e0c60e639b55ca0786e594773e9c3b3944c0639f00d284d35b3477fcd93dfd17"

URI_aarch64_libdaemon-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libdaemon-devel-0.14-31.el10.aarch64.rpm;name=aarch64_libdaemon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdaemon-devel}"
SRC_URI[aarch64_libdaemon-devel.sha256sum] = "75e2bedf355808c93f6209c94e817074569ab765393477d28c29276b423d2c38"

RDEPENDS:libdaemon = " \
 glibc \
 "
RDEPENDS:libdaemon-devel = " \
 libdaemon \
 pkgconf-pkg-config \
 "
