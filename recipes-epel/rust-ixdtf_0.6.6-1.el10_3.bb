# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ixdtf"
PV = "0.6.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-ixdtf+default-devel \
 rust-ixdtf+duration-devel \
 rust-ixdtf-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-ixdtf-0.6.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "98815bfb3b31c2f0168f79bdff84466879d7fc3c77906fa33a86b44a0c2c7e15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ixdtf+default-devel-0.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ixdtf+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ixdtf+default-devel.sha256sum] = "4cbf6cdc2828a729cd4dec270099b3526ac8490581628708970ac576d2af2875"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ixdtf+duration-devel-0.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ixdtf+duration-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ixdtf+duration-devel.sha256sum] = "becbfaeb44511d28161d7bf92f400628445120aa43549ed76718798ba1e6aefb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ixdtf-devel-0.6.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ixdtf-devel;unpack=0"
SRC_URI[x86_64_v2_rust-ixdtf-devel.sha256sum] = "adbc893b54e0ba2223eb889d286d978af3792dbb4174dba908f01f98a28eacf1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ixdtf+default-devel-0.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-ixdtf+default-devel;unpack=0"
SRC_URI[aarch64_rust-ixdtf+default-devel.sha256sum] = "245bb2dc80108274259112637b78147212c81ebbaad61a15c3723318b6be43f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ixdtf+duration-devel-0.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-ixdtf+duration-devel;unpack=0"
SRC_URI[aarch64_rust-ixdtf+duration-devel.sha256sum] = "abe3a570f8548c073df8bb363874c7447e4944692fb488969a45713c5c8a4954"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-ixdtf-devel-0.6.6-1.el10_3.noarch.rpm;name=aarch64_rust-ixdtf-devel;unpack=0"
SRC_URI[aarch64_rust-ixdtf-devel.sha256sum] = "22a51fe9057d2f59dc440e8beb3d139df08f8e1c318cc228ba3919aab8784fc7"

RDEPENDS:rust-ixdtf+default-devel = " \
 cargo \
 rust-ixdtf+duration-devel \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-ixdtf+duration-devel = " \
 cargo \
 rust-ixdtf-devel \
 "
RDEPENDS:rust-ixdtf-devel = " \
 cargo \
 rust \
 "
