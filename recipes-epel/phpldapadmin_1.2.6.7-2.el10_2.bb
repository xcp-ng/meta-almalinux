# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "phpldapadmin"
PV = "1.2.6.7"
PR = "2.el10_2"
PACKAGES = " \
 phpldapadmin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/phpldapadmin-1.2.6.7-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1aa2d7ac3bd1321901f76088889fa467fd8a735017210a833c29bbb50a6c87d0"

URI_x86_64_v2_phpldapadmin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phpldapadmin-1.2.6.7-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_phpldapadmin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_phpldapadmin}"
SRC_URI[x86_64_v2_phpldapadmin.sha256sum] = "da2deea9d7512f2cc3201b5f7304dfb8ec4ed04622283e5f135edf859fe6486b"

URI_aarch64_phpldapadmin = "${EPEL_MIRROR}/aarch64/Packages/p/phpldapadmin-1.2.6.7-2.el10_2.noarch.rpm;name=aarch64_phpldapadmin;unpack=0"
SRC_URI:append = " ${URI_aarch64_phpldapadmin}"
SRC_URI[aarch64_phpldapadmin.sha256sum] = "338ab94eaf759395770ddd44da8001375916112627eebceaee4c8cc4b01e449c"

RDEPENDS:phpldapadmin = " \
 bash \
 httpd-filesystem \
 virtual/php-date \
 virtual/php-gd \
 virtual/php-gettext \
 virtual/php-hash \
 virtual/php-iconv \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-mhash \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-session \
 virtual/php-xml \
 virtual/php-zlib \
 virtual/php_httpd_ \
 "
