# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cups-browsed"
PE = "1"
PV = "2.0.0"
PR = "8.el10"
PACKAGES = " \
 cups-browsed \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cups-browsed-2.0.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb4ffea8aaaebcc72759b579f59aee69bbadebbd1db3f3509248138e4cd7f4aa"

URI_x86_64_v2_cups-browsed = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cups-browsed-2.0.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_cups-browsed;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cups-browsed}"
SRC_URI[x86_64_v2_cups-browsed.sha256sum] = "1431e8c3dcd5dbc56406100417ad71b31d7b68f07ea38b53b10fc39201e26fa7"

URI_aarch64_cups-browsed = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cups-browsed-2.0.0-8.el10.aarch64.rpm;name=aarch64_cups-browsed;unpack=0"
SRC_URI:append = " ${URI_aarch64_cups-browsed}"
SRC_URI[aarch64_cups-browsed.sha256sum] = "35e3723510e6ef5e5a031792fadcdb7390ed6bb5e86b6aef46736ac843b663fc"

RDEPENDS:cups-browsed = " \
 avahi-glib \
 avahi-libs \
 bash \
 cups-filesystem \
 cups-libs \
 glib2 \
 glibc \
 libcupsfilters \
 libppd \
 systemd \
 "
