# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libcst"
PV = "1.9.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-libcst+default-devel \
 rust-libcst+trace-devel \
 rust-libcst-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libcst-1.9.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "edf0de226bf85fad625252642428201cc3793222402da30974e82e2c6aa114d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst+default-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libcst+default-devel.sha256sum] = "ac22fe84e271e35abb20168e04581141a308ad68bf582b53840adcd74e5a779d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst+trace-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst+trace-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libcst+trace-devel.sha256sum] = "0a6e2d089906575d614b268ce19ddf30c2b375325b224ffd9e9171b63d4daf58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libcst-devel-1.9.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libcst-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libcst-devel.sha256sum] = "e8059b69458f33ad85d0683138690eaabe34f4aeffff6783bb1c732da752d3c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst+default-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-libcst+default-devel;unpack=0"
SRC_URI[aarch64_rust-libcst+default-devel.sha256sum] = "3dea9aab13051b7d8b08eb279c7212291d6daffc6f534f3b532ae2eec0f0c6bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst+trace-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-libcst+trace-devel;unpack=0"
SRC_URI[aarch64_rust-libcst+trace-devel.sha256sum] = "44de8dc1a40f5f135ba98bcf0e7757d57d410578045b369344a93906e519e002"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libcst-devel-1.9.0-1.el10_3.noarch.rpm;name=aarch64_rust-libcst-devel;unpack=0"
SRC_URI[aarch64_rust-libcst-devel.sha256sum] = "cd67b0bed4a704a4dda4f75c9c7470c48c684194da4eaa97e3dcb9abed717151"

RDEPENDS:rust-libcst+default-devel = " \
 cargo \
 rust-libcst-devel \
 "
RDEPENDS:rust-libcst+trace-devel = " \
 cargo \
 rust-libcst-devel \
 rust-peg+trace-devel \
 "
RDEPENDS:rust-libcst-devel = " \
 cargo \
 rust \
 rust-annotate-snippets0.11+default-devel \
 rust-libcst_derive+default-devel \
 rust-memchr+default-devel \
 rust-paste+default-devel \
 rust-peg+default-devel \
 rust-regex+default-devel \
 rust-thiserror+default-devel \
 "
