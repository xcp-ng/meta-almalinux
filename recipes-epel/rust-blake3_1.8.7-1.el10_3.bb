# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blake3"
PV = "1.8.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-blake3+default-devel \
 rust-blake3+mmap-devel \
 rust-blake3+neon-devel \
 rust-blake3+rayon-devel \
 rust-blake3+serde-devel \
 rust-blake3+std-devel \
 rust-blake3+zeroize-devel \
 rust-blake3-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-blake3-1.8.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "00c33ef9bcdd0477931d90407641473c10a4a8fe70864d05befaffbf59102ae9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+default-devel-1.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake3+default-devel.sha256sum] = "8a7420b82984300e0cf1f076dd1cbd91df4045bdddd18d02be0b5b3d782329d6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+mmap-devel-1.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+mmap-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake3+mmap-devel.sha256sum] = "6dd704330e1defc2547d6b34aeda328d20a8e84ab2344b6313eae627c54a505b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+neon-devel-1.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+neon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake3+neon-devel.sha256sum] = "ff6977e15b50a2a185416c3dc15244052c60c85d4d3f8a2b714390615f8cc615"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+rayon-devel-1.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+rayon-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake3+rayon-devel.sha256sum] = "f4496dec5fd2761b0908ee48e71180ef5d7eeca0940c7387dcb8a01ed1c58690"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+serde-devel-1.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake3+serde-devel.sha256sum] = "3c58950f4007e34546c50a956869bcfef9d1f6cbc6a4884556f96d48c39eb727"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+std-devel-1.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake3+std-devel.sha256sum] = "1fa8443aea8dec927ca3d025e2c025c806ace5f082eedb616a0eedd65642fc8f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3+zeroize-devel-1.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3+zeroize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake3+zeroize-devel.sha256sum] = "9338eee36a927174a5b8b4e892e9719a96f8c7ee437a0d641432242c0c3d5422"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blake3-devel-1.8.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blake3-devel;unpack=0"
SRC_URI[x86_64_v2_rust-blake3-devel.sha256sum] = "c90d1da82dd4f3a9cac62330d997ae75904de8dddbd4741cf1193900a8c62f0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+default-devel-1.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+default-devel;unpack=0"
SRC_URI[aarch64_rust-blake3+default-devel.sha256sum] = "eca1544bb11705dd1400a7ec8cfbf3bebf0e7fb09754652e16d8e5309e956216"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+mmap-devel-1.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+mmap-devel;unpack=0"
SRC_URI[aarch64_rust-blake3+mmap-devel.sha256sum] = "55606d4c2eee9699a69587e25fb76a50985570452a6d845ec902e30a5e547cca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+neon-devel-1.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+neon-devel;unpack=0"
SRC_URI[aarch64_rust-blake3+neon-devel.sha256sum] = "db97dda1754d3ab33adcdee6a3d751ec11f7533dd608a3103681841c462da57e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+rayon-devel-1.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+rayon-devel;unpack=0"
SRC_URI[aarch64_rust-blake3+rayon-devel.sha256sum] = "50774c67599313a74ac3d5206549472616706f4c4cc51f0de1c3efb9a52c59a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+serde-devel-1.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+serde-devel;unpack=0"
SRC_URI[aarch64_rust-blake3+serde-devel.sha256sum] = "3bcf86b28b2c5390aa2393851895f9b2aac621a3e72af11acde688dd74ec9168"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+std-devel-1.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+std-devel;unpack=0"
SRC_URI[aarch64_rust-blake3+std-devel.sha256sum] = "5e29a398c15eae30345168ae9b3f36d5f38eae228dd5d38d15be0513e6351d59"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3+zeroize-devel-1.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-blake3+zeroize-devel;unpack=0"
SRC_URI[aarch64_rust-blake3+zeroize-devel.sha256sum] = "0e1d780e71f521767bd6047f6857068ef0841d509d8ad3d4566bed9bca2a913e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-blake3-devel-1.8.7-1.el10_3.noarch.rpm;name=aarch64_rust-blake3-devel;unpack=0"
SRC_URI[aarch64_rust-blake3-devel.sha256sum] = "c2f8681736b258aa1ea089c2d19d1ffb31db56a7cc2e7a4297d0d4774ca5c56f"

RDEPENDS:rust-blake3+default-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+mmap-devel = " \
 cargo \
 rust-blake3+std-devel \
 rust-blake3-devel \
 rust-memmap2+default-devel \
 "
RDEPENDS:rust-blake3+neon-devel = " \
 cargo \
 rust-blake3-devel \
 "
RDEPENDS:rust-blake3+rayon-devel = " \
 cargo \
 rust-blake3-devel \
 rust-rayon-core+default-devel \
 "
RDEPENDS:rust-blake3+serde-devel = " \
 cargo \
 rust-blake3-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-blake3+std-devel = " \
 cargo \
 rust-blake3-devel \
 rust-constant_time_eq+std-devel \
 "
RDEPENDS:rust-blake3+zeroize-devel = " \
 cargo \
 rust-arrayvec+zeroize-devel \
 rust-blake3-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-blake3-devel = " \
 cargo \
 python3 \
 rust-arrayvec-devel \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-constant_time_eq-devel \
 rust-cpufeatures+default-devel \
 "
