# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtelnet"
PV = "0.23"
PR = "11.el10_1"
PACKAGES = " \
 libtelnet \
 libtelnet-devel \
 libtelnet-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libtelnet-0.23-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "985f4d34442828f4e39000fb71ea9bba0c6e92dc7025fd1f6658a069c7deb404"

URI_x86_64_v2_libtelnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtelnet-0.23-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtelnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtelnet}"
SRC_URI[x86_64_v2_libtelnet.sha256sum] = "f714ea7d0a5f21fc5bfe472a66b3da18ab4e8496b9e24be54760c4ff43c249f8"

URI_x86_64_v2_libtelnet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtelnet-devel-0.23-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtelnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtelnet-devel}"
SRC_URI[x86_64_v2_libtelnet-devel.sha256sum] = "19f239a565fc7e901bbce42d47723adb26887873d746357f938810b78186ac68"

URI_x86_64_v2_libtelnet-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libtelnet-utils-0.23-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libtelnet-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtelnet-utils}"
SRC_URI[x86_64_v2_libtelnet-utils.sha256sum] = "94afaa099dc9de5f9bad66fc0558ad69e392ee2767e52f67a30df8d6e681b3b2"

URI_aarch64_libtelnet = "${EPEL_MIRROR}/aarch64/Packages/l/libtelnet-0.23-11.el10_1.aarch64.rpm;name=aarch64_libtelnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtelnet}"
SRC_URI[aarch64_libtelnet.sha256sum] = "29558c40cdd8900c004ef60e5df33eb61c48a2316cfc94cc3a283e0796519f9b"

URI_aarch64_libtelnet-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libtelnet-devel-0.23-11.el10_1.aarch64.rpm;name=aarch64_libtelnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtelnet-devel}"
SRC_URI[aarch64_libtelnet-devel.sha256sum] = "bdac39a11585d46a81f65e57af334bfb31790964ac4eea5d8129202fc82edf9f"

URI_aarch64_libtelnet-utils = "${EPEL_MIRROR}/aarch64/Packages/l/libtelnet-utils-0.23-11.el10_1.aarch64.rpm;name=aarch64_libtelnet-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtelnet-utils}"
SRC_URI[aarch64_libtelnet-utils.sha256sum] = "79b6c0d76840b7cb1638350c87c5596936beb6ba18ef3024d816230c3de3f3d8"

RDEPENDS:libtelnet = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libtelnet-devel = " \
 libtelnet \
 pkgconf-pkg-config \
 "
RDEPENDS:libtelnet-utils = " \
 glibc \
 libtelnet \
 "
