# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "annobin"
PV = "12.92"
PR = "1.el10"
PACKAGES = " \
 annobin-annocheck \
 annobin-docs \
 annobin-libannocheck \
 annobin-plugin-clang \
 annobin-plugin-gcc \
 annobin-plugin-llvm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/annobin-12.92-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "216a510a3d24b44b9c825acbbd162180ef287103c4db56e7a233b6ea7eef9db2"

URI_x86_64_v2_annobin-annocheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-annocheck-12.92-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-annocheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-annocheck}"
SRC_URI[x86_64_v2_annobin-annocheck.sha256sum] = "88e39c31de21ea56613bbef43a334c7bc87248139afaca1cefe148d50c29c62e"

URI_x86_64_v2_annobin-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-docs-12.92-1.el10.noarch.rpm;name=x86_64_v2_annobin-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-docs}"
SRC_URI[x86_64_v2_annobin-docs.sha256sum] = "f964b5ca270613fda5cfb3d8b686da4d4c5f054b1afdc30fc259c609e3c5b4a8"

URI_x86_64_v2_annobin-libannocheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-libannocheck-12.92-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-libannocheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-libannocheck}"
SRC_URI[x86_64_v2_annobin-libannocheck.sha256sum] = "b440591e2428346862f25beeec06945026617540c4b55ec972aa4ab6208799f3"

URI_x86_64_v2_annobin-plugin-clang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-clang-12.92-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-clang}"
SRC_URI[x86_64_v2_annobin-plugin-clang.sha256sum] = "91ec08b996e5f330afecff377c92f255cf899b6ad8233a8869f4560cc67154a4"

URI_x86_64_v2_annobin-plugin-gcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-gcc-12.92-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-gcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-gcc}"
SRC_URI[x86_64_v2_annobin-plugin-gcc.sha256sum] = "3f2bef6958bfbd6cb232b14782711f3e0a0ba90e06a257af4c751212853324ff"

URI_x86_64_v2_annobin-plugin-llvm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-llvm-12.92-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-llvm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_annobin-plugin-llvm}"
SRC_URI[x86_64_v2_annobin-plugin-llvm.sha256sum] = "b1ff1ea0efe021f454e0a33f7f61068f7c65dcde9a623a57cc3af1cf6224e6c5"

URI_aarch64_annobin-annocheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-annocheck-12.92-1.el10.aarch64.rpm;name=aarch64_annobin-annocheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-annocheck}"
SRC_URI[aarch64_annobin-annocheck.sha256sum] = "327e7f4167c72d2dc40d7df9f8812a324f0a557a9ec17496f85d5988362552d9"

URI_aarch64_annobin-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-docs-12.92-1.el10.noarch.rpm;name=aarch64_annobin-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-docs}"
SRC_URI[aarch64_annobin-docs.sha256sum] = "f964b5ca270613fda5cfb3d8b686da4d4c5f054b1afdc30fc259c609e3c5b4a8"

URI_aarch64_annobin-libannocheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-libannocheck-12.92-1.el10.aarch64.rpm;name=aarch64_annobin-libannocheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-libannocheck}"
SRC_URI[aarch64_annobin-libannocheck.sha256sum] = "78a3b2dc6177e5b40560ab6d1f3ce5aed36b5d1cb5d7237c19095da1980616df"

URI_aarch64_annobin-plugin-clang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-clang-12.92-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-clang;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-clang}"
SRC_URI[aarch64_annobin-plugin-clang.sha256sum] = "4e34048042d556dde9f360b7f3a2d2b0e49a3d89f73709b48b498a447084b194"

URI_aarch64_annobin-plugin-gcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-gcc-12.92-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-gcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-gcc}"
SRC_URI[aarch64_annobin-plugin-gcc.sha256sum] = "fd84bd76a7da2baee74e94d15f71df0b2c3503e13fa68659f7a0395c6263f43c"

URI_aarch64_annobin-plugin-llvm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-llvm-12.92-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-llvm;unpack=0"
SRC_URI:append = " ${URI_aarch64_annobin-plugin-llvm}"
SRC_URI[aarch64_annobin-plugin-llvm.sha256sum] = "df264fba150844c29d63a4378ee1f423424479ab95e11059fa096eb21a16a2b8"

RDEPENDS:annobin-annocheck = " \
 annobin-docs \
 cpio \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 rpm \
 rpm-libs \
 "
RDEPENDS:annobin-docs = " \
 "
RDEPENDS:annobin-libannocheck = " \
 annobin-docs \
 glibc \
 pkgconf-pkg-config \
 "
RDEPENDS:annobin-plugin-clang = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:annobin-plugin-gcc = " \
 annobin-docs \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:annobin-plugin-llvm = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
