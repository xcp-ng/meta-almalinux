# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kanagram"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kanagram \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kanagram-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "89cf45a9878d0933339a80377444c9756c37346ede7b056ed6ee59aa36a695f1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kanagram-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kanagram;unpack=0"
SRC_URI[x86_64_v2_kanagram.sha256sum] = "707e6a72215b0b343ea9228b367ed59541289410168fa00030d36149cae256ac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kanagram-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kanagram;unpack=0"
SRC_URI[aarch64_kanagram.sha256sum] = "0e2f3e58c6f6219dce6d618263335996b7de698aec8389ca4e783305a91cd140"

RDEPENDS:kanagram = " \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 libkeduvocdocument \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
