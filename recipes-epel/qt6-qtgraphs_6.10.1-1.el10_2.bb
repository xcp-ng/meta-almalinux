# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtgraphs"
PV = "6.10.1"
PR = "1.el10_2"
PACKAGES = " \
 qt6-qtgraphs \
 qt6-qtgraphs-devel \
 qt6-qtgraphs-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtgraphs-6.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b50e77d9161f96d17a201430e914eab0b016d70c039deb5c9619268665f32908"

URI_x86_64_v2_qt6-qtgraphs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgraphs-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgraphs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgraphs}"
SRC_URI[x86_64_v2_qt6-qtgraphs.sha256sum] = "079fa0cc9aadc3ada4744432fba3b1d3231866fab1ba8cfd0b4d68b7986b7827"

URI_x86_64_v2_qt6-qtgraphs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgraphs-devel-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgraphs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgraphs-devel}"
SRC_URI[x86_64_v2_qt6-qtgraphs-devel.sha256sum] = "560c28c84d28a409fc183a05bad263f8ead2573a2e2f344c6fe0a771542d7919"

URI_x86_64_v2_qt6-qtgraphs-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgraphs-examples-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgraphs-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgraphs-examples}"
SRC_URI[x86_64_v2_qt6-qtgraphs-examples.sha256sum] = "9aca7e87ccb964d464a04a43b7e7357b66d255979cb2ba0ac7d05d9abca3a82c"

URI_aarch64_qt6-qtgraphs = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgraphs-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtgraphs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgraphs}"
SRC_URI[aarch64_qt6-qtgraphs.sha256sum] = "9c8bc18a0e799be26dd27165628ff05c667df1ae5191e85111afb2076d4f1be7"

URI_aarch64_qt6-qtgraphs-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgraphs-devel-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtgraphs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgraphs-devel}"
SRC_URI[aarch64_qt6-qtgraphs-devel.sha256sum] = "3f7e1016b12b0c338f0b904644925d36c3e6c80c9f0bf96cb7756b50ec34ab0e"

URI_aarch64_qt6-qtgraphs-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgraphs-examples-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtgraphs-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgraphs-examples}"
SRC_URI[aarch64_qt6-qtgraphs-examples.sha256sum] = "3199653dd4c60b3389dc5d58ad85f2b448962960b7ba593faf9486f1d5216ffa"

RDEPENDS:qt6-qtgraphs = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 "
RDEPENDS:qt6-qtgraphs-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtgraphs \
 qt6-qtgraphs-devel \
 qt6-qtquick3d-devel \
 "
RDEPENDS:qt6-qtgraphs-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtgraphs \
 qt6-qtquick3d \
 "
