# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nh3"
PV = "0.2.21"
PR = "2.el10_2"
PACKAGES = " \
 python3-nh3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nh3-0.2.21-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7c001a37b59f29bf66865dc79f8151baa47bcb8b03aa5fee7992bf74c38c180"

URI_x86_64_v2_python3-nh3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nh3-0.2.21-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-nh3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nh3}"
SRC_URI[x86_64_v2_python3-nh3.sha256sum] = "ecbd8fd6dfb050ce34b21ba0c9288cc676a4fdfa21db2138cef05cc6919093ce"

URI_aarch64_python3-nh3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nh3-0.2.21-2.el10_2.aarch64.rpm;name=aarch64_python3-nh3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nh3}"
SRC_URI[aarch64_python3-nh3.sha256sum] = "c122eda2caf0083588eb637fb2e54f73ba2759954e288a5edc279cf34a9b8278"

RDEPENDS:python3-nh3 = " \
 glibc \
 libgcc \
 python3 \
 "
