# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "magma"
PV = "2.9.0"
PR = "6.el10_1"
PACKAGES:x86_64_v2 = " \
 magma \
 magma-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/magma-2.9.0-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a2a2bd32c35a676b15e74e7c2f0bb5d5b1636cbd7b30d2fe06e8d542d62903a5"

URI_x86_64_v2_magma = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/magma-2.9.0-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_magma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_magma}"
SRC_URI[x86_64_v2_magma.sha256sum] = "908accd109d111de306e8d0277f506a593bef9dbcd6162143639b5c896972bc3"

URI_x86_64_v2_magma-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/magma-devel-2.9.0-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_magma-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_magma-devel}"
SRC_URI[x86_64_v2_magma-devel.sha256sum] = "177d94f05604c306482c8f5b83893e8b1466d51e86e53e0e0f4341e1d8ceae16"

RDEPENDS:magma = " \
 flexiblas-netlib \
 glibc \
 hipblas \
 hipsparse \
 libgcc \
 libstdc++ \
 rocm-hip \
 "
RDEPENDS:magma-devel = " \
 magma \
 pkgconf-pkg-config \
 "
