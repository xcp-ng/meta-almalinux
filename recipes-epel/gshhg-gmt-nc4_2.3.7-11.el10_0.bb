# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gshhg-gmt-nc4"
PV = "2.3.7"
PR = "11.el10_0"
PACKAGES = " \
 gshhg-gmt-nc4 \
 gshhg-gmt-nc4-full \
 gshhg-gmt-nc4-high \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gshhg-gmt-nc4-2.3.7-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0df4c396636e2f94919dfef8fdd4fd9a11e1d35a86234003993e5d6b8441db3"

URI_x86_64_v2_gshhg-gmt-nc4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gshhg-gmt-nc4-2.3.7-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gshhg-gmt-nc4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gshhg-gmt-nc4}"
SRC_URI[x86_64_v2_gshhg-gmt-nc4.sha256sum] = "97f1973aa8d244d65124a72c433e9aea1c15353c1ac04d55fd9bffbeadf35d7c"

URI_x86_64_v2_gshhg-gmt-nc4-full = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gshhg-gmt-nc4-full-2.3.7-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gshhg-gmt-nc4-full;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gshhg-gmt-nc4-full}"
SRC_URI[x86_64_v2_gshhg-gmt-nc4-full.sha256sum] = "2b567e757398aeaa63369981ea5fe454e7edcdcb354daba16287fce285e204b9"

URI_x86_64_v2_gshhg-gmt-nc4-high = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gshhg-gmt-nc4-high-2.3.7-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gshhg-gmt-nc4-high;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gshhg-gmt-nc4-high}"
SRC_URI[x86_64_v2_gshhg-gmt-nc4-high.sha256sum] = "89e6a788cb381b1c1fbbdd602609647fa6e6a7f5099631902135eadb1794cc80"

URI_aarch64_gshhg-gmt-nc4 = "${EPEL_MIRROR}/aarch64/Packages/g/gshhg-gmt-nc4-2.3.7-11.el10_0.noarch.rpm;name=aarch64_gshhg-gmt-nc4;unpack=0"
SRC_URI:append = " ${URI_aarch64_gshhg-gmt-nc4}"
SRC_URI[aarch64_gshhg-gmt-nc4.sha256sum] = "8b602982ccd306baf571bd3fbdd7a7f1e1dcfce32297e84bd9ce97f1c7b6028a"

URI_aarch64_gshhg-gmt-nc4-full = "${EPEL_MIRROR}/aarch64/Packages/g/gshhg-gmt-nc4-full-2.3.7-11.el10_0.noarch.rpm;name=aarch64_gshhg-gmt-nc4-full;unpack=0"
SRC_URI:append = " ${URI_aarch64_gshhg-gmt-nc4-full}"
SRC_URI[aarch64_gshhg-gmt-nc4-full.sha256sum] = "69638d87c58e2bfa8f4ceb965665705245d5008cbb66177c74fd6e83b7f8c28a"

URI_aarch64_gshhg-gmt-nc4-high = "${EPEL_MIRROR}/aarch64/Packages/g/gshhg-gmt-nc4-high-2.3.7-11.el10_0.noarch.rpm;name=aarch64_gshhg-gmt-nc4-high;unpack=0"
SRC_URI:append = " ${URI_aarch64_gshhg-gmt-nc4-high}"
SRC_URI[aarch64_gshhg-gmt-nc4-high.sha256sum] = "c35658e26d7e39eaab54a1203ad8c328c9fa7286c3fefa92a17f18d3db08c564"

RDEPENDS:gshhg-gmt-nc4 = " \
 "
RDEPENDS:gshhg-gmt-nc4-full = " \
 gshhg-gmt-nc4 \
 "
RDEPENDS:gshhg-gmt-nc4-high = " \
 gshhg-gmt-nc4 \
 "
