# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iproute"
PV = "7.0.0"
PR = "2.el10"
PACKAGES = " \
 iproute \
 iproute-devel \
 iproute-tc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iproute-7.0.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "02a129bd886778f47fcc0b27e9cb76af5e88e1a0468a416592137e2b50aee88d"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - iproute-tc: libcap.so.2()(64bit)
# - iproute: libcap.so.2()(64bit)

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iproute-7.0.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iproute;unpack=0"
SRC_URI[x86_64_v2_iproute.sha256sum] = "5254fd45bebec992b3499201b58986a413696b084825692afa2af1a78f9849dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/iproute-devel-7.0.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iproute-devel;unpack=0"
SRC_URI[x86_64_v2_iproute-devel.sha256sum] = "5b7d867e409239715ebe144d4f84c88f8e96e0a6cf3514188a02a38f1ccded3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iproute-tc-7.0.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_iproute-tc;unpack=0"
SRC_URI[x86_64_v2_iproute-tc.sha256sum] = "30820b461ff2fba41a7c868a1d2a5628bc2bf2c074b48b68ad67820b705d8b47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iproute-7.0.0-2.el10.aarch64.rpm;name=aarch64_iproute;unpack=0"
SRC_URI[aarch64_iproute.sha256sum] = "c12cd2c65e0e8fd712319d0678d3f29d8958e50f2f73f8a05e1065f78db6024e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/iproute-devel-7.0.0-2.el10.aarch64.rpm;name=aarch64_iproute-devel;unpack=0"
SRC_URI[aarch64_iproute-devel.sha256sum] = "973023949e4ad928fb3f3f6a375e9fa3ea55dcee8b9aabbede204bb29f9a2085"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iproute-tc-7.0.0-2.el10.aarch64.rpm;name=aarch64_iproute-tc;unpack=0"
SRC_URI[aarch64_iproute-tc.sha256sum] = "11d9be5bd0b59fed3dd2cc0b8bafe8d7f01a1cacd139454f00913dc5b7eefd9e"

RDEPENDS:iproute:x86_64_v2 = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 libcap \
 libmnl \
 libselinux \
 psmisc \
"
RDEPENDS:iproute:aarch64 = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 libmnl \
 libselinux \
 psmisc \
"
RDEPENDS:iproute-devel = " \
 iproute \
 "
RDEPENDS:iproute-tc:x86_64_v2 = " \
 elfutils-libelf \
 glibc \
 iproute \
 iptables-libs \
 libbpf \
 libcap \
 libmnl \
"
RDEPENDS:iproute-tc:aarch64 = " \
 elfutils-libelf \
 glibc \
 iproute \
 iptables-libs \
 libbpf \
 libmnl \
"
