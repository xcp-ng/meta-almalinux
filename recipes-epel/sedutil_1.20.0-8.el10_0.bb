# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sedutil"
PV = "1.20.0"
PR = "8.el10_0"
PACKAGES = " \
 sedutil \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sedutil-1.20.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ca8392432dac5db5c0d0819247406df1368986603144d9bab3a85dd2a49a309"

URI_x86_64_v2_sedutil = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sedutil-1.20.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sedutil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sedutil}"
SRC_URI[x86_64_v2_sedutil.sha256sum] = "c0359d17e06150c82f216dabb3ae72bf63033585fe07893d103aa5cb2c088cc0"

URI_aarch64_sedutil = "${EPEL_MIRROR}/aarch64/Packages/s/sedutil-1.20.0-8.el10_0.aarch64.rpm;name=aarch64_sedutil;unpack=0"
SRC_URI:append = " ${URI_aarch64_sedutil}"
SRC_URI[aarch64_sedutil.sha256sum] = "664702a52ed5e957a206cde73f406c0dc8bec63ee68740395e06c9a622d6f562"

RDEPENDS:sedutil = " \
 glibc \
 libgcc \
 libstdc++ \
 "
