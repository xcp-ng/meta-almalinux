# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_edit"
PV = "0.23.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-toml_edit+debug-devel \
 rust-toml_edit+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit+serde-devel \
 rust-toml_edit+unbounded-devel \
 rust-toml_edit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_edit-0.23.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58351ff52f0698d584a8f0b85db51a6c01e920ff1be3b3d966f07123f37b3bbb"

URI_x86_64_v2_rust-toml_edit+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+debug-devel-0.23.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+debug-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+debug-devel.sha256sum] = "50f55801fc1c171d46e695e2b0e421699f85c16fea6c3589055667cb3b7115bb"

URI_x86_64_v2_rust-toml_edit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+default-devel-0.23.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+default-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+default-devel.sha256sum] = "6f5411bcb93b892bb4f1686169ff03af6971d50d9d9bdc3301718c3b79e86d9e"

URI_x86_64_v2_rust-toml_edit+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+display-devel-0.23.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+display-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+display-devel.sha256sum] = "7ba4bd219b55cbccbbf62f7aee3a1fc77d7191728a03a5108546fdf505550dd2"

URI_x86_64_v2_rust-toml_edit+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+parse-devel-0.23.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+parse-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+parse-devel.sha256sum] = "8c1da37eef350abd7f1689c817fb6bcfbcb5daefe7c1497a03c8ce1ef48796f4"

URI_x86_64_v2_rust-toml_edit+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+serde-devel-0.23.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+serde-devel.sha256sum] = "c38f6f66419947d234bde71d40ec366b2c3d3bde0d17bfc2d63b00f4f6019e6b"

URI_x86_64_v2_rust-toml_edit+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit+unbounded-devel-0.23.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml_edit+unbounded-devel.sha256sum] = "a13a877980a1e512a79b24ca4fc9c71f922e27bf0b1e4ad7487c68908ca9b909"

URI_x86_64_v2_rust-toml_edit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit-devel-0.23.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit-devel}"
SRC_URI[x86_64_v2_rust-toml_edit-devel.sha256sum] = "ba6d9dafa351c8f37c47db07debb5060c5d121f67e91c1837413479cf6a239eb"

URI_aarch64_rust-toml_edit+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+debug-devel-0.23.10-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+debug-devel}"
SRC_URI[aarch64_rust-toml_edit+debug-devel.sha256sum] = "50f49e7c0188741a98f1bdd555a0f531a5102c0d7378f8fa0e4ccedd12b6d6b3"

URI_aarch64_rust-toml_edit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+default-devel-0.23.10-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+default-devel}"
SRC_URI[aarch64_rust-toml_edit+default-devel.sha256sum] = "e710f646519b3713ec66e4b099040032b523d78066395e34b2e1b41dc58cd950"

URI_aarch64_rust-toml_edit+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+display-devel-0.23.10-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+display-devel}"
SRC_URI[aarch64_rust-toml_edit+display-devel.sha256sum] = "7845591b86731b1946601d92d914ebe87c47086f8c2024f757ee4321ede79a4b"

URI_aarch64_rust-toml_edit+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+parse-devel-0.23.10-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+parse-devel}"
SRC_URI[aarch64_rust-toml_edit+parse-devel.sha256sum] = "e1a0fabd9e700a5a882db5f023089efb869026dfcbf3525dcb43fc87f1ce62e8"

URI_aarch64_rust-toml_edit+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+serde-devel-0.23.10-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+serde-devel}"
SRC_URI[aarch64_rust-toml_edit+serde-devel.sha256sum] = "3822dee98a90d27d68e7ea3cc727473fc694e2ecc6c8f3c894c3cdc0a08188a2"

URI_aarch64_rust-toml_edit+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit+unbounded-devel-0.23.10-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit+unbounded-devel}"
SRC_URI[aarch64_rust-toml_edit+unbounded-devel.sha256sum] = "837b765a6479246fc2904f91d19ce87af2a43287c6bfefd57c8e5a76e78fbe2d"

URI_aarch64_rust-toml_edit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit-devel-0.23.10-1.el10_1.noarch.rpm;name=aarch64_rust-toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit-devel}"
SRC_URI[aarch64_rust-toml_edit-devel.sha256sum] = "9d02fda97da39db1eb50f21004c79c2240ffb75e98bcb34c4531ea6a5a98f94b"

RDEPENDS:rust-toml_edit+debug-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml_edit+display-devel \
 rust-toml_edit-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser+default-devel \
 "
RDEPENDS:rust-toml_edit+default-devel = " \
 cargo \
 rust-toml_edit+display-devel \
 rust-toml_edit+parse-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+display-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-toml_writer+default-devel \
 "
RDEPENDS:rust-toml_edit+parse-devel = " \
 cargo \
 rust-toml_edit-devel \
 rust-toml_parser+default-devel \
 rust-winnow+default-devel \
 "
RDEPENDS:rust-toml_edit+serde-devel = " \
 cargo \
 rust-serde_core+default-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-toml_datetime+serde-devel \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit+unbounded-devel = " \
 cargo \
 rust-toml_edit-devel \
 "
RDEPENDS:rust-toml_edit-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-toml_datetime+default-devel \
 "
