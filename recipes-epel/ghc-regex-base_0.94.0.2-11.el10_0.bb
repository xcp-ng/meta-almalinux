# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-regex-base"
PV = "0.94.0.2"
PR = "11.el10_0"
PACKAGES = " \
 ghc-regex-base \
 ghc-regex-base-devel \
 ghc-regex-base-doc \
 ghc-regex-base-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-regex-base-0.94.0.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d96cd8d19c6b09eea05a87a523e5ddb25f3d7edf8a7b9bcba8e175bd59acf18d"

URI_x86_64_v2_ghc-regex-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-base-0.94.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-base}"
SRC_URI[x86_64_v2_ghc-regex-base.sha256sum] = "e96e9c42a2214cc6dcc2843929d1712dc9a74fdd27ed8b7adb3f6cd1fb6dfb6d"

URI_x86_64_v2_ghc-regex-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-base-devel-0.94.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-base-devel}"
SRC_URI[x86_64_v2_ghc-regex-base-devel.sha256sum] = "c0d7a4f7791675a75ff3937842cd55e1a066f9a1564ef90abb42574031f0e894"

URI_x86_64_v2_ghc-regex-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-base-doc-0.94.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-regex-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-base-doc}"
SRC_URI[x86_64_v2_ghc-regex-base-doc.sha256sum] = "23805471542d5fc823004b31c476b5e095599f8b73625ab96f7e9ba57a8f8432"

URI_x86_64_v2_ghc-regex-base-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-regex-base-prof-0.94.0.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-regex-base-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-regex-base-prof}"
SRC_URI[x86_64_v2_ghc-regex-base-prof.sha256sum] = "5e3bcffc1738953a36caff9c0dd415922571757a988d4386a6541deb18ae772a"

URI_aarch64_ghc-regex-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-base-0.94.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-regex-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-base}"
SRC_URI[aarch64_ghc-regex-base.sha256sum] = "42c03777f728cd206e1298fc83abbe20d0687366d6cc1a7bf5cac82c151b7104"

URI_aarch64_ghc-regex-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-base-devel-0.94.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-regex-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-base-devel}"
SRC_URI[aarch64_ghc-regex-base-devel.sha256sum] = "0bcfe43f2afc6c00834136a234c675de1013638cb762d7b5fb72e4f038624643"

URI_aarch64_ghc-regex-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-base-doc-0.94.0.2-11.el10_0.noarch.rpm;name=aarch64_ghc-regex-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-base-doc}"
SRC_URI[aarch64_ghc-regex-base-doc.sha256sum] = "e0d0a53ab32cd90606eefdc275219e8422e373e4ab4ca3b2ea81b2130609cceb"

URI_aarch64_ghc-regex-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-regex-base-prof-0.94.0.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-regex-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-regex-base-prof}"
SRC_URI[aarch64_ghc-regex-base-prof.sha256sum] = "94508a192c156cafdfff390244511f3ed97ae33d3f2b4bf15051a8f3be6fe351"

RDEPENDS:ghc-regex-base = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-regex-base-devel = " \
 ghc-array-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-regex-base \
 ghc-text-devel \
 "
RDEPENDS:ghc-regex-base-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-regex-base-prof = " \
 ghc-array-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-regex-base-devel \
 ghc-text-prof \
 "
