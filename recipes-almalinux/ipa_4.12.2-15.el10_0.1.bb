# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipa"
PV = "4.12.2"
PR = "15.el10_0.1"
PACKAGES = " \
 ipa-client \
 ipa-client-common \
 ipa-client-encrypted-dns \
 ipa-client-epn \
 ipa-client-samba \
 ipa-common \
 ipa-selinux \
 ipa-selinux-luna \
 ipa-selinux-nfast \
 ipa-server \
 ipa-server-common \
 ipa-server-dns \
 ipa-server-encrypted-dns \
 ipa-server-trust-ad \
 python3-ipaclient \
 python3-ipalib \
 python3-ipaserver \
 python3-ipatests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipa-4.12.2-15.el10_0.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2af755c67f4f3fdb45c7c6f22ca2cf5b0d61f8d7c6281577e615c0da24a87bcf"

URI_x86_64_v2_ipa-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ipa-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client}"
SRC_URI[x86_64_v2_ipa-client.sha256sum] = "58ccfa9a438e5417d9dab4d207472d06ac6dc9c89bea094806233319374923b0"

URI_x86_64_v2_ipa-client-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-common-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_ipa-client-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-common}"
SRC_URI[x86_64_v2_ipa-client-common.sha256sum] = "8fc3a971c000d420f59c1e178d9ec1ed49fe813fa261a62664131a7700eb708f"

URI_x86_64_v2_ipa-client-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-encrypted-dns-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ipa-client-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-encrypted-dns}"
SRC_URI[x86_64_v2_ipa-client-encrypted-dns.sha256sum] = "7dc195468c79ee16ef748303d1b52274443778394105cf8e4f16dfa65d9fd5dc"

URI_x86_64_v2_ipa-client-epn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-epn-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ipa-client-epn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-epn}"
SRC_URI[x86_64_v2_ipa-client-epn.sha256sum] = "300edb1b6009e7f36cefd215917f8665fcdfc393b51e3f24e80f6b3b068df762"

URI_x86_64_v2_ipa-client-samba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-samba-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ipa-client-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-samba}"
SRC_URI[x86_64_v2_ipa-client-samba.sha256sum] = "78a437d9aa133591bbd34e5bca34a691fc9832e54ce5f4b93971fceb1765fd9d"

URI_x86_64_v2_ipa-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-common-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_ipa-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-common}"
SRC_URI[x86_64_v2_ipa-common.sha256sum] = "22f8c6bef8a065f1f5760933dda34f9edf851f0660a926e16f26f828396ce510"

URI_x86_64_v2_ipa-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_ipa-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-selinux}"
SRC_URI[x86_64_v2_ipa-selinux.sha256sum] = "1d920b6eb90547a26ceb2e93717ff49565acb2cd59195f5ab383f78da02f317c"

URI_x86_64_v2_ipa-selinux-luna = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-luna-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_ipa-selinux-luna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-selinux-luna}"
SRC_URI[x86_64_v2_ipa-selinux-luna.sha256sum] = "9ceefd1921ad06cefb32677e58b59d0df6b608cf85e168919b1875a8113a18a8"

URI_x86_64_v2_ipa-selinux-nfast = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-nfast-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_ipa-selinux-nfast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-selinux-nfast}"
SRC_URI[x86_64_v2_ipa-selinux-nfast.sha256sum] = "dd04bbf38ef0a3f2ae8b5b72ac6bc90265d58c54792c0533cbc550afc392a9f0"

URI_x86_64_v2_ipa-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ipa-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server}"
SRC_URI[x86_64_v2_ipa-server.sha256sum] = "b577601ad9a9d5634f76a47fab506d8075fec5a47e02edb14282443f93b1c5f3"

URI_x86_64_v2_ipa-server-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-common-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_ipa-server-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-common}"
SRC_URI[x86_64_v2_ipa-server-common.sha256sum] = "bae4fbd69e26956c5d5969abae1a567c7249bbaf23694523ae9057f309b70824"

URI_x86_64_v2_ipa-server-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-dns-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_ipa-server-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-dns}"
SRC_URI[x86_64_v2_ipa-server-dns.sha256sum] = "d68011bee38b709e41d48a107623fda8be01268f56aa750112f6ef811113cf08"

URI_x86_64_v2_ipa-server-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-encrypted-dns-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ipa-server-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-encrypted-dns}"
SRC_URI[x86_64_v2_ipa-server-encrypted-dns.sha256sum] = "e687bd5861dbb0db290e5016b023d02a48ff47262cb36082bb8f0df7bc7d10da"

URI_x86_64_v2_ipa-server-trust-ad = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-trust-ad-4.12.2-15.el10_0.1.x86_64_v2.rpm;name=x86_64_v2_ipa-server-trust-ad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-trust-ad}"
SRC_URI[x86_64_v2_ipa-server-trust-ad.sha256sum] = "85c88a18ce449cec2282d0d6b49a01757ba15031667b84bfc65c089b70a9dc60"

URI_x86_64_v2_python3-ipaclient = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaclient-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_python3-ipaclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipaclient}"
SRC_URI[x86_64_v2_python3-ipaclient.sha256sum] = "dd8a1f50c402fa33d0822345a594508b293266bd1862e875877daabdbf6fc20a"

URI_x86_64_v2_python3-ipalib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipalib-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_python3-ipalib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipalib}"
SRC_URI[x86_64_v2_python3-ipalib.sha256sum] = "dc8fc068fb753fb8238745c8a3ff902a51d96c5729162efd78b12f850e5be474"

URI_x86_64_v2_python3-ipaserver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaserver-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_python3-ipaserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipaserver}"
SRC_URI[x86_64_v2_python3-ipaserver.sha256sum] = "a4388950feacfdcd8576e3013104063df956260b000a58820007651ec47be40e"

URI_x86_64_v2_python3-ipatests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-ipatests-4.12.2-15.el10_0.1.noarch.rpm;name=x86_64_v2_python3-ipatests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipatests}"
SRC_URI[x86_64_v2_python3-ipatests.sha256sum] = "b7323e19b3f2ed06345cdd723a2207ded4a0ce6665a7a456597c962fc5c5661b"

URI_aarch64_ipa-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-4.12.2-15.el10_0.1.aarch64.rpm;name=aarch64_ipa-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client}"
SRC_URI[aarch64_ipa-client.sha256sum] = "17afeecabbdad28991f4b960d0e7f6dbf0d72aebbff0645ca8689cc506c51c6c"

URI_aarch64_ipa-client-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-common-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_ipa-client-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-common}"
SRC_URI[aarch64_ipa-client-common.sha256sum] = "8fc3a971c000d420f59c1e178d9ec1ed49fe813fa261a62664131a7700eb708f"

URI_aarch64_ipa-client-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-encrypted-dns-4.12.2-15.el10_0.1.aarch64.rpm;name=aarch64_ipa-client-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-encrypted-dns}"
SRC_URI[aarch64_ipa-client-encrypted-dns.sha256sum] = "eaea13c6b2a02055c293051ca4a4134147a3a9ef06999c976baf7349fbbc6a56"

URI_aarch64_ipa-client-epn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-epn-4.12.2-15.el10_0.1.aarch64.rpm;name=aarch64_ipa-client-epn;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-epn}"
SRC_URI[aarch64_ipa-client-epn.sha256sum] = "efe7603622bb5c295bbab3b532aa06daa3a7a37d844661ec71bb19e0091b984c"

URI_aarch64_ipa-client-samba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-samba-4.12.2-15.el10_0.1.aarch64.rpm;name=aarch64_ipa-client-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-samba}"
SRC_URI[aarch64_ipa-client-samba.sha256sum] = "3c8196136afde5c5a094cb99649030c3fd894cc8e34076b0d6cfddf36a431961"

URI_aarch64_ipa-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-common-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_ipa-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-common}"
SRC_URI[aarch64_ipa-common.sha256sum] = "22f8c6bef8a065f1f5760933dda34f9edf851f0660a926e16f26f828396ce510"

URI_aarch64_ipa-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_ipa-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-selinux}"
SRC_URI[aarch64_ipa-selinux.sha256sum] = "1d920b6eb90547a26ceb2e93717ff49565acb2cd59195f5ab383f78da02f317c"

URI_aarch64_ipa-selinux-luna = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-luna-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_ipa-selinux-luna;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-selinux-luna}"
SRC_URI[aarch64_ipa-selinux-luna.sha256sum] = "9ceefd1921ad06cefb32677e58b59d0df6b608cf85e168919b1875a8113a18a8"

URI_aarch64_ipa-selinux-nfast = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-nfast-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_ipa-selinux-nfast;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-selinux-nfast}"
SRC_URI[aarch64_ipa-selinux-nfast.sha256sum] = "dd04bbf38ef0a3f2ae8b5b72ac6bc90265d58c54792c0533cbc550afc392a9f0"

URI_aarch64_ipa-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-4.12.2-15.el10_0.1.aarch64.rpm;name=aarch64_ipa-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server}"
SRC_URI[aarch64_ipa-server.sha256sum] = "4ef6eefaa20892ca3573dc8deb7aa198f9ad38434964265c15539b1d1bb69c95"

URI_aarch64_ipa-server-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-common-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_ipa-server-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-common}"
SRC_URI[aarch64_ipa-server-common.sha256sum] = "bae4fbd69e26956c5d5969abae1a567c7249bbaf23694523ae9057f309b70824"

URI_aarch64_ipa-server-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-dns-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_ipa-server-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-dns}"
SRC_URI[aarch64_ipa-server-dns.sha256sum] = "d68011bee38b709e41d48a107623fda8be01268f56aa750112f6ef811113cf08"

URI_aarch64_ipa-server-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-encrypted-dns-4.12.2-15.el10_0.1.aarch64.rpm;name=aarch64_ipa-server-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-encrypted-dns}"
SRC_URI[aarch64_ipa-server-encrypted-dns.sha256sum] = "f1176a5dfd8157731007e1c4498b1854983f70c73f53b212b5d41fb67e44188e"

URI_aarch64_ipa-server-trust-ad = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-trust-ad-4.12.2-15.el10_0.1.aarch64.rpm;name=aarch64_ipa-server-trust-ad;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-trust-ad}"
SRC_URI[aarch64_ipa-server-trust-ad.sha256sum] = "d3c58796d7d4e0afed647f722dfddab179e48bc1e58998923246b1f94d8bc88f"

URI_aarch64_python3-ipaclient = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaclient-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_python3-ipaclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipaclient}"
SRC_URI[aarch64_python3-ipaclient.sha256sum] = "dd8a1f50c402fa33d0822345a594508b293266bd1862e875877daabdbf6fc20a"

URI_aarch64_python3-ipalib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipalib-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_python3-ipalib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipalib}"
SRC_URI[aarch64_python3-ipalib.sha256sum] = "dc8fc068fb753fb8238745c8a3ff902a51d96c5729162efd78b12f850e5be474"

URI_aarch64_python3-ipaserver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaserver-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_python3-ipaserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipaserver}"
SRC_URI[aarch64_python3-ipaserver.sha256sum] = "a4388950feacfdcd8576e3013104063df956260b000a58820007651ec47be40e"

URI_aarch64_python3-ipatests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-ipatests-4.12.2-15.el10_0.1.noarch.rpm;name=aarch64_python3-ipatests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipatests}"
SRC_URI[aarch64_python3-ipatests.sha256sum] = "b7323e19b3f2ed06345cdd723a2207ded4a0ce6665a7a456597c962fc5c5661b"

RDEPENDS:ipa-client = " \
 authselect \
 autofs \
 bash \
 bind-utils \
 certmonger \
 chrony \
 curl \
 cyrus-sasl-gssapi \
 glibc \
 hostname \
 ipa-client-common \
 ipa-common \
 jansson \
 krb5-libs \
 krb5-pkinit \
 krb5-workstation \
 libcom_err \
 libini_config \
 libnfsidmap \
 libsss_autofs \
 libsss_sudo \
 nss-tools \
 oddjob-mkhomedir \
 openldap \
 openssl-libs \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaclient \
 python3-ldap \
 python3-sssdconfig \
 sssd-idp \
 sssd-ipa \
 sssd-krb5 \
 sssd-tools \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_ge_7.21.7-2 \
 virtual/nfs-utils_or_nfsv4-client-utils \
 "
RDEPENDS:ipa-client-common = " \
 "
RDEPENDS:ipa-client-encrypted-dns = " \
 unbound \
 "
RDEPENDS:ipa-client-epn = " \
 bash \
 ipa-client \
 python3 \
 systemd \
 "
RDEPENDS:ipa-client-samba = " \
 cifs-utils \
 ipa-client \
 python3 \
 python3-samba \
 samba \
 samba-client \
 samba-common-tools \
 samba-winbind \
 sssd-winbind-idmap \
 tdb-tools \
 "
RDEPENDS:ipa-common = " \
 ipa-selinux \
 "
RDEPENDS:ipa-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-luna = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-nfast = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-server = " \
 389-ds-base \
 acl \
 bash \
 certmonger \
 chrony \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 fontawesome4-fonts \
 glibc \
 gssproxy \
 gzip \
 httpd \
 idm-pki-acme \
 idm-pki-ca \
 idm-pki-kra \
 ipa-client \
 ipa-common \
 ipa-server-common \
 jansson \
 krb5-libs \
 krb5-server \
 libcom_err \
 libgcc \
 libpwquality \
 libsss_certmap \
 libsss_nss_idmap \
 libtalloc \
 libtevent \
 libunistring \
 libuuid \
 libverto \
 mod_auth_gssapi \
 mod_lookup_identity \
 mod_session \
 mod_ssl \
 nss-tools \
 oddjob \
 open-sans-fonts \
 openldap \
 openldap-clients \
 openssl \
 openssl-libs \
 p11-kit \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaserver \
 python3-ldap \
 python3-mod_wsgi \
 python3-systemd \
 samba-client-libs \
 selinux-policy \
 shadow-utils \
 slapi-nis \
 softhsm \
 sssd-dbus \
 systemd \
 tar \
 "
RDEPENDS:ipa-server-common = " \
 almalinux-logos-ipa \
 bash \
 httpd \
 ipa-client-common \
 systemd \
 "
RDEPENDS:ipa-server-dns = " \
 bash \
 bind \
 bind-dnssec-utils \
 bind-dyndb-ldap \
 bind-utils \
 ipa-server \
 opendnssec \
 pkcs11-provider \
 python3 \
 softhsm \
 systemd \
 "
RDEPENDS:ipa-server-encrypted-dns = " \
 ipa-client-encrypted-dns \
 "
RDEPENDS:ipa-server-trust-ad = " \
 alternatives \
 bash \
 glibc \
 ipa-common \
 ipa-server \
 krb5-libs \
 libcom_err \
 libpwquality \
 libsss_idmap \
 libtalloc \
 libtevent \
 openldap \
 openssl-libs \
 python3 \
 python3-libsss_nss_idmap \
 python3-samba \
 python3-sss \
 samba \
 samba-client-libs \
 samba-winbind \
 sssd-winbind-idmap \
 "
RDEPENDS:python3-ipaclient = " \
 augeas-libs \
 ipa-client-common \
 ipa-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dns \
 python3-ipalib \
 python3-jinja2 \
 python3-qrcode \
 python3-six \
 "
RDEPENDS:python3-ipalib = " \
 gnupg2 \
 ipa-common \
 keyutils \
 python3 \
 python3-argcomplete \
 python3-cffi \
 python3-cryptography \
 python3-dateutil \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-ifaddr \
 python3-jwcrypto \
 python3-ldap \
 python3-libipa_hbac \
 python3-netaddr \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyusb \
 python3-qrcode \
 python3-requests \
 python3-setuptools \
 python3-six \
 python3-sss-murmur \
 python3-systemd \
 python3-urllib3 \
 python3-yubico \
 "
RDEPENDS:python3-ipaserver = " \
 augeas-libs \
 ipa-common \
 ipa-server-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-idm-pki \
 python3-ipaclient \
 python3-ipalib \
 python3-jwcrypto \
 python3-kdcproxy \
 python3-ldap \
 python3-lxml \
 python3-netaddr \
 python3-psutil \
 python3-pyasn1 \
 python3-requests \
 python3-six \
 python3-sssdconfig \
 python3-urllib3 \
 rpm-libs \
 "
RDEPENDS:python3-ipatests = " \
 iptables-nft \
 openssh-clients \
 python3-cryptography \
 python3-ipaclient \
 python3-ipaserver \
 python3-sssdconfig \
 tar \
 xz \
 "
