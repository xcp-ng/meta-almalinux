# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxxbridge-macro"
PV = "1.0.200"
PR = "1.el10_3"
PACKAGES = " \
 rust-cxxbridge-macro+default-devel \
 rust-cxxbridge-macro-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cxxbridge-macro-1.0.200-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b81fcf63f0f3d2927ce018c11b9d7635268f2e552aea732b56213d4df2f56840"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro+default-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxxbridge-macro+default-devel.sha256sum] = "d8a3e9177c8030a7c50e2362b346e3c7df46601afecf85677979c4d764d0ce13"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxxbridge-macro-devel-1.0.200-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cxxbridge-macro-devel.sha256sum] = "17c2e2d71983d3f0767bcef4ad61bb049e16f10064176ed020ddf0faa1b75dff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro+default-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-macro+default-devel;unpack=0"
SRC_URI[aarch64_rust-cxxbridge-macro+default-devel.sha256sum] = "85565d3f1f1ec754dc9d3e2fa3e6986831712999b977e514bb2231e55ec9b3a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cxxbridge-macro-devel-1.0.200-1.el10_3.noarch.rpm;name=aarch64_rust-cxxbridge-macro-devel;unpack=0"
SRC_URI[aarch64_rust-cxxbridge-macro-devel.sha256sum] = "87be0b3081204ea81c85c2ea7cd19adb64a8b390bf91e21cb7f5191972cbb825"

RDEPENDS:rust-cxxbridge-macro+default-devel = " \
 cargo \
 rust-cxxbridge-macro-devel \
 "
RDEPENDS:rust-cxxbridge-macro-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
