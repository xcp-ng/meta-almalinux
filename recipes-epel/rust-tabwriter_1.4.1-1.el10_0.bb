# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tabwriter"
PV = "1.4.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-tabwriter+ansi_formatting-devel \
 rust-tabwriter+default-devel \
 rust-tabwriter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tabwriter-1.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15643260eb5a364e31af286ce1b6e18b62feb195c2c6f01b4cb4ebf168858006"

URI_x86_64_v2_rust-tabwriter+ansi_formatting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tabwriter+ansi_formatting-devel-1.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tabwriter+ansi_formatting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tabwriter+ansi_formatting-devel}"
SRC_URI[x86_64_v2_rust-tabwriter+ansi_formatting-devel.sha256sum] = "6b57e914413dbf50c2ab2f49a4d718af3191221bfe22cfbc7a7516eafbeff40f"

URI_x86_64_v2_rust-tabwriter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tabwriter+default-devel-1.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tabwriter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tabwriter+default-devel}"
SRC_URI[x86_64_v2_rust-tabwriter+default-devel.sha256sum] = "1c75aa5ec83095074c4f1d6869583149b5ec70dce2928884f47bc8a58233ba40"

URI_x86_64_v2_rust-tabwriter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tabwriter-devel-1.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tabwriter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tabwriter-devel}"
SRC_URI[x86_64_v2_rust-tabwriter-devel.sha256sum] = "6a4f50cd42f600530fa30acfbbd4f56117e36c869b63b546c545688445c297ef"

URI_aarch64_rust-tabwriter+ansi_formatting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tabwriter+ansi_formatting-devel-1.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-tabwriter+ansi_formatting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tabwriter+ansi_formatting-devel}"
SRC_URI[aarch64_rust-tabwriter+ansi_formatting-devel.sha256sum] = "848ae733ce9e425158e63a59189c41ef48990d5c69cc622ee34d8caab09b940d"

URI_aarch64_rust-tabwriter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tabwriter+default-devel-1.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-tabwriter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tabwriter+default-devel}"
SRC_URI[aarch64_rust-tabwriter+default-devel.sha256sum] = "5d0e398b95dcfd5385f225d26921f00ec43d397b6ff0d4b00cb69cf3fccb1728"

URI_aarch64_rust-tabwriter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tabwriter-devel-1.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-tabwriter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tabwriter-devel}"
SRC_URI[aarch64_rust-tabwriter-devel.sha256sum] = "99ad6cc9ed17694d0251b7b9bb5f672b90faae5bbb97abe1b625d8048d0906cb"

RDEPENDS:rust-tabwriter+ansi_formatting-devel = " \
 cargo \
 rust-tabwriter-devel \
 "
RDEPENDS:rust-tabwriter+default-devel = " \
 cargo \
 rust-tabwriter-devel \
 "
RDEPENDS:rust-tabwriter-devel = " \
 cargo \
 rust-unicode-width+default-devel \
 "
