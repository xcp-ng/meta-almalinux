# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pdfminer"
PV = "20251230"
PR = "1.el10_2"
PACKAGES = " \
 python3-pdfminer \
 python3-pdfminer+image \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pdfminer-20251230-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "768de65f7607cdc5ae7730421bba76ddc52efbecb506717de82e3bb6865f12e6"

URI_x86_64_v2_python3-pdfminer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pdfminer-20251230-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pdfminer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pdfminer}"
SRC_URI[x86_64_v2_python3-pdfminer.sha256sum] = "bee947a263dc788013eb88d32c36651648d84ea1bc78853e33896dc028470da1"

URI_x86_64_v2_python3-pdfminer+image = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pdfminer+image-20251230-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pdfminer+image;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pdfminer+image}"
SRC_URI[x86_64_v2_python3-pdfminer+image.sha256sum] = "c478813a57e797f596414e6e063d2f4fa7e6a2ec081006c95868c80f2122aab2"

URI_aarch64_python3-pdfminer = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pdfminer-20251230-1.el10_2.noarch.rpm;name=aarch64_python3-pdfminer;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pdfminer}"
SRC_URI[aarch64_python3-pdfminer.sha256sum] = "300f2483e15c236c5d9c14a60b7876065b85ed13bd2f665cf0519e9e2b2b53ea"

URI_aarch64_python3-pdfminer+image = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pdfminer+image-20251230-1.el10_2.noarch.rpm;name=aarch64_python3-pdfminer+image;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pdfminer+image}"
SRC_URI[aarch64_python3-pdfminer+image.sha256sum] = "9f92d1116b69a84cd3f43e2b2c8a87c7eab19fff6bd3fdac4be9ac917cd2cd8b"

RDEPENDS:python3-pdfminer = " \
 python3 \
 python3-charset-normalizer \
 python3-cryptography \
 "
RDEPENDS:python3-pdfminer+image = " \
 python3 \
 python3-pdfminer \
 python3-pillow \
 "
