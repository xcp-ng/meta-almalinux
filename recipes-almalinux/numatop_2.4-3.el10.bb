# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "numatop"
PV = "2.4"
PR = "3.el10"
PACKAGES:x86_64_v2 = " \
 numatop \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/numatop-2.4-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7a0533209cdc30348211f23d4ce1744ddccc25ad3fab2c3d23fd5189417a3d2"

URI_x86_64_v2_numatop = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/numatop-2.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_numatop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_numatop}"
SRC_URI[x86_64_v2_numatop.sha256sum] = "dd11b92098d19fd8fa5e970d83cec276c44ef09dd305714bce060af6bf16dfe7"

RDEPENDS:numatop = " \
 glibc \
 ncurses-libs \
 numactl-libs \
 "
