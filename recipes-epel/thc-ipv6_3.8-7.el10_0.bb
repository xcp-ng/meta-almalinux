# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "thc-ipv6"
PV = "3.8"
PR = "7.el10_0"
PACKAGES = " \
 thc-ipv6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/thc-ipv6-3.8-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca348e5c9e4a0d0eaa485cb416c41c7db910c3538995954228c0d5f7ca10ba9e"

URI_x86_64_v2_thc-ipv6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/thc-ipv6-3.8-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_thc-ipv6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_thc-ipv6}"
SRC_URI[x86_64_v2_thc-ipv6.sha256sum] = "235d08b1b82caeb8732b4ff9650773b1b3358539d071444854fa97e26447481e"

URI_aarch64_thc-ipv6 = "${EPEL_MIRROR}/aarch64/Packages/t/thc-ipv6-3.8-7.el10_0.aarch64.rpm;name=aarch64_thc-ipv6;unpack=0"
SRC_URI:append = " ${URI_aarch64_thc-ipv6}"
SRC_URI[aarch64_thc-ipv6.sha256sum] = "4e1f98b6f3ec914da0d9b929420b42bd4f6f1a7751281f6cc8689a4b7b3015db"

RDEPENDS:thc-ipv6 = " \
 bash \
 glibc \
 libnetfilter_queue \
 libpcap \
 openssl-libs \
 perl-Socket \
 perl-interpreter \
 "
