# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-connection_pool"
PV = "2.2.5"
PR = "11.el10_1"
PACKAGES = " \
 rubygem-connection_pool \
 rubygem-connection_pool-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-connection_pool-2.2.5-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a81dcb6a53caf2306c9f706f2cd786f063fa45d4cde9fb5a7e5af02ba65b409"

URI_x86_64_v2_rubygem-connection_pool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-connection_pool-2.2.5-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-connection_pool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-connection_pool}"
SRC_URI[x86_64_v2_rubygem-connection_pool.sha256sum] = "84682ba6022113816b1e7422558bbb2ee3f98908eaf8b83e17f9ae760287e073"

URI_x86_64_v2_rubygem-connection_pool-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-connection_pool-doc-2.2.5-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-connection_pool-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-connection_pool-doc}"
SRC_URI[x86_64_v2_rubygem-connection_pool-doc.sha256sum] = "f45da652d6f8037d66dcce0805894624dc5b865f394320fd5c0b9c5eeb69cddb"

URI_aarch64_rubygem-connection_pool = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-connection_pool-2.2.5-11.el10_1.noarch.rpm;name=aarch64_rubygem-connection_pool;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-connection_pool}"
SRC_URI[aarch64_rubygem-connection_pool.sha256sum] = "04a89e33b9475c6e46e8c2813c30b6b3dd46094e0f2906f5ee110d9a9fe5acc4"

URI_aarch64_rubygem-connection_pool-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-connection_pool-doc-2.2.5-11.el10_1.noarch.rpm;name=aarch64_rubygem-connection_pool-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-connection_pool-doc}"
SRC_URI[aarch64_rubygem-connection_pool-doc.sha256sum] = "b4fe2be6fd73b48225947d1fc44d336ec96e5225370d47e8f573b06e218cc887"

RDEPENDS:rubygem-connection_pool = " \
 rubygems \
 "
RDEPENDS:rubygem-connection_pool-doc = " \
 rubygem-connection_pool \
 "
