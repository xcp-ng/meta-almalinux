# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-flagset"
PV = "0.4.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-flagset+default-devel \
 rust-flagset+serde-devel \
 rust-flagset+std-devel \
 rust-flagset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-flagset-0.4.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd758302f38e125db0550e11cc35e72d5ae1848ad2c844ca571c2e3165dfa010"

URI_x86_64_v2_rust-flagset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flagset+default-devel-0.4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flagset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flagset+default-devel}"
SRC_URI[x86_64_v2_rust-flagset+default-devel.sha256sum] = "69d1b2998d76b3503768e73d7c6a0780e2ff49dbd636d976a5bdea08c2b6714e"

URI_x86_64_v2_rust-flagset+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flagset+serde-devel-0.4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flagset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flagset+serde-devel}"
SRC_URI[x86_64_v2_rust-flagset+serde-devel.sha256sum] = "68d6a9a6bc4a693c5aaf05ec14bbab602abab454449989d0fce3e347764bc06c"

URI_x86_64_v2_rust-flagset+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flagset+std-devel-0.4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flagset+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flagset+std-devel}"
SRC_URI[x86_64_v2_rust-flagset+std-devel.sha256sum] = "dafb2eaddb757027bcc298a4dfa0c16f2291f459551dc8fc56f4f84de9affd2c"

URI_x86_64_v2_rust-flagset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-flagset-devel-0.4.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-flagset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-flagset-devel}"
SRC_URI[x86_64_v2_rust-flagset-devel.sha256sum] = "e10e4349460ca8192db63807479db126dbcce96290869033b621c60d7c3bc289"

URI_aarch64_rust-flagset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flagset+default-devel-0.4.7-1.el10_1.noarch.rpm;name=aarch64_rust-flagset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flagset+default-devel}"
SRC_URI[aarch64_rust-flagset+default-devel.sha256sum] = "20a7ea4558178d150259ceb4febb1d615e5b981e03852675dfcd9cd65c17fa36"

URI_aarch64_rust-flagset+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flagset+serde-devel-0.4.7-1.el10_1.noarch.rpm;name=aarch64_rust-flagset+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flagset+serde-devel}"
SRC_URI[aarch64_rust-flagset+serde-devel.sha256sum] = "533b07dd6a53b1309b9a77a30e4a547afa0e3f44901230cdfafe49cddcbe5141"

URI_aarch64_rust-flagset+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flagset+std-devel-0.4.7-1.el10_1.noarch.rpm;name=aarch64_rust-flagset+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flagset+std-devel}"
SRC_URI[aarch64_rust-flagset+std-devel.sha256sum] = "399b60cff9f54567b52a1350ccbda32f7cfc5f65b0281cff2eca2754b99e5891"

URI_aarch64_rust-flagset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-flagset-devel-0.4.7-1.el10_1.noarch.rpm;name=aarch64_rust-flagset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-flagset-devel}"
SRC_URI[aarch64_rust-flagset-devel.sha256sum] = "390351f11f094225589daf2fd45b8bd94e6e05e34cb39f42432c96781ff75f75"

RDEPENDS:rust-flagset+default-devel = " \
 cargo \
 rust-flagset-devel \
 "
RDEPENDS:rust-flagset+serde-devel = " \
 cargo \
 rust-flagset-devel \
 rust-serde+default-devel \
 rust-serde+serde_derive-devel \
 "
RDEPENDS:rust-flagset+std-devel = " \
 cargo \
 rust-flagset-devel \
 "
RDEPENDS:rust-flagset-devel = " \
 cargo \
 rust \
 "
