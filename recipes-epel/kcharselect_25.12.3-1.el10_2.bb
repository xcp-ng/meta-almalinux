# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcharselect"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kcharselect \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcharselect-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e7fc8167973428b0edafad534b7359d66ed91a851ae87d0439a27c260355acd1"

URI_x86_64_v2_kcharselect = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcharselect-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcharselect;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcharselect}"
SRC_URI[x86_64_v2_kcharselect.sha256sum] = "9dc2a97f628d52072eddd8e3d6b40cb5a327d95a45f5b2b1d165b9f84840f6cd"

URI_aarch64_kcharselect = "${EPEL_MIRROR}/aarch64/Packages/k/kcharselect-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kcharselect;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcharselect}"
SRC_URI[aarch64_kcharselect.sha256sum] = "ec06ea70492a06aadffc782442575f67b3f7369f6c7d1a7e535bd4750744be77"

RDEPENDS:kcharselect = " \
 glibc \
 kf6-kbookmarks \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
