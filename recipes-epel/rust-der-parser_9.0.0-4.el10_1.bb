# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-der-parser"
PV = "9.0.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-der-parser+bigint-devel \
 rust-der-parser+cookie-factory-devel \
 rust-der-parser+default-devel \
 rust-der-parser+num-bigint-devel \
 rust-der-parser+serialize-devel \
 rust-der-parser+std-devel \
 rust-der-parser+unstable-devel \
 rust-der-parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-der-parser-9.0.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdbfd5d80142a5f167c1fc33a847b933eb201ed755821ab38e370977e13a719d"

URI_x86_64_v2_rust-der-parser+bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+bigint-devel-9.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+bigint-devel}"
SRC_URI[x86_64_v2_rust-der-parser+bigint-devel.sha256sum] = "d52a6c1a9e746fd6cca9a6e0cf35119b51b4c9524d326376006e545f5f186cc4"

URI_x86_64_v2_rust-der-parser+cookie-factory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+cookie-factory-devel-9.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+cookie-factory-devel}"
SRC_URI[x86_64_v2_rust-der-parser+cookie-factory-devel.sha256sum] = "aa558d87cbafd4f883a3997e6392214e8bdd33d668646520082a74cde47e6e65"

URI_x86_64_v2_rust-der-parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+default-devel-9.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+default-devel}"
SRC_URI[x86_64_v2_rust-der-parser+default-devel.sha256sum] = "c68150f58c4ab53e8e37bfb5fad494281db0af0659677ca5bbdd6515b37a0a11"

URI_x86_64_v2_rust-der-parser+num-bigint-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+num-bigint-devel-9.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+num-bigint-devel}"
SRC_URI[x86_64_v2_rust-der-parser+num-bigint-devel.sha256sum] = "7e8289d1a268096761ebf5c99056243a3fb888a984178b585c855ae0c7cec81f"

URI_x86_64_v2_rust-der-parser+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+serialize-devel-9.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+serialize-devel}"
SRC_URI[x86_64_v2_rust-der-parser+serialize-devel.sha256sum] = "aa1ebcac7085fd51a4c8292e5816101b09d363db9fbe8c59a74fc94a2dd2bd2b"

URI_x86_64_v2_rust-der-parser+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+std-devel-9.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+std-devel}"
SRC_URI[x86_64_v2_rust-der-parser+std-devel.sha256sum] = "66a7449475f321bfaa38471d977356b7180a529dffad690851e6a3dc6d3142f9"

URI_x86_64_v2_rust-der-parser+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser+unstable-devel-9.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser+unstable-devel}"
SRC_URI[x86_64_v2_rust-der-parser+unstable-devel.sha256sum] = "b5e02517eb856991585622020c0438ac77b3c75f940d14254ca91aaabb64a70d"

URI_x86_64_v2_rust-der-parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-der-parser-devel-9.0.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-der-parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-der-parser-devel}"
SRC_URI[x86_64_v2_rust-der-parser-devel.sha256sum] = "3fc08a163e7f97445178b381ee40a5af1df3f082ec23b453316004286dcedc95"

URI_aarch64_rust-der-parser+bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+bigint-devel-9.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-der-parser+bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+bigint-devel}"
SRC_URI[aarch64_rust-der-parser+bigint-devel.sha256sum] = "f8bc58a762edfbb0a13bf8c31409ca36db7c00529f51c1ce4447221efd106e5a"

URI_aarch64_rust-der-parser+cookie-factory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+cookie-factory-devel-9.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-der-parser+cookie-factory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+cookie-factory-devel}"
SRC_URI[aarch64_rust-der-parser+cookie-factory-devel.sha256sum] = "91f4ddcfcfd63ca41bebe0a81b20d08211ba6eb23c44003036ca389e921c6cab"

URI_aarch64_rust-der-parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+default-devel-9.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-der-parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+default-devel}"
SRC_URI[aarch64_rust-der-parser+default-devel.sha256sum] = "45dc5ee6ffc6990cf12b49368b667d82d18398fbf2ca3606a66caf20bee2d03a"

URI_aarch64_rust-der-parser+num-bigint-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+num-bigint-devel-9.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-der-parser+num-bigint-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+num-bigint-devel}"
SRC_URI[aarch64_rust-der-parser+num-bigint-devel.sha256sum] = "dd55f5cd19dc9082fc12cecfd2b9df87e3d9a7f0b8500616d30de10c15e1d5e2"

URI_aarch64_rust-der-parser+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+serialize-devel-9.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-der-parser+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+serialize-devel}"
SRC_URI[aarch64_rust-der-parser+serialize-devel.sha256sum] = "6a71b29ef70138c0162e2c9f731c66aeebf661eee1b0bb13e49892ab3e1f5814"

URI_aarch64_rust-der-parser+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+std-devel-9.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-der-parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+std-devel}"
SRC_URI[aarch64_rust-der-parser+std-devel.sha256sum] = "febde0f6f5c0b84ff5d64b06e414f6507c41b6ee92e775af44165fd683e3fc11"

URI_aarch64_rust-der-parser+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser+unstable-devel-9.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-der-parser+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser+unstable-devel}"
SRC_URI[aarch64_rust-der-parser+unstable-devel.sha256sum] = "6346ac76a6334448f7993677ba8ff6a1b8fac5fd52f71df601d6210a27e4976d"

URI_aarch64_rust-der-parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-der-parser-devel-9.0.0-4.el10_1.noarch.rpm;name=aarch64_rust-der-parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-der-parser-devel}"
SRC_URI[aarch64_rust-der-parser-devel.sha256sum] = "9742daf9dac1665d0b0d6f415e18e88b6815593b2182ccac1329fd07be1bc441"

RDEPENDS:rust-der-parser+bigint-devel = " \
 cargo \
 rust-der-parser+num-bigint-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+cookie-factory-devel = " \
 cargo \
 rust-cookie-factory+default-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+default-devel = " \
 cargo \
 rust-der-parser+std-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+num-bigint-devel = " \
 cargo \
 rust-der-parser-devel \
 rust-num-bigint+default-devel \
 "
RDEPENDS:rust-der-parser+serialize-devel = " \
 cargo \
 rust-der-parser+cookie-factory-devel \
 rust-der-parser+std-devel \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+std-devel = " \
 cargo \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser+unstable-devel = " \
 cargo \
 rust-der-parser-devel \
 "
RDEPENDS:rust-der-parser-devel = " \
 cargo \
 rust \
 rust-asn1-rs+default-devel \
 rust-displaydoc-devel \
 rust-nom7+default-devel \
 rust-num-traits+default-devel \
 rust-rusticata-macros+default-devel \
 "
