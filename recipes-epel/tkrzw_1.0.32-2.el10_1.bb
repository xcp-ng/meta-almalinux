# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tkrzw"
PV = "1.0.32"
PR = "2.el10_1"
PACKAGES = " \
 tkrzw \
 tkrzw-devel \
 tkrzw-doc \
 tkrzw-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/t/tkrzw-1.0.32-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a6017f6c394a7e5f547e7543db666a3e7fc7a3ddce3febda52f6058e3cb3fe6e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tkrzw-1.0.32-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tkrzw;unpack=0"
SRC_URI[x86_64_v2_tkrzw.sha256sum] = "35a3a86b3d0cffe0251c17bb195bd4972dd2a1c6536ea25e4a65c97e79c6bd17"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tkrzw-devel-1.0.32-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tkrzw-devel;unpack=0"
SRC_URI[x86_64_v2_tkrzw-devel.sha256sum] = "cdf7cfc9f9fd87a3dd2c62248924bfc7b762c5f18df3cdca130523cd5afe65b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tkrzw-doc-1.0.32-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tkrzw-doc;unpack=0"
SRC_URI[x86_64_v2_tkrzw-doc.sha256sum] = "bfbeb7af55d7650ab0280dc15ece97b264542049cb5bdd5a016b433809f3de93"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tkrzw-libs-1.0.32-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tkrzw-libs;unpack=0"
SRC_URI[x86_64_v2_tkrzw-libs.sha256sum] = "6eb899856483a905a4e4b5441f23b4bba7fdca4179987f993b7f8c745d00d9d1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tkrzw-1.0.32-2.el10_1.aarch64.rpm;name=aarch64_tkrzw;unpack=0"
SRC_URI[aarch64_tkrzw.sha256sum] = "72255d154a217b076e700fad735033cb821cc10e1239ea2efbf2d414c4c0b456"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tkrzw-devel-1.0.32-2.el10_1.aarch64.rpm;name=aarch64_tkrzw-devel;unpack=0"
SRC_URI[aarch64_tkrzw-devel.sha256sum] = "b7e14443fe5b0070fed9ec2e451eaa48174fb9a77e1b01f27d7ef322f02f10da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tkrzw-doc-1.0.32-2.el10_1.noarch.rpm;name=aarch64_tkrzw-doc;unpack=0"
SRC_URI[aarch64_tkrzw-doc.sha256sum] = "265036a7c70fc98395c729604a177510732af17825e4afdc29d882f9de8ae0da"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/t/tkrzw-libs-1.0.32-2.el10_1.aarch64.rpm;name=aarch64_tkrzw-libs;unpack=0"
SRC_URI[aarch64_tkrzw-libs.sha256sum] = "d427dfba9213784606e9b681d26f3ab750f39c086a9208242229b12be7c35dc9"

RDEPENDS:tkrzw = " \
 glibc \
 libgcc \
 libstdc++ \
 tkrzw-libs \
 "
RDEPENDS:tkrzw-devel = " \
 pkgconf-pkg-config \
 tkrzw-libs \
 "
RDEPENDS:tkrzw-doc = " \
 "
RDEPENDS:tkrzw-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 xz-libs \
 zlib-ng-compat \
 "
