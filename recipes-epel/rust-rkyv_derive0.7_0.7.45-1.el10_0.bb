# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv_derive0.7"
PV = "0.7.45"
PR = "1.el10_0"
PACKAGES = " \
 rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel \
 rust-rkyv_derive0.7+archive_be-devel \
 rust-rkyv_derive0.7+archive_le-devel \
 rust-rkyv_derive0.7+copy-devel \
 rust-rkyv_derive0.7+default-devel \
 rust-rkyv_derive0.7+strict-devel \
 rust-rkyv_derive0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv_derive0.7-0.7.45-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a234807abd58ed440decf810ce8b9fcda63fc3e356c19cb1ff882d6e9a541546"

URI_x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel.sha256sum] = "4829937bf37253c1aaa7c9cb213c9046c4ac8f09f953cecc6366792fe9ad3dae"

URI_x86_64_v2_rust-rkyv_derive0.7+archive_be-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+archive_be-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+archive_be-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+archive_be-devel.sha256sum] = "f1f800bb1e7d946e9c082c07d1d6fafae8bccc969234ea185dedec6ca8b16b3c"

URI_x86_64_v2_rust-rkyv_derive0.7+archive_le-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+archive_le-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+archive_le-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+archive_le-devel.sha256sum] = "f5d894b3e2c16457c75d9605529e0013e01922655407951452707f0375f5f2bb"

URI_x86_64_v2_rust-rkyv_derive0.7+copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+copy-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+copy-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+copy-devel.sha256sum] = "6e2d3997d13e0f693f9a828e650feeb61b6f478e0da6153f5e1afa9340251ddf"

URI_x86_64_v2_rust-rkyv_derive0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+default-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+default-devel.sha256sum] = "d147b9ccb0386d69122a246b300929db8bc49688ac3fc31877f8547d9dfd4ef1"

URI_x86_64_v2_rust-rkyv_derive0.7+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+strict-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+strict-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+strict-devel.sha256sum] = "119483da146bfaa2ed8383b04ff79a527d1ed0b95e90aa6f2c899fbd15b04722"

URI_x86_64_v2_rust-rkyv_derive0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7-devel-0.7.45-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7-devel.sha256sum] = "120ed0789f3719b08bdc9f3f4bce2618087f4aa0caba0b8385bb034a024e53b9"

URI_aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel.sha256sum] = "9a79819382b1a73e5dcbdcf23707d2af31665b7a8036de1c61b43cab60b5d1d5"

URI_aarch64_rust-rkyv_derive0.7+archive_be-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+archive_be-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+archive_be-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+archive_be-devel.sha256sum] = "39d6690dca26d52ddd562bd8ee722e5d421f6070408023ebb348753610f6e393"

URI_aarch64_rust-rkyv_derive0.7+archive_le-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+archive_le-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+archive_le-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+archive_le-devel.sha256sum] = "5adb8b7d9f1b48639a650a62e884d6330e58c3b225b0f7994fc65d53d6640f55"

URI_aarch64_rust-rkyv_derive0.7+copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+copy-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+copy-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+copy-devel.sha256sum] = "de937bca3083d8c3daa68c4501064eb2acbee8a18899b2578af12ffe4d30c9f9"

URI_aarch64_rust-rkyv_derive0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+default-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+default-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+default-devel.sha256sum] = "b12cb84e9566b9e7bcf8b6f2412736dc4c1e458ab89608c6d6ef13cd35079c27"

URI_aarch64_rust-rkyv_derive0.7+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+strict-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+strict-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+strict-devel.sha256sum] = "b009b1bd0adce0f197bb04c42e4ba382ef3f562660e71bd053e2c239d9138d17"

URI_aarch64_rust-rkyv_derive0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7-devel-0.7.45-1.el10_0.noarch.rpm;name=aarch64_rust-rkyv_derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7-devel.sha256sum] = "3ff83039ba9cf3ff67b21a4e2549082e2a06c2bba9dd3d459628828b004c9851"

RDEPENDS:rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+archive_be-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+archive_le-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+copy-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+default-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+strict-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 "
