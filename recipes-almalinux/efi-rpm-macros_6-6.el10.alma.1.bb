# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "efi-rpm-macros"
PV = "6"
PR = "6.el10.alma.1"
PACKAGES = " \
 efi-filesystem \
 efi-srpm-macros \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/efi-rpm-macros-6-6.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ad1887456a461fd1286ea2eef0759047d10cdf4244806fb4cc619c536e4334b9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/efi-filesystem-6-6.el10.alma.1.noarch.rpm;name=x86_64_v2_efi-filesystem;unpack=0"
SRC_URI[x86_64_v2_efi-filesystem.sha256sum] = "d3355977a9f3513adc3a134c62e93dcce39f5ef0e3949f0b155223d9cc6c4258"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/efi-srpm-macros-6-6.el10.alma.1.noarch.rpm;name=x86_64_v2_efi-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_efi-srpm-macros.sha256sum] = "dc33deadb41135d9d2b5dfe7a817991ab3bccdbd1566d3f8477a3dd9ac609430"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/efi-filesystem-6-6.el10.alma.1.noarch.rpm;name=aarch64_efi-filesystem;unpack=0"
SRC_URI[aarch64_efi-filesystem.sha256sum] = "d3355977a9f3513adc3a134c62e93dcce39f5ef0e3949f0b155223d9cc6c4258"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/efi-srpm-macros-6-6.el10.alma.1.noarch.rpm;name=aarch64_efi-srpm-macros;unpack=0"
SRC_URI[aarch64_efi-srpm-macros.sha256sum] = "dc33deadb41135d9d2b5dfe7a817991ab3bccdbd1566d3f8477a3dd9ac609430"

RDEPENDS:efi-filesystem = " \
 filesystem \
 "
RDEPENDS:efi-srpm-macros = " \
 bash \
 rpm \
 "
