# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lld15"
PV = "15.0.7"
PR = "8.el10_0"
PACKAGES = " \
 lld15-devel \
 lld15-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lld15-15.0.7-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa79b0b11bf34908ce22849c6e3bcca5d01d23d5c62c1aecb1d9bb01533b54cd"

URI_x86_64_v2_lld15-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld15-devel-15.0.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld15-devel}"
SRC_URI[x86_64_v2_lld15-devel.sha256sum] = "cd9eb553c2ad23615e8393ea24c7bf170a0d18aac975d5ad4e34993e0e4a58f4"

URI_x86_64_v2_lld15-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lld15-libs-15.0.7-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lld15-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lld15-libs}"
SRC_URI[x86_64_v2_lld15-libs.sha256sum] = "42daec58d24474c3d9136b32ee9db30615f6d78d7de3674a4655a5d4c83745b4"

URI_aarch64_lld15-devel = "${EPEL_MIRROR}/aarch64/Packages/l/lld15-devel-15.0.7-8.el10_0.aarch64.rpm;name=aarch64_lld15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld15-devel}"
SRC_URI[aarch64_lld15-devel.sha256sum] = "d5b4ab6b02201be632f91619ae355ab610b21683483425e85627f1960da88ee1"

URI_aarch64_lld15-libs = "${EPEL_MIRROR}/aarch64/Packages/l/lld15-libs-15.0.7-8.el10_0.aarch64.rpm;name=aarch64_lld15-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lld15-libs}"
SRC_URI[aarch64_lld15-libs.sha256sum] = "e5a103e2c5c1c5f2629e4b9b5c89291337f3b58c8dbc2b0a7570eac927f30bda"

RDEPENDS:lld15-devel = " \
 lld15-libs \
 "
RDEPENDS:lld15-libs = " \
 glibc \
 libstdc++ \
 llvm15-libs \
 zlib-ng-compat \
 "
