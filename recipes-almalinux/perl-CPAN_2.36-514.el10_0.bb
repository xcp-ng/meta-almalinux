# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN"
PV = "2.36"
PR = "514.el10_0"
PACKAGES = " \
 perl-CPAN \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-CPAN-2.36-514.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f3ee16d74daf717a14f7a74547f80eea3ed5f2a0c50c99001d5f11b2c11ff27"

URI_x86_64_v2_perl-CPAN = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-CPAN-2.36-514.el10_0.noarch.rpm;name=x86_64_v2_perl-CPAN;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CPAN}"
SRC_URI[x86_64_v2_perl-CPAN.sha256sum] = "e4d75af4f7a7842ffcd64d919c7b569ab36d79b10910fc26c80083897258df7a"

URI_aarch64_perl-CPAN = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-CPAN-2.36-514.el10_0.noarch.rpm;name=aarch64_perl-CPAN;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CPAN}"
SRC_URI[aarch64_perl-CPAN.sha256sum] = "e4d75af4f7a7842ffcd64d919c7b569ab36d79b10910fc26c80083897258df7a"

RDEPENDS:perl-CPAN = " \
 make \
 perl \
 perl-Archive-Tar \
 perl-Archive-Zip \
 perl-CPAN \
 perl-CPAN-Meta \
 perl-CPAN-Meta-Requirements \
 perl-Carp \
 perl-Compress-Bzip2 \
 perl-Data-Dumper \
 perl-Devel-Size \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-DirHandle \
 perl-Dumpvalue \
 perl-Errno \
 perl-Exporter \
 perl-ExtUtils-CBuilder \
 perl-ExtUtils-MakeMaker \
 perl-ExtUtils-Manifest \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-HomeDir \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Std \
 perl-HTTP-Tiny \
 perl-IO-Compress \
 perl-Module-Build \
 perl-Module-Signature \
 perl-Net-Ping \
 perl-POSIX \
 perl-PathTools \
 perl-Safe \
 perl-Sys-Hostname \
 perl-Term-ReadLine \
 perl-Text-Glob \
 perl-Text-ParseWords \
 perl-Text-Tabs+Wrap \
 perl-Time-Local \
 perl-URI \
 perl-User-pwent \
 perl-autouse \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libnet \
 perl-libs \
 perl-local-lib \
 perl-overload \
 perl-vars \
 "
