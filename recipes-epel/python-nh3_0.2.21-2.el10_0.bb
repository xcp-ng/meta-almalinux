# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-nh3"
PV = "0.2.21"
PR = "2.el10_0"
PACKAGES = " \
 python3-nh3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-nh3-0.2.21-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7652315df0d32983f4768dcc4b753ec66558512e988c9edb2480ad1c2c58ebbd"

URI_x86_64_v2_python3-nh3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-nh3-0.2.21-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-nh3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nh3}"
SRC_URI[x86_64_v2_python3-nh3.sha256sum] = "bcdb1cb8f8d18fcc110bb13536e914c6a6c628d47f59ad696eabadd1748f4f9e"

URI_aarch64_python3-nh3 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-nh3-0.2.21-2.el10_0.aarch64.rpm;name=aarch64_python3-nh3;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nh3}"
SRC_URI[aarch64_python3-nh3.sha256sum] = "dee061302b80b83ae59517e0e689706aefa8a4b3453982a97a95035a55f3c6a7"

RDEPENDS:python3-nh3 = " \
 glibc \
 libgcc \
 python3 \
 "
