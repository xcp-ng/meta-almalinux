# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dary_heap"
PV = "0.3.8"
PR = "1.el10_0"
PACKAGES = " \
 rust-dary_heap+default-devel \
 rust-dary_heap+extra-devel \
 rust-dary_heap+serde-devel \
 rust-dary_heap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dary_heap-0.3.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c74f8199262946a46dbfb608cf87b85fc6adb55b1768f8e5167dd77914b7022a"

URI_x86_64_v2_rust-dary_heap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap+default-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap+default-devel}"
SRC_URI[x86_64_v2_rust-dary_heap+default-devel.sha256sum] = "edb6f2864c2f4b06c67175443c67ddeded81fa3d3089f278f1b1b2601100f5e9"

URI_x86_64_v2_rust-dary_heap+extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap+extra-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap+extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap+extra-devel}"
SRC_URI[x86_64_v2_rust-dary_heap+extra-devel.sha256sum] = "eebd7de5b502fbb32be0607f4b66cbb2f8df414883531467c988e63284de2290"

URI_x86_64_v2_rust-dary_heap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap+serde-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap+serde-devel}"
SRC_URI[x86_64_v2_rust-dary_heap+serde-devel.sha256sum] = "ee9ff6af4e643961838cb4fe5c3b28b021862f150f277677d4ce40fbe7bd2249"

URI_x86_64_v2_rust-dary_heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap-devel-0.3.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap-devel}"
SRC_URI[x86_64_v2_rust-dary_heap-devel.sha256sum] = "00fdec64ceab775f8b16db42c0ed39db454ba606065439275ee7a6adbf40cae3"

URI_aarch64_rust-dary_heap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap+default-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-dary_heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap+default-devel}"
SRC_URI[aarch64_rust-dary_heap+default-devel.sha256sum] = "8c580894a14e471580850383ae8642687b236166025aea6bb72ce8113d470548"

URI_aarch64_rust-dary_heap+extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap+extra-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-dary_heap+extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap+extra-devel}"
SRC_URI[aarch64_rust-dary_heap+extra-devel.sha256sum] = "ca37560514858fc40e16354d6c9fc00e79dce6a7d717d1331decb7ad5657aa1c"

URI_aarch64_rust-dary_heap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap+serde-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-dary_heap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap+serde-devel}"
SRC_URI[aarch64_rust-dary_heap+serde-devel.sha256sum] = "6bf50385576d873c16becfa1a8a42567a0fcd40b72cf317ef889b0dfdd3eb6f8"

URI_aarch64_rust-dary_heap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap-devel-0.3.8-1.el10_0.noarch.rpm;name=aarch64_rust-dary_heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap-devel}"
SRC_URI[aarch64_rust-dary_heap-devel.sha256sum] = "7372ea8f9c2ca6b3c7d27662a92295c68316860c79c0346fae9f4fd3014aa703"

RDEPENDS:rust-dary_heap+default-devel = " \
 cargo \
 rust-dary_heap-devel \
 "
RDEPENDS:rust-dary_heap+extra-devel = " \
 cargo \
 rust-dary_heap-devel \
 "
RDEPENDS:rust-dary_heap+serde-devel = " \
 cargo \
 rust-dary_heap-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-dary_heap-devel = " \
 cargo \
 "
