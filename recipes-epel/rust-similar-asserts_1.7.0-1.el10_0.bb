# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-similar-asserts"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-similar-asserts+default-devel \
 rust-similar-asserts+serde-devel \
 rust-similar-asserts+unicode-devel \
 rust-similar-asserts-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-similar-asserts-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc1d4257c024567228c32c1ed7d4bfdfb540c6e5e44b730cde9a0506bc048bdf"

URI_x86_64_v2_rust-similar-asserts+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-asserts+default-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-asserts+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-asserts+default-devel}"
SRC_URI[x86_64_v2_rust-similar-asserts+default-devel.sha256sum] = "cf6f61e9b1cb1125f8d62e66035558d5033234349ce4eb3e84086c99d7eba857"

URI_x86_64_v2_rust-similar-asserts+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-asserts+serde-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-asserts+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-asserts+serde-devel}"
SRC_URI[x86_64_v2_rust-similar-asserts+serde-devel.sha256sum] = "d8fd646bc31280ef3bd16427411c0ba24b80c7a97dd5ee37ed7ef9708a0286ac"

URI_x86_64_v2_rust-similar-asserts+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-asserts+unicode-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-asserts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-asserts+unicode-devel}"
SRC_URI[x86_64_v2_rust-similar-asserts+unicode-devel.sha256sum] = "75d282e11fc8959bd9e82584f6ec8880cfce127f1457f4f6dad326bb20e3bc75"

URI_x86_64_v2_rust-similar-asserts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-similar-asserts-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-similar-asserts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-similar-asserts-devel}"
SRC_URI[x86_64_v2_rust-similar-asserts-devel.sha256sum] = "213043f3be3e8403a6b4f6c6f7e61124081f876f32874918690be496cbc3a088"

URI_aarch64_rust-similar-asserts+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-asserts+default-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar-asserts+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-asserts+default-devel}"
SRC_URI[aarch64_rust-similar-asserts+default-devel.sha256sum] = "88a0a590e09c3968847ed05b47d6123450ac2d78a946e0c555f205a72fe15310"

URI_aarch64_rust-similar-asserts+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-asserts+serde-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar-asserts+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-asserts+serde-devel}"
SRC_URI[aarch64_rust-similar-asserts+serde-devel.sha256sum] = "d4341e535bd6a18338d8dc5df7b06f5102431c53b646a28c4502baca0e14e308"

URI_aarch64_rust-similar-asserts+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-asserts+unicode-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar-asserts+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-asserts+unicode-devel}"
SRC_URI[aarch64_rust-similar-asserts+unicode-devel.sha256sum] = "a70d784777c4b2d98d3d837a54a44351542a10e296eddcdbaae42be2a54503b4"

URI_aarch64_rust-similar-asserts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-similar-asserts-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-similar-asserts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-similar-asserts-devel}"
SRC_URI[aarch64_rust-similar-asserts-devel.sha256sum] = "ba7c772ecfd0fa57b0d259fdd677a1bca59bc0191c00d9df7bcf0edebdf141ac"

RDEPENDS:rust-similar-asserts+default-devel = " \
 cargo \
 rust-similar-asserts+unicode-devel \
 rust-similar-asserts-devel \
 "
RDEPENDS:rust-similar-asserts+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-similar-asserts-devel \
 "
RDEPENDS:rust-similar-asserts+unicode-devel = " \
 cargo \
 rust-similar+unicode-devel \
 rust-similar-asserts-devel \
 "
RDEPENDS:rust-similar-asserts-devel = " \
 cargo \
 rust \
 rust-console-devel \
 rust-similar+default-devel \
 rust-similar+inline-devel \
 "
