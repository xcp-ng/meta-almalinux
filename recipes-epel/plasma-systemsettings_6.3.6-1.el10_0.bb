# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-systemsettings"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-systemsettings \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-systemsettings-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0987d19597d242cd9cf5934d2d8024ff2e537cb2b7411bb51611b613387f65da"

URI_x86_64_v2_plasma-systemsettings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-systemsettings-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-systemsettings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-systemsettings}"
SRC_URI[x86_64_v2_plasma-systemsettings.sha256sum] = "e3d9151b4362e62ba4f567cf8c08570ad1375bd00663af612435b5cb6b1f06a8"

URI_aarch64_plasma-systemsettings = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-systemsettings-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-systemsettings;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-systemsettings}"
SRC_URI[aarch64_plasma-systemsettings.sha256sum] = "29f4cb0240606aceebcd6c95945e8ad0c57f7715a81eed5bd9a5fbc723721ed1"

RDEPENDS:plasma-systemsettings = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-krunner \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
