# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pest"
PV = "2.8.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-pest+const_prec_climber-devel \
 rust-pest+default-devel \
 rust-pest+memchr-devel \
 rust-pest+miette-error-devel \
 rust-pest+pretty-print-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pest-2.8.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae31c9cd995f27b2451363468da2d03940b7ee8527fab0a25fc1a509f56e1601"

URI_x86_64_v2_rust-pest+const_prec_climber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+const_prec_climber-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+const_prec_climber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+const_prec_climber-devel}"
SRC_URI[x86_64_v2_rust-pest+const_prec_climber-devel.sha256sum] = "b1c8532dc4747c752c68a1c79e09bad2cfc66464b8e2e0a9d353c450bd149196"

URI_x86_64_v2_rust-pest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+default-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+default-devel}"
SRC_URI[x86_64_v2_rust-pest+default-devel.sha256sum] = "799e2c5e650240e7dba9d05ae04eb67baa2679b12f6527244f28e741f1c8e174"

URI_x86_64_v2_rust-pest+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+memchr-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+memchr-devel}"
SRC_URI[x86_64_v2_rust-pest+memchr-devel.sha256sum] = "a8ea03c09a0a144db1b953d1b5b54d61aa4446b7fac821b754c01aa4b0621d23"

URI_x86_64_v2_rust-pest+miette-error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+miette-error-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+miette-error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+miette-error-devel}"
SRC_URI[x86_64_v2_rust-pest+miette-error-devel.sha256sum] = "a97e0460fd864523631bf2d9be91122c99817e0180f9088080fc78073c197819"

URI_x86_64_v2_rust-pest+pretty-print-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+pretty-print-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+pretty-print-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+pretty-print-devel}"
SRC_URI[x86_64_v2_rust-pest+pretty-print-devel.sha256sum] = "67271c0f6ca13a8f16b5be737b6e4e6616c6c778cf1361dcaa931e6aaabd3ff7"

URI_x86_64_v2_rust-pest+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest+std-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest+std-devel}"
SRC_URI[x86_64_v2_rust-pest+std-devel.sha256sum] = "92bf0db4e92ae91a58734d0fe0917546ab994cbefaecf0d1d8da8c1a037b773c"

URI_x86_64_v2_rust-pest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pest-devel-2.8.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pest-devel}"
SRC_URI[x86_64_v2_rust-pest-devel.sha256sum] = "9fa828665495f5e76aeb84de3949633bf432d1d756489de278cc1fe075d61f57"

URI_aarch64_rust-pest+const_prec_climber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+const_prec_climber-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest+const_prec_climber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+const_prec_climber-devel}"
SRC_URI[aarch64_rust-pest+const_prec_climber-devel.sha256sum] = "b7fe6bc85209cb7f00f06c8e093cfa5b657bdf8b5dc21ffb10f51f82c08bbd41"

URI_aarch64_rust-pest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+default-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+default-devel}"
SRC_URI[aarch64_rust-pest+default-devel.sha256sum] = "e860a0da0c70eee6e3bd47e07df9679585e4927d825a61b568bb1aae3ffd21d5"

URI_aarch64_rust-pest+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+memchr-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+memchr-devel}"
SRC_URI[aarch64_rust-pest+memchr-devel.sha256sum] = "f06a056e135d2aac98f5fb64fffc094769dc8919a7c5540cdcdee55aabc863e4"

URI_aarch64_rust-pest+miette-error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+miette-error-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest+miette-error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+miette-error-devel}"
SRC_URI[aarch64_rust-pest+miette-error-devel.sha256sum] = "240fe0c78055cf8aaaaad4feb1686ed29c6df1c8e415767d01b9a385ff83ac25"

URI_aarch64_rust-pest+pretty-print-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+pretty-print-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest+pretty-print-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+pretty-print-devel}"
SRC_URI[aarch64_rust-pest+pretty-print-devel.sha256sum] = "9737c71ba3b89cad6ff9cfa65ffd284a26784f24c09212db51f136219c9e43d9"

URI_aarch64_rust-pest+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest+std-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest+std-devel}"
SRC_URI[aarch64_rust-pest+std-devel.sha256sum] = "a5fbbefc6838941fb7b448265ecb7853baa64abf32fbf0cac7d41e00b31eb63f"

URI_aarch64_rust-pest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pest-devel-2.8.3-1.el10_0.noarch.rpm;name=aarch64_rust-pest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pest-devel}"
SRC_URI[aarch64_rust-pest-devel.sha256sum] = "e6396c3f02ae09bb93043a664de5aace8ffdd1e2677a9a141a9fbbb585e6027f"

RDEPENDS:rust-pest+const_prec_climber-devel = " \
 cargo \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+default-devel = " \
 cargo \
 rust-pest+memchr-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+memchr-devel = " \
 cargo \
 rust-memchr+default-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+miette-error-devel = " \
 cargo \
 rust-miette+default-devel \
 rust-miette+fancy-devel \
 rust-pest+pretty-print-devel \
 rust-pest+std-devel \
 rust-pest-devel \
 "
RDEPENDS:rust-pest+pretty-print-devel = " \
 cargo \
 rust-pest-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-pest+std-devel = " \
 cargo \
 rust-pest-devel \
 rust-ucd-trie+std-devel \
 "
RDEPENDS:rust-pest-devel = " \
 cargo \
 rust \
 rust-ucd-trie-devel \
 "
