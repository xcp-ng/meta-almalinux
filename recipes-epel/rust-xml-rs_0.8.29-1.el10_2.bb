# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xml-rs"
PV = "0.8.29"
PR = "1.el10_2"
PACKAGES = " \
 rust-xml-rs+default-devel \
 rust-xml-rs-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-xml-rs-0.8.29-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f95693811ee4781961efc623ed2240c1248ba96f0e6aa1e2ab26e30678f3c40a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xml-rs+default-devel-0.8.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xml-rs+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xml-rs+default-devel.sha256sum] = "3441b53776d2e0d419ae7522d872b007cdbb673b5b52146ee3435566c753b98b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xml-rs-devel-0.8.29-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xml-rs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xml-rs-devel.sha256sum] = "b9f4ec52bbf408efd1c2a4a91e27cbfaced805d02a2954e05727c16b8e31945c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xml-rs+default-devel-0.8.29-1.el10_2.noarch.rpm;name=aarch64_rust-xml-rs+default-devel;unpack=0"
SRC_URI[aarch64_rust-xml-rs+default-devel.sha256sum] = "6d9ac66eeff40ad670c48c0e5054af8852dad3900858820c85b231aee087bf8d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xml-rs-devel-0.8.29-1.el10_2.noarch.rpm;name=aarch64_rust-xml-rs-devel;unpack=0"
SRC_URI[aarch64_rust-xml-rs-devel.sha256sum] = "797463c9867bec578e3b1b3e1fe73a634ba0893eec539e94f385afb77789ce71"

RDEPENDS:rust-xml-rs+default-devel = " \
 cargo \
 rust-xml-rs-devel \
 "
RDEPENDS:rust-xml-rs-devel = " \
 cargo \
 rust \
 "
