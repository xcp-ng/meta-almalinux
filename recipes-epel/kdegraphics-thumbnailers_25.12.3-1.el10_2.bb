# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-thumbnailers"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdegraphics-thumbnailers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-thumbnailers-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65c27fa35cb3fe1df3240a5e8527f6b6b5289ff99c2886f776590e47d759a729"

URI_x86_64_v2_kdegraphics-thumbnailers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-thumbnailers-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-thumbnailers}"
SRC_URI[x86_64_v2_kdegraphics-thumbnailers.sha256sum] = "0e675a49eda3ae6d696e1af4e50a2b44a2ec0757529b06bc20bc0b1e5b539426"

URI_aarch64_kdegraphics-thumbnailers = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-thumbnailers-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdegraphics-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-thumbnailers}"
SRC_URI[aarch64_kdegraphics-thumbnailers.sha256sum] = "f91dd0c44d6aadfa701961e67345a0ce1868b06cf0553b4f50595b590cbaf755"

RDEPENDS:kdegraphics-thumbnailers = " \
 glibc \
 kdegraphics-mobipocket \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libkdcraw \
 libkexiv2-qt6 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
