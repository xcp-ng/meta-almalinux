# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kfourinline"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kfourinline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kfourinline-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e5f14ed184166febcb6cee30fc8d4b975133771104554107cb6a5657a1092d3"

URI_x86_64_v2_kfourinline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfourinline-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfourinline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kfourinline}"
SRC_URI[x86_64_v2_kfourinline.sha256sum] = "294a505896bd9c4088d138fc84321811d51b3e136b5720b34597f045030ed176"

URI_aarch64_kfourinline = "${EPEL_MIRROR}/aarch64/Packages/k/kfourinline-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kfourinline;unpack=0"
SRC_URI:append = " ${URI_aarch64_kfourinline}"
SRC_URI[aarch64_kfourinline.sha256sum] = "dfd2471e7c378c52c09018493c36c16abfc3ce3f45744904e21749db1f9c98b8"

RDEPENDS:kfourinline = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
