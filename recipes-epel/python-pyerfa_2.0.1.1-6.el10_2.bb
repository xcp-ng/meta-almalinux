# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyerfa"
PV = "2.0.1.1"
PR = "6.el10_2"
PACKAGES = " \
 python3-pyerfa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyerfa-2.0.1.1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85735b0f998f52e3dc51166d3454d0c5a99a756f45187ac3d50c03db19a941e7"

URI_x86_64_v2_python3-pyerfa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyerfa-2.0.1.1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyerfa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyerfa}"
SRC_URI[x86_64_v2_python3-pyerfa.sha256sum] = "b46325ac33ce7c23c71fb90833c7187eb93e3aae99711dc7ff43eb68c6f6d007"

URI_aarch64_python3-pyerfa = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyerfa-2.0.1.1-6.el10_2.aarch64.rpm;name=aarch64_python3-pyerfa;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyerfa}"
SRC_URI[aarch64_python3-pyerfa.sha256sum] = "6d9fbd082eb52b56b6550960e37dd0b1c9414b2b7a0c396d81e28dc58fb98ec0"

RDEPENDS:python3-pyerfa = " \
 erfa \
 glibc \
 python3 \
 python3-numpy \
 "
