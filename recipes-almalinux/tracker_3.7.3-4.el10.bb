# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tracker"
PV = "3.7.3"
PR = "4.el10"
PACKAGES = " \
 libtracker-sparql \
 tracker \
 tracker-devel \
 tracker-doc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tracker-3.7.3-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49c3e6fccaa35d99b3cda4a21472bb709d37dfca177113dbecb6fb76cf283756"

URI_x86_64_v2_libtracker-sparql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtracker-sparql-3.7.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_libtracker-sparql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtracker-sparql}"
SRC_URI[x86_64_v2_libtracker-sparql.sha256sum] = "e9e3fe743000f88f8ef89f5480b764559f45b4e1eedf81ea945963c4668a1e7f"

URI_x86_64_v2_tracker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tracker-3.7.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_tracker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tracker}"
SRC_URI[x86_64_v2_tracker.sha256sum] = "f287e696d6020c8419d184f68267236fe64658481ccf6a1eaf2ee92a5d2362d9"

URI_x86_64_v2_tracker-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tracker-devel-3.7.3-4.el10.x86_64_v2.rpm;name=x86_64_v2_tracker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tracker-devel}"
SRC_URI[x86_64_v2_tracker-devel.sha256sum] = "0a645246f658fa7f0e8af44a59972f9943d8d1dba9b7f3ab56ea03755835ad2e"

URI_x86_64_v2_tracker-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/tracker-doc-3.7.3-4.el10.noarch.rpm;name=x86_64_v2_tracker-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tracker-doc}"
SRC_URI[x86_64_v2_tracker-doc.sha256sum] = "60625c525e1320fdd7ba8ca422355daa1b6f3d1e363b98f7c5478f1631343a90"

URI_aarch64_libtracker-sparql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtracker-sparql-3.7.3-4.el10.aarch64.rpm;name=aarch64_libtracker-sparql;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtracker-sparql}"
SRC_URI[aarch64_libtracker-sparql.sha256sum] = "04cce9f99070c6ec62002b6349f18e5d6c59b3e4e3fb348ad5fe112f5ef8f975"

URI_aarch64_tracker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tracker-3.7.3-4.el10.aarch64.rpm;name=aarch64_tracker;unpack=0"
SRC_URI:append = " ${URI_aarch64_tracker}"
SRC_URI[aarch64_tracker.sha256sum] = "7688a449560da68c9f0725f5e2dfbecf321c4fa09d6a3f68e6f1b7a04cb2b9da"

URI_aarch64_tracker-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tracker-devel-3.7.3-4.el10.aarch64.rpm;name=aarch64_tracker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_tracker-devel}"
SRC_URI[aarch64_tracker-devel.sha256sum] = "f946a962295b22f31abddcd4ff8eca46239f1c7f09ded508df5a255d4936f14f"

URI_aarch64_tracker-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/tracker-doc-3.7.3-4.el10.noarch.rpm;name=aarch64_tracker-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_tracker-doc}"
SRC_URI[aarch64_tracker-doc.sha256sum] = "60625c525e1320fdd7ba8ca422355daa1b6f3d1e363b98f7c5478f1631343a90"

RDEPENDS:libtracker-sparql = " \
 avahi-glib \
 avahi-libs \
 bash \
 glib2 \
 glibc \
 json-glib \
 libicu \
 libsoup3 \
 libxml2 \
 sqlite-libs \
 "
RDEPENDS:tracker = " \
 avahi-glib \
 avahi-libs \
 bash \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 libtracker-sparql \
 sqlite-libs \
 "
RDEPENDS:tracker-devel = " \
 bash \
 glib2-devel \
 json-glib-devel \
 libtracker-sparql \
 libxml2-devel \
 pkgconf-pkg-config \
 sqlite-devel \
 "
RDEPENDS:tracker-doc = " \
 "
