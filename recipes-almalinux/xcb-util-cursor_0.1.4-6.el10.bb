# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xcb-util-cursor"
PV = "0.1.4"
PR = "6.el10"
PACKAGES = " \
 xcb-util-cursor \
 xcb-util-cursor-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xcb-util-cursor-0.1.4-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96826177e40f591169aaa9ec88e1bb188f8ffff129dd38ba71f7d0e1be645ad8"

URI_x86_64_v2_xcb-util-cursor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xcb-util-cursor-0.1.4-6.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util-cursor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-cursor}"
SRC_URI[x86_64_v2_xcb-util-cursor.sha256sum] = "0fb97341f9401f63e39daa6a0142d50067c890fa8571f3400279bf2eb6282541"

URI_x86_64_v2_xcb-util-cursor-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xcb-util-cursor-devel-0.1.4-6.el10.x86_64_v2.rpm;name=x86_64_v2_xcb-util-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xcb-util-cursor-devel}"
SRC_URI[x86_64_v2_xcb-util-cursor-devel.sha256sum] = "ff402c7837fc34f38dc9d3640d328a5a3dad496275d570d65d6b0eec9124d2d4"

URI_aarch64_xcb-util-cursor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xcb-util-cursor-0.1.4-6.el10.aarch64.rpm;name=aarch64_xcb-util-cursor;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-cursor}"
SRC_URI[aarch64_xcb-util-cursor.sha256sum] = "078be266dfcec29da880cce3eeeebbe8478ed6cc8d405e3c9dd6b03fd2ea3659"

URI_aarch64_xcb-util-cursor-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xcb-util-cursor-devel-0.1.4-6.el10.aarch64.rpm;name=aarch64_xcb-util-cursor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xcb-util-cursor-devel}"
SRC_URI[aarch64_xcb-util-cursor-devel.sha256sum] = "427a9a687303afa7eb3a30bddf8fde5f45595e16bcdefbe8895909f2ce9e3a79"

RDEPENDS:xcb-util-cursor = " \
 glibc \
 libxcb \
 xcb-util-image \
 xcb-util-renderutil \
 "
RDEPENDS:xcb-util-cursor-devel = " \
 libxcb-devel \
 pkgconf-pkg-config \
 xcb-util-cursor \
 xcb-util-image-devel \
 xcb-util-renderutil-devel \
 "
