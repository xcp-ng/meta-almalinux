# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mio"
PV = "1.2.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-mio+default-devel \
 rust-mio+log-devel \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mio-1.2.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61ae453708ea51fa96375cd0f5758837000b8ccaf680096aa8c4ed0a63460a15"

URI_x86_64_v2_rust-mio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+default-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+default-devel}"
SRC_URI[x86_64_v2_rust-mio+default-devel.sha256sum] = "a158192b9799f2b91e1c40f183d5ccc1ce51407fad630bc048a35e7df07aac5b"

URI_x86_64_v2_rust-mio+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+log-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+log-devel}"
SRC_URI[x86_64_v2_rust-mio+log-devel.sha256sum] = "e91d99be43fc0c9b4be5fc0d946ba4407c162ac3df87af03b130f923389fac21"

URI_x86_64_v2_rust-mio+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+net-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+net-devel}"
SRC_URI[x86_64_v2_rust-mio+net-devel.sha256sum] = "d1bc14c5b86d7cff173ff4d4bef527808921709e5f96566ff0bf7d663c22603e"

URI_x86_64_v2_rust-mio+os-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-ext-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+os-ext-devel}"
SRC_URI[x86_64_v2_rust-mio+os-ext-devel.sha256sum] = "37561e29b4148f7cd51aef9624781071aa81ade0f0997557acaa760e25341e85"

URI_x86_64_v2_rust-mio+os-poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio+os-poll-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio+os-poll-devel}"
SRC_URI[x86_64_v2_rust-mio+os-poll-devel.sha256sum] = "d2baff1e07f7009890998d4e7efc0afd1ba9df0af0a0783da58abef93c2213ea"

URI_x86_64_v2_rust-mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio-devel-1.2.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio-devel}"
SRC_URI[x86_64_v2_rust-mio-devel.sha256sum] = "bdc8c2055f88b62584cb0417725aa0cd5231e3f17e5917d813cbce77c857dfa6"

URI_aarch64_rust-mio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+default-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-mio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+default-devel}"
SRC_URI[aarch64_rust-mio+default-devel.sha256sum] = "896867ec485fad856ba9a6aef076a1b64cacfca6069b021ac2614dd9fc1b5969"

URI_aarch64_rust-mio+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+log-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-mio+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+log-devel}"
SRC_URI[aarch64_rust-mio+log-devel.sha256sum] = "ba447db71daa74a2d7945b9babc9a406c5571719f14a8d026849313c0f720bae"

URI_aarch64_rust-mio+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+net-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-mio+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+net-devel}"
SRC_URI[aarch64_rust-mio+net-devel.sha256sum] = "0243493f3d39586bce33513a60a69ea96e2c95e9c42864a643d26a4880b24008"

URI_aarch64_rust-mio+os-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-ext-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-mio+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+os-ext-devel}"
SRC_URI[aarch64_rust-mio+os-ext-devel.sha256sum] = "e2a0ff66a6723e2585559319be4cd23519c41490a0432f8fa6bc63120a2a5654"

URI_aarch64_rust-mio+os-poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio+os-poll-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-mio+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio+os-poll-devel}"
SRC_URI[aarch64_rust-mio+os-poll-devel.sha256sum] = "636d7938c36d9eb0e87e1304370c42b82fe246abe251500adc24586bb08f6ef4"

URI_aarch64_rust-mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio-devel-1.2.2-1.el10_2.noarch.rpm;name=aarch64_rust-mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio-devel}"
SRC_URI[aarch64_rust-mio-devel.sha256sum] = "5255f31e70e61b5fd9a72ebbdeb4e936eea94df4ca38357efa79d6ed421ccd67"

RDEPENDS:rust-mio+default-devel = " \
 cargo \
 rust-mio+log-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+net-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-ext-devel = " \
 cargo \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 "
RDEPENDS:rust-mio+os-poll-devel = " \
 cargo \
 rust-mio-devel \
 "
RDEPENDS:rust-mio-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "
