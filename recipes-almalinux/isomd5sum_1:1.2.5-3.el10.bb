# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "isomd5sum"
PE = "1"
PV = "1.2.5"
PR = "3.el10"
PACKAGES = " \
 isomd5sum \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/isomd5sum-1.2.5-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "17f0481fa302f5f70b2d32ae9ece90bb5e9863f516efb6e9ed3cdb4adc70960d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/isomd5sum-1.2.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_isomd5sum;unpack=0"
SRC_URI[x86_64_v2_isomd5sum.sha256sum] = "a4535e3114e22014eb08a582a9033f6c4a73743cf7e1480a14a69ed39d5fb217"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/isomd5sum-1.2.5-3.el10.aarch64.rpm;name=aarch64_isomd5sum;unpack=0"
SRC_URI[aarch64_isomd5sum.sha256sum] = "c5fd9947718f8b92d32c866ffc2a3a4cc5dafa8980c27d27f2befb45edad1cbb"

RDEPENDS:isomd5sum = " \
 glibc \
 popt \
 "
