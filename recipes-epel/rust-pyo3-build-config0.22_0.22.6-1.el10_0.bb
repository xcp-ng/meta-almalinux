# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pyo3-build-config0.22"
PV = "0.22.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-pyo3-build-config0.22+abi3-devel \
 rust-pyo3-build-config0.22+abi3-py310-devel \
 rust-pyo3-build-config0.22+abi3-py311-devel \
 rust-pyo3-build-config0.22+abi3-py312-devel \
 rust-pyo3-build-config0.22+abi3-py37-devel \
 rust-pyo3-build-config0.22+abi3-py38-devel \
 rust-pyo3-build-config0.22+abi3-py39-devel \
 rust-pyo3-build-config0.22+default-devel \
 rust-pyo3-build-config0.22+extension-module-devel \
 rust-pyo3-build-config0.22+resolve-config-devel \
 rust-pyo3-build-config0.22-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pyo3-build-config0.22-0.22.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2b7b516bcf0b4ff5b58ec7c1fd1022c27f8da0683935b7dc4e7c4eca51017df2"

URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+abi3-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+abi3-devel.sha256sum] = "1881e3a52b2a319e497bfcacf4a5da3d56297321579a894ead005e3602d64f0f"

URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py310-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+abi3-py310-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py310-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+abi3-py310-devel.sha256sum] = "315a5436bd93c16d53df08e8d6eae0ade45fc3dafcb13bc4b1ae4d73fded6ada"

URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py311-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+abi3-py311-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py311-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+abi3-py311-devel.sha256sum] = "06cbbc5b28fc2bec16719d297d354c9044e876be6dd1e6db14cc00eb5106711a"

URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py312-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+abi3-py312-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py312-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+abi3-py312-devel.sha256sum] = "d11bd6164747cedbe4d66cb483578fb836109e7836e35fc002f118783170a6eb"

URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py37-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+abi3-py37-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py37-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+abi3-py37-devel.sha256sum] = "b6798d62de17f10c2ca2272b8d27659b1779837a6bb2cddcaddc113fd71745a9"

URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py38-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+abi3-py38-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py38-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+abi3-py38-devel.sha256sum] = "43ed3234d1b63807b8fc84ac849037dbe83d45e421194d8d423aa902b8bdf05f"

URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py39-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+abi3-py39-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+abi3-py39-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+abi3-py39-devel.sha256sum] = "a491bcb3b91926996cf658502564b3c9a675e096219463affa1b3c1a93cde01e"

URI_x86_64_v2_rust-pyo3-build-config0.22+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+default-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+default-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+default-devel.sha256sum] = "c18a262fa128c624ef567a35169570bf4f19e2fd30038135be669f162154f61a"

URI_x86_64_v2_rust-pyo3-build-config0.22+extension-module-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+extension-module-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+extension-module-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+extension-module-devel.sha256sum] = "b5b736b9c923677cb0872418db934bb708b39c05afda54ebdc37b49ae8962ef9"

URI_x86_64_v2_rust-pyo3-build-config0.22+resolve-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22+resolve-config-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22+resolve-config-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22+resolve-config-devel.sha256sum] = "91abe54b562519cc22337619270f56af4e415ddc7737129b4e31051e4f31ba16"

URI_x86_64_v2_rust-pyo3-build-config0.22-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pyo3-build-config0.22-devel-0.22.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pyo3-build-config0.22-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pyo3-build-config0.22-devel}"
SRC_URI[x86_64_v2_rust-pyo3-build-config0.22-devel.sha256sum] = "9c2b95d9f36c5e3e32454773f608a235ed397d811e3d78d6ce4f39170b5d0f8c"

URI_aarch64_rust-pyo3-build-config0.22+abi3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+abi3-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+abi3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+abi3-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+abi3-devel.sha256sum] = "6ac241001d46823142d9e15a2dc6210c5774de1ef91fdf320a5b71e401409efd"

URI_aarch64_rust-pyo3-build-config0.22+abi3-py310-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+abi3-py310-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+abi3-py310-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+abi3-py310-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+abi3-py310-devel.sha256sum] = "ce95f3e1af10637298ded703c83c2e68bd730255abd7970ebc8cad4ba71eb881"

URI_aarch64_rust-pyo3-build-config0.22+abi3-py311-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+abi3-py311-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+abi3-py311-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+abi3-py311-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+abi3-py311-devel.sha256sum] = "638ab0551e506d45358f8a917322b5892f1ad2325c7394e044ccb2486e59105b"

URI_aarch64_rust-pyo3-build-config0.22+abi3-py312-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+abi3-py312-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+abi3-py312-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+abi3-py312-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+abi3-py312-devel.sha256sum] = "8ed5b0dd0bab65611e7fef86b3b3440f0a803060643f47c32c09b64c95b95049"

URI_aarch64_rust-pyo3-build-config0.22+abi3-py37-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+abi3-py37-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+abi3-py37-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+abi3-py37-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+abi3-py37-devel.sha256sum] = "8118ab1bea4a21024f9c7b3bb640903665fc2f13ed8bfc14a213dc9f3ceaa2ca"

URI_aarch64_rust-pyo3-build-config0.22+abi3-py38-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+abi3-py38-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+abi3-py38-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+abi3-py38-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+abi3-py38-devel.sha256sum] = "7be5e8ddb3f51bd45abdacc7e990ffd956b7baeb8a9d90c91cfdb43d0f746a4d"

URI_aarch64_rust-pyo3-build-config0.22+abi3-py39-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+abi3-py39-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+abi3-py39-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+abi3-py39-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+abi3-py39-devel.sha256sum] = "8237def033f47350b89fb789ab6a92aa8e97a3d583bfab0fa0df589a5da4ce10"

URI_aarch64_rust-pyo3-build-config0.22+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+default-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+default-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+default-devel.sha256sum] = "d7258017c977429972579dea561f9ea9402f1c2a7161286912ae13a8f6e003c4"

URI_aarch64_rust-pyo3-build-config0.22+extension-module-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+extension-module-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+extension-module-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+extension-module-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+extension-module-devel.sha256sum] = "baa5d2890a250797261afb8535ef077687b0dd01a6a1d61bbb04edd8fc697749"

URI_aarch64_rust-pyo3-build-config0.22+resolve-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22+resolve-config-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22+resolve-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22+resolve-config-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22+resolve-config-devel.sha256sum] = "1f807e7fe7702096a6ec36c6faf1aafa05cf0200fbb0a45765f81ea9c3cced91"

URI_aarch64_rust-pyo3-build-config0.22-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pyo3-build-config0.22-devel-0.22.6-1.el10_0.noarch.rpm;name=aarch64_rust-pyo3-build-config0.22-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pyo3-build-config0.22-devel}"
SRC_URI[aarch64_rust-pyo3-build-config0.22-devel.sha256sum] = "e75d4e821e1dd48f61718c51fd45ebdb525f67603f658f0adbb0fea1b985d2b2"

RDEPENDS:rust-pyo3-build-config0.22+abi3-devel = " \
 cargo \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22+abi3-py310-devel = " \
 cargo \
 rust-pyo3-build-config0.22+abi3-py311-devel \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22+abi3-py311-devel = " \
 cargo \
 rust-pyo3-build-config0.22+abi3-py312-devel \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22+abi3-py312-devel = " \
 cargo \
 rust-pyo3-build-config0.22+abi3-devel \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22+abi3-py37-devel = " \
 cargo \
 rust-pyo3-build-config0.22+abi3-py38-devel \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22+abi3-py38-devel = " \
 cargo \
 rust-pyo3-build-config0.22+abi3-py39-devel \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22+abi3-py39-devel = " \
 cargo \
 rust-pyo3-build-config0.22+abi3-py310-devel \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22+default-devel = " \
 cargo \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22+extension-module-devel = " \
 cargo \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22+resolve-config-devel = " \
 cargo \
 rust-pyo3-build-config0.22-devel \
 "
RDEPENDS:rust-pyo3-build-config0.22-devel = " \
 cargo \
 python3 \
 rust-once_cell+default-devel \
 rust-target-lexicon0.12+default-devel \
 "
