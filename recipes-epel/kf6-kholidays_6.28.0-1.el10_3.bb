# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kholidays"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kholidays \
 kf6-kholidays-devel \
 kf6-kholidays-doc \
 kf6-kholidays-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kholidays-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5aed41f478b69ef413466c80a33ef3d4e39770e4303bbe62cc83ced8e95effc0"

URI_x86_64_v2_kf6-kholidays = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays}"
SRC_URI[x86_64_v2_kf6-kholidays.sha256sum] = "bad4c40107b64c2d5fc106ba394f448d625a4f06598f5e4d2fb5b5a86f2b3861"

URI_x86_64_v2_kf6-kholidays-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kholidays-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-devel}"
SRC_URI[x86_64_v2_kf6-kholidays-devel.sha256sum] = "e563c2d5f930908ab498f37c9202d3a01894d75945f2a6309a654822619a6251"

URI_x86_64_v2_kf6-kholidays-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kholidays-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-doc}"
SRC_URI[x86_64_v2_kf6-kholidays-doc.sha256sum] = "84e4c13daec79e461323a43201a3a491301f2f67865473f1f5477e7c83080f85"

URI_x86_64_v2_kf6-kholidays-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kholidays-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kholidays-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kholidays-html}"
SRC_URI[x86_64_v2_kf6-kholidays-html.sha256sum] = "5f63dc3de8ca301e7660df1c347f168ed4050e272eaad4c16f1b3cd9a71eeecf"

URI_aarch64_kf6-kholidays = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kholidays;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays}"
SRC_URI[aarch64_kf6-kholidays.sha256sum] = "b41b8f2a9a4c0c9bab4ef54ccc1d18e0a4a1db96ca62396a878cdbdc68ac0bc4"

URI_aarch64_kf6-kholidays-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kholidays-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-devel}"
SRC_URI[aarch64_kf6-kholidays-devel.sha256sum] = "1827fe6df3d472c1be1dc6d7a4d6ab70147531ce1ffd5cd90893347ff41d5e38"

URI_aarch64_kf6-kholidays-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kholidays-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-doc}"
SRC_URI[aarch64_kf6-kholidays-doc.sha256sum] = "e6d8bb38c3d708b1e9ddf7ba6ae6100bfee1806a7dfaaa757261db9dc07df8a2"

URI_aarch64_kf6-kholidays-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kholidays-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kholidays-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kholidays-html}"
SRC_URI[aarch64_kf6-kholidays-html.sha256sum] = "48df1c2f0f0ed4b7fdfce216b17dc010593befd8e1a434022a8112c90a237116"

RDEPENDS:kf6-kholidays = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kholidays-devel = " \
 cmake-filesystem \
 kf6-kholidays \
 "
RDEPENDS:kf6-kholidays-doc = " \
 "
RDEPENDS:kf6-kholidays-html = " \
 "
