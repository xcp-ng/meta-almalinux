# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ktrip"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ktrip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ktrip-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56522dd063be131225658467e1d7387c14f58a50772165d2cc0b52cf528ed93a"

URI_x86_64_v2_ktrip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ktrip-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ktrip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ktrip}"
SRC_URI[x86_64_v2_ktrip.sha256sum] = "c4d8c56553411179b824bb73b006dec395119d0634797f37348377c118905e97"

URI_aarch64_ktrip = "${EPEL_MIRROR}/aarch64/Packages/k/ktrip-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ktrip;unpack=0"
SRC_URI:append = " ${URI_aarch64_ktrip}"
SRC_URI[aarch64_ktrip.sha256sum] = "e466d8a8dddb763b7d1eff71f153b1110adea1a5b1828f65ad9daa5b17a426d1"

RDEPENDS:ktrip = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kpublictransport \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
