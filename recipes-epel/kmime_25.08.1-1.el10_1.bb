# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmime"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kmime \
 kmime-devel \
 kmime-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmime-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c260749ced4d7d985fc720160815f9d4536c8be904f74cc21871929dd375342"

URI_x86_64_v2_kmime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime}"
SRC_URI[x86_64_v2_kmime.sha256sum] = "f960262a5d82b82734c4490bee58c4b54065239d8bcb3ce9685749bc8e2fea25"

URI_x86_64_v2_kmime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime-devel}"
SRC_URI[x86_64_v2_kmime-devel.sha256sum] = "b4a62d405d3c110b25411784523ed61b82118b55e5dc0e9be622e78b141a0295"

URI_x86_64_v2_kmime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmime-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kmime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmime-doc}"
SRC_URI[x86_64_v2_kmime-doc.sha256sum] = "f29c2583d0fd4cd51c329d87c2dd953ce4e71045630bb0ba76b172fa460dbf8b"

URI_aarch64_kmime = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kmime;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime}"
SRC_URI[aarch64_kmime.sha256sum] = "5936d0a66dc483f08e0c7cb85c625a2b89811c3e9c882defef4e78cbd03925a2"

URI_aarch64_kmime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kmime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime-devel}"
SRC_URI[aarch64_kmime-devel.sha256sum] = "5c7e56ad32a543a6092379ba7a12f6375adc5bb30ac5fbbc6d39e2e36de5ae7b"

URI_aarch64_kmime-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kmime-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_kmime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmime-doc}"
SRC_URI[aarch64_kmime-doc.sha256sum] = "2c2bae1417066cf05ef193e3aa2ad9bb3858d8cbb543481fef9f6935b90f8d02"

RDEPENDS:kmime = " \
 glibc \
 kf6-kcodecs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kmime-devel = " \
 boost-devel \
 cmake-filesystem \
 kf6-kcodecs-devel \
 kmime \
 "
RDEPENDS:kmime-doc = " \
 "
