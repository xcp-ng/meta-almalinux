# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knighttime"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 knighttime \
 knighttime-devel \
 knighttime-doc \
 knighttime-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knighttime-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9dba774728b80bb5b84d807d9410b18be47c1d73fafe74f48f27b43c268f15bd"

URI_x86_64_v2_knighttime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knighttime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knighttime}"
SRC_URI[x86_64_v2_knighttime.sha256sum] = "4c0f7fc49be894172aff263ed9e16724f0f41d267d510be12163f35522ea9f9c"

URI_x86_64_v2_knighttime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-devel-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knighttime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knighttime-devel}"
SRC_URI[x86_64_v2_knighttime-devel.sha256sum] = "17996e7c6e8e5103ef0eee49037a00d07614c542fb2ff03eaf2c0d3ca47eecdd"

URI_x86_64_v2_knighttime-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-doc-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_knighttime-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knighttime-doc}"
SRC_URI[x86_64_v2_knighttime-doc.sha256sum] = "54cc67293aa9445d638a206cd074be7a3b93d5178a9d0da25da4dba7b00368bb"

URI_x86_64_v2_knighttime-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knighttime-html-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_knighttime-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knighttime-html}"
SRC_URI[x86_64_v2_knighttime-html.sha256sum] = "44d3e38819dd7cb5b81047c01e56bd920fa0c050d3e5ec7a8631baba1e97471a"

URI_aarch64_knighttime = "${EPEL_MIRROR}/aarch64/Packages/k/knighttime-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_knighttime;unpack=0"
SRC_URI:append = " ${URI_aarch64_knighttime}"
SRC_URI[aarch64_knighttime.sha256sum] = "282a1eed237c611a4c14bc03534dc12e12d18842c544318bc1809e659187fe00"

URI_aarch64_knighttime-devel = "${EPEL_MIRROR}/aarch64/Packages/k/knighttime-devel-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_knighttime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_knighttime-devel}"
SRC_URI[aarch64_knighttime-devel.sha256sum] = "8eb9d054261b5066e457db43aded3e09ca9b96638063ac48d5c29cc7f3f13914"

URI_aarch64_knighttime-doc = "${EPEL_MIRROR}/aarch64/Packages/k/knighttime-doc-6.6.4-1.el10_2.noarch.rpm;name=aarch64_knighttime-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_knighttime-doc}"
SRC_URI[aarch64_knighttime-doc.sha256sum] = "f4205dcc71eb580c11c784ba73f708c7cce450122f0d1a2ef70c84ea257a1dc1"

URI_aarch64_knighttime-html = "${EPEL_MIRROR}/aarch64/Packages/k/knighttime-html-6.6.4-1.el10_2.noarch.rpm;name=aarch64_knighttime-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_knighttime-html}"
SRC_URI[aarch64_knighttime-html.sha256sum] = "5d72e7a7583247f4414a2e37775d1d3b06cb2760af182def2e658d302396c157"

RDEPENDS:knighttime = " \
 bash \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kholidays \
 libstdc++ \
 qt6-qtbase \
 qt6-qtpositioning \
 "
RDEPENDS:knighttime-devel = " \
 cmake-filesystem \
 knighttime \
 "
RDEPENDS:knighttime-doc = " \
 "
RDEPENDS:knighttime-html = " \
 "
