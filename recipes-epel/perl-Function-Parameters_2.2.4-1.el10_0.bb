# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Function-Parameters"
PV = "2.2.4"
PR = "1.el10_0"
PACKAGES = " \
 perl-Function-Parameters \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Function-Parameters-2.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "696fc4dd5baf218779bc4d5420512ffef1e4c6a870b2d8c827952a779965d790"

URI_x86_64_v2_perl-Function-Parameters = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Function-Parameters-2.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Function-Parameters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Function-Parameters}"
SRC_URI[x86_64_v2_perl-Function-Parameters.sha256sum] = "5b728dff4246e882ea9bc5ffa83b28f47575d167895902b52d583dc901374d02"

URI_aarch64_perl-Function-Parameters = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Function-Parameters-2.2.4-1.el10_0.aarch64.rpm;name=aarch64_perl-Function-Parameters;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Function-Parameters}"
SRC_URI[aarch64_perl-Function-Parameters.sha256sum] = "8e83a9361ebb298f26b023295fbf91817969ce18bf058e3e3916d415dd7d840f"

RDEPENDS:perl-Function-Parameters = " \
 glibc \
 perl-Carp \
 perl-Function-Parameters \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
