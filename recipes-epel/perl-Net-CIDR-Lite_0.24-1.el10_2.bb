# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-CIDR-Lite"
PV = "0.24"
PR = "1.el10_2"
PACKAGES = " \
 perl-Net-CIDR-Lite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-CIDR-Lite-0.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8104b4e60998b604ea6c7c000e19144a642a213f0214ef1f8eda47bd094d320a"

URI_x86_64_v2_perl-Net-CIDR-Lite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-CIDR-Lite-0.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-CIDR-Lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-CIDR-Lite}"
SRC_URI[x86_64_v2_perl-Net-CIDR-Lite.sha256sum] = "6bc45116a5f8621f80083e3c2297e6d1177fcba9f210cd2edf0f9deaa06bf20f"

URI_aarch64_perl-Net-CIDR-Lite = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-CIDR-Lite-0.24-1.el10_2.noarch.rpm;name=aarch64_perl-Net-CIDR-Lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-CIDR-Lite}"
SRC_URI[aarch64_perl-Net-CIDR-Lite.sha256sum] = "3fdcfa6438e325621d96b2edfec81ffba7d37657270f2fce8e6836d4dfda5f90"

RDEPENDS:perl-Net-CIDR-Lite = " \
 perl-Carp \
 perl-libs \
 perl-vars \
 "
