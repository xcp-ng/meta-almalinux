# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_nl"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_nl+default-devel \
 rust-uu_nl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_nl-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89acf10afb6f2111f62f93ac51e5fb3ae7f05102ae1d1621e12f95e29722dce3"

URI_x86_64_v2_rust-uu_nl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_nl+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_nl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_nl+default-devel}"
SRC_URI[x86_64_v2_rust-uu_nl+default-devel.sha256sum] = "b6c40b34b624f0ce29d41bdbc70d7db26d7a4025a6a0796b7cf10843fad6c9fa"

URI_x86_64_v2_rust-uu_nl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_nl-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_nl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_nl-devel}"
SRC_URI[x86_64_v2_rust-uu_nl-devel.sha256sum] = "79f85eca24e0ee45c2f985d94ff1df8ae4f42202c1d37032cda19005a69a81d7"

URI_aarch64_rust-uu_nl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_nl+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_nl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_nl+default-devel}"
SRC_URI[aarch64_rust-uu_nl+default-devel.sha256sum] = "6d39089c4dea0ef233a75a37729aa9ef3cd3f01deb5c924da8c699c71a251013"

URI_aarch64_rust-uu_nl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_nl-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_nl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_nl-devel}"
SRC_URI[aarch64_rust-uu_nl-devel.sha256sum] = "e5f8f63d5da723c52b0b864b5fc887c6f8e0b1c2990d990b156b05b67761a056"

RDEPENDS:rust-uu_nl+default-devel = " \
 cargo \
 rust-uu_nl-devel \
 "
RDEPENDS:rust-uu_nl-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-itoa+default-devel \
 rust-regex+default-devel \
 rust-uucore+default-devel \
 "
