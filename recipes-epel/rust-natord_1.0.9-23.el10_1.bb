# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-natord"
PV = "1.0.9"
PR = "23.el10_1"
PACKAGES = " \
 rust-natord+default-devel \
 rust-natord-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-natord-1.0.9-23.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ace6fdb5f5a97208b18b4ad7620a7f91089d0bdc209ea6f4afbfc06c7414916f"

URI_x86_64_v2_rust-natord+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-natord+default-devel-1.0.9-23.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-natord+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-natord+default-devel}"
SRC_URI[x86_64_v2_rust-natord+default-devel.sha256sum] = "e5aa95f35be41d5ddc94afa9678b7d4401ca4ec437f5ae51398f045ee92feb1f"

URI_x86_64_v2_rust-natord-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-natord-devel-1.0.9-23.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-natord-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-natord-devel}"
SRC_URI[x86_64_v2_rust-natord-devel.sha256sum] = "b171d2ee747ef55308c0b3132b53a29c398d03f294b533ed1886fe13517c1ff6"

URI_aarch64_rust-natord+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-natord+default-devel-1.0.9-23.el10_1.noarch.rpm;name=aarch64_rust-natord+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-natord+default-devel}"
SRC_URI[aarch64_rust-natord+default-devel.sha256sum] = "407316cb5ff075eb529eb4127d4d9c848d032904357ba5180f3bc3502f85f368"

URI_aarch64_rust-natord-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-natord-devel-1.0.9-23.el10_1.noarch.rpm;name=aarch64_rust-natord-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-natord-devel}"
SRC_URI[aarch64_rust-natord-devel.sha256sum] = "f5f5ca0ada2a78e7a9c84d4cdb25610933613aa26746066a7329600c89ca266f"

RDEPENDS:rust-natord+default-devel = " \
 cargo \
 rust-natord-devel \
 "
RDEPENDS:rust-natord-devel = " \
 cargo \
 "
