# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "annobin"
PV = "13.31"
PR = "1.el10"
PACKAGES = " \
 annobin-annocheck \
 annobin-docs \
 annobin-libannocheck \
 annobin-plugin-clang \
 annobin-plugin-gcc \
 annobin-plugin-llvm \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/annobin-13.31-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b14adb27d49bc3477269f641b49d67d81fd749677dc0fb269f97212d51e22230"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-annocheck-13.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-annocheck;unpack=0"
SRC_URI[x86_64_v2_annobin-annocheck.sha256sum] = "9c3bbe4f55c0ab507be4535cdb95d9e3ee29bdb6085df9d92bb12aaff47702ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-docs-13.31-1.el10.noarch.rpm;name=x86_64_v2_annobin-docs;unpack=0"
SRC_URI[x86_64_v2_annobin-docs.sha256sum] = "7c7b1eb26dbad09371b80140931307e5f5f31e2925bd888fb312e26b1d2fc8e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-libannocheck-13.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-libannocheck;unpack=0"
SRC_URI[x86_64_v2_annobin-libannocheck.sha256sum] = "4eb5f2fdd99fd1950c09269bf7b916e339028deb4f182fb1293a3af974b00fa1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-clang-13.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-clang;unpack=0"
SRC_URI[x86_64_v2_annobin-plugin-clang.sha256sum] = "ec13d5f4679feff026ee79abf52a3fd90cd1ccfa1cad137a3cab416e29670f77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-gcc-13.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-gcc;unpack=0"
SRC_URI[x86_64_v2_annobin-plugin-gcc.sha256sum] = "aaf9ec35c8557fa30962d2166127be47be4cca3c400b064a067895a8981c717c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/annobin-plugin-llvm-13.31-1.el10.x86_64_v2.rpm;name=x86_64_v2_annobin-plugin-llvm;unpack=0"
SRC_URI[x86_64_v2_annobin-plugin-llvm.sha256sum] = "d4b641e3540b59c2f4431664e61afe1301ebdf6fba166a380604cdc820d50061"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-annocheck-13.31-1.el10.aarch64.rpm;name=aarch64_annobin-annocheck;unpack=0"
SRC_URI[aarch64_annobin-annocheck.sha256sum] = "d0d3a2b32aa0b10aa8b290a7be1cc172e4c0fec61065a64186f8c1619f84539f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-docs-13.31-1.el10.noarch.rpm;name=aarch64_annobin-docs;unpack=0"
SRC_URI[aarch64_annobin-docs.sha256sum] = "7c7b1eb26dbad09371b80140931307e5f5f31e2925bd888fb312e26b1d2fc8e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-libannocheck-13.31-1.el10.aarch64.rpm;name=aarch64_annobin-libannocheck;unpack=0"
SRC_URI[aarch64_annobin-libannocheck.sha256sum] = "34032d92827b3db9ec484913de00fbd98eb6e4110a9e1f9cd5ee027321ae87d6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-clang-13.31-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-clang;unpack=0"
SRC_URI[aarch64_annobin-plugin-clang.sha256sum] = "67f165b00eded8ecadb554155d5c571dc26dcaa3bcc1f3c8e6d268c1a6c5bf09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-gcc-13.31-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-gcc;unpack=0"
SRC_URI[aarch64_annobin-plugin-gcc.sha256sum] = "e618d970fd1267da5c9ea323627a086eec441c5bf38eb62684d7667bd797f7ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/annobin-plugin-llvm-13.31-1.el10.aarch64.rpm;name=aarch64_annobin-plugin-llvm;unpack=0"
SRC_URI[aarch64_annobin-plugin-llvm.sha256sum] = "3ac66a1df5b05db284255534bf432448df6018fd5a561f294bc4262d643fc4ce"

RDEPENDS:annobin-annocheck = " \
 annobin-docs \
 cpio \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 rpm \
 rpm-libs \
 "
RDEPENDS:annobin-docs = " \
 "
RDEPENDS:annobin-libannocheck = " \
 annobin-docs \
 glibc \
 pkgconf-pkg-config \
 "
RDEPENDS:annobin-plugin-clang = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
RDEPENDS:annobin-plugin-gcc = " \
 annobin-docs \
 gcc \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:annobin-plugin-llvm = " \
 annobin-docs \
 glibc \
 libgcc \
 libstdc++ \
 llvm-libs \
 "
