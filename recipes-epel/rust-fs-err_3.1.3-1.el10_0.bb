# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fs-err"
PV = "3.1.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-fs-err+default-devel \
 rust-fs-err+expose_original_error-devel \
 rust-fs-err+tokio-devel \
 rust-fs-err-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-fs-err-3.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2311353c913ebd4b03d80d50e1925e72d7014ed46258c95201bc66b2c4cdc452"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err+default-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fs-err+default-devel.sha256sum] = "8d845e78364cef6a49652624684d57d733740f61bf4cda6b2ef52877b019e1bd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err+expose_original_error-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err+expose_original_error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fs-err+expose_original_error-devel.sha256sum] = "db536bb769532fd190e62d56a8a78f36a5d4044606c7e7c55981c95160b9cc8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err+tokio-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fs-err+tokio-devel.sha256sum] = "34e80623ec8eeaa435d1cc421bf51cc64538d94267196d85ed0bf4528cc1e722"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fs-err-devel-3.1.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fs-err-devel;unpack=0"
SRC_URI[x86_64_v2_rust-fs-err-devel.sha256sum] = "3bb8d95d76af815d44965392f850517e34e4979019b16f1aaf014e49ea447ae9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err+default-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-fs-err+default-devel;unpack=0"
SRC_URI[aarch64_rust-fs-err+default-devel.sha256sum] = "2183dcea8026535ca38cd9a342565c10b92225c30188d6147e7cc445da055e16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err+expose_original_error-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-fs-err+expose_original_error-devel;unpack=0"
SRC_URI[aarch64_rust-fs-err+expose_original_error-devel.sha256sum] = "5e94553699d97fa0fc3467b00b2e1986c25ec8bc9df052a19eb903157bac10f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err+tokio-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-fs-err+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-fs-err+tokio-devel.sha256sum] = "8a31f311895813ecc0b66631ac70f6186bf15e9a843c62dad9d07484e0e39b6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-fs-err-devel-3.1.3-1.el10_0.noarch.rpm;name=aarch64_rust-fs-err-devel;unpack=0"
SRC_URI[aarch64_rust-fs-err-devel.sha256sum] = "dc19193f41cd7948db4ca263cdb3f4f7a912f38d6f44524419a57f3b07683017"

RDEPENDS:rust-fs-err+default-devel = " \
 cargo \
 rust-fs-err-devel \
 "
RDEPENDS:rust-fs-err+expose_original_error-devel = " \
 cargo \
 rust-fs-err-devel \
 "
RDEPENDS:rust-fs-err+tokio-devel = " \
 cargo \
 rust-fs-err-devel \
 rust-tokio+fs-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-fs-err-devel = " \
 cargo \
 rust-autocfg+default-devel \
 "
