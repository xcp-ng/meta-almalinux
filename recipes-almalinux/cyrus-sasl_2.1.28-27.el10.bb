# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cyrus-sasl"
PV = "2.1.28"
PR = "27.el10"
PACKAGES = " \
 cyrus-sasl \
 cyrus-sasl-devel \
 cyrus-sasl-gs2 \
 cyrus-sasl-gssapi \
 cyrus-sasl-ldap \
 cyrus-sasl-lib \
 cyrus-sasl-md5 \
 cyrus-sasl-plain \
 cyrus-sasl-scram \
 cyrus-sasl-sql \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cyrus-sasl-2.1.28-27.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e32c62010fd86ecb45d1fb1d4c1d6891b45820216d643ad79be9a88e1e2274d"

URI_x86_64_v2_cyrus-sasl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl}"
SRC_URI[x86_64_v2_cyrus-sasl.sha256sum] = "585ef230ca5b8a618e9310a82e3e0de79f7fb8cc607a1a613ff52b4882652973"

URI_x86_64_v2_cyrus-sasl-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-devel-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-devel}"
SRC_URI[x86_64_v2_cyrus-sasl-devel.sha256sum] = "431c1ab898a514b7c5106ff18780480f6c962dd8828eef276ab48bae1011af5d"

URI_x86_64_v2_cyrus-sasl-gs2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-gs2-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-gs2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-gs2}"
SRC_URI[x86_64_v2_cyrus-sasl-gs2.sha256sum] = "c397dd9dc890d64343ae8a080f8e075f17b6ad719618528a690e06b8e349a586"

URI_x86_64_v2_cyrus-sasl-gssapi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-gssapi-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-gssapi}"
SRC_URI[x86_64_v2_cyrus-sasl-gssapi.sha256sum] = "2fc570d3f57f609287076e255fc542d66606886db9408ab814162a80641fb86e"

URI_x86_64_v2_cyrus-sasl-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-ldap-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-ldap}"
SRC_URI[x86_64_v2_cyrus-sasl-ldap.sha256sum] = "976abc6d194bb9399bc54d5dfa3c6b5f60091713c17de6f563900c9d400cb0f3"

URI_x86_64_v2_cyrus-sasl-lib = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-lib-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-lib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-lib}"
SRC_URI[x86_64_v2_cyrus-sasl-lib.sha256sum] = "55975f7bd6bb9500ff6084b137101e7b7764ab69e51c3400b2adc7d811a36263"

URI_x86_64_v2_cyrus-sasl-md5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-md5-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-md5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-md5}"
SRC_URI[x86_64_v2_cyrus-sasl-md5.sha256sum] = "3390df29d0f4b85eea439d9d4af29843fc2a661136a25a38e7d1022d54769d8c"

URI_x86_64_v2_cyrus-sasl-plain = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-plain-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-plain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-plain}"
SRC_URI[x86_64_v2_cyrus-sasl-plain.sha256sum] = "a09da4da004564648f860dbb6360b9d22e668dd3412f7f70203ca7d5baeb8d62"

URI_x86_64_v2_cyrus-sasl-scram = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cyrus-sasl-scram-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-scram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-scram}"
SRC_URI[x86_64_v2_cyrus-sasl-scram.sha256sum] = "92a5ffa8d800c7df7c36abf9a4d6f74aa4855e1729d69eabcf97655bf9ffefaf"

URI_x86_64_v2_cyrus-sasl-sql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cyrus-sasl-sql-2.1.28-27.el10.x86_64_v2.rpm;name=x86_64_v2_cyrus-sasl-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cyrus-sasl-sql}"
SRC_URI[x86_64_v2_cyrus-sasl-sql.sha256sum] = "3cbff549c698307a5c7f37ad5137b29d4a30ae3af218f0179406e2c97bcb399b"

URI_aarch64_cyrus-sasl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl}"
SRC_URI[aarch64_cyrus-sasl.sha256sum] = "dca8b04dfc7dad3c2eba144bbe4ffe1957965f71d227889d4aae188767a97407"

URI_aarch64_cyrus-sasl-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-devel-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-devel}"
SRC_URI[aarch64_cyrus-sasl-devel.sha256sum] = "4bc78222799a7be04c60a4a6f26f7c0ce63a9f856330d7af2abe7689c6dd1f59"

URI_aarch64_cyrus-sasl-gs2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-gs2-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl-gs2;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-gs2}"
SRC_URI[aarch64_cyrus-sasl-gs2.sha256sum] = "8ed1fc73c02fe2cc1514aca3497b520de31d396b07dae029e2701803409ac7a6"

URI_aarch64_cyrus-sasl-gssapi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-gssapi-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl-gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-gssapi}"
SRC_URI[aarch64_cyrus-sasl-gssapi.sha256sum] = "ac4fd94458220eb2fb2f7765b222fff1fa256e2c17575bcab9e8fbc18c957c18"

URI_aarch64_cyrus-sasl-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-ldap-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-ldap}"
SRC_URI[aarch64_cyrus-sasl-ldap.sha256sum] = "7088ed2a49d47a2fb6e4104744825c405edc21847f9efa1e4e4a7477dc92f435"

URI_aarch64_cyrus-sasl-lib = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-lib-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl-lib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-lib}"
SRC_URI[aarch64_cyrus-sasl-lib.sha256sum] = "49c1b2621709fc4fe730e084b89c5a91ebfdfdeb34e0cf5cea06161729acfb45"

URI_aarch64_cyrus-sasl-md5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-md5-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl-md5;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-md5}"
SRC_URI[aarch64_cyrus-sasl-md5.sha256sum] = "0f0686c98a379604cfd60b9c73ae18b614e97a57c5a0d83dac89178bd7ff45f9"

URI_aarch64_cyrus-sasl-plain = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-plain-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl-plain;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-plain}"
SRC_URI[aarch64_cyrus-sasl-plain.sha256sum] = "b51872dc7e9c87838774769e4df820c218861e0e8e21d618a4d622f0d6dddd0f"

URI_aarch64_cyrus-sasl-scram = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cyrus-sasl-scram-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl-scram;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-scram}"
SRC_URI[aarch64_cyrus-sasl-scram.sha256sum] = "2b16ae4d67016af91bd7cb659ed1e93c56e6916cfecadb9fdce7150453d9a488"

URI_aarch64_cyrus-sasl-sql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cyrus-sasl-sql-2.1.28-27.el10.aarch64.rpm;name=aarch64_cyrus-sasl-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_cyrus-sasl-sql}"
SRC_URI[aarch64_cyrus-sasl-sql.sha256sum] = "40ffded3d8682c59762f7a084f5f05acdeebf7a2360cf29fbb08b2686152ccf3"

RDEPENDS:cyrus-sasl = " \
 bash \
 cyrus-sasl-lib \
 gdbm-libs \
 glibc \
 krb5-libs \
 libxcrypt \
 openldap \
 openssl-libs \
 pam-libs \
 shadow-utils \
 util-linux \
 "
RDEPENDS:cyrus-sasl-devel = " \
 cyrus-sasl \
 cyrus-sasl-lib \
 glibc \
 krb5-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:cyrus-sasl-gs2 = " \
 cyrus-sasl-lib \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-gssapi = " \
 cyrus-sasl-lib \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-ldap = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 openldap \
 "
RDEPENDS:cyrus-sasl-lib = " \
 gdbm-libs \
 glibc \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-md5 = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:cyrus-sasl-plain = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 "
RDEPENDS:cyrus-sasl-scram = " \
 cyrus-sasl-lib \
 glibc \
 libxcrypt \
 openssl-libs \
 "
RDEPENDS:cyrus-sasl-sql = " \
 cyrus-sasl-lib \
 glibc \
 libpq \
 libxcrypt \
 mariadb-connector-c \
 "
