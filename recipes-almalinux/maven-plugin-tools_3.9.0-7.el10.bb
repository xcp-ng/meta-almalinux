# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-plugin-tools"
PV = "3.9.0"
PR = "7.el10"
PACKAGES = " \
 maven-plugin-annotations \
 maven-plugin-plugin \
 maven-plugin-tools \
 maven-plugin-tools-annotations \
 maven-plugin-tools-api \
 maven-plugin-tools-generators \
 maven-plugin-tools-java \
 maven-plugin-tools-javadoc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-plugin-tools-3.9.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e534d4a6381f6f2cbbc3dfd2b91080e6655ef574dc656d5723a9f907d97d0811"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-plugin-annotations-3.9.0-7.el10.noarch.rpm;name=x86_64_v2_maven-plugin-annotations;unpack=0"
SRC_URI[x86_64_v2_maven-plugin-annotations.sha256sum] = "1526d1dd701047f385ef031786fb622684bc749d3ec4c43d66f1a050e0ab6417"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-plugin-plugin-3.9.0-7.el10.noarch.rpm;name=x86_64_v2_maven-plugin-plugin;unpack=0"
SRC_URI[x86_64_v2_maven-plugin-plugin.sha256sum] = "3c0a006cf9f9299d9e900f6060d49b62fecb68273946c75b2374bacf5873bd2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-plugin-tools-3.9.0-7.el10.noarch.rpm;name=x86_64_v2_maven-plugin-tools;unpack=0"
SRC_URI[x86_64_v2_maven-plugin-tools.sha256sum] = "c7be395792c543f7e82e0428a4e1c6c173b3674b81a7e428c583a6b809730b47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-plugin-tools-annotations-3.9.0-7.el10.noarch.rpm;name=x86_64_v2_maven-plugin-tools-annotations;unpack=0"
SRC_URI[x86_64_v2_maven-plugin-tools-annotations.sha256sum] = "25bfb98167ad544f64d330bbe075d13a7aecd650832fb69c604a44a4177a5a5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-plugin-tools-api-3.9.0-7.el10.noarch.rpm;name=x86_64_v2_maven-plugin-tools-api;unpack=0"
SRC_URI[x86_64_v2_maven-plugin-tools-api.sha256sum] = "813001be7c23483ade10ecdee9f02ce0d3a9a4cf1061db2f81b9c6d08e4c9271"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-plugin-tools-generators-3.9.0-7.el10.noarch.rpm;name=x86_64_v2_maven-plugin-tools-generators;unpack=0"
SRC_URI[x86_64_v2_maven-plugin-tools-generators.sha256sum] = "9295f7767b7413244ecd12102e701456b825c563b550b64ada664bd254fcef3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-plugin-tools-java-3.9.0-7.el10.noarch.rpm;name=x86_64_v2_maven-plugin-tools-java;unpack=0"
SRC_URI[x86_64_v2_maven-plugin-tools-java.sha256sum] = "17d5a36bbe6753ef1d3bb3a2ff9642a34432f0d0b2f1dad388acfa306c8bfe5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-plugin-tools-javadoc-3.9.0-7.el10.noarch.rpm;name=x86_64_v2_maven-plugin-tools-javadoc;unpack=0"
SRC_URI[x86_64_v2_maven-plugin-tools-javadoc.sha256sum] = "17875eea10d88a129cadbc7b72c33827eaf0f310ccb1098dd4dc7361a077d8de"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-plugin-annotations-3.9.0-7.el10.noarch.rpm;name=aarch64_maven-plugin-annotations;unpack=0"
SRC_URI[aarch64_maven-plugin-annotations.sha256sum] = "1526d1dd701047f385ef031786fb622684bc749d3ec4c43d66f1a050e0ab6417"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-plugin-plugin-3.9.0-7.el10.noarch.rpm;name=aarch64_maven-plugin-plugin;unpack=0"
SRC_URI[aarch64_maven-plugin-plugin.sha256sum] = "3c0a006cf9f9299d9e900f6060d49b62fecb68273946c75b2374bacf5873bd2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-plugin-tools-3.9.0-7.el10.noarch.rpm;name=aarch64_maven-plugin-tools;unpack=0"
SRC_URI[aarch64_maven-plugin-tools.sha256sum] = "c7be395792c543f7e82e0428a4e1c6c173b3674b81a7e428c583a6b809730b47"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-plugin-tools-annotations-3.9.0-7.el10.noarch.rpm;name=aarch64_maven-plugin-tools-annotations;unpack=0"
SRC_URI[aarch64_maven-plugin-tools-annotations.sha256sum] = "25bfb98167ad544f64d330bbe075d13a7aecd650832fb69c604a44a4177a5a5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-plugin-tools-api-3.9.0-7.el10.noarch.rpm;name=aarch64_maven-plugin-tools-api;unpack=0"
SRC_URI[aarch64_maven-plugin-tools-api.sha256sum] = "813001be7c23483ade10ecdee9f02ce0d3a9a4cf1061db2f81b9c6d08e4c9271"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-plugin-tools-generators-3.9.0-7.el10.noarch.rpm;name=aarch64_maven-plugin-tools-generators;unpack=0"
SRC_URI[aarch64_maven-plugin-tools-generators.sha256sum] = "9295f7767b7413244ecd12102e701456b825c563b550b64ada664bd254fcef3e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-plugin-tools-java-3.9.0-7.el10.noarch.rpm;name=aarch64_maven-plugin-tools-java;unpack=0"
SRC_URI[aarch64_maven-plugin-tools-java.sha256sum] = "17d5a36bbe6753ef1d3bb3a2ff9642a34432f0d0b2f1dad388acfa306c8bfe5c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-plugin-tools-javadoc-3.9.0-7.el10.noarch.rpm;name=aarch64_maven-plugin-tools-javadoc;unpack=0"
SRC_URI[aarch64_maven-plugin-tools-javadoc.sha256sum] = "17875eea10d88a129cadbc7b72c33827eaf0f310ccb1098dd4dc7361a077d8de"

RDEPENDS:maven-plugin-annotations = " \
 javapackages-filesystem \
 "
RDEPENDS:maven-plugin-plugin = " \
 javapackages-filesystem \
 maven-plugin-annotations \
 maven-plugin-tools-annotations \
 maven-plugin-tools-api \
 maven-plugin-tools-generators \
 maven-plugin-tools-java \
 plexus-build-api0 \
 plexus-utils \
 "
RDEPENDS:maven-plugin-tools = " \
 javapackages-filesystem \
 maven-parent \
 "
RDEPENDS:maven-plugin-tools-annotations = " \
 javapackages-filesystem \
 jsoup \
 maven-lib \
 maven-plugin-annotations \
 maven-plugin-tools-api \
 objectweb-asm \
 plexus-archiver \
 plexus-utils \
 qdox \
 sisu \
 slf4j \
 "
RDEPENDS:maven-plugin-tools-api = " \
 httpcomponents-client \
 httpcomponents-core \
 javapackages-filesystem \
 maven-lib \
 maven-wagon \
 plexus-languages \
 plexus-utils \
 slf4j \
 "
RDEPENDS:maven-plugin-tools-generators = " \
 javapackages-filesystem \
 jsoup \
 maven-lib \
 maven-plugin-tools-api \
 objectweb-asm \
 plexus-utils \
 "
RDEPENDS:maven-plugin-tools-java = " \
 javapackages-filesystem \
 maven-lib \
 maven-plugin-tools-api \
 plexus-utils \
 qdox \
 sisu \
 "
RDEPENDS:maven-plugin-tools-javadoc = " \
 javapackages-filesystem \
 "
