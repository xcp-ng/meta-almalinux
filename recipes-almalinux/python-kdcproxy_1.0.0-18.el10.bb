# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-kdcproxy"
PV = "1.0.0"
PR = "18.el10"
PACKAGES = " \
 python3-kdcproxy \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-kdcproxy-1.0.0-18.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b62f14413dc1087af39938d824fa957ee4843aa76040385519a152fd98075c78"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-kdcproxy-1.0.0-18.el10.noarch.rpm;name=x86_64_v2_python3-kdcproxy;unpack=0"
SRC_URI[x86_64_v2_python3-kdcproxy.sha256sum] = "bf31140be5ceeff3c043737d1c1b533a380a5d37f5289fbc445612a6e489be57"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-kdcproxy-1.0.0-18.el10.noarch.rpm;name=aarch64_python3-kdcproxy;unpack=0"
SRC_URI[aarch64_python3-kdcproxy.sha256sum] = "bf31140be5ceeff3c043737d1c1b533a380a5d37f5289fbc445612a6e489be57"

RDEPENDS:python3-kdcproxy = " \
 python3 \
 python3-dns \
 python3-pyasn1 \
 "
