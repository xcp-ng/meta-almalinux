# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-conda-package-streaming"
PV = "0.11.0"
PR = "4.el10_2"
PACKAGES = " \
 python3-conda-package-streaming \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-conda-package-streaming-0.11.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8b83a5591665c3e9b28af047e0d5b0ee3920104d1b8b0bb0ab810924f45fc4c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-conda-package-streaming-0.11.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-conda-package-streaming;unpack=0"
SRC_URI[x86_64_v2_python3-conda-package-streaming.sha256sum] = "8443ec2c5aa8225c344762c5e33e3659ccecfa3bde6a2535601e81d202fc7cca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-conda-package-streaming-0.11.0-4.el10_2.noarch.rpm;name=aarch64_python3-conda-package-streaming;unpack=0"
SRC_URI[aarch64_python3-conda-package-streaming.sha256sum] = "bc3d64290c86a161e75d8a26037673c2cd1c457fb8b0acb11721d3dc599f4f4c"

RDEPENDS:python3-conda-package-streaming = " \
 python3 \
 python3-requests \
 python3-zstandard \
 "
