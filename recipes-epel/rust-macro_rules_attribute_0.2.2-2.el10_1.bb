# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-macro_rules_attribute"
PV = "0.2.2"
PR = "2.el10_1"
PACKAGES = " \
 rust-macro_rules_attribute+better-docs-devel \
 rust-macro_rules_attribute+default-devel \
 rust-macro_rules_attribute+verbose-expansions-devel \
 rust-macro_rules_attribute-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-macro_rules_attribute-0.2.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f044e12186f081b2947d15f0030a11bbf9b4496ce149bc43feb22f8d9bcc8f5"

URI_x86_64_v2_rust-macro_rules_attribute+better-docs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute+better-docs-devel-0.2.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute+better-docs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute+better-docs-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute+better-docs-devel.sha256sum] = "c07d8eaf7dd499925970fd0a1455441abdb08f9bc89bfce70d6788f4e9c2446a"

URI_x86_64_v2_rust-macro_rules_attribute+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute+default-devel-0.2.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute+default-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute+default-devel.sha256sum] = "e0c998540b49c760e67b108291d51a770a3783d558467498deb54742fd87eedb"

URI_x86_64_v2_rust-macro_rules_attribute+verbose-expansions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute+verbose-expansions-devel-0.2.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute+verbose-expansions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute+verbose-expansions-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute+verbose-expansions-devel.sha256sum] = "96b8496b2634a890b86bfbc9c77f60cd162a861e719713dcf8b451e8d74e3b12"

URI_x86_64_v2_rust-macro_rules_attribute-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute-devel-0.2.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute-devel.sha256sum] = "97556faee3a5418c340059ff7d959d9728f997033c9de9039c4d2b92696951a2"

URI_aarch64_rust-macro_rules_attribute+better-docs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute+better-docs-devel-0.2.2-2.el10_1.noarch.rpm;name=aarch64_rust-macro_rules_attribute+better-docs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute+better-docs-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute+better-docs-devel.sha256sum] = "20cfa4680eb7ee1606ecb81ba3c49103c78557c37f011608df0cd5bb8790d754"

URI_aarch64_rust-macro_rules_attribute+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute+default-devel-0.2.2-2.el10_1.noarch.rpm;name=aarch64_rust-macro_rules_attribute+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute+default-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute+default-devel.sha256sum] = "adda837d032227739c9601e43894b256f66048cc4f29f272d6c91a72d57df659"

URI_aarch64_rust-macro_rules_attribute+verbose-expansions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute+verbose-expansions-devel-0.2.2-2.el10_1.noarch.rpm;name=aarch64_rust-macro_rules_attribute+verbose-expansions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute+verbose-expansions-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute+verbose-expansions-devel.sha256sum] = "9e9f11b7ef82bebf14cb265ccee25f3fa50928f250bde438fd0ec9404baa5aba"

URI_aarch64_rust-macro_rules_attribute-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute-devel-0.2.2-2.el10_1.noarch.rpm;name=aarch64_rust-macro_rules_attribute-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute-devel.sha256sum] = "ab49378496c838bb87349d593cdb72164457d65a4e196a4aabe9bad38b56e93e"

RDEPENDS:rust-macro_rules_attribute+better-docs-devel = " \
 cargo \
 rust-macro_rules_attribute-devel \
 "
RDEPENDS:rust-macro_rules_attribute+default-devel = " \
 cargo \
 rust-macro_rules_attribute-devel \
 "
RDEPENDS:rust-macro_rules_attribute+verbose-expansions-devel = " \
 cargo \
 rust-macro_rules_attribute-devel \
 rust-macro_rules_attribute-proc_macro+verbose-expansions-devel \
 "
RDEPENDS:rust-macro_rules_attribute-devel = " \
 cargo \
 rust-macro_rules_attribute-proc_macro+default-devel \
 rust-paste+default-devel \
 "
