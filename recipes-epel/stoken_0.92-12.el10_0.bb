# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stoken"
PV = "0.92"
PR = "12.el10_0"
PACKAGES = " \
 stoken-cli \
 stoken-devel \
 stoken-gui \
 stoken-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stoken-0.92-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9339f21c49d814985073b56c44a2258553fabef380bc621aceff51e90c06362f"

URI_x86_64_v2_stoken-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-cli-0.92-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-cli}"
SRC_URI[x86_64_v2_stoken-cli.sha256sum] = "aaf0a3c1a98156e2b1939e6be0e9b82abf938f0cccc63f24c984fb61d43b9aa1"

URI_x86_64_v2_stoken-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-devel-0.92-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-devel}"
SRC_URI[x86_64_v2_stoken-devel.sha256sum] = "511a10623839e79d524319671cd077ab8aa6a19cb143cdb9dd8a65c1f39e3add"

URI_x86_64_v2_stoken-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-gui-0.92-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-gui}"
SRC_URI[x86_64_v2_stoken-gui.sha256sum] = "d96538f3109c07fce71678ba9376c2111fa58a7897a9b874207bc0c93a0463ff"

URI_x86_64_v2_stoken-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stoken-libs-0.92-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stoken-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stoken-libs}"
SRC_URI[x86_64_v2_stoken-libs.sha256sum] = "f3268a011b1b50bb177c198d7bff00605f2661e98c619ee0adde3ae9487b62a0"

URI_aarch64_stoken-cli = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-cli-0.92-12.el10_0.aarch64.rpm;name=aarch64_stoken-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-cli}"
SRC_URI[aarch64_stoken-cli.sha256sum] = "9fce078aacfb3edef8757e9fb15e19c73ce9a8bddaa2a68043c37c6444c0f62b"

URI_aarch64_stoken-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-devel-0.92-12.el10_0.aarch64.rpm;name=aarch64_stoken-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-devel}"
SRC_URI[aarch64_stoken-devel.sha256sum] = "93cab91f7d36a7768d06d97a45a32cce09b34a04142266ecf632b00b30b954af"

URI_aarch64_stoken-gui = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-gui-0.92-12.el10_0.aarch64.rpm;name=aarch64_stoken-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-gui}"
SRC_URI[aarch64_stoken-gui.sha256sum] = "37a9490aa401f93e02b70af7d947cbc517552f614b8b2473cb11311451c2584a"

URI_aarch64_stoken-libs = "${EPEL_MIRROR}/aarch64/Packages/s/stoken-libs-0.92-12.el10_0.aarch64.rpm;name=aarch64_stoken-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_stoken-libs}"
SRC_URI[aarch64_stoken-libs.sha256sum] = "12d2dda5b65e5602d25c74f2896232854147a6790f0ccbea0ed7815e75dc79f0"

RDEPENDS:stoken-cli = " \
 glibc \
 stoken-libs \
 "
RDEPENDS:stoken-devel = " \
 libxml2-devel \
 nettle-devel \
 pkgconf-pkg-config \
 stoken-libs \
 "
RDEPENDS:stoken-gui = " \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 stoken-libs \
 "
RDEPENDS:stoken-libs = " \
 glibc \
 gmp \
 libxml2 \
 nettle \
 "
