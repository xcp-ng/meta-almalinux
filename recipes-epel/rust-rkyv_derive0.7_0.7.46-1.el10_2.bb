# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv_derive0.7"
PV = "0.7.46"
PR = "1.el10_2"
PACKAGES = " \
 rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel \
 rust-rkyv_derive0.7+archive_be-devel \
 rust-rkyv_derive0.7+archive_le-devel \
 rust-rkyv_derive0.7+copy-devel \
 rust-rkyv_derive0.7+default-devel \
 rust-rkyv_derive0.7+strict-devel \
 rust-rkyv_derive0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv_derive0.7-0.7.46-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "382426f86c176a3829924e754ec32b314ada78b02e09722df16ee8dcc04a4396"

URI_x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel.sha256sum] = "687fa16807feb276d6af33192e8d2329513961bc5fd99cba9addfb8640745d93"

URI_x86_64_v2_rust-rkyv_derive0.7+archive_be-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+archive_be-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+archive_be-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+archive_be-devel.sha256sum] = "2a7a109297fba016b45ba6c1481a11e3a08f01f4b8f3c5f2e77b6e29f163fad9"

URI_x86_64_v2_rust-rkyv_derive0.7+archive_le-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+archive_le-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+archive_le-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+archive_le-devel.sha256sum] = "f60978d9b3a69e1ee44385e772f1e9810c55d755632e661c8380eab947b298f5"

URI_x86_64_v2_rust-rkyv_derive0.7+copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+copy-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+copy-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+copy-devel.sha256sum] = "64b6e99e224dd946d9e225ba0ed01ec60d6a56dd2e6353bf987a3105367a5c7e"

URI_x86_64_v2_rust-rkyv_derive0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+default-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+default-devel.sha256sum] = "b221ec46b48c30f8d733ad4527e13430ebc8766339fb79ebcc2e6217e2f2acee"

URI_x86_64_v2_rust-rkyv_derive0.7+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7+strict-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7+strict-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7+strict-devel.sha256sum] = "1196964e1c2e96c0863394ccbcb291a9cb3977c98a3f9c5b400ae4d782d93e5c"

URI_x86_64_v2_rust-rkyv_derive0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv_derive0.7-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv_derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv_derive0.7-devel}"
SRC_URI[x86_64_v2_rust-rkyv_derive0.7-devel.sha256sum] = "5de49519e94173b8901a3849c330a7d724fb5ddb1ea0c1487fe23191e3db56d7"

URI_aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel.sha256sum] = "5308d1de1b5c88806ecbf4d2266272ab2ae259f983c8aed140bb390d4319774b"

URI_aarch64_rust-rkyv_derive0.7+archive_be-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+archive_be-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+archive_be-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+archive_be-devel.sha256sum] = "1df58211668e44ce3bdebd81217fd997a2442986a3f122641ec2f239e33f940b"

URI_aarch64_rust-rkyv_derive0.7+archive_le-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+archive_le-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+archive_le-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+archive_le-devel.sha256sum] = "fd62b2029ca8bdae29037f3c17a653e56115ad58d17cb8f23a69597df8c9fd6c"

URI_aarch64_rust-rkyv_derive0.7+copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+copy-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+copy-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+copy-devel.sha256sum] = "9cb923ca679e4f5fdb7cca1e79334a93278bbaab9a779ef9e9d58279194b5d80"

URI_aarch64_rust-rkyv_derive0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+default-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+default-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+default-devel.sha256sum] = "edd7ebd4cc22f14464ca132f984f97c8a413a226b6260a1c087c2b003e119b4d"

URI_aarch64_rust-rkyv_derive0.7+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7+strict-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7+strict-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7+strict-devel.sha256sum] = "5f1615fc48d7e46e87eba88d2a372f9a78f2aac1d2e90d072e829ce65126bc78"

URI_aarch64_rust-rkyv_derive0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv_derive0.7-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv_derive0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv_derive0.7-devel}"
SRC_URI[aarch64_rust-rkyv_derive0.7-devel.sha256sum] = "a4cf2c01772cee03ac2ca84cc0ef6642902bebe1eeca370837eba9d5a35fb738"

RDEPENDS:rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+archive_be-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+archive_le-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+copy-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+default-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7+strict-devel = " \
 cargo \
 rust-rkyv_derive0.7-devel \
 "
RDEPENDS:rust-rkyv_derive0.7-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 "
