# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foreign-types0.3"
PV = "0.3.2"
PR = "11.el10_0"
PACKAGES = " \
 rust-foreign-types0.3+default-devel \
 rust-foreign-types0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foreign-types0.3-0.3.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65dd99802561382ec2d1cdb75667c75a6ef7f603c05d350beca9c0a6d281bc17"

URI_x86_64_v2_rust-foreign-types0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types0.3+default-devel-0.3.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types0.3+default-devel}"
SRC_URI[x86_64_v2_rust-foreign-types0.3+default-devel.sha256sum] = "c0e50cb28021e608f593a72eabdc672a3da757b1fb6b571462a43a65bb0c3292"

URI_x86_64_v2_rust-foreign-types0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types0.3-devel-0.3.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types0.3-devel}"
SRC_URI[x86_64_v2_rust-foreign-types0.3-devel.sha256sum] = "eaaba24da594a8992bfdb9924f3ddcf19fad00ef6a86346624d39754ced6d937"

URI_aarch64_rust-foreign-types0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types0.3+default-devel-0.3.2-11.el10_0.noarch.rpm;name=aarch64_rust-foreign-types0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types0.3+default-devel}"
SRC_URI[aarch64_rust-foreign-types0.3+default-devel.sha256sum] = "5202413292af1de8890a42a87a8e573ef4ab7e3d9eecb80a1d94c0def1c71a1a"

URI_aarch64_rust-foreign-types0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types0.3-devel-0.3.2-11.el10_0.noarch.rpm;name=aarch64_rust-foreign-types0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types0.3-devel}"
SRC_URI[aarch64_rust-foreign-types0.3-devel.sha256sum] = "2738fb6a187b04c3f8b56a5d18b349576b9adfbe56c6d0cd936e039f25a034bf"

RDEPENDS:rust-foreign-types0.3+default-devel = " \
 cargo \
 rust-foreign-types0.3-devel \
 "
RDEPENDS:rust-foreign-types0.3-devel = " \
 cargo \
 rust-foreign-types-shared0.1+default-devel \
 "
