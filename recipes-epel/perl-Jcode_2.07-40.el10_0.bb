# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Jcode"
PV = "2.07"
PR = "40.el10_0"
PACKAGES = " \
 perl-Jcode \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Jcode-2.07-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b66911ad71cb18fb2cc28e7b2238cefbc2817a986c120414f32f5761190d9cd"

URI_x86_64_v2_perl-Jcode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Jcode-2.07-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Jcode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Jcode}"
SRC_URI[x86_64_v2_perl-Jcode.sha256sum] = "84e6b102457880ae6c33a7caf9da3eb9f6e149a3fd93739504253afc302ece21"

URI_aarch64_perl-Jcode = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Jcode-2.07-40.el10_0.noarch.rpm;name=aarch64_perl-Jcode;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Jcode}"
SRC_URI[aarch64_perl-Jcode.sha256sum] = "d09b755040e340a2a506722fcf13a545a08c0b7a1373219ed6d93829b63d25fe"

RDEPENDS:perl-Jcode = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-MIME-Base64 \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 perl-vars \
 "
