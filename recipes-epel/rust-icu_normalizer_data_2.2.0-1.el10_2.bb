# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_normalizer_data"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_normalizer_data+default-devel \
 rust-icu_normalizer_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_normalizer_data-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e9f8bb1999adc00f162058a91189b4b5e3bddb043808d2324e07ecd810ea0a9"

URI_x86_64_v2_rust-icu_normalizer_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer_data+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer_data+default-devel.sha256sum] = "6b9dfce56fe6e8abf1083ad4bde13073664d8edfe60f204c01ce9e6cf8d62106"

URI_x86_64_v2_rust-icu_normalizer_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_normalizer_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_normalizer_data-devel}"
SRC_URI[x86_64_v2_rust-icu_normalizer_data-devel.sha256sum] = "940effd3cda776b5bdd3b350405d30edd9eca05d892ed09a089887ffd075f64f"

URI_aarch64_rust-icu_normalizer_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer_data+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer_data+default-devel}"
SRC_URI[aarch64_rust-icu_normalizer_data+default-devel.sha256sum] = "3e6b6ae67379d8d639c65beb265d8542b05a6e717747831d868f543d821795a9"

URI_aarch64_rust-icu_normalizer_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_normalizer_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_normalizer_data-devel}"
SRC_URI[aarch64_rust-icu_normalizer_data-devel.sha256sum] = "9357e23cadae6b0e7e0ed2cc98e14f5340908545b23632986ccb021d2f1992b3"

RDEPENDS:rust-icu_normalizer_data+default-devel = " \
 cargo \
 rust-icu_normalizer_data-devel \
 "
RDEPENDS:rust-icu_normalizer_data-devel = " \
 cargo \
 rust \
 "
