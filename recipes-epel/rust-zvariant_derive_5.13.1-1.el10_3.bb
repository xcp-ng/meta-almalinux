# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zvariant_derive"
PV = "5.13.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-zvariant_derive+default-devel \
 rust-zvariant_derive+gvariant-devel \
 rust-zvariant_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zvariant_derive-5.13.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "814f29554946f83f5d18fa7538820fda243e90d7274bbdf422dcf11f6a9ffb0b"

URI_x86_64_v2_rust-zvariant_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_derive+default-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_derive+default-devel}"
SRC_URI[x86_64_v2_rust-zvariant_derive+default-devel.sha256sum] = "fc8d17d63bee660212e3f86399926e8976a29c12bc14cb57a07f9a8235fb3fd5"

URI_x86_64_v2_rust-zvariant_derive+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_derive+gvariant-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_derive+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_derive+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant_derive+gvariant-devel.sha256sum] = "b67138149e2ebd92993b62a407fbc899d8dd0fd20bd4f15188fe3c10d577af18"

URI_x86_64_v2_rust-zvariant_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant_derive-devel-5.13.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant_derive-devel}"
SRC_URI[x86_64_v2_rust-zvariant_derive-devel.sha256sum] = "9046cbed2ae95a408ea96a5f840ce606eb694dbfa86f301696892fe94c1758a4"

URI_aarch64_rust-zvariant_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_derive+default-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_derive+default-devel}"
SRC_URI[aarch64_rust-zvariant_derive+default-devel.sha256sum] = "28c41424247966eda0bc88139a459664ed2af7ce475d5ce6d7a264ae7a63670b"

URI_aarch64_rust-zvariant_derive+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_derive+gvariant-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant_derive+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_derive+gvariant-devel}"
SRC_URI[aarch64_rust-zvariant_derive+gvariant-devel.sha256sum] = "d04998c529f85de4ce56709bdbae485ced7eb464b096b5bca65ac3586a6a413b"

URI_aarch64_rust-zvariant_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant_derive-devel-5.13.1-1.el10_3.noarch.rpm;name=aarch64_rust-zvariant_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant_derive-devel}"
SRC_URI[aarch64_rust-zvariant_derive-devel.sha256sum] = "b6b9f5098294f173de684c11d816d210534abf3472def72d9568e50f7dd91962"

RDEPENDS:rust-zvariant_derive+default-devel = " \
 cargo \
 rust-zvariant_derive-devel \
 "
RDEPENDS:rust-zvariant_derive+gvariant-devel = " \
 cargo \
 rust-zvariant_derive-devel \
 rust-zvariant_utils+gvariant-devel \
 "
RDEPENDS:rust-zvariant_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro-crate+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-zvariant_utils+default-devel \
 "
