# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R"
PV = "4.6.1"
PR = "1.el10_3"
PACKAGES = " \
 R \
 R-core \
 R-core-devel \
 R-devel \
 R-java \
 R-java-devel \
 libRmath \
 libRmath-devel \
 libRmath-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-4.6.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f6afb23b6b6e27054544c51359fd159be32f03a6cf3275251e6a4cf39541e84"

URI_x86_64_v2_R = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R}"
SRC_URI[x86_64_v2_R.sha256sum] = "5ea645142672b260998078a295a3dc48e0ea72a3be17faf80f91cce698b74293"

URI_x86_64_v2_R-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-core-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-core}"
SRC_URI[x86_64_v2_R-core.sha256sum] = "ffe57ccb91532b2039b338b72f10686cbc6fe3b7bdcac49b7301aa435ffcaa5e"

URI_x86_64_v2_R-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-core-devel-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-core-devel}"
SRC_URI[x86_64_v2_R-core-devel.sha256sum] = "8ab0f54c0ae01cc7c363595860b5559589519f5c55f22678776ce992f9c3b880"

URI_x86_64_v2_R-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-devel-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-devel}"
SRC_URI[x86_64_v2_R-devel.sha256sum] = "9d8919bcf22655233f25bf843e461bc59351ddd573b78cc13cccb05bffc27772"

URI_x86_64_v2_R-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-java-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-java}"
SRC_URI[x86_64_v2_R-java.sha256sum] = "6a99936838a08a36da122103a6e5b3644856cc2678fac8d39e20974696182161"

URI_x86_64_v2_R-java-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-java-devel-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-java-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-java-devel}"
SRC_URI[x86_64_v2_R-java-devel.sha256sum] = "425ce626a2a2ca449b1b30344d6485b223630c9ac26ee0b8972f1bb2a4f1fadf"

URI_x86_64_v2_libRmath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libRmath-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libRmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libRmath}"
SRC_URI[x86_64_v2_libRmath.sha256sum] = "143d7431f0618caf7a35708c390fa929d0aa24e6cd884886c179a41877641633"

URI_x86_64_v2_libRmath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libRmath-devel-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libRmath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libRmath-devel}"
SRC_URI[x86_64_v2_libRmath-devel.sha256sum] = "063dedb8f4bc279305e78d2ee1ce80786517575f5dfca8b9d8950690cefcc7cd"

URI_x86_64_v2_libRmath-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libRmath-static-4.6.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libRmath-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libRmath-static}"
SRC_URI[x86_64_v2_libRmath-static.sha256sum] = "9db38b7894274723d416341d6527c99f872b0e64240a51b6c9bdb6a1b0b4ae3c"

URI_aarch64_R = "${EPEL_MIRROR}/aarch64/Packages/r/R-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_R;unpack=0"
SRC_URI:append = " ${URI_aarch64_R}"
SRC_URI[aarch64_R.sha256sum] = "73b8be2a7fbea08a9d593e3f3e6acf45317e0d1e9bf13a6e92dddc4f8b0d9329"

URI_aarch64_R-core = "${EPEL_MIRROR}/aarch64/Packages/r/R-core-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_R-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-core}"
SRC_URI[aarch64_R-core.sha256sum] = "4b3ce2d966a4d11d79c1fbf996f074f5290fc9fde902762f299bb15d0e9995c6"

URI_aarch64_R-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/R-core-devel-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_R-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-core-devel}"
SRC_URI[aarch64_R-core-devel.sha256sum] = "8507abdb897086b1046bec85652da0e8ce42cd88e5acda0dc77dbd228c475ed0"

URI_aarch64_R-devel = "${EPEL_MIRROR}/aarch64/Packages/r/R-devel-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_R-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-devel}"
SRC_URI[aarch64_R-devel.sha256sum] = "9ce476a1094daa844d8525e576cea31b626c0605bcbbfa514608f77947a7c67d"

URI_aarch64_R-java = "${EPEL_MIRROR}/aarch64/Packages/r/R-java-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_R-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-java}"
SRC_URI[aarch64_R-java.sha256sum] = "5fca5a1def73f5cecc6624e284893356125284f60ac6bd1176af763d19d4e887"

URI_aarch64_R-java-devel = "${EPEL_MIRROR}/aarch64/Packages/r/R-java-devel-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_R-java-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-java-devel}"
SRC_URI[aarch64_R-java-devel.sha256sum] = "acb4eb426e0086e63aa0f4712a6af831d387d979c1f0847e155addbdf2ad27a1"

URI_aarch64_libRmath = "${EPEL_MIRROR}/aarch64/Packages/l/libRmath-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_libRmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_libRmath}"
SRC_URI[aarch64_libRmath.sha256sum] = "9961edf5c7b579ef5a1e174aa2ccaaed936000c30cbf3ad87d6a475679f052fa"

URI_aarch64_libRmath-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libRmath-devel-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_libRmath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libRmath-devel}"
SRC_URI[aarch64_libRmath-devel.sha256sum] = "6461bbe5cd31afb89011b6bc6495c55099c1b6e588221485c9eb5baaf446b7e5"

URI_aarch64_libRmath-static = "${EPEL_MIRROR}/aarch64/Packages/l/libRmath-static-4.6.1-1.el10_3.aarch64.rpm;name=aarch64_libRmath-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libRmath-static}"
SRC_URI[aarch64_libRmath-static.sha256sum] = "f8685bb336dce4f76cba855997dc5df984f5f7a6c4ea0b33369917a79f5fedd1"

RDEPENDS:R = " \
 R-devel \
 "
RDEPENDS:R-core = " \
 bash \
 bzip2-libs \
 cairo \
 flexiblas-netlib \
 glib2 \
 glibc \
 less \
 libRmath \
 libX11 \
 libXmu \
 libXt \
 libdeflate \
 libgcc \
 libgomp \
 libicu \
 libjpeg-turbo \
 libpng \
 libtiff \
 libtirpc \
 libzstd \
 pango \
 pcre2 \
 readline \
 tcl \
 tk \
 tre \
 tzdata \
 unzip \
 virtual/libcurl.so.4___64bit_ \
 xdg-utils \
 xz-libs \
 zip \
 zlib-ng-compat \
 "
RDEPENDS:R-core-devel = " \
 R-core \
 bzip2-devel \
 flexiblas-devel \
 gcc-c++ \
 gcc-gfortran \
 libRmath-devel \
 libX11-devel \
 libdeflate-devel \
 libicu-devel \
 libtirpc-devel \
 libzstd-devel \
 make \
 pcre2-devel \
 pkgconf-pkg-config \
 redhat-rpm-config \
 tre-devel \
 xz-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:R-devel = " \
 R-core-devel \
 R-java-devel \
 R-rpm-macros \
 "
RDEPENDS:R-java = " \
 R-core \
 java-21-openjdk-headless \
 "
RDEPENDS:R-java-devel = " \
 R-core-devel \
 R-java \
 java-21-openjdk-devel \
 "
RDEPENDS:libRmath = " \
 glibc \
 "
RDEPENDS:libRmath-devel = " \
 libRmath \
 pkgconf-pkg-config \
 "
RDEPENDS:libRmath-static = " \
 libRmath-devel \
 "
