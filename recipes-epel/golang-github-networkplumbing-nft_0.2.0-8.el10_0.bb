# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-networkplumbing-nft"
PV = "0.2.0"
PR = "8.el10_0"
PACKAGES = " \
 golang-github-networkplumbing-nft-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-networkplumbing-nft-0.2.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fdbbf55aff24168c74e62770ce4ac2be2ef0e831903d407e6ffd5f776f7d06f"

URI_x86_64_v2_golang-github-networkplumbing-nft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-networkplumbing-nft-devel-0.2.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-networkplumbing-nft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-networkplumbing-nft-devel}"
SRC_URI[x86_64_v2_golang-github-networkplumbing-nft-devel.sha256sum] = "c8ad82149eac018c10d887aa1df9d9f0ee16a0242cf24d54f4a2120251103e63"

URI_aarch64_golang-github-networkplumbing-nft-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-networkplumbing-nft-devel-0.2.0-8.el10_0.noarch.rpm;name=aarch64_golang-github-networkplumbing-nft-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-networkplumbing-nft-devel}"
SRC_URI[aarch64_golang-github-networkplumbing-nft-devel.sha256sum] = "5e6c892ed2c4c6b739c6040afae512484e9e57530ac1893b47293bfc41738681"

RDEPENDS:golang-github-networkplumbing-nft-devel = " \
 go-filesystem \
 nftables-devel \
 "
