# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-starlette"
PV = "0.47.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-starlette \
 python3-starlette+full \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-starlette-0.47.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "734fb2cb21cbb7ed74eeef6dd6646d0444b96522cfc6aba39667b607c66c269d"

URI_x86_64_v2_python3-starlette = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-starlette-0.47.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-starlette;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-starlette}"
SRC_URI[x86_64_v2_python3-starlette.sha256sum] = "9abf3a12f0e1671bc5aa499f114e233268128151da536c2ae84712aa2f213def"

URI_x86_64_v2_python3-starlette+full = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-starlette+full-0.47.0-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-starlette+full;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-starlette+full}"
SRC_URI[x86_64_v2_python3-starlette+full.sha256sum] = "eff4a5a3dc9e85096e2ad42b41bab798e6ba63d29c75b2c85e1af5205dd5664f"

URI_aarch64_python3-starlette = "${EPEL_MIRROR}/aarch64/Packages/p/python3-starlette-0.47.0-2.el10_2.noarch.rpm;name=aarch64_python3-starlette;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-starlette}"
SRC_URI[aarch64_python3-starlette.sha256sum] = "e705d81d4ce92e3830666573df817e67f5d5945e984a61e1ee725d71e7288ada"

URI_aarch64_python3-starlette+full = "${EPEL_MIRROR}/aarch64/Packages/p/python3-starlette+full-0.47.0-2.el10_2.noarch.rpm;name=aarch64_python3-starlette+full;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-starlette+full}"
SRC_URI[aarch64_python3-starlette+full.sha256sum] = "9d8d4f39bece9e9a971351c0db243731b66b144afd0574226a5cdcc3b3c175bc"

RDEPENDS:python3-starlette = " \
 python3 \
 python3-anyio \
 "
RDEPENDS:python3-starlette+full = " \
 python3 \
 python3-httpx \
 python3-itsdangerous \
 python3-jinja2 \
 python3-python-multipart \
 python3-pyyaml \
 python3-starlette \
 "
