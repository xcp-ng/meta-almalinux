# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyparsing"
PV = "3.1.1"
PR = "7.el10"
PACKAGES = " \
 pyparsing-doc \
 python3-pyparsing \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pyparsing-3.1.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bef2b60aa34fda9d1e539fe6c6d51950d94713543616bf6c054507995f414a7f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pyparsing-doc-3.1.1-7.el10.noarch.rpm;name=x86_64_v2_pyparsing-doc;unpack=0"
SRC_URI[x86_64_v2_pyparsing-doc.sha256sum] = "2e5df3e4e04703640480d7c704ecc0af825a29ff1fe318a114ef27b08c40d665"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-pyparsing-3.1.1-7.el10.noarch.rpm;name=x86_64_v2_python3-pyparsing;unpack=0"
SRC_URI[x86_64_v2_python3-pyparsing.sha256sum] = "bddd7ddda39e05a7ce9430b7407eaf7f832f9145aaa1380acfafb31b927fc904"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pyparsing-doc-3.1.1-7.el10.noarch.rpm;name=aarch64_pyparsing-doc;unpack=0"
SRC_URI[aarch64_pyparsing-doc.sha256sum] = "2e5df3e4e04703640480d7c704ecc0af825a29ff1fe318a114ef27b08c40d665"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-pyparsing-3.1.1-7.el10.noarch.rpm;name=aarch64_python3-pyparsing;unpack=0"
SRC_URI[aarch64_python3-pyparsing.sha256sum] = "bddd7ddda39e05a7ce9430b7407eaf7f832f9145aaa1380acfafb31b927fc904"

RDEPENDS:pyparsing-doc = " \
 "
RDEPENDS:python3-pyparsing = " \
 python3 \
 "
