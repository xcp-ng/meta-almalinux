# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tower-http"
PV = "0.6.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-tower-http+add-extension-devel \
 rust-tower-http+async-compression-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+base64-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-full-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+compression-zstd-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-full-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+decompression-zstd-devel \
 rust-tower-http+default-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+full-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+httpdate-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+mime-devel \
 rust-tower-http+mime_guess-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+on-early-drop-devel \
 rust-tower-http+percent-encoding-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+tokio-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http+tower-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http+util-devel \
 rust-tower-http+uuid-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-tower-http-0.6.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7abae3048718d3e34281e98500b99189e08bf4fadb23eea0bd2dab7769410aee"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+add-extension-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+add-extension-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+add-extension-devel.sha256sum] = "2de00a793f2bf94c0521e86458aa07746e2489c4403cfb6c07809f1de12bdbca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+async-compression-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+async-compression-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+async-compression-devel.sha256sum] = "a93d3d260cdb8c86e86a3628985fd8a591e70227e8ff269d1cf5661760dbb196"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+auth-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+auth-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+auth-devel.sha256sum] = "d9fc0409c4605781843637871aac9d44ad38be9bcdfc39834ee974dd0a6e4f34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+base64-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+base64-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+base64-devel.sha256sum] = "df6f6061501dfe1120ef987bc155824bd554acd1eeebf296240048899f91666c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+catch-panic-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+catch-panic-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+catch-panic-devel.sha256sum] = "734e96d13958479eb8e3fe5abb7d5adf512c2f778673f4d3ce4c3722e2e85de0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-br-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-br-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+compression-br-devel.sha256sum] = "fe0bc1c19157f80dfa6e606eef0fd8a3f41e84142f6af7a90688ce7884c3ef5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-deflate-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-deflate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+compression-deflate-devel.sha256sum] = "b75b54b41350afe437761c777b873dc69da81cf0a970c200209e888e84992e00"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-full-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+compression-full-devel.sha256sum] = "ab28c651b9a07b78041ef624cfac4c0564d3a12b00e40a93e831677a7c8a2943"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-gzip-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-gzip-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+compression-gzip-devel.sha256sum] = "5fc81e13ee77f889b1254dc3ff4f17b978e13deb31a10b2c5e41c03475d2e926"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+compression-zstd-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+compression-zstd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+compression-zstd-devel.sha256sum] = "c2b16b9b59f890ac52d9aca490a857e785dfb2bca412dbc4c5fa2c5b93d40843"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+cors-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+cors-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+cors-devel.sha256sum] = "fc00cf49ef743a982dc22383eb0bdccbbfc1b662555ad19c547de247a133e822"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-br-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-br-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+decompression-br-devel.sha256sum] = "659718e42c2c829c2a43b895ef060f4da90ef8df810fd6fecaed8207195503da"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-deflate-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-deflate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+decompression-deflate-devel.sha256sum] = "4cb17c90f6941a5cd925f03bd94f05b9e1568e2ce17af2dd4749474f9b694e53"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-full-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+decompression-full-devel.sha256sum] = "82fe89b04b65568da69f4aedd629f8ccaa04e5445ab7a684557bd38358af0c62"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-gzip-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-gzip-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+decompression-gzip-devel.sha256sum] = "6b4cacf7cf967c1faffb9e1bc6c3ca64488096ddcf64b89b7f8f83bc36a902a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+decompression-zstd-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+decompression-zstd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+decompression-zstd-devel.sha256sum] = "e2013e19d12bc91a2689e5aa64c1dac0a92e7777da4d401fcf7003d6342a5907"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+default-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+default-devel.sha256sum] = "d1a513828e0cebbd9d5bf3b57c4f68146dc4a9fad08b34094dbeef1d1906b764"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+follow-redirect-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+follow-redirect-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+follow-redirect-devel.sha256sum] = "f175aced8688912b6e96d2c26486bc14940446f8f2b3d78c07f80941cdb625fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+fs-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+fs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+fs-devel.sha256sum] = "1f05f3fd725979a467ddc6fc66dc9206cf608f3712272f3944041f1b992c4983"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+full-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+full-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+full-devel.sha256sum] = "72e3ad5336469e93889dc4671ec4d964558f1875a993f128033839168f4ca696"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+futures-core-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+futures-core-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+futures-core-devel.sha256sum] = "13e39c0b5c39f46b92e460cc122fa86b688afb8676fd49e6b3f350d8fb9a1fed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+futures-util-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+futures-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+futures-util-devel.sha256sum] = "fc85546eb07f799df7b3551341c48b2d6d6e985a2b216af979bfddce0887cbcb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+httpdate-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+httpdate-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+httpdate-devel.sha256sum] = "a44b166e66cbbd200b4b8b09f0ad2cc4f6b35def06baf2dcbb6bc0dfee2b3aab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+limit-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+limit-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+limit-devel.sha256sum] = "1b028ee5e84f5779980dd1accff2b3868d2a788a21c727707d282fe7e736f1ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+map-request-body-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+map-request-body-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+map-request-body-devel.sha256sum] = "6dc81e8df17c641e79f3ea97a235d213e35b4ad443367cdf0179ba687257b30d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+map-response-body-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+map-response-body-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+map-response-body-devel.sha256sum] = "4a9a0aecc2482fa23240ac7d67376f96935441f92293108b341cc9ca7abc7737"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+metrics-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+metrics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+metrics-devel.sha256sum] = "c19bac374016549ec4b3fb6ec89f6c834ad19006751d8e96ee545699a3500ff8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+mime-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+mime-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+mime-devel.sha256sum] = "4dcd5ff0db0fe5233a0d91af3c0a05708416ac120f2a6a4a500d34c675627b0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+mime_guess-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+mime_guess-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+mime_guess-devel.sha256sum] = "acf2a93d6dc4c57eb25b9005993854da5e689a249cb3888d2a37e4d34983cc4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+normalize-path-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+normalize-path-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+normalize-path-devel.sha256sum] = "0f5665bd00f366ad2084eac933b96bae64ae2770bace74e48422c2d0f97dca5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+on-early-drop-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+on-early-drop-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+on-early-drop-devel.sha256sum] = "317d1bfc22efe18bceb49923dc3df8a98517531c845b47eef0edd578dbf0b804"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+percent-encoding-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+percent-encoding-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+percent-encoding-devel.sha256sum] = "a7d0cea4e9f61fb332671fcf9f9dfcc69a29327fef9f6eaea3180d1383b7a487"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+propagate-header-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+propagate-header-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+propagate-header-devel.sha256sum] = "464c1551ad3a5583af8e04e2307c79ca5ecc8652aff3807cd4092b37eca08ef9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+redirect-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+redirect-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+redirect-devel.sha256sum] = "b04399eb42a01ba48fa5c16dfa2963db7a09a40eb288f1ce785d852bf0f1ccf9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+request-id-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+request-id-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+request-id-devel.sha256sum] = "d3d599d2e51059039361cbbad901acc4efaa1430fd3f11ac0ea5c566f08684b6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+sensitive-headers-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+sensitive-headers-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+sensitive-headers-devel.sha256sum] = "1c4d41796164164c8f6e0001350fcc953ad13d658c28a1e6663a7e218f9d62e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+set-header-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+set-header-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+set-header-devel.sha256sum] = "8f6511a9f2c4b2bf379e56c9059518baea01cf79f61253f04c57927ea6687534"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+set-status-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+set-status-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+set-status-devel.sha256sum] = "d0e0aa6b76e785efaaf4903d2f443f9fa8266a51b98347450dbb8436c4bb4f29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+timeout-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+timeout-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+timeout-devel.sha256sum] = "7e50b65a2762f82ef1576b64014a1281da1ae6a5bb9c6f2361560785130fb717"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tokio-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+tokio-devel.sha256sum] = "1489735e1120cb2efc4d7ed676624424176c40314cdde51b037a3ac390cd8fe9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tokio-util-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tokio-util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+tokio-util-devel.sha256sum] = "93ea8762bd1ce5e6892c813417e4e0c933fe8e0904a5ebf6763bfa1e4698139c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tower-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tower-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+tower-devel.sha256sum] = "d10d26ab688a1810f85a91f6a7373b6e9e6cd18346c9f554aa74129ca7788b9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+trace-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+trace-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+trace-devel.sha256sum] = "b542c2bba345a7d345b3de88bd3ac10e26063aabda5a0938a4c6b1afc88bfef3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+tracing-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+tracing-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+tracing-devel.sha256sum] = "48d58a0f9cd7802305aceee677258369ec09fb55e128346a5ce09d03d8a2987f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+util-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+util-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+util-devel.sha256sum] = "1ed968e01652f502fa60ecd2fbabec87f59e1dfd380c37f52ff4cc20c7c5fe70"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+uuid-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+uuid-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+uuid-devel.sha256sum] = "70d86cef1f45a5c6167b3d91e7118b59af5f43b289b0e883ab791e4ac87331a3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http+validate-request-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http+validate-request-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http+validate-request-devel.sha256sum] = "d0f5b77ddfcf89fff3decba4663a08c30699d4d3af37bf1fe76a2dfdcf3236de"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tower-http-devel-0.6.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tower-http-devel;unpack=0"
SRC_URI[x86_64_v2_rust-tower-http-devel.sha256sum] = "cc914f0cb16a429ec109e35d5f728f739f559233e2a60e088b9f18f18c424fe6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+add-extension-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+add-extension-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+add-extension-devel.sha256sum] = "5cd7126faaa0d747485928e803128928fc92f88c2db1c79b00887b7e1e762f83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+async-compression-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+async-compression-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+async-compression-devel.sha256sum] = "cb9e00c2985ff256b92ab89a83934f84c8b37645f82a5d2821a5a4529e70ec95"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+auth-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+auth-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+auth-devel.sha256sum] = "903549652280088e476df88f7322f79cbb10d5535ac4b84e08ca056eb0deb986"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+base64-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+base64-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+base64-devel.sha256sum] = "35d6e2f2cc7544777244026294fa8604953b1e19ea341288152417d9d3b047aa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+catch-panic-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+catch-panic-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+catch-panic-devel.sha256sum] = "5dfc5c8369d99c345b41ec36891523e17cb8cbe0ea9c29f3c25610614cd0e019"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-br-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-br-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+compression-br-devel.sha256sum] = "3388308f86487d372291c40562c3f0a7c89d127d6b1bd6a1bd46d68d359a172d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-deflate-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-deflate-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+compression-deflate-devel.sha256sum] = "f843a7a76ba1f58688df9d028b665fc6d4aa74d60b7d3242fe2c62bacdc09add"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-full-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-full-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+compression-full-devel.sha256sum] = "db9b1204f9855bc907729945a44a4e13c2b180fe778b7a232e3a43802d31a06d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-gzip-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-gzip-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+compression-gzip-devel.sha256sum] = "654d4e55546f6525a1e3372550308dc273e2727e2f8516556d9f2e733b7ae928"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+compression-zstd-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+compression-zstd-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+compression-zstd-devel.sha256sum] = "c44e57ce2ad8279ccf96efba03b0565642d1cc2eadd5e1df37e7455a36a3c336"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+cors-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+cors-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+cors-devel.sha256sum] = "7cc592c06e277b33e60d08a0f0bc5ef8f36e3e5658a7985d3b88e7aed8039194"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-br-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-br-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+decompression-br-devel.sha256sum] = "16d109f6974257b3bf1ea28021fe44b41dfdc9e31fa919657f59b85c50a398f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-deflate-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-deflate-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+decompression-deflate-devel.sha256sum] = "a7135067096804f0516463bc870b6092a372c564431bfe6f37ec8616acf1a73d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-full-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-full-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+decompression-full-devel.sha256sum] = "efc19cc336b41f2fc35d34e6d32f02ae25adbf06be403f1c0c728cdee1175cd3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-gzip-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-gzip-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+decompression-gzip-devel.sha256sum] = "f46a233c3a67d16350fdfe1d4b5f6f5bd3d1fa7d9c5fb12d98210f64c450a5b1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+decompression-zstd-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+decompression-zstd-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+decompression-zstd-devel.sha256sum] = "d32e34c812d310d670848a36659cf9afc17544207ef558f01c7765176db8e7a0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+default-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+default-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+default-devel.sha256sum] = "a388012a635bb30a769e19f1ef9b61f1c48c95d483225d258f0acdd291f38075"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+follow-redirect-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+follow-redirect-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+follow-redirect-devel.sha256sum] = "9e5c019c25c16202441625630a3d7aedd9536dcc903794167e08e6081b615da7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+fs-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+fs-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+fs-devel.sha256sum] = "c43e713cf2eed737455b46cbcfc68136b6d2f74251bbe1e51f8a3eecd800be56"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+full-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+full-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+full-devel.sha256sum] = "1616bf594a3e70ba6ca463f3bba32b86f5b2099d490a3f58d15f934bfbcce965"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+futures-core-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+futures-core-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+futures-core-devel.sha256sum] = "8cd7f0b43ad7105b081cade97554d6ae8a2add02525a2c79d149d90476c8f457"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+futures-util-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+futures-util-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+futures-util-devel.sha256sum] = "9e08145dbf01e47c66dca9cb5038135bc6a58cee8b44e14af0ad4085aa918eee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+httpdate-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+httpdate-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+httpdate-devel.sha256sum] = "b9a898743274f07ae2dfb21d12a40e463385769e0c1d36c936d6057c34f2677a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+limit-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+limit-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+limit-devel.sha256sum] = "78ca5cc6a049d2e7641cc187f38c32b01fddfd1ed528bc9edf292971435adeb5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+map-request-body-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+map-request-body-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+map-request-body-devel.sha256sum] = "c64b68dd35944bcf556623b9c0d75cc90973964f7b16d4000e1527aded023a2c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+map-response-body-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+map-response-body-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+map-response-body-devel.sha256sum] = "df00afa561c0a7ac0ca8008063b12c281cfe8a9c125f6a06459bd9edeab91a3c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+metrics-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+metrics-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+metrics-devel.sha256sum] = "87e48d0bc0b8c264c297aa4751c9454517bc07d9b73df1c6ce93b9cefb98f14d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+mime-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+mime-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+mime-devel.sha256sum] = "44fab2b6b1297849b3c18a2d671a28a56cb811c3284d73dff8b740c34afafb70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+mime_guess-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+mime_guess-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+mime_guess-devel.sha256sum] = "dd7ed80c6318bd4cfed93140a3faae06fc1970649bbc8110e75fa53b39230e4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+normalize-path-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+normalize-path-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+normalize-path-devel.sha256sum] = "81bebc132a6404af3701c836fc49e73f3b6976a6dc0629d2b190bc13110a1ae5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+on-early-drop-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+on-early-drop-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+on-early-drop-devel.sha256sum] = "4f414b6c1624ec9d8216297dc15e876be3038eddf9959a553492fda424aa2788"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+percent-encoding-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+percent-encoding-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+percent-encoding-devel.sha256sum] = "639531002f593128283e9ff5142c49809ab1ec6d37d0a04994b2be6e1900038d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+propagate-header-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+propagate-header-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+propagate-header-devel.sha256sum] = "80ffc2437b9c4231e548b0a973d4550bff08f24cb29d7f7a46aaecf93bd96046"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+redirect-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+redirect-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+redirect-devel.sha256sum] = "ccbad209af9a35ad71a8aed1a84e221dcfad35f58c82d39284ca5314c7de3265"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+request-id-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+request-id-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+request-id-devel.sha256sum] = "e8dbf24c62e4e893de18e5722cde7ba17d88f03d42838e58aaad4e9907759a61"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+sensitive-headers-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+sensitive-headers-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+sensitive-headers-devel.sha256sum] = "258fd4d344fbb3ac58175e927107863e33476d87e24395febe3e2d2185fa7d48"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+set-header-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+set-header-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+set-header-devel.sha256sum] = "f02636210deff4cc5f0fd7f3e6c0074a5e8e2ec8ead65696d53744b8c908d300"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+set-status-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+set-status-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+set-status-devel.sha256sum] = "5740b1443e0afc909a3089b6bcd297c10f5dc612703951542ae178f2f509bb99"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+timeout-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+timeout-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+timeout-devel.sha256sum] = "f24ff723c9fdcba80f88d1ca33d0101d9e4272f04535f715d827d4749352dbdb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tokio-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+tokio-devel.sha256sum] = "8ed1dd7da352e641e39bd5b66a84cac91beff322f600ed6e795add9799f8bb21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tokio-util-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+tokio-util-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+tokio-util-devel.sha256sum] = "1b199a587755f242844b0f9be779c732ea7761349f4f134bf0e44a6e61e90ae4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tower-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+tower-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+tower-devel.sha256sum] = "211b7e75fe410050d91d385671242d2961edffc0478061f4aa75926ad78766d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+trace-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+trace-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+trace-devel.sha256sum] = "b76f039ffcdc0b0f4aa8ed627ea8b5747f91795d962a6b5724a8a3995d663315"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+tracing-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+tracing-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+tracing-devel.sha256sum] = "9378564b87dd9c2654d96daa65f0ed7506d398d648c5dd2c4d13f12365043ced"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+util-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+util-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+util-devel.sha256sum] = "b3eb6e66c5360861fceb1a0a2b319fac1ffa6d488ffef61268fa18e366b3e7a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+uuid-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+uuid-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+uuid-devel.sha256sum] = "74ccd5973b76f987af0e773b3dd2ab3d52dc996d7ddbbb2a27255986a5b1faeb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http+validate-request-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http+validate-request-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http+validate-request-devel.sha256sum] = "21f3bc0363062dfe5f061ecfdb732e2ea89300a7d9ffe0bbae89a90fd62438db"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-tower-http-devel-0.6.11-1.el10_2.noarch.rpm;name=aarch64_rust-tower-http-devel;unpack=0"
SRC_URI[aarch64_rust-tower-http-devel.sha256sum] = "7b112e2e0065aa312f7c100b6b853134cf285d0424261675ad5822dcc6dee785"

RDEPENDS:rust-tower-http+add-extension-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+async-compression-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+auth-devel = " \
 cargo \
 rust-tower-http+base64-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+catch-panic-devel = " \
 cargo \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-br-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-tokio-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-deflate-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-http-body+default-devel \
 rust-tokio-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-full-devel = " \
 cargo \
 rust-tower-http+compression-br-devel \
 rust-tower-http+compression-deflate-devel \
 rust-tower-http+compression-gzip-devel \
 rust-tower-http+compression-zstd-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-gzip-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-tokio-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+compression-zstd-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-http-body+default-devel \
 rust-tokio-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+cors-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-br-devel = " \
 cargo \
 rust-async-compression+brotli-devel \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tokio-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-deflate-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zlib-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tokio-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-full-devel = " \
 cargo \
 rust-tower-http+decompression-br-devel \
 rust-tower-http+decompression-deflate-devel \
 rust-tower-http+decompression-gzip-devel \
 rust-tower-http+decompression-zstd-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-gzip-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+gzip-devel \
 rust-async-compression+tokio-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tokio-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+decompression-zstd-devel = " \
 cargo \
 rust-async-compression+default-devel \
 rust-async-compression+tokio-devel \
 rust-async-compression+zstd-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tokio-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+default-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+follow-redirect-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tower+default-devel \
 rust-tower+util-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-tower-http+fs-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-http-range-header+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 rust-tower-http+futures-core-devel \
 rust-tower-http+futures-util-devel \
 rust-tower-http+httpdate-devel \
 rust-tower-http+mime-devel \
 rust-tower-http+mime_guess-devel \
 rust-tower-http+percent-encoding-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+full-devel = " \
 cargo \
 rust-tower-http+add-extension-devel \
 rust-tower-http+auth-devel \
 rust-tower-http+catch-panic-devel \
 rust-tower-http+compression-full-devel \
 rust-tower-http+cors-devel \
 rust-tower-http+decompression-full-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http+fs-devel \
 rust-tower-http+limit-devel \
 rust-tower-http+map-request-body-devel \
 rust-tower-http+map-response-body-devel \
 rust-tower-http+metrics-devel \
 rust-tower-http+normalize-path-devel \
 rust-tower-http+on-early-drop-devel \
 rust-tower-http+propagate-header-devel \
 rust-tower-http+redirect-devel \
 rust-tower-http+request-id-devel \
 rust-tower-http+sensitive-headers-devel \
 rust-tower-http+set-header-devel \
 rust-tower-http+set-status-devel \
 rust-tower-http+timeout-devel \
 rust-tower-http+trace-devel \
 rust-tower-http+util-devel \
 rust-tower-http+validate-request-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+futures-core-devel = " \
 cargo \
 rust-futures-core-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+futures-util-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+httpdate-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+limit-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+map-request-body-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+map-response-body-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+metrics-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+mime-devel = " \
 cargo \
 rust-mime-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+mime_guess-devel = " \
 cargo \
 rust-mime_guess-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+normalize-path-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+on-early-drop-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+percent-encoding-devel = " \
 cargo \
 rust-percent-encoding+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+propagate-header-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+redirect-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+request-id-devel = " \
 cargo \
 rust-tower-http+uuid-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+sensitive-headers-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+set-header-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+set-status-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+timeout-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tokio-devel = " \
 cargo \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tokio-util-devel = " \
 cargo \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tower-devel = " \
 cargo \
 rust-tower+default-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+trace-devel = " \
 cargo \
 rust-http-body+default-devel \
 rust-tower-http+tracing-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+tracing-devel = " \
 cargo \
 rust-tower-http-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tower-http+util-devel = " \
 cargo \
 rust-tower-http+tower-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http+uuid-devel = " \
 cargo \
 rust-tower-http-devel \
 rust-uuid+default-devel \
 rust-uuid+v4-devel \
 "
RDEPENDS:rust-tower-http+validate-request-devel = " \
 cargo \
 rust-tower-http+mime-devel \
 rust-tower-http-devel \
 "
RDEPENDS:rust-tower-http-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tower-layer+default-devel \
 rust-tower-service+default-devel \
 "
