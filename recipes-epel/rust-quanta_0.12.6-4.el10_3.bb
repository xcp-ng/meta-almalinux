# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quanta"
PV = "0.12.6"
PR = "4.el10_3"
PACKAGES = " \
 rust-quanta+default-devel \
 rust-quanta+flaky_tests-devel \
 rust-quanta+prost-devel \
 rust-quanta+prost-types-devel \
 rust-quanta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quanta-0.12.6-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8783b8155886d21db7d68c7e4f8fa79d0f08a62f4e6af0e887f324504b3b7b51"

URI_x86_64_v2_rust-quanta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta+default-devel-0.12.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta+default-devel}"
SRC_URI[x86_64_v2_rust-quanta+default-devel.sha256sum] = "6d0dc4e2a89ca4e393a1d2fded54cf6481bde8060ea7c425f8a7967e7cc40a1e"

URI_x86_64_v2_rust-quanta+flaky_tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta+flaky_tests-devel-0.12.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta+flaky_tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta+flaky_tests-devel}"
SRC_URI[x86_64_v2_rust-quanta+flaky_tests-devel.sha256sum] = "bae8f9365e10023be6ba4571f25fc616e4fb13781ef7eab94842090bd1bfcb90"

URI_x86_64_v2_rust-quanta+prost-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta+prost-devel-0.12.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta+prost-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta+prost-devel}"
SRC_URI[x86_64_v2_rust-quanta+prost-devel.sha256sum] = "139c9a2e5a6d70332370914a1656bff74d7b2fb0055d33c266b830e56eb91da7"

URI_x86_64_v2_rust-quanta+prost-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta+prost-types-devel-0.12.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta+prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta+prost-types-devel}"
SRC_URI[x86_64_v2_rust-quanta+prost-types-devel.sha256sum] = "ef376cd5aae5d3c2df1e499957683cdbfc5c3c9bacf04b110dee4643ed88ae98"

URI_x86_64_v2_rust-quanta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quanta-devel-0.12.6-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quanta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quanta-devel}"
SRC_URI[x86_64_v2_rust-quanta-devel.sha256sum] = "b833095485ca5ee6b0d2137df0be7b234c37a3334ffd682c352123737d7678ed"

URI_aarch64_rust-quanta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta+default-devel-0.12.6-4.el10_3.noarch.rpm;name=aarch64_rust-quanta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta+default-devel}"
SRC_URI[aarch64_rust-quanta+default-devel.sha256sum] = "c7ca0e3612d53990e810280c5f3c49a14f7f73983f6dd2214b5cb14f086664e4"

URI_aarch64_rust-quanta+flaky_tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta+flaky_tests-devel-0.12.6-4.el10_3.noarch.rpm;name=aarch64_rust-quanta+flaky_tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta+flaky_tests-devel}"
SRC_URI[aarch64_rust-quanta+flaky_tests-devel.sha256sum] = "02346bdf95cd4452ba3f12a0ce63748ff871edb350de193a82fbf618ed83decd"

URI_aarch64_rust-quanta+prost-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta+prost-devel-0.12.6-4.el10_3.noarch.rpm;name=aarch64_rust-quanta+prost-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta+prost-devel}"
SRC_URI[aarch64_rust-quanta+prost-devel.sha256sum] = "6af203940ad55e8dadd9418d09eccf573951a0a18e28f50cff089183ef7e1e88"

URI_aarch64_rust-quanta+prost-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta+prost-types-devel-0.12.6-4.el10_3.noarch.rpm;name=aarch64_rust-quanta+prost-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta+prost-types-devel}"
SRC_URI[aarch64_rust-quanta+prost-types-devel.sha256sum] = "052668cab38c59b6c5b337f3f09e2e640920024cf27ae11100e5042c268dbdf0"

URI_aarch64_rust-quanta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quanta-devel-0.12.6-4.el10_3.noarch.rpm;name=aarch64_rust-quanta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quanta-devel}"
SRC_URI[aarch64_rust-quanta-devel.sha256sum] = "2a0b6194d44fd1c05b4874c01d2bb7e791a4649d4c9096a3c9b070020fcfdcdd"

RDEPENDS:rust-quanta+default-devel = " \
 cargo \
 rust-quanta-devel \
 "
RDEPENDS:rust-quanta+flaky_tests-devel = " \
 cargo \
 rust-quanta-devel \
 "
RDEPENDS:rust-quanta+prost-devel = " \
 cargo \
 rust-quanta+prost-types-devel \
 rust-quanta-devel \
 "
RDEPENDS:rust-quanta+prost-types-devel = " \
 cargo \
 rust-prost-types-devel \
 rust-quanta-devel \
 "
RDEPENDS:rust-quanta-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 rust-raw-cpuid+default-devel \
 "
