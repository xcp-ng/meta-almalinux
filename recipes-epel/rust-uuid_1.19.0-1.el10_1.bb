# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uuid"
PV = "1.19.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-uuid+arbitrary-devel \
 rust-uuid+atomic-devel \
 rust-uuid+bytemuck-devel \
 rust-uuid+default-devel \
 rust-uuid+fast-rng-devel \
 rust-uuid+md5-devel \
 rust-uuid+rng-devel \
 rust-uuid+rng-getrandom-devel \
 rust-uuid+rng-rand-devel \
 rust-uuid+serde-devel \
 rust-uuid+sha1-devel \
 rust-uuid+slog-devel \
 rust-uuid+std-devel \
 rust-uuid+v1-devel \
 rust-uuid+v3-devel \
 rust-uuid+v4-devel \
 rust-uuid+v5-devel \
 rust-uuid+v6-devel \
 rust-uuid+v7-devel \
 rust-uuid+v8-devel \
 rust-uuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uuid-1.19.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80b3f714e6dc42143b9429eef5d5e9c47454931d2df6b4d526901506f7bbd8c7"

URI_x86_64_v2_rust-uuid+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+arbitrary-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-uuid+arbitrary-devel.sha256sum] = "a00b94d89de838360ecef1af614d32f270085319e9da6e1a0703d6e09a1bce06"

URI_x86_64_v2_rust-uuid+atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+atomic-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+atomic-devel}"
SRC_URI[x86_64_v2_rust-uuid+atomic-devel.sha256sum] = "107b543f0fe8502a3bb7e20877a7343ad04c1d5489ee6135112d8d6f02c8f9f2"

URI_x86_64_v2_rust-uuid+bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+bytemuck-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+bytemuck-devel}"
SRC_URI[x86_64_v2_rust-uuid+bytemuck-devel.sha256sum] = "c0627b2d8244ba3423e5b72c6365caf90240eb65d729d2f49beb69e15bdac74e"

URI_x86_64_v2_rust-uuid+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+default-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+default-devel}"
SRC_URI[x86_64_v2_rust-uuid+default-devel.sha256sum] = "03a8aca55267e999cd79cce9930144099be164c7fed2e5837d486d3782bc28eb"

URI_x86_64_v2_rust-uuid+fast-rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+fast-rng-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+fast-rng-devel}"
SRC_URI[x86_64_v2_rust-uuid+fast-rng-devel.sha256sum] = "6ae5a95cb08fc1877d86caf2de6826c81193efd477c1267fc247a79790702b62"

URI_x86_64_v2_rust-uuid+md5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+md5-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+md5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+md5-devel}"
SRC_URI[x86_64_v2_rust-uuid+md5-devel.sha256sum] = "7fdf98c669704ef01b3f5a383bbf6536f4d8eea7c1d0ba96e933834195fea720"

URI_x86_64_v2_rust-uuid+rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-devel.sha256sum] = "0e7fcee415af3651f57a5590074171a7684fa8c74ac9081624b2b82af0025124"

URI_x86_64_v2_rust-uuid+rng-getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-getrandom-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-getrandom-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-getrandom-devel.sha256sum] = "47bfa7e7dedd587a89d2d2f7a7196a13800b13cb96902428ee6c3e3bbec78f09"

URI_x86_64_v2_rust-uuid+rng-rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+rng-rand-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+rng-rand-devel}"
SRC_URI[x86_64_v2_rust-uuid+rng-rand-devel.sha256sum] = "fbc982b547eb3f542ac48cc2610a28017663b1db9a53f6c11ab36064fcb184f0"

URI_x86_64_v2_rust-uuid+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+serde-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+serde-devel}"
SRC_URI[x86_64_v2_rust-uuid+serde-devel.sha256sum] = "4cd7cf62a1637b1422384f131112802f2f72b0bf86d64c9393942d568966c735"

URI_x86_64_v2_rust-uuid+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+sha1-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+sha1-devel}"
SRC_URI[x86_64_v2_rust-uuid+sha1-devel.sha256sum] = "3fb1a392da32b150d97c516001a9c30d9f914514017f93cd669d7e509629c96f"

URI_x86_64_v2_rust-uuid+slog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+slog-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+slog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+slog-devel}"
SRC_URI[x86_64_v2_rust-uuid+slog-devel.sha256sum] = "a07ba98642d7edceeb7bba3e8a6f67fe1a80e0d99b4479b63973833762b7613b"

URI_x86_64_v2_rust-uuid+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+std-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+std-devel}"
SRC_URI[x86_64_v2_rust-uuid+std-devel.sha256sum] = "7e771ea950e33fde4123231e85ae15cd21b8309e06a333edccdecd433bd7cbb8"

URI_x86_64_v2_rust-uuid+v1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v1-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v1-devel}"
SRC_URI[x86_64_v2_rust-uuid+v1-devel.sha256sum] = "5f3e06cab9610bfa194c3e8abd0a98c0269dfdb916b72d85499ae7706fadf32e"

URI_x86_64_v2_rust-uuid+v3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v3-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v3-devel}"
SRC_URI[x86_64_v2_rust-uuid+v3-devel.sha256sum] = "adf4fe685e44a2684975840cf62441cffff7e4069208b9ca7a7f6950113628b2"

URI_x86_64_v2_rust-uuid+v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v4-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v4-devel}"
SRC_URI[x86_64_v2_rust-uuid+v4-devel.sha256sum] = "b99277c4d00cabde0d7f00d344dda291c7fc93e63160c0fdf05c2cad79847328"

URI_x86_64_v2_rust-uuid+v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v5-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v5-devel}"
SRC_URI[x86_64_v2_rust-uuid+v5-devel.sha256sum] = "340fafe8a44edbd8b1b9c30c20b956b6ef904f1ae8bd6f4f32c9e54276bf76ff"

URI_x86_64_v2_rust-uuid+v6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v6-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v6-devel}"
SRC_URI[x86_64_v2_rust-uuid+v6-devel.sha256sum] = "be7fb243c465a4bffe2fa6e5c3d4300a4f2ba1b617a8aa909eab2ae88dd5b4ca"

URI_x86_64_v2_rust-uuid+v7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v7-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v7-devel}"
SRC_URI[x86_64_v2_rust-uuid+v7-devel.sha256sum] = "76a30cbe3c87747dff2ec15217d0ede79a4c17b3b7b9348a27d8ca0681fc6fcd"

URI_x86_64_v2_rust-uuid+v8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid+v8-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid+v8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid+v8-devel}"
SRC_URI[x86_64_v2_rust-uuid+v8-devel.sha256sum] = "b6ee0164b37a6a5ba3154c348536d5faec6d108ec1c34cfe4a984447628be17e"

URI_x86_64_v2_rust-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uuid-devel-1.19.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uuid-devel}"
SRC_URI[x86_64_v2_rust-uuid-devel.sha256sum] = "035181a21e763582784639bdc4eb87be7036c78151730948647d824ee6c7545d"

URI_aarch64_rust-uuid+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+arbitrary-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+arbitrary-devel}"
SRC_URI[aarch64_rust-uuid+arbitrary-devel.sha256sum] = "e659174966507107993a946b0b7a8cbd0e5609b781beba58643a7b9e9a369094"

URI_aarch64_rust-uuid+atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+atomic-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+atomic-devel}"
SRC_URI[aarch64_rust-uuid+atomic-devel.sha256sum] = "00fab49da69b45ee3f8c8af52b21ab3a07af79bf32e6e86f59f0adf5630429fb"

URI_aarch64_rust-uuid+bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+bytemuck-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+bytemuck-devel}"
SRC_URI[aarch64_rust-uuid+bytemuck-devel.sha256sum] = "382739c000e495ea106def76d297dd1f382642fd2e8fd56b9a260c60dd0de537"

URI_aarch64_rust-uuid+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+default-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+default-devel}"
SRC_URI[aarch64_rust-uuid+default-devel.sha256sum] = "3054ceed9f959512c219eeda812850f473ed5b3682d901119a495acd1d59c072"

URI_aarch64_rust-uuid+fast-rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+fast-rng-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+fast-rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+fast-rng-devel}"
SRC_URI[aarch64_rust-uuid+fast-rng-devel.sha256sum] = "dce2b3ccb98462c247ea2fedd07c1af991a9ad196ed2ad19219e3a287508d221"

URI_aarch64_rust-uuid+md5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+md5-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+md5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+md5-devel}"
SRC_URI[aarch64_rust-uuid+md5-devel.sha256sum] = "b2199558a7ccb5975a0347d377afec8690f82ade5d16de2f9acdd93a6b3c3af5"

URI_aarch64_rust-uuid+rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-devel}"
SRC_URI[aarch64_rust-uuid+rng-devel.sha256sum] = "7c81a93ff007aabda14164946cb2a78a39b6d91fe7dc6505ad80d14507a212f8"

URI_aarch64_rust-uuid+rng-getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-getrandom-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+rng-getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-getrandom-devel}"
SRC_URI[aarch64_rust-uuid+rng-getrandom-devel.sha256sum] = "286766c9a56d5839437cdba05c7f929f08b0b99514994428d456c1e7e1175122"

URI_aarch64_rust-uuid+rng-rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+rng-rand-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+rng-rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+rng-rand-devel}"
SRC_URI[aarch64_rust-uuid+rng-rand-devel.sha256sum] = "af469317e943d9e24163c73bcb8a997429ad60e3a64290f0345b24ccd46edfdb"

URI_aarch64_rust-uuid+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+serde-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+serde-devel}"
SRC_URI[aarch64_rust-uuid+serde-devel.sha256sum] = "784025dbaf6752b94a67769b07390aaa640d0ae98fd3777cc605ce677f0aeb80"

URI_aarch64_rust-uuid+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+sha1-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+sha1-devel}"
SRC_URI[aarch64_rust-uuid+sha1-devel.sha256sum] = "eab835b2df09b45d6beb9f8642ee5b14fd96883ae47bfef212e743475a22210a"

URI_aarch64_rust-uuid+slog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+slog-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+slog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+slog-devel}"
SRC_URI[aarch64_rust-uuid+slog-devel.sha256sum] = "56f63a54799aebc934b29f529bb8ba3a746c1927bb0d1eed6f2b913826941c97"

URI_aarch64_rust-uuid+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+std-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+std-devel}"
SRC_URI[aarch64_rust-uuid+std-devel.sha256sum] = "4efff98ba111522db5a882afe3aba0af48448c6c03f3952dc5a907227e9a0646"

URI_aarch64_rust-uuid+v1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v1-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+v1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v1-devel}"
SRC_URI[aarch64_rust-uuid+v1-devel.sha256sum] = "77a48a087bdd8604ac5c93185e9ef20dd4ca6f5aa160ef72b3ad49e94404e0ac"

URI_aarch64_rust-uuid+v3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v3-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+v3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v3-devel}"
SRC_URI[aarch64_rust-uuid+v3-devel.sha256sum] = "90c3226ae84286f40f85be7334df1311051147c08856cfdeb4556a38f6cacd6d"

URI_aarch64_rust-uuid+v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v4-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v4-devel}"
SRC_URI[aarch64_rust-uuid+v4-devel.sha256sum] = "26692aba901a34232940ca26f73892134c940c519cfb82971ba8e7fa94b3ebd9"

URI_aarch64_rust-uuid+v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v5-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v5-devel}"
SRC_URI[aarch64_rust-uuid+v5-devel.sha256sum] = "c6c36aadbfcb7b128a6559b48cf724410b3973ff4a729ae6f439d6ed99fc1b59"

URI_aarch64_rust-uuid+v6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v6-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+v6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v6-devel}"
SRC_URI[aarch64_rust-uuid+v6-devel.sha256sum] = "14e6fe36ca48484f6c499e936d2fc4a6ae6a75f621bc25c46273399adf98954e"

URI_aarch64_rust-uuid+v7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v7-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+v7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v7-devel}"
SRC_URI[aarch64_rust-uuid+v7-devel.sha256sum] = "2e929843bd8bccd23e201f2a1477ce57bf8f3a9ce50e01e77c7280575bfb782b"

URI_aarch64_rust-uuid+v8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid+v8-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid+v8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid+v8-devel}"
SRC_URI[aarch64_rust-uuid+v8-devel.sha256sum] = "99708ab998181590e1be525f3d968a452c573e363388dcd87581e343d77ea6c4"

URI_aarch64_rust-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uuid-devel-1.19.0-1.el10_1.noarch.rpm;name=aarch64_rust-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uuid-devel}"
SRC_URI[aarch64_rust-uuid-devel.sha256sum] = "a3c51a6ae65b8561e3c906a19f44c87bec3290853bdab17f1bd7e3c7f24a1032"

RDEPENDS:rust-uuid+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+atomic-devel = " \
 cargo \
 rust-atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+bytemuck-devel = " \
 cargo \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+default-devel = " \
 cargo \
 rust-uuid+std-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+fast-rng-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+md5-devel = " \
 cargo \
 rust-md-5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-getrandom-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+rng-rand-devel = " \
 cargo \
 rust-rand+default-devel \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+sha1-devel = " \
 cargo \
 rust-sha1_smol-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+slog-devel = " \
 cargo \
 rust-slog+default-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+std-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v1-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v3-devel = " \
 cargo \
 rust-uuid+md5-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v4-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v5-devel = " \
 cargo \
 rust-uuid+sha1-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v6-devel = " \
 cargo \
 rust-uuid+atomic-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v7-devel = " \
 cargo \
 rust-uuid+rng-devel \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid+v8-devel = " \
 cargo \
 rust-uuid-devel \
 "
RDEPENDS:rust-uuid-devel = " \
 cargo \
 rust \
 "
