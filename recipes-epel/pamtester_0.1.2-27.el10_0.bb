# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pamtester"
PV = "0.1.2"
PR = "27.el10_0"
PACKAGES = " \
 pamtester \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pamtester-0.1.2-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42da991e1c067cac414a3c481f50434f967eb061f518c3da5434c94f8b45b7a8"

URI_x86_64_v2_pamtester = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pamtester-0.1.2-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pamtester;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pamtester}"
SRC_URI[x86_64_v2_pamtester.sha256sum] = "335075c31ce2332590db4d7070146d446175167c0d741eba9a5da0f1a05b232b"

URI_aarch64_pamtester = "${EPEL_MIRROR}/aarch64/Packages/p/pamtester-0.1.2-27.el10_0.aarch64.rpm;name=aarch64_pamtester;unpack=0"
SRC_URI:append = " ${URI_aarch64_pamtester}"
SRC_URI[aarch64_pamtester.sha256sum] = "b4c3d75022bef9b538ff7d69a89acda9d9b154261984898da570e16bd387f799"

RDEPENDS:pamtester = " \
 glibc \
 pam-libs \
 "
