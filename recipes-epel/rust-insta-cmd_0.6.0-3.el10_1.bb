# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-insta-cmd"
PV = "0.6.0"
PR = "3.el10_1"
PACKAGES = " \
 rust-insta-cmd+default-devel \
 rust-insta-cmd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-insta-cmd-0.6.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab63ed58345e270731e3f1aad3f41beecb93c91dfb682c393b40228d622e3dee"

URI_x86_64_v2_rust-insta-cmd+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta-cmd+default-devel-0.6.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta-cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta-cmd+default-devel}"
SRC_URI[x86_64_v2_rust-insta-cmd+default-devel.sha256sum] = "8ccb5c5e6f3d1a7aca0aa0e4a4183ad5fac41cdf6f181fe7d7809a58086b85fd"

URI_x86_64_v2_rust-insta-cmd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-insta-cmd-devel-0.6.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-insta-cmd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-insta-cmd-devel}"
SRC_URI[x86_64_v2_rust-insta-cmd-devel.sha256sum] = "3e36a0298b1941f1dc2af16f4a7223ae8a8d8984dd53261f65df93daec76dc43"

URI_aarch64_rust-insta-cmd+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta-cmd+default-devel-0.6.0-3.el10_1.noarch.rpm;name=aarch64_rust-insta-cmd+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta-cmd+default-devel}"
SRC_URI[aarch64_rust-insta-cmd+default-devel.sha256sum] = "d6aaa9ec9d4db89cde8608197de036ac0c81d02d236ff9cd05d8736528af4583"

URI_aarch64_rust-insta-cmd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-insta-cmd-devel-0.6.0-3.el10_1.noarch.rpm;name=aarch64_rust-insta-cmd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-insta-cmd-devel}"
SRC_URI[aarch64_rust-insta-cmd-devel.sha256sum] = "8673e49d618c16d67c65a9cd92624357bb27416610b7e060d7e49c67bf3b6ca0"

RDEPENDS:rust-insta-cmd+default-devel = " \
 cargo \
 rust-insta-cmd-devel \
 "
RDEPENDS:rust-insta-cmd-devel = " \
 cargo \
 rust \
 rust-insta+default-devel \
 rust-insta+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
