# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdiamond"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kdiamond \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kdiamond-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1c38e0b694a589dd300b8ce30c4dff39a642d62b48b95d58fab39e41cfa445fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiamond-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiamond;unpack=0"
SRC_URI[x86_64_v2_kdiamond.sha256sum] = "97c60cefb9eeb5233bab9fbf2998cc60fa1369c6fcde9f40b979c19e5bbdd7a1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kdiamond-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kdiamond;unpack=0"
SRC_URI[aarch64_kdiamond.sha256sum] = "a0ca56174c75309f033ab4d1bdbbf765b36c0ddc7833f57245b81fa5d0bc568a"

RDEPENDS:kdiamond = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
