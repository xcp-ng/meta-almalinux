# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arcstr"
PV = "1.2.0"
PR = "5.el10_2"
PACKAGES = " \
 rust-arcstr+default-devel \
 rust-arcstr+serde-devel \
 rust-arcstr+std-devel \
 rust-arcstr+substr-devel \
 rust-arcstr+substr-usize-indices-devel \
 rust-arcstr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arcstr-1.2.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0bbc70f90b45470bb2308824062333729bffb039e1792a121015f0bd9a2a6ce"

URI_x86_64_v2_rust-arcstr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+default-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+default-devel}"
SRC_URI[x86_64_v2_rust-arcstr+default-devel.sha256sum] = "cf0aee3818fc976ab2fa5e760d256413b49b2d5b48f90daca92b86679778c3d2"

URI_x86_64_v2_rust-arcstr+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+serde-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+serde-devel}"
SRC_URI[x86_64_v2_rust-arcstr+serde-devel.sha256sum] = "a477016bc7e403afca15bb2defc35193c900e980bba02df2e26ebd73ca7a15f2"

URI_x86_64_v2_rust-arcstr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+std-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+std-devel}"
SRC_URI[x86_64_v2_rust-arcstr+std-devel.sha256sum] = "c0a1664936132cc65eb7dc01e43f0ff40f5ae95276cbc2618fb983bba7d00d36"

URI_x86_64_v2_rust-arcstr+substr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+substr-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+substr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+substr-devel}"
SRC_URI[x86_64_v2_rust-arcstr+substr-devel.sha256sum] = "74383f91df2138c3473c3ccfc6db9efdbcd7ea75fde354b79de88530244a5b0b"

URI_x86_64_v2_rust-arcstr+substr-usize-indices-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr+substr-usize-indices-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr+substr-usize-indices-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr+substr-usize-indices-devel}"
SRC_URI[x86_64_v2_rust-arcstr+substr-usize-indices-devel.sha256sum] = "b5c522290dd03046d8cb1523ac0515cda1eca1f0b6b54420ea674999e465abfa"

URI_x86_64_v2_rust-arcstr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arcstr-devel-1.2.0-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arcstr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arcstr-devel}"
SRC_URI[x86_64_v2_rust-arcstr-devel.sha256sum] = "c596a734692f0cd5dadeb00a7795944f64e948ba6aa41d1321af3e943467ad99"

URI_aarch64_rust-arcstr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+default-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-arcstr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+default-devel}"
SRC_URI[aarch64_rust-arcstr+default-devel.sha256sum] = "5470fda0fdedb041fb72ec9b06e74957992b9e9c476302b065fc28c8e33f7c21"

URI_aarch64_rust-arcstr+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+serde-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-arcstr+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+serde-devel}"
SRC_URI[aarch64_rust-arcstr+serde-devel.sha256sum] = "aae496efbf41dab02fa3a94aa3648aea28723ce02fdd4e10f6fd4aca59e674f8"

URI_aarch64_rust-arcstr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+std-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-arcstr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+std-devel}"
SRC_URI[aarch64_rust-arcstr+std-devel.sha256sum] = "4c8ac879b7cdc4a9d2e59290d9d711541fe58e8bf67d13d3dfe9ed8d4a85ad72"

URI_aarch64_rust-arcstr+substr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+substr-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-arcstr+substr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+substr-devel}"
SRC_URI[aarch64_rust-arcstr+substr-devel.sha256sum] = "db85c11ced09d55ffd4e64c27a34a98060c9e96ff52ff90ff9f6001cc7cbf9ef"

URI_aarch64_rust-arcstr+substr-usize-indices-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr+substr-usize-indices-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-arcstr+substr-usize-indices-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr+substr-usize-indices-devel}"
SRC_URI[aarch64_rust-arcstr+substr-usize-indices-devel.sha256sum] = "7b42d8310092976eab264599e9508316e98a4187019cea1bdbc65bc17d52782a"

URI_aarch64_rust-arcstr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arcstr-devel-1.2.0-5.el10_2.noarch.rpm;name=aarch64_rust-arcstr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arcstr-devel}"
SRC_URI[aarch64_rust-arcstr-devel.sha256sum] = "d1d3bc73926a57e91bf2a7e765f097805e8f6531078e52b10100b3b003834747"

RDEPENDS:rust-arcstr+default-devel = " \
 cargo \
 rust-arcstr+substr-devel \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr+serde-devel = " \
 cargo \
 rust-arcstr-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-arcstr+std-devel = " \
 cargo \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr+substr-devel = " \
 cargo \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr+substr-usize-indices-devel = " \
 cargo \
 rust-arcstr+substr-devel \
 rust-arcstr-devel \
 "
RDEPENDS:rust-arcstr-devel = " \
 cargo \
 rust \
 "
