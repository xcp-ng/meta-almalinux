# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-fo"
PV = "0.20040420"
PR = "29.el10"
PACKAGES = " \
 hyphen-fo \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-fo-0.20040420-29.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff1fab9b2f7c0aaa47c4bdd3803c4fed43d75f88bd2762ffa396f20fcb6e36c4"

URI_x86_64_v2_hyphen-fo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-fo-0.20040420-29.el10.noarch.rpm;name=x86_64_v2_hyphen-fo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hyphen-fo}"
SRC_URI[x86_64_v2_hyphen-fo.sha256sum] = "75d6ba2f1d83c9d147efc3b7c2616c69ed0d18cd48356c1868478b5f03938bc3"

URI_aarch64_hyphen-fo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-fo-0.20040420-29.el10.noarch.rpm;name=aarch64_hyphen-fo;unpack=0"
SRC_URI:append = " ${URI_aarch64_hyphen-fo}"
SRC_URI[aarch64_hyphen-fo.sha256sum] = "75d6ba2f1d83c9d147efc3b7c2616c69ed0d18cd48356c1868478b5f03938bc3"

RDEPENDS:hyphen-fo = " \
 hyphen \
 "
