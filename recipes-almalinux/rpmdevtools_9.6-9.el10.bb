# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpmdevtools"
PV = "9.6"
PR = "9.el10"
PACKAGES = " \
 rpmdevtools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rpmdevtools-9.6-9.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1cde85978848f5f77ccf339e0e4cf0b4792b86a53fd3dea58c31bff4113e1ab3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpmdevtools-9.6-9.el10.noarch.rpm;name=x86_64_v2_rpmdevtools;unpack=0"
SRC_URI[x86_64_v2_rpmdevtools.sha256sum] = "eec8370b135caabd3b4a01aa9c24fdd11549397bf4bf314aded905966b2b899e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpmdevtools-9.6-9.el10.noarch.rpm;name=aarch64_rpmdevtools;unpack=0"
SRC_URI[aarch64_rpmdevtools.sha256sum] = "eec8370b135caabd3b4a01aa9c24fdd11549397bf4bf314aded905966b2b899e"

RDEPENDS:rpmdevtools = " \
 bash \
 curl \
 diffutils \
 emacs-filesystem \
 file \
 findutils \
 gawk \
 grep \
 python3 \
 python3-argcomplete \
 python3-requests \
 python3-rpm \
 rpm-build \
 sed \
 "
