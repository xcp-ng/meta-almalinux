# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tungstenite"
PV = "0.23.0"
PR = "3.el10_1"
PACKAGES = " \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+data-encoding-devel \
 rust-tungstenite+default-devel \
 rust-tungstenite+handshake-devel \
 rust-tungstenite+http-devel \
 rust-tungstenite+httparse-devel \
 rust-tungstenite+native-tls-crate-devel \
 rust-tungstenite+native-tls-devel \
 rust-tungstenite+rustls-devel \
 rust-tungstenite+rustls-native-certs-devel \
 rust-tungstenite+rustls-pki-types-devel \
 rust-tungstenite+rustls-tls-native-roots-devel \
 rust-tungstenite+rustls-tls-webpki-roots-devel \
 rust-tungstenite+sha1-devel \
 rust-tungstenite+url-devel \
 rust-tungstenite+webpki-roots-devel \
 rust-tungstenite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tungstenite-0.23.0-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77ac0bc09ddaf9fc1abb3d3c9a693e29c26e7eb83cc140c9237b4c78bb4cc02b"

URI_x86_64_v2_rust-tungstenite+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+__rustls-tls-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+__rustls-tls-devel.sha256sum] = "6cef89ec037966e000de0af3f9b5a840d4ac118003b80d26d7d58d26c5416384"

URI_x86_64_v2_rust-tungstenite+data-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+data-encoding-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+data-encoding-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+data-encoding-devel.sha256sum] = "e9291fd410c1989993f317c406b74d79421bdaeb779df667d0c90df0a5a2fbb3"

URI_x86_64_v2_rust-tungstenite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+default-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+default-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+default-devel.sha256sum] = "473c126b911c1d5944d4a81fe12fe41ae660368a7ec014de585e4b603b6e13da"

URI_x86_64_v2_rust-tungstenite+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+handshake-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+handshake-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+handshake-devel.sha256sum] = "3e713a51ce428478b91f0f65df32ecea7ea4c707ad3e2aef1777ddf3fe6f30f9"

URI_x86_64_v2_rust-tungstenite+http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+http-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+http-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+http-devel.sha256sum] = "177ec6a99af1b92a26da5ed70483c2ff2073d24fa40d99a62941a45000d0b84f"

URI_x86_64_v2_rust-tungstenite+httparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+httparse-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+httparse-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+httparse-devel.sha256sum] = "db397aef74d8f4e10322aac249bc8851081a649b60842de436d7c2af22999dc4"

URI_x86_64_v2_rust-tungstenite+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+native-tls-crate-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+native-tls-crate-devel.sha256sum] = "d3c72104f9f852b822783c219e330fd7339838f935f6eb78057a23531cf410a9"

URI_x86_64_v2_rust-tungstenite+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+native-tls-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+native-tls-devel.sha256sum] = "837344d48285d27bacbaa358c8ed2be03d9487296f2e96f14c136dad0b2e179a"

URI_x86_64_v2_rust-tungstenite+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-devel.sha256sum] = "674bb617624dc9241968b2e66ffd69d22e23a1f896756dc9ddadd7e17fc4fa1c"

URI_x86_64_v2_rust-tungstenite+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-native-certs-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-native-certs-devel.sha256sum] = "46ef3eed3a654a05fb51d3d4c34f395e2dd7927f8c0050553c34e809fcb26791"

URI_x86_64_v2_rust-tungstenite+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-pki-types-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-pki-types-devel.sha256sum] = "2afb39498a80c9ba867c73c51bfb265d94b3f7a66d9c5de0b9372580e3df7b4a"

URI_x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-tls-native-roots-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "9288434ba676901e7699cf36db32afc06222345611ab02a2bf674cb14a770a30"

URI_x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+rustls-tls-webpki-roots-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "1a6c33af8e3e7c2372a43ec19653d12b25a90095e52ff7b233a94014fc5f426a"

URI_x86_64_v2_rust-tungstenite+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+sha1-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+sha1-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+sha1-devel.sha256sum] = "7a57d06858674c8003276ba056fd4bfdb86238adefe4d7915dd3a25ffb35c1af"

URI_x86_64_v2_rust-tungstenite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+url-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+url-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+url-devel.sha256sum] = "2b134d9f8b025cef67e00620f83d0a2a8802dbf38db6f93847e9416b1b4d7854"

URI_x86_64_v2_rust-tungstenite+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite+webpki-roots-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tungstenite+webpki-roots-devel.sha256sum] = "af70d7d9b0ddeeed2735fd75fb26453a4779e3ca844774d521e0e6b18a204006"

URI_x86_64_v2_rust-tungstenite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tungstenite-devel-0.23.0-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tungstenite-devel}"
SRC_URI[x86_64_v2_rust-tungstenite-devel.sha256sum] = "c73a5ce0714fb4bf7df6dd4b4bee4a7d8ddb57e14444b5a41da9128c6b5a0a62"

URI_aarch64_rust-tungstenite+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+__rustls-tls-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tungstenite+__rustls-tls-devel.sha256sum] = "1bc571c0fcdc07f7a71ee221285fdae05ccc2343e969570de4a96a00c018ed4a"

URI_aarch64_rust-tungstenite+data-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+data-encoding-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+data-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+data-encoding-devel}"
SRC_URI[aarch64_rust-tungstenite+data-encoding-devel.sha256sum] = "c26b19972de19339fc3c4abec390cacb9e81aaf43213a48ee80f218eb0621b23"

URI_aarch64_rust-tungstenite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+default-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+default-devel}"
SRC_URI[aarch64_rust-tungstenite+default-devel.sha256sum] = "3851ead6ea0ec115168466461514ab1219c3c7979a73c46f0221aedb2347cf64"

URI_aarch64_rust-tungstenite+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+handshake-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+handshake-devel}"
SRC_URI[aarch64_rust-tungstenite+handshake-devel.sha256sum] = "f7d26f767975a25504423ffae2228ab179d0fc87514315f3bb6d39f574e53f5c"

URI_aarch64_rust-tungstenite+http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+http-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+http-devel}"
SRC_URI[aarch64_rust-tungstenite+http-devel.sha256sum] = "9e25e32d2045ecd603f593c15077a8e688e67a3799806399721144b0b4462446"

URI_aarch64_rust-tungstenite+httparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+httparse-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+httparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+httparse-devel}"
SRC_URI[aarch64_rust-tungstenite+httparse-devel.sha256sum] = "f2e659f1749ea291212969966ffc7ea1c291456390b517fc5e94b59b9a8b46be"

URI_aarch64_rust-tungstenite+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+native-tls-crate-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tungstenite+native-tls-crate-devel.sha256sum] = "4233ca9166c30f182120ea2a91a6b775a2d1f352ebf8e4b0ffabbfabc180e746"

URI_aarch64_rust-tungstenite+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+native-tls-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+native-tls-devel}"
SRC_URI[aarch64_rust-tungstenite+native-tls-devel.sha256sum] = "385b05970100e15a37d9aaf41165600b10563e1aa38192586e35abeb6b01539d"

URI_aarch64_rust-tungstenite+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-devel.sha256sum] = "6d28140138d086f456a8a8dd0f4798aa5687f3c1ae9621cd6b48d8080f691e73"

URI_aarch64_rust-tungstenite+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-native-certs-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-native-certs-devel.sha256sum] = "88c90c068a7c5a197034ae02908b1163e5effe9438014da0265bf220ee819a6b"

URI_aarch64_rust-tungstenite+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-pki-types-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-pki-types-devel.sha256sum] = "074e2d051a642ea85f3caf08ea0cc221a8d57ee4a04c37d7e196c1a5dc6a8d3f"

URI_aarch64_rust-tungstenite+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-tls-native-roots-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "a51276fb79639d9e44d70036d49e28d7916db652df96d7c6acbc932c59d7960e"

URI_aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+rustls-tls-webpki-roots-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "16da0707fbcb9e3f2e06311975975e0a1c84c5723987ba5b0abe83c7dcd464d3"

URI_aarch64_rust-tungstenite+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+sha1-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+sha1-devel}"
SRC_URI[aarch64_rust-tungstenite+sha1-devel.sha256sum] = "f9391a7a06f766348047d18b9855bff4ab8cf6479171e9c7ffafde45b83f15aa"

URI_aarch64_rust-tungstenite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+url-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+url-devel}"
SRC_URI[aarch64_rust-tungstenite+url-devel.sha256sum] = "ed190f473f39e76c9ae324faf9aaa5cf77648c50a3ce02ba131c50e75e2d49fe"

URI_aarch64_rust-tungstenite+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite+webpki-roots-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite+webpki-roots-devel}"
SRC_URI[aarch64_rust-tungstenite+webpki-roots-devel.sha256sum] = "49b585d02c37e59fb25008f84771f22c7183ba86923b260da4b1b3099d694c76"

URI_aarch64_rust-tungstenite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tungstenite-devel-0.23.0-3.el10_1.noarch.rpm;name=aarch64_rust-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tungstenite-devel}"
SRC_URI[aarch64_rust-tungstenite-devel.sha256sum] = "1b4b4f54788c8eb874826d67a8d6de2b4fe900c67330499c2817f87c79797c51"

RDEPENDS:rust-tungstenite+__rustls-tls-devel = " \
 cargo \
 rust-tungstenite+rustls-devel \
 rust-tungstenite+rustls-pki-types-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+data-encoding-devel = " \
 cargo \
 rust-data-encoding+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+default-devel = " \
 cargo \
 rust-tungstenite+handshake-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+handshake-devel = " \
 cargo \
 rust-tungstenite+data-encoding-devel \
 rust-tungstenite+http-devel \
 rust-tungstenite+httparse-devel \
 rust-tungstenite+sha1-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+http-devel = " \
 cargo \
 rust-http+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+httparse-devel = " \
 cargo \
 rust-httparse+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+native-tls-devel = " \
 cargo \
 rust-tungstenite+native-tls-crate-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-devel = " \
 cargo \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs0.7+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+rustls-native-certs-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tungstenite+__rustls-tls-devel \
 rust-tungstenite+webpki-roots-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+sha1-devel = " \
 cargo \
 rust-sha1+default-devel \
 rust-tungstenite-devel \
 "
RDEPENDS:rust-tungstenite+url-devel = " \
 cargo \
 rust-tungstenite-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-tungstenite+webpki-roots-devel = " \
 cargo \
 rust-tungstenite-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-tungstenite-devel = " \
 cargo \
 rust \
 rust-byteorder+default-devel \
 rust-bytes+default-devel \
 rust-log+default-devel \
 rust-rand0.8+default-devel \
 rust-thiserror1+default-devel \
 rust-utf-8+default-devel \
 "
