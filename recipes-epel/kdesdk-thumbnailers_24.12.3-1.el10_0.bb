# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdesdk-thumbnailers"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kdesdk-thumbnailers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdesdk-thumbnailers-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "40a5b17cfff13b897ca8a55eb627fac26cf4604094da52bd28f5a83134e4e5f1"

URI_x86_64_v2_kdesdk-thumbnailers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdesdk-thumbnailers-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdesdk-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdesdk-thumbnailers}"
SRC_URI[x86_64_v2_kdesdk-thumbnailers.sha256sum] = "efa42359bd0769385c0b66bdd6146bc82b01ee4a94b276ce491a3b5e43ea543b"

URI_aarch64_kdesdk-thumbnailers = "${EPEL_MIRROR}/aarch64/Packages/k/kdesdk-thumbnailers-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kdesdk-thumbnailers;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdesdk-thumbnailers}"
SRC_URI[aarch64_kdesdk-thumbnailers.sha256sum] = "0d5bbb22d485a6d2ed4e853391e2ff07ac302e36bb76a5374215b792b7f72bf1"

RDEPENDS:kdesdk-thumbnailers = " \
 gettext-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kio-gui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
