# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtdatavis3d"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtdatavis3d \
 qt5-qtdatavis3d-devel \
 qt5-qtdatavis3d-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtdatavis3d-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d00b4e056b2385ea940019b3ae16bb1e338f188fe16fefe4527472fd040e699"

URI_x86_64_v2_qt5-qtdatavis3d = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d.sha256sum] = "c7611c68d6cfb32f071b8a6e09b943737285b6402a99af651fb676e3c19504cc"

URI_x86_64_v2_qt5-qtdatavis3d-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d-devel}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d-devel.sha256sum] = "705d249797fb4bd2f2eb9aa2e8c0a3be414066c16df17d03e9574de904b29b3e"

URI_x86_64_v2_qt5-qtdatavis3d-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdatavis3d-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdatavis3d-examples}"
SRC_URI[x86_64_v2_qt5-qtdatavis3d-examples.sha256sum] = "6513286f9ba105396b2bcffc3d0ccb32978d09c530feacad8f556424759895dc"

URI_aarch64_qt5-qtdatavis3d = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtdatavis3d;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d}"
SRC_URI[aarch64_qt5-qtdatavis3d.sha256sum] = "11e34aee5e90e6544483c5104427e6a5e8ba1a56eed32a46fe21f10ff8f44d16"

URI_aarch64_qt5-qtdatavis3d-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtdatavis3d-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d-devel}"
SRC_URI[aarch64_qt5-qtdatavis3d-devel.sha256sum] = "3ab6cf3fe302b7ab1ff3ab16d7e0692cdbc0aa5a315791d6efb0cff597cb7af8"

URI_aarch64_qt5-qtdatavis3d-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdatavis3d-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtdatavis3d-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdatavis3d-examples}"
SRC_URI[aarch64_qt5-qtdatavis3d-examples.sha256sum] = "b149f2405d3d884d03490e0dd0357fb2bfce55719eb61b521ee66687559f3616"

RDEPENDS:qt5-qtdatavis3d = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtdatavis3d-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdatavis3d \
 qt5-qtdeclarative-devel \
 "
RDEPENDS:qt5-qtdatavis3d-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdatavis3d \
 qt5-qtdeclarative \
 "
