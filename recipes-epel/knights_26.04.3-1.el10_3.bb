# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "knights"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 knights \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/knights-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3880b9b0587c9ca353dfdfef982b8bb578c19f2f1bfd5d32003434d4ea364c11"

URI_x86_64_v2_knights = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/knights-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_knights;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_knights}"
SRC_URI[x86_64_v2_knights.sha256sum] = "cc572c50c4c38742a7383f1d3d360e512261f68feab7bd067d83407d49e11321"

URI_aarch64_knights = "${EPEL_MIRROR}/aarch64/Packages/k/knights-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_knights;unpack=0"
SRC_URI:append = " ${URI_aarch64_knights}"
SRC_URI[aarch64_knights.sha256sum] = "68d4f66885be9ef5e56317523047aeab85778259afb0ac6f3bce026f52f2cafb"

RDEPENDS:knights = " \
 glibc \
 gnuchess \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kplotting \
 kf6-ksvg \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
