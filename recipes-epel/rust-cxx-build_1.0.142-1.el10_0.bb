# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cxx-build"
PV = "1.0.142"
PR = "1.el10_0"
PACKAGES = " \
 rust-cxx-build+default-devel \
 rust-cxx-build+experimental-async-fn-devel \
 rust-cxx-build+parallel-devel \
 rust-cxx-build-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cxx-build-1.0.142-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74b08b3bff022c66b384cfab945a001ac53771f3dff0d5309b70b53820f5f595"

URI_x86_64_v2_rust-cxx-build+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+default-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build+default-devel}"
SRC_URI[x86_64_v2_rust-cxx-build+default-devel.sha256sum] = "61db886123eb92b4cb6494a54b4e368cbe4e08b04d499c2307da9707f3368e01"

URI_x86_64_v2_rust-cxx-build+experimental-async-fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+experimental-async-fn-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+experimental-async-fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build+experimental-async-fn-devel}"
SRC_URI[x86_64_v2_rust-cxx-build+experimental-async-fn-devel.sha256sum] = "5b60740147a362b099cac9b4ebb355ca4a77b81f0d4a81ce1407b777e86f3064"

URI_x86_64_v2_rust-cxx-build+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build+parallel-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build+parallel-devel}"
SRC_URI[x86_64_v2_rust-cxx-build+parallel-devel.sha256sum] = "e8b3e2fff2f347b596255b6b3c870da0cef4ee8019b1d167eb681c587d2c96a7"

URI_x86_64_v2_rust-cxx-build-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cxx-build-devel-1.0.142-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cxx-build-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cxx-build-devel}"
SRC_URI[x86_64_v2_rust-cxx-build-devel.sha256sum] = "705ba51517e1490d8dc622fbcc3d506307a5980706632248f9d8a7d2324861ca"

URI_aarch64_rust-cxx-build+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+default-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx-build+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build+default-devel}"
SRC_URI[aarch64_rust-cxx-build+default-devel.sha256sum] = "87a403e0be315b05079ad1c2da2d82a20414e58da7de380bc1523153a09c7687"

URI_aarch64_rust-cxx-build+experimental-async-fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+experimental-async-fn-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx-build+experimental-async-fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build+experimental-async-fn-devel}"
SRC_URI[aarch64_rust-cxx-build+experimental-async-fn-devel.sha256sum] = "2cb619d0d54c6ada42a17f059ec2d464e09d5d1d7a1e57d2f479fa3e413f2621"

URI_aarch64_rust-cxx-build+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build+parallel-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx-build+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build+parallel-devel}"
SRC_URI[aarch64_rust-cxx-build+parallel-devel.sha256sum] = "88785700e67bfe97e704b4c4a0e3acfaa7bfdca268e000566c3bf678b230ff48"

URI_aarch64_rust-cxx-build-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cxx-build-devel-1.0.142-1.el10_0.noarch.rpm;name=aarch64_rust-cxx-build-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cxx-build-devel}"
SRC_URI[aarch64_rust-cxx-build-devel.sha256sum] = "69b9c96627df36b857b4a08f363cee3682b0f92d48b60af02bf5a3758ef3aefc"

RDEPENDS:rust-cxx-build+default-devel = " \
 cargo \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build+experimental-async-fn-devel = " \
 cargo \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build+parallel-devel = " \
 cargo \
 rust-cc+parallel-devel \
 rust-cxx-build-devel \
 "
RDEPENDS:rust-cxx-build-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-codespan-reporting+default-devel \
 rust-proc-macro2+span-locations-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-scratch+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
