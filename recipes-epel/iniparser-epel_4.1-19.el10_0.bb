# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iniparser-epel"
PV = "4.1"
PR = "19.el10_0"
PACKAGES = " \
 iniparser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/iniparser-epel-4.1-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae9e6e9ce0c83a64e707bda9f6a372984f266299db297c346551c87b994e0abe"

URI_x86_64_v2_iniparser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iniparser-devel-4.1-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iniparser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iniparser-devel}"
SRC_URI[x86_64_v2_iniparser-devel.sha256sum] = "503a1c69b7d09aab390eb9c30177285a7a95028ecd99f7269cb98d43cd36c3fb"

URI_aarch64_iniparser-devel = "${EPEL_MIRROR}/aarch64/Packages/i/iniparser-devel-4.1-19.el10_0.aarch64.rpm;name=aarch64_iniparser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iniparser-devel}"
SRC_URI[aarch64_iniparser-devel.sha256sum] = "51a5a9e67c0f48f4c12503a355839e3f60f87406822d11f16406b9aebd9f7d26"

RDEPENDS:iniparser-devel = " \
 iniparser \
 "
