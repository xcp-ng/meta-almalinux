# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-aws-v4"
PV = "3.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-aws-v4-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-aws-v4-3.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c579a7f1e38d4ec7c6940ce05d0dd8d70b891b492ae2527dfc0b009e8eae8227"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aws-v4+default-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aws-v4+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-aws-v4+default-devel.sha256sum] = "087fbdc9d31282f10bf8f31cabc215ee2517e60c770e2fd8fe068de0a9fb9d2a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aws-v4-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aws-v4-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-aws-v4-devel.sha256sum] = "fac913c98a8b35c93dd0b23292a63292e505f82f50972192575e481441901fff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aws-v4+default-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-aws-v4+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-aws-v4+default-devel.sha256sum] = "b870b8f933d3f70c80c9e9099a44e4844b718bd53bb2fb85282420cc6d8b0fd3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aws-v4-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-aws-v4-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-aws-v4-devel.sha256sum] = "64606909025d8f6be6ed9ea13867ef98a304e5c31465fb29f4da90d6ce2290ac"

RDEPENDS:rust-reqsign-aws-v4+default-devel = " \
 cargo \
 rust-reqsign-aws-v4-devel \
 "
RDEPENDS:rust-reqsign-aws-v4-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-hex+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-quick-xml+default-devel \
 rust-quick-xml+serialize-devel \
 rust-reqsign-core+default-devel \
 rust-rust-ini+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-sha1+default-devel \
 "
