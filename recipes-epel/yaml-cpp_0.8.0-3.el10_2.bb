# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yaml-cpp"
PV = "0.8.0"
PR = "3.el10_2"
PACKAGES = " \
 yaml-cpp \
 yaml-cpp-devel \
 yaml-cpp-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yaml-cpp-0.8.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcde3a88cf9b317651018f04efa408c951236a4e40de87a3f3af77a6d834dd3f"

URI_x86_64_v2_yaml-cpp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yaml-cpp-0.8.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yaml-cpp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yaml-cpp}"
SRC_URI[x86_64_v2_yaml-cpp.sha256sum] = "8a16d1415939fdf7d4578c80fdfb0fb6821621de4d59439a956659eb823b4aca"

URI_x86_64_v2_yaml-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yaml-cpp-devel-0.8.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yaml-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yaml-cpp-devel}"
SRC_URI[x86_64_v2_yaml-cpp-devel.sha256sum] = "81b03472be70ef536127514b3526914a45a898404c55eaf9fa047613bb45c9b4"
RPROVIDES:yaml-cpp-devel:x86_64_v2 = "virtual/pkgconfig_yaml-cpp_"

URI_x86_64_v2_yaml-cpp-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yaml-cpp-static-0.8.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yaml-cpp-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yaml-cpp-static}"
SRC_URI[x86_64_v2_yaml-cpp-static.sha256sum] = "86f7ac95fbbf9855d9457bf0f6a9c713fdc51fb277c759cf1721a6ead7afea63"

URI_aarch64_yaml-cpp = "${EPEL_MIRROR}/aarch64/Packages/y/yaml-cpp-0.8.0-3.el10_2.aarch64.rpm;name=aarch64_yaml-cpp;unpack=0"
SRC_URI:append = " ${URI_aarch64_yaml-cpp}"
SRC_URI[aarch64_yaml-cpp.sha256sum] = "4a1ce3607612b5a7de0b655359a0ed7fe43a66669262bd88ce5a687cd2a6e2cd"

URI_aarch64_yaml-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yaml-cpp-devel-0.8.0-3.el10_2.aarch64.rpm;name=aarch64_yaml-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yaml-cpp-devel}"
SRC_URI[aarch64_yaml-cpp-devel.sha256sum] = "c8c2d352ac0da7e49a50bd741d7f2ce4fc5bd2be61265a46900da7ce2ea12e45"
RPROVIDES:yaml-cpp-devel:aarch64 = "virtual/pkgconfig_yaml-cpp_"

URI_aarch64_yaml-cpp-static = "${EPEL_MIRROR}/aarch64/Packages/y/yaml-cpp-static-0.8.0-3.el10_2.aarch64.rpm;name=aarch64_yaml-cpp-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_yaml-cpp-static}"
SRC_URI[aarch64_yaml-cpp-static.sha256sum] = "376171c3fda25e739f6b1cf9dc33e61a96139515fc0119b670aebdb53357bcc4"

RDEPENDS:yaml-cpp = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:yaml-cpp-devel = " \
 cmake-filesystem \
 libstdc++-devel \
 pkgconf-pkg-config \
 yaml-cpp \
 "
RDEPENDS:yaml-cpp-static = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 yaml-cpp-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/pkgconfig_yaml-cpp_"

PROVIDES:append:aarch64 = " rpm/virtual/pkgconfig_yaml-cpp_"
