# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-table-chinese"
PV = "1.8.12"
PR = "7.el10"
PACKAGES = " \
 ibus-table-chinese \
 ibus-table-chinese-array \
 ibus-table-chinese-cangjie \
 ibus-table-chinese-cantonese \
 ibus-table-chinese-easy \
 ibus-table-chinese-erbi \
 ibus-table-chinese-quick \
 ibus-table-chinese-scj \
 ibus-table-chinese-stroke5 \
 ibus-table-chinese-wu \
 ibus-table-chinese-wubi-haifeng \
 ibus-table-chinese-wubi-jidian \
 ibus-table-chinese-yong \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ibus-table-chinese-1.8.12-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35b38d3af42a1926ab70a7696801192967b365f228fa87cf326e07ffb202ae9a"

URI_x86_64_v2_ibus-table-chinese = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese}"
SRC_URI[x86_64_v2_ibus-table-chinese.sha256sum] = "3cee82cd88fec90c66fb72060add371d1d0b07deed140a0a927b4ee68ad0f9e9"

URI_x86_64_v2_ibus-table-chinese-array = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-array-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-array}"
SRC_URI[x86_64_v2_ibus-table-chinese-array.sha256sum] = "34f8a12e6d642fd12904b4c8007cdef27e6a5e450b97c4b832ebad8d3a3ec9b1"

URI_x86_64_v2_ibus-table-chinese-cangjie = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-cangjie-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-cangjie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-cangjie}"
SRC_URI[x86_64_v2_ibus-table-chinese-cangjie.sha256sum] = "66f82204b3d8c8a67a3245dea0252624302f872541e6bbe0b1c0f75dedabf7bf"

URI_x86_64_v2_ibus-table-chinese-cantonese = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-cantonese-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-cantonese;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-cantonese}"
SRC_URI[x86_64_v2_ibus-table-chinese-cantonese.sha256sum] = "d77a5241474939ee3a9445294558a204b2b1a1cea0eb201f178ddeb48c5ab1d0"

URI_x86_64_v2_ibus-table-chinese-easy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-easy-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-easy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-easy}"
SRC_URI[x86_64_v2_ibus-table-chinese-easy.sha256sum] = "d45fb860c197cf9687f63601356e78ed979730467e58ac0b6edc7c8f27df9bd2"

URI_x86_64_v2_ibus-table-chinese-erbi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-erbi-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-erbi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-erbi}"
SRC_URI[x86_64_v2_ibus-table-chinese-erbi.sha256sum] = "8ad8c594981d9e50cfcbb3180590fc503e0228d27275ef2b9beb1ea1b456d2ff"

URI_x86_64_v2_ibus-table-chinese-quick = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-quick-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-quick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-quick}"
SRC_URI[x86_64_v2_ibus-table-chinese-quick.sha256sum] = "59e6762e49ab53b9cb5149cd8bc6108df2cdbb77e03737fd3da2ffc17b2a88b2"

URI_x86_64_v2_ibus-table-chinese-scj = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-scj-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-scj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-scj}"
SRC_URI[x86_64_v2_ibus-table-chinese-scj.sha256sum] = "8fb196f205f53c782d24fcc40c02b5da8ed745e3ff3eca0026d62240f0628c9d"

URI_x86_64_v2_ibus-table-chinese-stroke5 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-stroke5-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-stroke5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-stroke5}"
SRC_URI[x86_64_v2_ibus-table-chinese-stroke5.sha256sum] = "ce621ef72a14f93ad992a2a15d2c85cf78da866a64f45695f9e94312e6dde484"

URI_x86_64_v2_ibus-table-chinese-wu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-wu-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-wu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-wu}"
SRC_URI[x86_64_v2_ibus-table-chinese-wu.sha256sum] = "3ecb64f3f29ed91bc425f40955c46ecdc189136db73407a615489f0305eb99cc"

URI_x86_64_v2_ibus-table-chinese-wubi-haifeng = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-wubi-haifeng-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-wubi-haifeng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-wubi-haifeng}"
SRC_URI[x86_64_v2_ibus-table-chinese-wubi-haifeng.sha256sum] = "1533d2555ed1b68573e16033af279052a18e7d6dc7a2c2aa232227d02cba39ce"

URI_x86_64_v2_ibus-table-chinese-wubi-jidian = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-wubi-jidian-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-wubi-jidian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-wubi-jidian}"
SRC_URI[x86_64_v2_ibus-table-chinese-wubi-jidian.sha256sum] = "ccdd65dbc10d9d561e0efd02713150abba3615f7ddddc861e473e78729ad8e32"

URI_x86_64_v2_ibus-table-chinese-yong = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ibus-table-chinese-yong-1.8.12-7.el10.noarch.rpm;name=x86_64_v2_ibus-table-chinese-yong;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-table-chinese-yong}"
SRC_URI[x86_64_v2_ibus-table-chinese-yong.sha256sum] = "bbd9b40f9100e2e20b99ad288f08bc5e0ec3aa7eacc551f08ff45db52f230de9"

URI_aarch64_ibus-table-chinese = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese}"
SRC_URI[aarch64_ibus-table-chinese.sha256sum] = "3cee82cd88fec90c66fb72060add371d1d0b07deed140a0a927b4ee68ad0f9e9"

URI_aarch64_ibus-table-chinese-array = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-array-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-array}"
SRC_URI[aarch64_ibus-table-chinese-array.sha256sum] = "34f8a12e6d642fd12904b4c8007cdef27e6a5e450b97c4b832ebad8d3a3ec9b1"

URI_aarch64_ibus-table-chinese-cangjie = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-cangjie-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-cangjie;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-cangjie}"
SRC_URI[aarch64_ibus-table-chinese-cangjie.sha256sum] = "66f82204b3d8c8a67a3245dea0252624302f872541e6bbe0b1c0f75dedabf7bf"

URI_aarch64_ibus-table-chinese-cantonese = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-cantonese-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-cantonese;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-cantonese}"
SRC_URI[aarch64_ibus-table-chinese-cantonese.sha256sum] = "d77a5241474939ee3a9445294558a204b2b1a1cea0eb201f178ddeb48c5ab1d0"

URI_aarch64_ibus-table-chinese-easy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-easy-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-easy;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-easy}"
SRC_URI[aarch64_ibus-table-chinese-easy.sha256sum] = "d45fb860c197cf9687f63601356e78ed979730467e58ac0b6edc7c8f27df9bd2"

URI_aarch64_ibus-table-chinese-erbi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-erbi-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-erbi;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-erbi}"
SRC_URI[aarch64_ibus-table-chinese-erbi.sha256sum] = "8ad8c594981d9e50cfcbb3180590fc503e0228d27275ef2b9beb1ea1b456d2ff"

URI_aarch64_ibus-table-chinese-quick = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-quick-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-quick;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-quick}"
SRC_URI[aarch64_ibus-table-chinese-quick.sha256sum] = "59e6762e49ab53b9cb5149cd8bc6108df2cdbb77e03737fd3da2ffc17b2a88b2"

URI_aarch64_ibus-table-chinese-scj = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-scj-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-scj;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-scj}"
SRC_URI[aarch64_ibus-table-chinese-scj.sha256sum] = "8fb196f205f53c782d24fcc40c02b5da8ed745e3ff3eca0026d62240f0628c9d"

URI_aarch64_ibus-table-chinese-stroke5 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-stroke5-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-stroke5;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-stroke5}"
SRC_URI[aarch64_ibus-table-chinese-stroke5.sha256sum] = "ce621ef72a14f93ad992a2a15d2c85cf78da866a64f45695f9e94312e6dde484"

URI_aarch64_ibus-table-chinese-wu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-wu-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-wu;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-wu}"
SRC_URI[aarch64_ibus-table-chinese-wu.sha256sum] = "3ecb64f3f29ed91bc425f40955c46ecdc189136db73407a615489f0305eb99cc"

URI_aarch64_ibus-table-chinese-wubi-haifeng = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-wubi-haifeng-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-wubi-haifeng;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-wubi-haifeng}"
SRC_URI[aarch64_ibus-table-chinese-wubi-haifeng.sha256sum] = "1533d2555ed1b68573e16033af279052a18e7d6dc7a2c2aa232227d02cba39ce"

URI_aarch64_ibus-table-chinese-wubi-jidian = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-wubi-jidian-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-wubi-jidian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-wubi-jidian}"
SRC_URI[aarch64_ibus-table-chinese-wubi-jidian.sha256sum] = "ccdd65dbc10d9d561e0efd02713150abba3615f7ddddc861e473e78729ad8e32"

URI_aarch64_ibus-table-chinese-yong = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ibus-table-chinese-yong-1.8.12-7.el10.noarch.rpm;name=aarch64_ibus-table-chinese-yong;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-table-chinese-yong}"
SRC_URI[aarch64_ibus-table-chinese-yong.sha256sum] = "bbd9b40f9100e2e20b99ad288f08bc5e0ec3aa7eacc551f08ff45db52f230de9"

RDEPENDS:ibus-table-chinese = " \
 ibus-table \
 "
RDEPENDS:ibus-table-chinese-array = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-cangjie = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-cantonese = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-easy = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-erbi = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-quick = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-scj = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-stroke5 = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-wu = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-wubi-haifeng = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-wubi-jidian = " \
 ibus-table-chinese \
 "
RDEPENDS:ibus-table-chinese-yong = " \
 ibus-table-chinese \
 "
