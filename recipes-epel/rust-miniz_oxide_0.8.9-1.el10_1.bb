# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-miniz_oxide"
PV = "0.8.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-miniz_oxide+block-boundary-devel \
 rust-miniz_oxide+default-devel \
 rust-miniz_oxide+serde-devel \
 rust-miniz_oxide+simd-adler32-devel \
 rust-miniz_oxide+simd-devel \
 rust-miniz_oxide+std-devel \
 rust-miniz_oxide+with-alloc-devel \
 rust-miniz_oxide-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-miniz_oxide-0.8.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b381e2b5c630022c96f4dc255105fd6c2ad570c2e51387736a35f3aee1eab08"

URI_x86_64_v2_rust-miniz_oxide+block-boundary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+block-boundary-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+block-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+block-boundary-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+block-boundary-devel.sha256sum] = "fad3e496ec041c6fbc8ddfeebfd66abf865e29608a60d38a2364c79e9deaa619"

URI_x86_64_v2_rust-miniz_oxide+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+default-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+default-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+default-devel.sha256sum] = "61f51b5d5ca0f965d99960b4752fca6bb5a51897c736e15dfcc04c8f537f5953"

URI_x86_64_v2_rust-miniz_oxide+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+serde-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+serde-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+serde-devel.sha256sum] = "14f58b6b6d5f759ce47a1487394c0cf71143c849bc399c1f607a01e938792e4e"

URI_x86_64_v2_rust-miniz_oxide+simd-adler32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+simd-adler32-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+simd-adler32-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+simd-adler32-devel.sha256sum] = "70ad2e6ed6f90611192572b0b6fbe384a134265b0db51df826a27f24da65a7d5"

URI_x86_64_v2_rust-miniz_oxide+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+simd-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+simd-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+simd-devel.sha256sum] = "d68daf90141335bcc3d5ce9f9b06f5c6db8edb6519d480fe421d04892fd82a63"

URI_x86_64_v2_rust-miniz_oxide+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+std-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+std-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+std-devel.sha256sum] = "95a9428d003c1b92be97cfb376567ec6cc6e8cb766b473bc4c92ac2681617690"

URI_x86_64_v2_rust-miniz_oxide+with-alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide+with-alloc-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide+with-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide+with-alloc-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide+with-alloc-devel.sha256sum] = "b98a7002ba6def7aa8539f44b18ee61e9db6b5a17d85bcd65d90cf5925b11235"

URI_x86_64_v2_rust-miniz_oxide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-miniz_oxide-devel-0.8.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-miniz_oxide-devel}"
SRC_URI[x86_64_v2_rust-miniz_oxide-devel.sha256sum] = "bf213bf603403e18919cec01529345e5f554c7bd80b6ff82a49eab7309ef27e5"

URI_aarch64_rust-miniz_oxide+block-boundary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+block-boundary-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-miniz_oxide+block-boundary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+block-boundary-devel}"
SRC_URI[aarch64_rust-miniz_oxide+block-boundary-devel.sha256sum] = "c996f3e4f7c4e639f681d4d97584b726328ee7451197335bdc723ff2058f53af"

URI_aarch64_rust-miniz_oxide+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+default-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-miniz_oxide+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+default-devel}"
SRC_URI[aarch64_rust-miniz_oxide+default-devel.sha256sum] = "e96cef633658e38f9e59603edc0d8e13d200d70e841c74b23f0f1aa3331456ad"

URI_aarch64_rust-miniz_oxide+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+serde-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-miniz_oxide+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+serde-devel}"
SRC_URI[aarch64_rust-miniz_oxide+serde-devel.sha256sum] = "096297874e9699682277c39e8bef37dfca9b5309edda2bc997e756d597bac5fe"

URI_aarch64_rust-miniz_oxide+simd-adler32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+simd-adler32-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-miniz_oxide+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+simd-adler32-devel}"
SRC_URI[aarch64_rust-miniz_oxide+simd-adler32-devel.sha256sum] = "57218d8fd54e18fbf9e94c2a2c7c2e3ed2c9b23c42ee9fdb4e04c316bed9b693"

URI_aarch64_rust-miniz_oxide+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+simd-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-miniz_oxide+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+simd-devel}"
SRC_URI[aarch64_rust-miniz_oxide+simd-devel.sha256sum] = "0e9ccad69560c9a78cdc159a8147460a7a3948ef2e02b70a1ac8e3725dcda55c"

URI_aarch64_rust-miniz_oxide+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+std-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-miniz_oxide+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+std-devel}"
SRC_URI[aarch64_rust-miniz_oxide+std-devel.sha256sum] = "6885500ff2c2981cced13780ee56d211c8c9dd8cc878394bcad6df86123fd7f2"

URI_aarch64_rust-miniz_oxide+with-alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide+with-alloc-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-miniz_oxide+with-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide+with-alloc-devel}"
SRC_URI[aarch64_rust-miniz_oxide+with-alloc-devel.sha256sum] = "10c566c2bfe53f2ef7dee397390fffb7553dec88274ef26f8988206004d4900a"

URI_aarch64_rust-miniz_oxide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-miniz_oxide-devel-0.8.9-1.el10_1.noarch.rpm;name=aarch64_rust-miniz_oxide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-miniz_oxide-devel}"
SRC_URI[aarch64_rust-miniz_oxide-devel.sha256sum] = "512a7f3ff8a06724b619f3b44d694c56a181fa759d4f8a366803116161eff454"

RDEPENDS:rust-miniz_oxide+block-boundary-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+default-devel = " \
 cargo \
 rust-miniz_oxide+with-alloc-devel \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+serde-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-miniz_oxide+simd-adler32-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 rust-simd-adler32-devel \
 "
RDEPENDS:rust-miniz_oxide+simd-devel = " \
 cargo \
 rust-miniz_oxide+simd-adler32-devel \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+std-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide+with-alloc-devel = " \
 cargo \
 rust-miniz_oxide-devel \
 "
RDEPENDS:rust-miniz_oxide-devel = " \
 cargo \
 rust-adler2-devel \
 "
