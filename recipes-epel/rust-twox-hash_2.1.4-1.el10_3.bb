# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-twox-hash"
PV = "2.1.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-twox-hash+alloc-devel \
 rust-twox-hash+default-devel \
 rust-twox-hash+random-devel \
 rust-twox-hash+serialize-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-twox-hash-2.1.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "25a3852eb66441e989956764f6c6b58072356a96f5e10d61f266f7afafa1eff9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+alloc-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+alloc-devel.sha256sum] = "3212879c4495ef52659df88e87aa3fc01aeb93d7e3c37b940fbc400a5bb228a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+default-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+default-devel.sha256sum] = "04ef36dbce3a0266141121f44e63a8b811e17508d81096e7ab3be9ddb1b08d6d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+random-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+random-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+random-devel.sha256sum] = "6753a7f73edda8ec5ec944e67b3578a494ef53b1764eaccaf2f3292b3bcbc587"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+serialize-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+serialize-devel.sha256sum] = "0cbbb8d1b0b13e921c2e8904d86a87c5df3932060b6783c377ca77b6d2cd2d59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+std-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+std-devel.sha256sum] = "0cfea4f95c057c7af33789f036a8b93486c9947224ace88bf3860e668df85d9c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash32-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash32-devel.sha256sum] = "7dd1b6d2a8ef6b3117c73ee345fb16c7ef68aaf432f4f08c12f091e5f2344190"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_128-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_128-devel.sha256sum] = "9555676ebca9715bf296051e8d07f2133117333c1e8fdde7636414822abeeebe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash3_64-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash3_64-devel.sha256sum] = "1e84c9d3083e2d21a425dbe6a83eb1e5d913a1798da46ec8138623b3a6992aca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash+xxhash64-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash+xxhash64-devel.sha256sum] = "34a6e91c9988338061aaf4319e2317dc72df533fda333acd20c6bcf2867aa8cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twox-hash-devel-2.1.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twox-hash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-twox-hash-devel.sha256sum] = "d723ecb11aee8469be1ff26bf145e92b424acc8ee2c79086cf4aac0158e8d86c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+alloc-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+alloc-devel.sha256sum] = "e8ba571b502dea59282ff7d883de66dc49a7577b18b6c6b1f93e4c6ecd54b9ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+default-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+default-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+default-devel.sha256sum] = "8cd2d2fbc710edf35250a4399e723b157e17109a91e5583ba8da8afef3d9b52d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+random-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+random-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+random-devel.sha256sum] = "9fffa16cb3da7780ef8f32f7378b10493d61c51bfa6b31eb5744901f771c0dac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+serialize-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+serialize-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+serialize-devel.sha256sum] = "c5fcdf55e7639cb2ba08e8f581a6bc23516b54086047d60cc113f640a5c719d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+std-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+std-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+std-devel.sha256sum] = "d4459b2cf6aed836bdd92b92a37adf353355d097f6be9c78ceec9f198973ad11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash32-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+xxhash32-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+xxhash32-devel.sha256sum] = "25fb06c86dcbdf33bd3457893cf8bf0e7f28595140dd7f2c7f6748e2a5c69f8c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_128-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_128-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+xxhash3_128-devel.sha256sum] = "78fb4ce12a8a97e2cb9e9a9e36315de87bbff5af8d5b6fc89c3781aed9587567"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash3_64-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+xxhash3_64-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+xxhash3_64-devel.sha256sum] = "aab51d4731320e3d39e77a2c1c6dcc8a0081f6539c6922b881e3fd70d6822839"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash+xxhash64-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash+xxhash64-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash+xxhash64-devel.sha256sum] = "6095a844c188b5553461bde1c118a77d9ff824b6f3dd984c88a6778915553ae2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-twox-hash-devel-2.1.4-1.el10_3.noarch.rpm;name=aarch64_rust-twox-hash-devel;unpack=0"
SRC_URI[aarch64_rust-twox-hash-devel.sha256sum] = "34a2362a61ffc89f693b0119baeae6f6ba12a160a4a79ea5960fe168414b1f7f"

RDEPENDS:rust-twox-hash+alloc-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+default-devel = " \
 cargo \
 rust-twox-hash+random-devel \
 rust-twox-hash+std-devel \
 rust-twox-hash+xxhash32-devel \
 rust-twox-hash+xxhash3_128-devel \
 rust-twox-hash+xxhash3_64-devel \
 rust-twox-hash+xxhash64-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+random-devel = " \
 cargo \
 rust-twox-hash-devel \
 virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0 \
 virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0 \
 "
RDEPENDS:rust-twox-hash+serialize-devel = " \
 cargo \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+std-devel = " \
 cargo \
 rust-twox-hash+alloc-devel \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash32-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_128-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash3_64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash+xxhash64-devel = " \
 cargo \
 rust-twox-hash-devel \
 "
RDEPENDS:rust-twox-hash-devel = " \
 cargo \
 rust \
 "
