# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "urdfdom-headers"
PV = "1.1.2"
PR = "1.el10_0"
PACKAGES = " \
 urdfdom-headers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/urdfdom-headers-1.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d81c9055fee7b13930cbe558e3d6422186a8f90e3375119b79e86cba46cc2706"

URI_x86_64_v2_urdfdom-headers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/urdfdom-headers-devel-1.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_urdfdom-headers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_urdfdom-headers-devel}"
SRC_URI[x86_64_v2_urdfdom-headers-devel.sha256sum] = "055e654a9f9fe287c2da8d7c399210ed8ecb2f9663e190968d3d4595f694cf84"

URI_aarch64_urdfdom-headers-devel = "${EPEL_MIRROR}/aarch64/Packages/u/urdfdom-headers-devel-1.1.2-1.el10_0.noarch.rpm;name=aarch64_urdfdom-headers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_urdfdom-headers-devel}"
SRC_URI[aarch64_urdfdom-headers-devel.sha256sum] = "570b552ef80c531af6cb63d153b64d68872e64cab6a4fa7c433dc3ad7d7b01e3"

RDEPENDS:urdfdom-headers-devel = " \
 pkgconf-pkg-config \
 "
