# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-codespan-reporting0.11"
PV = "0.11.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-codespan-reporting0.11+ascii-only-devel \
 rust-codespan-reporting0.11+default-devel \
 rust-codespan-reporting0.11+serde-devel \
 rust-codespan-reporting0.11+serialization-devel \
 rust-codespan-reporting0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-codespan-reporting0.11-0.11.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69d377f71b58104c3bfa0dc0879246e60c2fe7bf395f2fd5d70551d2d985d789"

URI_x86_64_v2_rust-codespan-reporting0.11+ascii-only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting0.11+ascii-only-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting0.11+ascii-only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting0.11+ascii-only-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting0.11+ascii-only-devel.sha256sum] = "313b6c8cca25896dd03f2f6ea842aa09462550c7bf74912b1332a038fd9d6e2b"

URI_x86_64_v2_rust-codespan-reporting0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting0.11+default-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting0.11+default-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting0.11+default-devel.sha256sum] = "4034e7cabeab153b728bffcdd1cf465b47360babf4c313619a8e39aa25d6f7e8"

URI_x86_64_v2_rust-codespan-reporting0.11+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting0.11+serde-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting0.11+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting0.11+serde-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting0.11+serde-devel.sha256sum] = "9ff875494a8c50391962ced5ccd28254f5955975b6d312b3f1717c0a671de273"

URI_x86_64_v2_rust-codespan-reporting0.11+serialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting0.11+serialization-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting0.11+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting0.11+serialization-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting0.11+serialization-devel.sha256sum] = "45f33131045ad22f5ade4df7c9437694ffe3cadecde0fa51e60ba1579cb328bd"

URI_x86_64_v2_rust-codespan-reporting0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting0.11-devel-0.11.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting0.11-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting0.11-devel.sha256sum] = "dbaa3233fe4abab2ea66fa3e9a9bc5aefb89030766fccc391836c791b7ea85c2"

URI_aarch64_rust-codespan-reporting0.11+ascii-only-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting0.11+ascii-only-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting0.11+ascii-only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting0.11+ascii-only-devel}"
SRC_URI[aarch64_rust-codespan-reporting0.11+ascii-only-devel.sha256sum] = "b7cf2540a70aad451313c70090730a6dac29179781bfe27e1d3984ab4abe58ca"

URI_aarch64_rust-codespan-reporting0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting0.11+default-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting0.11+default-devel}"
SRC_URI[aarch64_rust-codespan-reporting0.11+default-devel.sha256sum] = "ae684dbdf20a2cf91514ab3b34a9c3955d276064a05cd5d52beca78b678a5cd5"

URI_aarch64_rust-codespan-reporting0.11+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting0.11+serde-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting0.11+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting0.11+serde-devel}"
SRC_URI[aarch64_rust-codespan-reporting0.11+serde-devel.sha256sum] = "80b773548444a7db395c82549a2536dba60e4740f4287dde5a988954e95bb93c"

URI_aarch64_rust-codespan-reporting0.11+serialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting0.11+serialization-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting0.11+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting0.11+serialization-devel}"
SRC_URI[aarch64_rust-codespan-reporting0.11+serialization-devel.sha256sum] = "30345428e7e8d7e1a54e19a41e86c9c497a27ad7e69b860b8bb08e8d294fd3ca"

URI_aarch64_rust-codespan-reporting0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting0.11-devel-0.11.1-1.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting0.11-devel}"
SRC_URI[aarch64_rust-codespan-reporting0.11-devel.sha256sum] = "c79a592b31acc54d4f1b360cb8c6245c4f2c8e73b806568e0d77f4b2b98964e1"

RDEPENDS:rust-codespan-reporting0.11+ascii-only-devel = " \
 cargo \
 rust-codespan-reporting0.11-devel \
 "
RDEPENDS:rust-codespan-reporting0.11+default-devel = " \
 cargo \
 rust-codespan-reporting0.11-devel \
 "
RDEPENDS:rust-codespan-reporting0.11+serde-devel = " \
 cargo \
 rust-codespan-reporting0.11-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-codespan-reporting0.11+serialization-devel = " \
 cargo \
 rust-codespan-reporting0.11+serde-devel \
 rust-codespan-reporting0.11-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-codespan-reporting0.11-devel = " \
 cargo \
 rust-termcolor+default-devel \
 rust-unicode-width0.1+default-devel \
 "
