# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "baresip"
PV = "4.10.0"
PR = "1.el10_3"
PACKAGES = " \
 baresip \
 baresip-aac \
 baresip-alsa \
 baresip-av1 \
 baresip-avcodec \
 baresip-avfilter \
 baresip-avformat \
 baresip-codec2 \
 baresip-ctrl_dbus \
 baresip-devel \
 baresip-g722 \
 baresip-gst \
 baresip-gtk \
 baresip-jack \
 baresip-mqtt \
 baresip-opus \
 baresip-pipewire \
 baresip-plc \
 baresip-portaudio \
 baresip-pulse \
 baresip-sdl \
 baresip-snapshot \
 baresip-sndfile \
 baresip-swscale \
 baresip-tools \
 baresip-v4l2 \
 baresip-vp8 \
 baresip-vp9 \
 baresip-x11 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/baresip-4.10.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6d72e7e06f6be84695216e54974b894d981ac4cc0deee826d4babac217d835b"

URI_x86_64_v2_baresip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip}"
SRC_URI[x86_64_v2_baresip.sha256sum] = "4dae206d69a287435f686087d5d6ef9fc51a22466707c57adc19830701d5f5ae"

URI_x86_64_v2_baresip-aac = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-aac-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-aac;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-aac}"
SRC_URI[x86_64_v2_baresip-aac.sha256sum] = "77f72ff7903354e376b4a9ec5e969416ce65e3fe3a4530ca791dcb73c0ba71bc"

URI_x86_64_v2_baresip-alsa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-alsa-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-alsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-alsa}"
SRC_URI[x86_64_v2_baresip-alsa.sha256sum] = "050c4fad626c0629945aceb6f620b2d3619dc74c9512dc15aba8a8b92d16de1e"

URI_x86_64_v2_baresip-av1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-av1-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-av1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-av1}"
SRC_URI[x86_64_v2_baresip-av1.sha256sum] = "4f82ceea6bf393645b7dd2f5403e42a8ae9e86a21e648d0e54f9aa28cb353c3e"

URI_x86_64_v2_baresip-avcodec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avcodec-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avcodec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avcodec}"
SRC_URI[x86_64_v2_baresip-avcodec.sha256sum] = "39df6b105fab42fb9b1eae232dd026cf36ce8b312f0a6e5b559779b15408c0ff"

URI_x86_64_v2_baresip-avfilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avfilter-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avfilter}"
SRC_URI[x86_64_v2_baresip-avfilter.sha256sum] = "693ecf2aeab01d9163b501969badd3d0f903b59c95d380b9fafa178b2b17b6c0"

URI_x86_64_v2_baresip-avformat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-avformat-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-avformat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-avformat}"
SRC_URI[x86_64_v2_baresip-avformat.sha256sum] = "a098e1f3b6d031d21f1bc819fbc3287d54631bab2c484180968a281b52c352ae"

URI_x86_64_v2_baresip-codec2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-codec2-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-codec2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-codec2}"
SRC_URI[x86_64_v2_baresip-codec2.sha256sum] = "380e08ce117672e6b820dbe9c607a542197bd03782a2967a5615485a2307206d"

URI_x86_64_v2_baresip-ctrl_dbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-ctrl_dbus-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-ctrl_dbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-ctrl_dbus}"
SRC_URI[x86_64_v2_baresip-ctrl_dbus.sha256sum] = "da6ab9348f968b4683c704d32be650eab88e0bef728c8b3b48431e41402535f7"

URI_x86_64_v2_baresip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-devel-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-devel}"
SRC_URI[x86_64_v2_baresip-devel.sha256sum] = "b5cc96e5d5c4c9acba2a5c245903e798d9610678fb2ac402f0d9978b42229903"

URI_x86_64_v2_baresip-g722 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-g722-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-g722;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-g722}"
SRC_URI[x86_64_v2_baresip-g722.sha256sum] = "04eb40013d5786beaf7f01a7c539e73ed23963bf70f2384bcb520546461f6836"

URI_x86_64_v2_baresip-gst = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gst-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gst;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-gst}"
SRC_URI[x86_64_v2_baresip-gst.sha256sum] = "ca2fef34a3c3750fde3064e89bd7450867e38cfacf2e975a44741091669ff1c8"

URI_x86_64_v2_baresip-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-gtk-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-gtk}"
SRC_URI[x86_64_v2_baresip-gtk.sha256sum] = "9ce41ef77234f7b0c53544fef0c784fafc5020d8034a364473589bd1e9cb3303"

URI_x86_64_v2_baresip-jack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-jack-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-jack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-jack}"
SRC_URI[x86_64_v2_baresip-jack.sha256sum] = "5552b3d860a1896f1c91c44f7bb5d64d66086d9bb02da8edeb8161a00a11a527"

URI_x86_64_v2_baresip-mqtt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-mqtt-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-mqtt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-mqtt}"
SRC_URI[x86_64_v2_baresip-mqtt.sha256sum] = "89c5c6e865e90def9fce08d37fb55e2b059162af9d5701cdc359aadfb9bd2744"

URI_x86_64_v2_baresip-opus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-opus-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-opus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-opus}"
SRC_URI[x86_64_v2_baresip-opus.sha256sum] = "7bfe204728e10f232912f65ae5f2538779e4a8b3adb056b76ff740818e270736"

URI_x86_64_v2_baresip-pipewire = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pipewire-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pipewire;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-pipewire}"
SRC_URI[x86_64_v2_baresip-pipewire.sha256sum] = "6d19e68d76acc99bd78c5e86219b09b82564486214af5216748da7401de92317"

URI_x86_64_v2_baresip-plc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-plc-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-plc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-plc}"
SRC_URI[x86_64_v2_baresip-plc.sha256sum] = "493d10d1d551ff6356f7c7befbc4dfd8d90c348b8342843554b7878ab5ee7269"

URI_x86_64_v2_baresip-portaudio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-portaudio-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-portaudio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-portaudio}"
SRC_URI[x86_64_v2_baresip-portaudio.sha256sum] = "be7c68ee071ac6421833d1614bb9b723a6a0d60ce60069b1afb2875c3ca2888a"

URI_x86_64_v2_baresip-pulse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-pulse-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-pulse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-pulse}"
SRC_URI[x86_64_v2_baresip-pulse.sha256sum] = "d36c30869fcc1cef1247526889e266d39f7c43ea910317e16439099d3eb4393a"

URI_x86_64_v2_baresip-sdl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sdl-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sdl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-sdl}"
SRC_URI[x86_64_v2_baresip-sdl.sha256sum] = "79ba75da88faeb37b83896f314c4b6adfed6f7ec799c54da4dbefa8d86c0e2bf"

URI_x86_64_v2_baresip-snapshot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-snapshot-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-snapshot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-snapshot}"
SRC_URI[x86_64_v2_baresip-snapshot.sha256sum] = "1e7a7cef5da78025409ce2708aeab73a80109ccfef804a356bc89440d417c752"

URI_x86_64_v2_baresip-sndfile = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-sndfile-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-sndfile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-sndfile}"
SRC_URI[x86_64_v2_baresip-sndfile.sha256sum] = "56abb47a986295222cf21db4263867c129a27d8e097ee12110ab91f1f128f0a8"

URI_x86_64_v2_baresip-swscale = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-swscale-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-swscale;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-swscale}"
SRC_URI[x86_64_v2_baresip-swscale.sha256sum] = "391b8779d350536108599aac0c5b0eee24a3076f61ace55a757a8fd12f834f6b"

URI_x86_64_v2_baresip-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-tools-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-tools}"
SRC_URI[x86_64_v2_baresip-tools.sha256sum] = "f6ab4c4f70390f55d3d725312e626447e91e281ed673c956a6b17b814e5b2308"

URI_x86_64_v2_baresip-v4l2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-v4l2-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-v4l2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-v4l2}"
SRC_URI[x86_64_v2_baresip-v4l2.sha256sum] = "75b90fbc228a29f2af6c2bf60a448de7f2fb960eb4b8235e0fd1feaa5f4b794a"

URI_x86_64_v2_baresip-vp8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp8-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-vp8}"
SRC_URI[x86_64_v2_baresip-vp8.sha256sum] = "0495b48b844ec9e7284445a90aab8d3602f43ffad542ee2a588a7f5eea475c92"

URI_x86_64_v2_baresip-vp9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-vp9-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-vp9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-vp9}"
SRC_URI[x86_64_v2_baresip-vp9.sha256sum] = "2a99598ca647d19edef813a9e59a7d360ec24d87843bf507a7029237f2f426cc"

URI_x86_64_v2_baresip-x11 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/baresip-x11-4.10.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_baresip-x11;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_baresip-x11}"
SRC_URI[x86_64_v2_baresip-x11.sha256sum] = "5c5882bb8eaeaadd51d828dd9a6340d7b2e31f69ee71065041fcb51ebd21e03e"

URI_aarch64_baresip = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip}"
SRC_URI[aarch64_baresip.sha256sum] = "4367d395afe0f90c328c321922b49f68e04730f032a7fb28938b6f872eaa1f9b"

URI_aarch64_baresip-aac = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-aac-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-aac;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-aac}"
SRC_URI[aarch64_baresip-aac.sha256sum] = "f12ac1f59d5d49c0d39bcc905b530f3a0cd45cc2d8cfd0e98016d5f5562cb017"

URI_aarch64_baresip-alsa = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-alsa-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-alsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-alsa}"
SRC_URI[aarch64_baresip-alsa.sha256sum] = "d38d27b238acce8229af3f4d61ffeeb0262e588c046d601a3c4d1437f832c596"

URI_aarch64_baresip-av1 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-av1-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-av1;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-av1}"
SRC_URI[aarch64_baresip-av1.sha256sum] = "6c2cf653237740bd48f8b1bf5d55b4b45fd60eb68243b5458249669db1458874"

URI_aarch64_baresip-avcodec = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avcodec-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-avcodec;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avcodec}"
SRC_URI[aarch64_baresip-avcodec.sha256sum] = "285ccaee9708d3b5b027d64400e9e1225e8254ee6f972247c48edb8651cd88fd"

URI_aarch64_baresip-avfilter = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avfilter-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-avfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avfilter}"
SRC_URI[aarch64_baresip-avfilter.sha256sum] = "c8919ac063060a4e188459349cf779bb2a3c867dca4d2ff5e842fb9043a1ba17"

URI_aarch64_baresip-avformat = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-avformat-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-avformat;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-avformat}"
SRC_URI[aarch64_baresip-avformat.sha256sum] = "b2a2be8e2fe96f7e93927350b850b9e0b7bc2236dad20c9880582d3486a13a89"

URI_aarch64_baresip-codec2 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-codec2-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-codec2;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-codec2}"
SRC_URI[aarch64_baresip-codec2.sha256sum] = "fe82714cc8257ba67f1feb5f7fb1ef64483a47533fa2187700975b28af7c6405"

URI_aarch64_baresip-ctrl_dbus = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-ctrl_dbus-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-ctrl_dbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-ctrl_dbus}"
SRC_URI[aarch64_baresip-ctrl_dbus.sha256sum] = "a426af84f03216011249addab88feb5773d3d5c6dfb139738e8590486e3fbb25"

URI_aarch64_baresip-devel = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-devel-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-devel}"
SRC_URI[aarch64_baresip-devel.sha256sum] = "cef92b828b1b8501703115c2cd5298b3725ae28847e653d768910fc8c1ce5652"

URI_aarch64_baresip-g722 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-g722-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-g722;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-g722}"
SRC_URI[aarch64_baresip-g722.sha256sum] = "6aa2df68ceae9293f4fcff5ebd33a4946b99256b9ab4354364fd3881ce66ad90"

URI_aarch64_baresip-gst = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-gst-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-gst;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-gst}"
SRC_URI[aarch64_baresip-gst.sha256sum] = "2ee5499f61c83da8dd923fe4b62396f7f8c8a0679d349da34b54b644ad6f6147"

URI_aarch64_baresip-gtk = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-gtk-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-gtk}"
SRC_URI[aarch64_baresip-gtk.sha256sum] = "214d8123d3a94c408fac3411d58e730a818d4fb5e2b3aff89cab5a1e0d1c97d1"

URI_aarch64_baresip-jack = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-jack-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-jack;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-jack}"
SRC_URI[aarch64_baresip-jack.sha256sum] = "7c2e42967ac3ba6ceacf820a41e452dfeb2faa2feb328fc6b557e835068cb778"

URI_aarch64_baresip-mqtt = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-mqtt-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-mqtt;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-mqtt}"
SRC_URI[aarch64_baresip-mqtt.sha256sum] = "b667a817c7306df2b80d841f1624da9af86eaaed40b0ca2d92b3486185acc175"

URI_aarch64_baresip-opus = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-opus-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-opus;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-opus}"
SRC_URI[aarch64_baresip-opus.sha256sum] = "02d255cddc6bf749e0ed03809949ebdb8236969194eec23f2c4d9144db5f6c63"

URI_aarch64_baresip-pipewire = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-pipewire-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-pipewire;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-pipewire}"
SRC_URI[aarch64_baresip-pipewire.sha256sum] = "9eb95b3cd8f6162108b4f26ccd593a350a0eef7cc9f3bd3b066ba611288daf39"

URI_aarch64_baresip-plc = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-plc-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-plc;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-plc}"
SRC_URI[aarch64_baresip-plc.sha256sum] = "936048e3dd2dcb16b5239432ddc327041b79a421b32ab0ca5aab74c685470157"

URI_aarch64_baresip-portaudio = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-portaudio-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-portaudio;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-portaudio}"
SRC_URI[aarch64_baresip-portaudio.sha256sum] = "abc8eaa4bac5bde16ae62974ca4d403bf9fb1ccc537090ef6b12fedde6bcc213"

URI_aarch64_baresip-pulse = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-pulse-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-pulse;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-pulse}"
SRC_URI[aarch64_baresip-pulse.sha256sum] = "df3556697d502041b8f314e6067e8fa790789430ccd289ac7a00950eb2b69fa9"

URI_aarch64_baresip-sdl = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-sdl-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-sdl;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-sdl}"
SRC_URI[aarch64_baresip-sdl.sha256sum] = "b92ba033e7a495fd7c1d66b79effdb0cf43deecdf4d40537cb98e0af48413104"

URI_aarch64_baresip-snapshot = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-snapshot-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-snapshot;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-snapshot}"
SRC_URI[aarch64_baresip-snapshot.sha256sum] = "b6d90e741b855edb7f72083bc4f0c55dbc37dbb270cdf583c1c50ac1b1b16eaa"

URI_aarch64_baresip-sndfile = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-sndfile-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-sndfile;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-sndfile}"
SRC_URI[aarch64_baresip-sndfile.sha256sum] = "48ce89502e5d0c63cb32bc616cbfdded4d1365cada9c27a4acb1b9d3bc9edfcf"

URI_aarch64_baresip-swscale = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-swscale-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-swscale;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-swscale}"
SRC_URI[aarch64_baresip-swscale.sha256sum] = "5d3617fc5d2b1f3a0e0d3f650d5f98d1d3f798274187e09ffc9a9dd272d58384"

URI_aarch64_baresip-tools = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-tools-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-tools}"
SRC_URI[aarch64_baresip-tools.sha256sum] = "485ed59b3cb2414ac70b48264f481a72e3bdad60935552652d29ad3c305e44d5"

URI_aarch64_baresip-v4l2 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-v4l2-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-v4l2;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-v4l2}"
SRC_URI[aarch64_baresip-v4l2.sha256sum] = "85dc9d339bfc9de75f57d2353d037fd1b705a6f7d87a0d3a7b105aa505801f11"

URI_aarch64_baresip-vp8 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp8-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-vp8;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-vp8}"
SRC_URI[aarch64_baresip-vp8.sha256sum] = "80a388c1db3ebf65b5f9ac4feb136a8039abce6ffaa1b988092607d7382e89a7"

URI_aarch64_baresip-vp9 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-vp9-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-vp9;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-vp9}"
SRC_URI[aarch64_baresip-vp9.sha256sum] = "7abc23d3302d5dd667752c770488bdc3cc3af5bec912d36e32bcda60f760b9c4"

URI_aarch64_baresip-x11 = "${EPEL_MIRROR}/aarch64/Packages/b/baresip-x11-4.10.0-1.el10_3.aarch64.rpm;name=aarch64_baresip-x11;unpack=0"
SRC_URI:append = " ${URI_aarch64_baresip-x11}"
SRC_URI[aarch64_baresip-x11.sha256sum] = "ff62defe370ee760defb077c921a5b3efa13ab1cde0ba84a6e5dd7069d756a98"

RDEPENDS:baresip = " \
 glibc \
 libre \
 "
RDEPENDS:baresip-aac = " \
 baresip \
 fdk-aac-free \
 glibc \
 "
RDEPENDS:baresip-alsa = " \
 alsa-lib \
 baresip \
 glibc \
 "
RDEPENDS:baresip-av1 = " \
 baresip \
 glibc \
 libaom \
 "
RDEPENDS:baresip-avcodec = " \
 baresip \
 glibc \
 libavcodec-free \
 libavutil-free \
 "
RDEPENDS:baresip-avfilter = " \
 baresip \
 glibc \
 libavfilter-free \
 libavutil-free \
 "
RDEPENDS:baresip-avformat = " \
 baresip \
 glibc \
 libavcodec-free \
 libavdevice-free \
 libavformat-free \
 libavutil-free \
 libswresample-free \
 "
RDEPENDS:baresip-codec2 = " \
 baresip \
 codec2 \
 glibc \
 "
RDEPENDS:baresip-ctrl_dbus = " \
 baresip \
 glib2 \
 glibc \
 "
RDEPENDS:baresip-devel = " \
 baresip \
 pkgconf-pkg-config \
 "
RDEPENDS:baresip-g722 = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-gst = " \
 baresip \
 glib2 \
 glibc \
 gstreamer1 \
 "
RDEPENDS:baresip-gtk = " \
 adwaita-icon-theme \
 baresip \
 glib2 \
 glibc \
 gnome-shell-extension-appindicator \
 gtk3 \
 "
RDEPENDS:baresip-jack = " \
 baresip \
 glibc \
 pipewire-jack-audio-connection-kit-libs \
 "
RDEPENDS:baresip-mqtt = " \
 baresip \
 glibc \
 mosquitto \
 "
RDEPENDS:baresip-opus = " \
 baresip \
 glibc \
 opus \
 "
RDEPENDS:baresip-pipewire = " \
 baresip \
 glibc \
 pipewire-libs \
 "
RDEPENDS:baresip-plc = " \
 baresip \
 glibc \
 spandsp \
 "
RDEPENDS:baresip-portaudio = " \
 baresip \
 glibc \
 portaudio \
 "
RDEPENDS:baresip-pulse = " \
 baresip \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:baresip-sdl = " \
 baresip \
 glibc \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:baresip-snapshot = " \
 baresip \
 glibc \
 libpng \
 "
RDEPENDS:baresip-sndfile = " \
 baresip \
 glibc \
 libsndfile \
 "
RDEPENDS:baresip-swscale = " \
 baresip \
 glibc \
 libswscale-free \
 "
RDEPENDS:baresip-tools = " \
 baresip \
 python3 \
 "
RDEPENDS:baresip-v4l2 = " \
 baresip \
 glibc \
 "
RDEPENDS:baresip-vp8 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-vp9 = " \
 baresip \
 glibc \
 libvpx \
 "
RDEPENDS:baresip-x11 = " \
 baresip \
 glibc \
 libX11 \
 libXext \
 "
