# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiostream"
PV = "0.7.0"
PR = "3.el10_2"
PACKAGES = " \
 python3-aiostream \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiostream-0.7.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76f388aafc5f3bceb43dc7dee4ab9f56ecfa1e33d1512fed353f55e36f90f95b"

URI_x86_64_v2_python3-aiostream = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiostream-0.7.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiostream;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiostream}"
SRC_URI[x86_64_v2_python3-aiostream.sha256sum] = "33a5c587ec49bdf1e47d9d857a59d16580e955a79a1beacf24497691b9677666"

URI_aarch64_python3-aiostream = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiostream-0.7.0-3.el10_2.noarch.rpm;name=aarch64_python3-aiostream;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiostream}"
SRC_URI[aarch64_python3-aiostream.sha256sum] = "df0c59e748d5cd1108c18ea12fc738eb4178c3849104f93e3ce39fdd09c4d73e"

RDEPENDS:python3-aiostream = " \
 python3 \
 python3-typing-extensions \
 "
