# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-Helpers"
PV = "0.028"
PR = "1.el10_3"
PACKAGES = " \
 perl-ExtUtils-Helpers \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-Helpers-0.028-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4e72c4e14e8e7215280a787cfaeef66ab62e25ee201a8fe2198cb99891b9f605"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-Helpers-0.028-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-Helpers;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-Helpers.sha256sum] = "0d47544cd5e754ac7205b4647adc5390de32493daf36e6ec6eb98dd9b095e537"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-Helpers-0.028-1.el10_3.noarch.rpm;name=aarch64_perl-ExtUtils-Helpers;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-Helpers.sha256sum] = "68a7f674e7140dc803b15980376b9b002275ee884c45a399fb180b564a782784"

RDEPENDS:perl-ExtUtils-Helpers = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-PathTools \
 perl-Text-ParseWords \
 perl-libs \
 "
