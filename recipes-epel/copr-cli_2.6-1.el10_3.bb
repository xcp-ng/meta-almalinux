# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "copr-cli"
PV = "2.6"
PR = "1.el10_3"
PACKAGES = " \
 copr-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/copr-cli-2.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a2887c4583b0b2a31fc42ccaa86acf2cfb93ea371c790b72f6d43db39091c06"

URI_x86_64_v2_copr-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/copr-cli-2.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_copr-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_copr-cli}"
SRC_URI[x86_64_v2_copr-cli.sha256sum] = "035b6c8a3492032621fe81800941d42830569d06ff99a0ac1cadf81562c5964d"

URI_aarch64_copr-cli = "${EPEL_MIRROR}/aarch64/Packages/c/copr-cli-2.6-1.el10_3.noarch.rpm;name=aarch64_copr-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_copr-cli}"
SRC_URI[aarch64_copr-cli.sha256sum] = "a8342a189c91e8e79f796e6ca19f77f02e518b0258e0f61f24850a60a8443d38"

RDEPENDS:copr-cli = " \
 python3 \
 python3-copr \
 python3-humanize \
 python3-jinja2 \
 python3-koji \
 python3-rich \
 python3-setuptools \
 python3-typing-extensions \
 wget \
 "
