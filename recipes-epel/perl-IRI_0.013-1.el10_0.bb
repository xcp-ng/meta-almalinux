# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IRI"
PV = "0.013"
PR = "1.el10_0"
PACKAGES = " \
 perl-IRI \
 perl-IRI-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-IRI-0.013-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e3c7b4a6545fbf58cd8cb56c92963528b452cd36daabcabf2483e878b90d6207"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IRI-0.013-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IRI;unpack=0"
SRC_URI[x86_64_v2_perl-IRI.sha256sum] = "72f59d53a06e4b8fbb89e972bcb039904ac1f472bb3ad286d3227717d2640ef0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IRI-tests-0.013-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IRI-tests;unpack=0"
SRC_URI[x86_64_v2_perl-IRI-tests.sha256sum] = "5737b0ba7c3213184368400335b538f73484e0512f4a3d803f265fcce2b33042"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-IRI-0.013-1.el10_0.noarch.rpm;name=aarch64_perl-IRI;unpack=0"
SRC_URI[aarch64_perl-IRI.sha256sum] = "0e3a3c73bfcef025fa5c6bb52038b32582968d6842dfbda600efb80959404dd5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-IRI-tests-0.013-1.el10_0.noarch.rpm;name=aarch64_perl-IRI-tests;unpack=0"
SRC_URI[aarch64_perl-IRI-tests.sha256sum] = "48286eefc0835573cf4351790805069d7c7437816a68f36696ca51687db7c01b"

RDEPENDS:perl-IRI = " \
 perl-Data-Dumper \
 perl-Moo \
 perl-MooX-HandlesVia \
 perl-Scalar-List-Utils \
 perl-Type-Tiny \
 perl-libs \
 "
RDEPENDS:perl-IRI-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Encode \
 perl-IRI \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-URI \
 perl-interpreter \
 perl-libs \
 "
