# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-log"
PV = "0.4.33"
PR = "1.el10_2"
PACKAGES = " \
 rust-log+default-devel \
 rust-log+kv-devel \
 rust-log+max_level_debug-devel \
 rust-log+max_level_error-devel \
 rust-log+max_level_info-devel \
 rust-log+max_level_off-devel \
 rust-log+max_level_trace-devel \
 rust-log+max_level_warn-devel \
 rust-log+release_max_level_debug-devel \
 rust-log+release_max_level_error-devel \
 rust-log+release_max_level_info-devel \
 rust-log+release_max_level_off-devel \
 rust-log+release_max_level_trace-devel \
 rust-log+release_max_level_warn-devel \
 rust-log+serde-devel \
 rust-log+serde_core-devel \
 rust-log+std-devel \
 rust-log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-log-0.4.33-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34f18d4c1cc09ffcbc2e9d46fd19523a5b6991f9695fdc8e563c5c638f740ec5"

URI_x86_64_v2_rust-log+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+default-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+default-devel}"
SRC_URI[x86_64_v2_rust-log+default-devel.sha256sum] = "63a29adcb718fa72fb99bf2cb20c3fb31e83038e7c67fbd69d14ff57028f2f9a"

URI_x86_64_v2_rust-log+kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+kv-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+kv-devel}"
SRC_URI[x86_64_v2_rust-log+kv-devel.sha256sum] = "8dd1181f749849452c6e18ca2625f81fc5795e9cd46aa5c1ef2aea69c83a989b"

URI_x86_64_v2_rust-log+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_debug-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_debug-devel.sha256sum] = "3dd0edd24e25027b22eabd435e64480a7d37fbd6da83467e0e915c68e83758f1"

URI_x86_64_v2_rust-log+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_error-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_error-devel.sha256sum] = "c1d363377b5e3d48207db457c882ac9baa8a220834f030701b47ee86d5deb050"

URI_x86_64_v2_rust-log+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_info-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_info-devel.sha256sum] = "f054f56995d6b8927c9ba90fe3effa4ea68d7b6e78755ad6db1e00d7ffbc9ff1"

URI_x86_64_v2_rust-log+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_off-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_off-devel.sha256sum] = "a5352795801c2089d440765ed3788d62a372ec194d970982ccdefd287129b7f9"

URI_x86_64_v2_rust-log+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_trace-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_trace-devel.sha256sum] = "78656c20aaf1cafe69b1bd39a6b0c7e3d642c03a7d03f5a0ef4c409afde16c11"

URI_x86_64_v2_rust-log+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+max_level_warn-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-log+max_level_warn-devel.sha256sum] = "30aa3f8b539d8c9811185f2200ae03ee4ffea1a45a1fdeb5b6405f43d2010771"

URI_x86_64_v2_rust-log+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_debug-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_debug-devel.sha256sum] = "0acab76ac826f1a28be1e3030e73ffaf47efaf28b7f18bb742dd7d828ba7708c"

URI_x86_64_v2_rust-log+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_error-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_error-devel.sha256sum] = "3eebf1a8f6bee874bec4fb54c0620970bc49f4913ac4de1a0278d7e2a4cab536"

URI_x86_64_v2_rust-log+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_info-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_info-devel.sha256sum] = "6082f8c8f7839d50dc29762bf00c04e1204577d804b52351ac55f037cca885a6"

URI_x86_64_v2_rust-log+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_off-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_off-devel.sha256sum] = "27cd9fee1322182c9e1394f4c2664f3113fb1e972da5a25a7f8e33c77e32ad52"

URI_x86_64_v2_rust-log+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_trace-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_trace-devel.sha256sum] = "3f4ac815ebbd7be0634f9c5dbe656c9f9233613a0f9d6833a06d8da2a888028e"

URI_x86_64_v2_rust-log+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+release_max_level_warn-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-log+release_max_level_warn-devel.sha256sum] = "28dbbed3b870df3fff2357a0e9ced59028dcd3baf30e63a5e3bf8198919da891"

URI_x86_64_v2_rust-log+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+serde-devel}"
SRC_URI[x86_64_v2_rust-log+serde-devel.sha256sum] = "bcf3332ab37767325253f207b6663d111f0a2fcbc0ac85cc8965ee1a0dd41620"

URI_x86_64_v2_rust-log+serde_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+serde_core-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+serde_core-devel}"
SRC_URI[x86_64_v2_rust-log+serde_core-devel.sha256sum] = "17591bb71633b3bf4b0755fa63c0e2f4a3d95615beed2c4e7baed2e500d893b5"

URI_x86_64_v2_rust-log+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log+std-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log+std-devel}"
SRC_URI[x86_64_v2_rust-log+std-devel.sha256sum] = "038ef7d5c459d36ec46fb4a4776e7e4fb1d991ca04dc8434762d04890641cf15"

URI_x86_64_v2_rust-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-log-devel-0.4.33-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-log-devel}"
SRC_URI[x86_64_v2_rust-log-devel.sha256sum] = "adc45a01ff5c8f87594fcf731436d9650781df3866abe11aa77e934630a7f440"

URI_aarch64_rust-log+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+default-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+default-devel}"
SRC_URI[aarch64_rust-log+default-devel.sha256sum] = "369cc4841530f67b27d1af1e7db542fe04e2c466c8cf841bec183845f0773bd5"

URI_aarch64_rust-log+kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+kv-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+kv-devel}"
SRC_URI[aarch64_rust-log+kv-devel.sha256sum] = "2f7935c6792cd7c87fa151aa12fc4bf12e3a1e00598b4cbbed8d3eb12f52ccd5"

URI_aarch64_rust-log+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_debug-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_debug-devel}"
SRC_URI[aarch64_rust-log+max_level_debug-devel.sha256sum] = "bbc530352f63030008efd89dffb1ade2e8ca33a4732e5820a152b055cff26512"

URI_aarch64_rust-log+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_error-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_error-devel}"
SRC_URI[aarch64_rust-log+max_level_error-devel.sha256sum] = "0b052c3ab7020243d9c3a36e9d1d7e35c5d94ee12a43d82b1a3b065be2bbfc56"

URI_aarch64_rust-log+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_info-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_info-devel}"
SRC_URI[aarch64_rust-log+max_level_info-devel.sha256sum] = "888301089ab76c6ab7ea0bf88267214eb9da529a7f76b97addf65076885b0bab"

URI_aarch64_rust-log+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_off-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_off-devel}"
SRC_URI[aarch64_rust-log+max_level_off-devel.sha256sum] = "43e24afafd09c94f9c905ca55c9a80771f601fa610eae3beb562c0505857c7ae"

URI_aarch64_rust-log+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_trace-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_trace-devel}"
SRC_URI[aarch64_rust-log+max_level_trace-devel.sha256sum] = "2d2a9040fe6f6678af6790891bd5c111bae3ba3ee1e87c92c66ab592e15375e5"

URI_aarch64_rust-log+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+max_level_warn-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+max_level_warn-devel}"
SRC_URI[aarch64_rust-log+max_level_warn-devel.sha256sum] = "9522abe219fbcb6d58b9fde339556d42af678f4afdc62111fed3711e3049464f"

URI_aarch64_rust-log+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_debug-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-log+release_max_level_debug-devel.sha256sum] = "58630bcd80f032230648203f0b36dd0173bc04759cc267da9a35308476e351f3"

URI_aarch64_rust-log+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_error-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_error-devel}"
SRC_URI[aarch64_rust-log+release_max_level_error-devel.sha256sum] = "41f0d0b223a94c63026da5608b59c54358d63fbfede3ac79caf49476bb120ae8"

URI_aarch64_rust-log+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_info-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_info-devel}"
SRC_URI[aarch64_rust-log+release_max_level_info-devel.sha256sum] = "62f46bd850973fa0406e5ad7841215ca0565e1d2842d3cceaaf08cc1aabf0efc"

URI_aarch64_rust-log+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_off-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_off-devel}"
SRC_URI[aarch64_rust-log+release_max_level_off-devel.sha256sum] = "386776ed5de108b9836247005781655a64805bf4abb428562f3bff545815d4bc"

URI_aarch64_rust-log+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_trace-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-log+release_max_level_trace-devel.sha256sum] = "a2e89d5eb7199ff429860535edac6b869f14ccc215621c6be81b9311df3573c2"

URI_aarch64_rust-log+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+release_max_level_warn-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-log+release_max_level_warn-devel.sha256sum] = "2634039b890210507564c2e53c996a4bef9a6c4df8cf3cf89e54da62e4bc1e26"

URI_aarch64_rust-log+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+serde-devel}"
SRC_URI[aarch64_rust-log+serde-devel.sha256sum] = "1c3e48cdf78c0843130d89e2b11dd81d74cf5c450add2ea839f6e1d8c792faa3"

URI_aarch64_rust-log+serde_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+serde_core-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+serde_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+serde_core-devel}"
SRC_URI[aarch64_rust-log+serde_core-devel.sha256sum] = "6bb98e9baf165359fe19c3b2d4daf859fda7f542bed2e0e87677fb94f1f9ac24"

URI_aarch64_rust-log+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log+std-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log+std-devel}"
SRC_URI[aarch64_rust-log+std-devel.sha256sum] = "cb57248bf95ac74891ac2a01bfc881c696cee0ca9ed29f604c4cdb73c7b0190e"

URI_aarch64_rust-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-log-devel-0.4.33-1.el10_2.noarch.rpm;name=aarch64_rust-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-log-devel}"
SRC_URI[aarch64_rust-log-devel.sha256sum] = "fda28cb6969d1bc295490c8127c20f75be292c4f9db9afb92d6584d00332cbf0"

RDEPENDS:rust-log+default-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+kv-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_debug-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_error-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_info-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_off-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_trace-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+release_max_level_warn-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde-devel = " \
 cargo \
 rust-log+serde_core-devel \
 rust-log-devel \
 "
RDEPENDS:rust-log+serde_core-devel = " \
 cargo \
 rust-log-devel \
 rust-serde_core-devel \
 "
RDEPENDS:rust-log+std-devel = " \
 cargo \
 rust-log-devel \
 "
RDEPENDS:rust-log-devel = " \
 cargo \
 rust \
 "
