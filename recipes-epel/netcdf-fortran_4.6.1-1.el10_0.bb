# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netcdf-fortran"
PV = "4.6.1"
PR = "1.el10_0"
PACKAGES = " \
 netcdf-fortran \
 netcdf-fortran-devel \
 netcdf-fortran-mpich \
 netcdf-fortran-mpich-devel \
 netcdf-fortran-mpich-static \
 netcdf-fortran-openmpi \
 netcdf-fortran-openmpi-devel \
 netcdf-fortran-openmpi-static \
 netcdf-fortran-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netcdf-fortran-4.6.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49503e11080c8e20376344997a9300b3ef2eb6e8e8d918fb24f7c13dcb51ae53"

URI_x86_64_v2_netcdf-fortran = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-4.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran}"
SRC_URI[x86_64_v2_netcdf-fortran.sha256sum] = "80a7a4fe45b2def8dbb025817055b2d302a88b7af3910e8b695c455c4e2f47d7"

URI_x86_64_v2_netcdf-fortran-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-devel-4.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-devel}"
SRC_URI[x86_64_v2_netcdf-fortran-devel.sha256sum] = "6c249e9d2352b737fe0caff5b725c4783010d4a3aa1438648d1d3071667dce63"

URI_x86_64_v2_netcdf-fortran-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-mpich-4.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-mpich}"
SRC_URI[x86_64_v2_netcdf-fortran-mpich.sha256sum] = "804216a702052edc73fe321df5611b74d05f7327c7aafc2b0b35a0f016c1bcbd"

URI_x86_64_v2_netcdf-fortran-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-mpich-devel-4.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-mpich-devel}"
SRC_URI[x86_64_v2_netcdf-fortran-mpich-devel.sha256sum] = "d066efa988ed469ee5a7e7ced5d0157926da8ea755507745adebe3d699c998a3"

URI_x86_64_v2_netcdf-fortran-mpich-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-mpich-static-4.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-mpich-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-mpich-static}"
SRC_URI[x86_64_v2_netcdf-fortran-mpich-static.sha256sum] = "89f1d92ea80f6b03060b41d8ab8f96143cec82eb20b8ec1619f5fc3c3d414e89"

URI_x86_64_v2_netcdf-fortran-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-openmpi-4.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-openmpi}"
SRC_URI[x86_64_v2_netcdf-fortran-openmpi.sha256sum] = "6620fd02df9a9a09ce5954b70a995a1046d3573a094644d2bac7b5b0c874207a"

URI_x86_64_v2_netcdf-fortran-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-openmpi-devel-4.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-openmpi-devel}"
SRC_URI[x86_64_v2_netcdf-fortran-openmpi-devel.sha256sum] = "2d9da80e3316b65601fe09cab1f75a581a4c0d7d5ccad32b8c22dcb69446dd88"

URI_x86_64_v2_netcdf-fortran-openmpi-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-openmpi-static-4.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-openmpi-static}"
SRC_URI[x86_64_v2_netcdf-fortran-openmpi-static.sha256sum] = "8f3019bf0e37495df7800f6a943f92bc2fdc41855d6bf3e6704751079c0feeb6"

URI_x86_64_v2_netcdf-fortran-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcdf-fortran-static-4.6.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcdf-fortran-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcdf-fortran-static}"
SRC_URI[x86_64_v2_netcdf-fortran-static.sha256sum] = "1e3d81477d554c2c9cee80b232e9f7500872441d018cd449553b72c391d00485"

URI_aarch64_netcdf-fortran = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-4.6.1-1.el10_0.aarch64.rpm;name=aarch64_netcdf-fortran;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran}"
SRC_URI[aarch64_netcdf-fortran.sha256sum] = "7d88765e5b97f521459cb2ca30b52bd0a19b384ff64d72a4ea63d7775c66dacb"

URI_aarch64_netcdf-fortran-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-devel-4.6.1-1.el10_0.aarch64.rpm;name=aarch64_netcdf-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-devel}"
SRC_URI[aarch64_netcdf-fortran-devel.sha256sum] = "9b5ca4855b3888d99bb117d8a3e4ac01c4e538ccdb4a4b23259d099985704bd7"

URI_aarch64_netcdf-fortran-mpich = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-mpich-4.6.1-1.el10_0.aarch64.rpm;name=aarch64_netcdf-fortran-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-mpich}"
SRC_URI[aarch64_netcdf-fortran-mpich.sha256sum] = "aa5f3f476c60662992115f482de59f69abb92c6c3f652d5e6dee2d1b10db2698"

URI_aarch64_netcdf-fortran-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-mpich-devel-4.6.1-1.el10_0.aarch64.rpm;name=aarch64_netcdf-fortran-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-mpich-devel}"
SRC_URI[aarch64_netcdf-fortran-mpich-devel.sha256sum] = "f604b0db3474daf7a045b90e8220d636ba0c45547ccd12f43dc1908da6099b25"

URI_aarch64_netcdf-fortran-mpich-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-mpich-static-4.6.1-1.el10_0.aarch64.rpm;name=aarch64_netcdf-fortran-mpich-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-mpich-static}"
SRC_URI[aarch64_netcdf-fortran-mpich-static.sha256sum] = "e04197bff8067edd0636b4368cea373ae53b053f5447bbe0344d53a5e2642f25"

URI_aarch64_netcdf-fortran-openmpi = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-openmpi-4.6.1-1.el10_0.aarch64.rpm;name=aarch64_netcdf-fortran-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-openmpi}"
SRC_URI[aarch64_netcdf-fortran-openmpi.sha256sum] = "bddafea8238107265387eb3ee673286197f154ccb7c97419aaead087c5e51d09"

URI_aarch64_netcdf-fortran-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-openmpi-devel-4.6.1-1.el10_0.aarch64.rpm;name=aarch64_netcdf-fortran-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-openmpi-devel}"
SRC_URI[aarch64_netcdf-fortran-openmpi-devel.sha256sum] = "ebbec78b627c1f483421271117c848a33c005ee74352dc9159cc0a487c4ae8bf"

URI_aarch64_netcdf-fortran-openmpi-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-openmpi-static-4.6.1-1.el10_0.aarch64.rpm;name=aarch64_netcdf-fortran-openmpi-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-openmpi-static}"
SRC_URI[aarch64_netcdf-fortran-openmpi-static.sha256sum] = "224e5966a2502b111621fd92984fa635bfa50e73cfb4cf4cfd42f6405bd49a42"

URI_aarch64_netcdf-fortran-static = "${EPEL_MIRROR}/aarch64/Packages/n/netcdf-fortran-static-4.6.1-1.el10_0.aarch64.rpm;name=aarch64_netcdf-fortran-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcdf-fortran-static}"
SRC_URI[aarch64_netcdf-fortran-static.sha256sum] = "88891b2476f9d58754dda6b6df9cbca0390128345c5d850282bc58791307a979"

RDEPENDS:netcdf-fortran:x86_64_v2 = " \
 glibc \
 libgcc \
 libgfortran \
 netcdf \
"
RDEPENDS:netcdf-fortran:aarch64 = " \
 glibc \
 libgfortran \
 netcdf \
"
RDEPENDS:netcdf-fortran-devel = " \
 bash \
 gcc-gfortran \
 netcdf-devel \
 netcdf-fortran \
 pkgconf-pkg-config \
 "
RDEPENDS:netcdf-fortran-mpich:x86_64_v2 = " \
 glibc \
 libgcc \
 libgfortran \
 netcdf-mpich \
"
RDEPENDS:netcdf-fortran-mpich:aarch64 = " \
 glibc \
 libgfortran \
 netcdf-mpich \
"
RDEPENDS:netcdf-fortran-mpich-devel = " \
 bash \
 gcc-gfortran \
 libcurl-devel \
 netcdf-fortran-mpich \
 netcdf-mpich-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:netcdf-fortran-mpich-static = " \
 netcdf-fortran-mpich-devel \
 "
RDEPENDS:netcdf-fortran-openmpi:x86_64_v2 = " \
 glibc \
 libgcc \
 libgfortran \
 netcdf-openmpi \
"
RDEPENDS:netcdf-fortran-openmpi:aarch64 = " \
 glibc \
 libgfortran \
 netcdf-openmpi \
"
RDEPENDS:netcdf-fortran-openmpi-devel = " \
 bash \
 gcc-gfortran \
 libcurl-devel \
 netcdf-fortran-openmpi \
 netcdf-openmpi-devel \
 openmpi-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:netcdf-fortran-openmpi-static = " \
 netcdf-fortran-openmpi-devel \
 "
RDEPENDS:netcdf-fortran-static = " \
 netcdf-fortran-devel \
 "
