# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "psimd"
PV = "20200517.072586a"
PR = "8.el10_1"
PACKAGES = " \
 psimd-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/psimd-20200517.072586a-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "631b10cb988facce707427a3612f8f7d77c187e905de477305068a0b42ebc368"

URI_x86_64_v2_psimd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/psimd-devel-20200517.072586a-8.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_psimd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_psimd-devel}"
SRC_URI[x86_64_v2_psimd-devel.sha256sum] = "c90587cfb4e752bef4280a0604082c42f305610dbf675f70e6ee2ae0e280e426"

URI_aarch64_psimd-devel = "${EPEL_MIRROR}/aarch64/Packages/p/psimd-devel-20200517.072586a-8.el10_1.noarch.rpm;name=aarch64_psimd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_psimd-devel}"
SRC_URI[aarch64_psimd-devel.sha256sum] = "7b40fb6d6579e3f1e7ab78b622b517b229b19cea7b03136eb756d94cde2426e1"

RDEPENDS:psimd-devel = " \
 "
