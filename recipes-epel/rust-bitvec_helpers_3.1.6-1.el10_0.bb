# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bitvec_helpers"
PV = "3.1.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-bitvec_helpers+bitstream-io-devel \
 rust-bitvec_helpers+bitvec-devel \
 rust-bitvec_helpers+default-devel \
 rust-bitvec_helpers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bitvec_helpers-3.1.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dafc41669ec0204a5d900dfb51f7a34782f878a7864e07d8b0030e52826f763e"

URI_x86_64_v2_rust-bitvec_helpers+bitstream-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec_helpers+bitstream-io-devel-3.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec_helpers+bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec_helpers+bitstream-io-devel}"
SRC_URI[x86_64_v2_rust-bitvec_helpers+bitstream-io-devel.sha256sum] = "9b2cf36e7dbfc40fed15ac22523805b21835a70d739d9dd407ff9def8d799f17"

URI_x86_64_v2_rust-bitvec_helpers+bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec_helpers+bitvec-devel-3.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec_helpers+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec_helpers+bitvec-devel}"
SRC_URI[x86_64_v2_rust-bitvec_helpers+bitvec-devel.sha256sum] = "7a9789969ae8692d165e502504095e7939e5982d97fcbcc105910c540567c396"

URI_x86_64_v2_rust-bitvec_helpers+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec_helpers+default-devel-3.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec_helpers+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec_helpers+default-devel}"
SRC_URI[x86_64_v2_rust-bitvec_helpers+default-devel.sha256sum] = "4164d03f25e000753cf095906c550c1d6eb5e98d6b68a2bbb13d70cca6ccc85a"

URI_x86_64_v2_rust-bitvec_helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bitvec_helpers-devel-3.1.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bitvec_helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bitvec_helpers-devel}"
SRC_URI[x86_64_v2_rust-bitvec_helpers-devel.sha256sum] = "aea98e8ff5a27cd2b33b2bb576e1255d8f9878394f47c502c4a0cdb7b25ea195"

URI_aarch64_rust-bitvec_helpers+bitstream-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec_helpers+bitstream-io-devel-3.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-bitvec_helpers+bitstream-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec_helpers+bitstream-io-devel}"
SRC_URI[aarch64_rust-bitvec_helpers+bitstream-io-devel.sha256sum] = "6b1d2a6fe1f51515d3a3831d6477cbe8155a44e26fd42273fc88f316a92dae88"

URI_aarch64_rust-bitvec_helpers+bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec_helpers+bitvec-devel-3.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-bitvec_helpers+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec_helpers+bitvec-devel}"
SRC_URI[aarch64_rust-bitvec_helpers+bitvec-devel.sha256sum] = "04add96880cf977a2db48adfa7d8ad12830cd069ae143a4042155fd6e5991d26"

URI_aarch64_rust-bitvec_helpers+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec_helpers+default-devel-3.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-bitvec_helpers+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec_helpers+default-devel}"
SRC_URI[aarch64_rust-bitvec_helpers+default-devel.sha256sum] = "eefb01e98ed3395004bc269b2a88c94eb4c067b1a4538a74ec30f945ed4a58a1"

URI_aarch64_rust-bitvec_helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bitvec_helpers-devel-3.1.6-1.el10_0.noarch.rpm;name=aarch64_rust-bitvec_helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bitvec_helpers-devel}"
SRC_URI[aarch64_rust-bitvec_helpers-devel.sha256sum] = "cdbbd8568b89135f525e63d11168032e6ab1b05c339e7533543388baa2bf5610"

RDEPENDS:rust-bitvec_helpers+bitstream-io-devel = " \
 cargo \
 rust-bitstream-io2+default-devel \
 rust-bitvec_helpers-devel \
 "
RDEPENDS:rust-bitvec_helpers+bitvec-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-bitvec+default-devel \
 rust-bitvec_helpers-devel \
 rust-funty+default-devel \
 "
RDEPENDS:rust-bitvec_helpers+default-devel = " \
 cargo \
 rust-bitvec_helpers+bitvec-devel \
 rust-bitvec_helpers-devel \
 "
RDEPENDS:rust-bitvec_helpers-devel = " \
 cargo \
 rust \
 "
