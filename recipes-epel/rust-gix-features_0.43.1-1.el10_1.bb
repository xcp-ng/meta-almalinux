# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-features"
PV = "0.43.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-features+cache-efficiency-debug-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+document-features-devel \
 rust-gix-features+fs-read-dir-devel \
 rust-gix-features+io-pipe-devel \
 rust-gix-features+once_cell-devel \
 rust-gix-features+parallel-devel \
 rust-gix-features+prodash-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+progress-unit-bytes-devel \
 rust-gix-features+progress-unit-human-numbers-devel \
 rust-gix-features+tracing-detail-devel \
 rust-gix-features+tracing-devel \
 rust-gix-features+walkdir-devel \
 rust-gix-features+zlib-devel \
 rust-gix-features+zlib-ng-devel \
 rust-gix-features+zlib-rs-devel \
 rust-gix-features+zlib-rust-backend-devel \
 rust-gix-features+zlib-stock-devel \
 rust-gix-features-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-features-0.43.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a379e8e3754dc8f8343aaacb149e73cd557c3383a9051576c06d63ce0a507c2"

URI_x86_64_v2_rust-gix-features+cache-efficiency-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+cache-efficiency-debug-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+cache-efficiency-debug-devel}"
SRC_URI[x86_64_v2_rust-gix-features+cache-efficiency-debug-devel.sha256sum] = "7d026c968158c95e4af655579e62befb419d500a88dfd2f8bb5e3f9f85ff2391"

URI_x86_64_v2_rust-gix-features+crc32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+crc32-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+crc32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+crc32-devel}"
SRC_URI[x86_64_v2_rust-gix-features+crc32-devel.sha256sum] = "37436b4162cc14bccdac159761b5b73538b8cfb98a6de4bb71c402a7b381ba06"

URI_x86_64_v2_rust-gix-features+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+default-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+default-devel}"
SRC_URI[x86_64_v2_rust-gix-features+default-devel.sha256sum] = "87eb2d38587d6f28350e6d365fba9a081b559f6998bf2c412b6492704ec4f880"

URI_x86_64_v2_rust-gix-features+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+document-features-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-features+document-features-devel.sha256sum] = "b9c6c3c4351f9370d25c7e71f111a4de6eafa5a2763b44638d99df425cb7e863"

URI_x86_64_v2_rust-gix-features+fs-read-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+fs-read-dir-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+fs-read-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+fs-read-dir-devel}"
SRC_URI[x86_64_v2_rust-gix-features+fs-read-dir-devel.sha256sum] = "07faa4eff7a75777932b59f05535a49438f0752699290280b74bc3b65c1c376b"

URI_x86_64_v2_rust-gix-features+io-pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+io-pipe-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+io-pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+io-pipe-devel}"
SRC_URI[x86_64_v2_rust-gix-features+io-pipe-devel.sha256sum] = "0167100e3b28f7f4549c0a6ed5d9451612954296e6ffa0e5c62524f28365ace7"

URI_x86_64_v2_rust-gix-features+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+once_cell-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+once_cell-devel}"
SRC_URI[x86_64_v2_rust-gix-features+once_cell-devel.sha256sum] = "55cad7eb6afcd0f1e12d2e059999c2c6b03d689725cd13e4b8b9066780a1d0ad"

URI_x86_64_v2_rust-gix-features+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+parallel-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix-features+parallel-devel.sha256sum] = "8ebf93e74fc134dd22b7260f8afcf696e374c3ceb321daa6a729ebc6c1a72881"

URI_x86_64_v2_rust-gix-features+prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+prodash-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+prodash-devel}"
SRC_URI[x86_64_v2_rust-gix-features+prodash-devel.sha256sum] = "497f1eeaa7e4fb74a24f61d17b04ff40548237f42c54f4abafa67bde80330eff"

URI_x86_64_v2_rust-gix-features+progress-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-devel.sha256sum] = "b2519409be277174414f1bc814fba10ef946d04b17c5734b57edcc64bf68b3f6"

URI_x86_64_v2_rust-gix-features+progress-unit-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-unit-bytes-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-unit-bytes-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-unit-bytes-devel.sha256sum] = "d96bc001f4227d17c9cbfd433759d23ac4de2ed2066fc6b6791370550dca4498"

URI_x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+progress-unit-human-numbers-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel}"
SRC_URI[x86_64_v2_rust-gix-features+progress-unit-human-numbers-devel.sha256sum] = "e1b8e9dafbd23bde93477af85f6b2a1a8ae822b4470724ffb00b608ca5a07173"

URI_x86_64_v2_rust-gix-features+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+tracing-detail-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix-features+tracing-detail-devel.sha256sum] = "211bf1f6f95eaf2c2a772244d7ec0e2534e8f0cf2bab3b5de4e18110f9b196f6"

URI_x86_64_v2_rust-gix-features+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+tracing-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix-features+tracing-devel.sha256sum] = "fc78009500cd9eb6432d589a00cb62cbc3d1ce37e6c1d5296234f71444e0b471"

URI_x86_64_v2_rust-gix-features+walkdir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+walkdir-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+walkdir-devel}"
SRC_URI[x86_64_v2_rust-gix-features+walkdir-devel.sha256sum] = "b5c4f978ae351e2d0f946b6988516208c56a9b537f578411309b7463355acddf"

URI_x86_64_v2_rust-gix-features+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-devel.sha256sum] = "d81c65ab8f929eede0a979e954d4071d250b1c9d58d522bbf7aa5d24f28f151e"

URI_x86_64_v2_rust-gix-features+zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-ng-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-ng-devel.sha256sum] = "74225250c26483a1d7161906de03e468e99af61bbf271f25b9ac71f17bb643e0"

URI_x86_64_v2_rust-gix-features+zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-rs-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-rs-devel.sha256sum] = "5016ee5d2a33ef6b1f1e9295388d02b7f4720a5ff1236709f4b23294825db71c"

URI_x86_64_v2_rust-gix-features+zlib-rust-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-rust-backend-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-rust-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-rust-backend-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-rust-backend-devel.sha256sum] = "fa41d82cffeb49581b39995f1e35db08588f92b193eaf83acc718615cb6d8d51"

URI_x86_64_v2_rust-gix-features+zlib-stock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features+zlib-stock-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features+zlib-stock-devel}"
SRC_URI[x86_64_v2_rust-gix-features+zlib-stock-devel.sha256sum] = "bcb17cf450dfceb7a20d54093f18405366a231e436fe04bc5f24cef82d0ad294"

URI_x86_64_v2_rust-gix-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-features-devel-0.43.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-features-devel}"
SRC_URI[x86_64_v2_rust-gix-features-devel.sha256sum] = "66a033087183c804c03ff45fd566e49cae1fd4b69bde4ede5300522efa383fdf"

URI_aarch64_rust-gix-features+cache-efficiency-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+cache-efficiency-debug-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+cache-efficiency-debug-devel}"
SRC_URI[aarch64_rust-gix-features+cache-efficiency-debug-devel.sha256sum] = "f92a5baf40142068cc687f26e23e18d11e2b4c5edb11f252dac4dcece2c33257"

URI_aarch64_rust-gix-features+crc32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+crc32-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+crc32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+crc32-devel}"
SRC_URI[aarch64_rust-gix-features+crc32-devel.sha256sum] = "31852a54e74b3575a7663ffa856cc548bd013dc4b915ba45dcccff441c4f5eb9"

URI_aarch64_rust-gix-features+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+default-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+default-devel}"
SRC_URI[aarch64_rust-gix-features+default-devel.sha256sum] = "b138a4c9a117e5dba6e703746a00a3d7335e043efaef2833efd6cf3c064d5723"

URI_aarch64_rust-gix-features+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+document-features-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+document-features-devel}"
SRC_URI[aarch64_rust-gix-features+document-features-devel.sha256sum] = "b323e0fd98475bd7029231ce0a9c8c50252c09c5e7b7b19a55071c828b1619b3"

URI_aarch64_rust-gix-features+fs-read-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+fs-read-dir-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+fs-read-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+fs-read-dir-devel}"
SRC_URI[aarch64_rust-gix-features+fs-read-dir-devel.sha256sum] = "8f14dcbe161b31059f8389f32d8f743af78a3c653cfae69c80ab585eab5eaf00"

URI_aarch64_rust-gix-features+io-pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+io-pipe-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+io-pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+io-pipe-devel}"
SRC_URI[aarch64_rust-gix-features+io-pipe-devel.sha256sum] = "83423cc8b653236c45dad49b2452f310b448417d9ba8c91486711c3c4d1e8a3f"

URI_aarch64_rust-gix-features+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+once_cell-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+once_cell-devel}"
SRC_URI[aarch64_rust-gix-features+once_cell-devel.sha256sum] = "f94fab73ba30bf146c771a78a7e80da9c5c0588bf05f62d30e04876a08d71aff"

URI_aarch64_rust-gix-features+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+parallel-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+parallel-devel}"
SRC_URI[aarch64_rust-gix-features+parallel-devel.sha256sum] = "e7a9606bc5311f9be44883ad157a13f0a73ad0c64d876475cc75517448a958df"

URI_aarch64_rust-gix-features+prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+prodash-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+prodash-devel}"
SRC_URI[aarch64_rust-gix-features+prodash-devel.sha256sum] = "212a4aa0d3ac85c3e885a7d4ca5d777a97dcdd6097caceb0cf349cc8c4b23efc"

URI_aarch64_rust-gix-features+progress-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+progress-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-devel}"
SRC_URI[aarch64_rust-gix-features+progress-devel.sha256sum] = "8d70f6574f21e89521ed5f5cad7a149a09e7188d42e32bd7e9aa581d027dfa60"

URI_aarch64_rust-gix-features+progress-unit-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-unit-bytes-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+progress-unit-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-unit-bytes-devel}"
SRC_URI[aarch64_rust-gix-features+progress-unit-bytes-devel.sha256sum] = "674115d51cea88e2dbd1e3780c79504bedc29e8c1e3097fa6a4a4f2698b05b54"

URI_aarch64_rust-gix-features+progress-unit-human-numbers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+progress-unit-human-numbers-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+progress-unit-human-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+progress-unit-human-numbers-devel}"
SRC_URI[aarch64_rust-gix-features+progress-unit-human-numbers-devel.sha256sum] = "2dd8d3499372531c93eaad6a4124f73ade582978f109935aa8b5bf4ef98b9b3d"

URI_aarch64_rust-gix-features+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+tracing-detail-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix-features+tracing-detail-devel.sha256sum] = "1d122d23a399065536cc55cf7fc13932eb44763bdd3e6d378851ac3a3834a3ed"

URI_aarch64_rust-gix-features+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+tracing-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+tracing-devel}"
SRC_URI[aarch64_rust-gix-features+tracing-devel.sha256sum] = "001814f6d7eb513b111ef22e21ab73df5f36d702d68a859284f83764fcdf7630"

URI_aarch64_rust-gix-features+walkdir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+walkdir-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+walkdir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+walkdir-devel}"
SRC_URI[aarch64_rust-gix-features+walkdir-devel.sha256sum] = "1c1835994bfd0a92c0fb318bc9559697af0031e65a50dc5efae35a41fca88e4d"

URI_aarch64_rust-gix-features+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-devel.sha256sum] = "85df2a0c2485c72e8f99bfc2aed82ad0dcf0c78dd09f4d1480e0d9d3e8209ece"

URI_aarch64_rust-gix-features+zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-ng-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-ng-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-ng-devel.sha256sum] = "bbb8a87b90b3b5c1f04ed27c3d861aeb7e3d2126b9b6ee5303a8fd0599e29d8d"

URI_aarch64_rust-gix-features+zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-rs-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-rs-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-rs-devel.sha256sum] = "89a14d4a4730f381a2d8c7cf3d6a41c35d202b8d910cf5cf59daa80bb41087c3"

URI_aarch64_rust-gix-features+zlib-rust-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-rust-backend-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+zlib-rust-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-rust-backend-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-rust-backend-devel.sha256sum] = "25c836259b87ca37400bc31e8838398dfea3e55da314170b9a7bd80080716fc4"

URI_aarch64_rust-gix-features+zlib-stock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features+zlib-stock-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features+zlib-stock-devel}"
SRC_URI[aarch64_rust-gix-features+zlib-stock-devel.sha256sum] = "fc07624b88461a56354bdc6baa02bede563af544347642207dd4fec95c4a8418"

URI_aarch64_rust-gix-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-features-devel-0.43.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-features-devel}"
SRC_URI[aarch64_rust-gix-features-devel.sha256sum] = "de5c2937fdbb589abef35388866262aef245383b171fa02f7c09e148a20197a4"

RDEPENDS:rust-gix-features+cache-efficiency-debug-devel = " \
 cargo \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+crc32-devel = " \
 cargo \
 rust-crc32fast+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+default-devel = " \
 cargo \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+fs-read-dir-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-utils+default-devel \
 "
RDEPENDS:rust-gix-features+io-pipe-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+once_cell-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-gix-features+parallel-devel = " \
 cargo \
 rust-crossbeam-channel+default-devel \
 rust-gix-features-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-features+prodash-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 "
RDEPENDS:rust-gix-features+progress-devel = " \
 cargo \
 rust-gix-features+prodash-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+progress-unit-bytes-devel = " \
 cargo \
 rust-bytesize+default-devel \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 rust-prodash+unit-bytes-devel \
 "
RDEPENDS:rust-gix-features+progress-unit-human-numbers-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-prodash+default-devel \
 rust-prodash+unit-human-devel \
 "
RDEPENDS:rust-gix-features+tracing-detail-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-trace+tracing-detail-devel \
 "
RDEPENDS:rust-gix-features+tracing-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-trace+tracing-devel \
 "
RDEPENDS:rust-gix-features+walkdir-devel = " \
 cargo \
 rust-gix-features-devel \
 rust-gix-path+default-devel \
 rust-gix-utils+default-devel \
 rust-walkdir+default-devel \
 "
RDEPENDS:rust-gix-features+zlib-devel = " \
 cargo \
 rust-flate2+zlib-rs-devel \
 rust-flate2-devel \
 rust-gix-features-devel \
 rust-thiserror+default-devel \
 "
RDEPENDS:rust-gix-features+zlib-ng-devel = " \
 cargo \
 rust-gix-features+zlib-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+zlib-rs-devel = " \
 cargo \
 rust-gix-features+zlib-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+zlib-rust-backend-devel = " \
 cargo \
 rust-gix-features+zlib-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features+zlib-stock-devel = " \
 cargo \
 rust-gix-features+zlib-devel \
 rust-gix-features-devel \
 "
RDEPENDS:rust-gix-features-devel = " \
 cargo \
 rust \
 rust-gix-trace+default-devel \
 rust-libc+default-devel \
 "
