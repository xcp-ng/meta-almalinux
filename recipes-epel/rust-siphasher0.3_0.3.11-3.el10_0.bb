# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-siphasher0.3"
PV = "0.3.11"
PR = "3.el10_0"
PACKAGES = " \
 rust-siphasher0.3+default-devel \
 rust-siphasher0.3+serde-devel \
 rust-siphasher0.3+serde_json-devel \
 rust-siphasher0.3+serde_no_std-devel \
 rust-siphasher0.3+serde_std-devel \
 rust-siphasher0.3+std-devel \
 rust-siphasher0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-siphasher0.3-0.3.11-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b030ac2a04b2770849cd8e0616a94cd1b40461ecbcd8014b26aef7f6620b822"

URI_x86_64_v2_rust-siphasher0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher0.3+default-devel-0.3.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher0.3+default-devel}"
SRC_URI[x86_64_v2_rust-siphasher0.3+default-devel.sha256sum] = "b66af6f4fcc19630e46d8a179bb8f3e418317af1cd06c4661a3b9e2c0a07d3d5"

URI_x86_64_v2_rust-siphasher0.3+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher0.3+serde-devel-0.3.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher0.3+serde-devel}"
SRC_URI[x86_64_v2_rust-siphasher0.3+serde-devel.sha256sum] = "2e4680f23a1fa5d7464dbfe3817c8299e32db0e7dca4f6d26dc60e3dd9530cf8"

URI_x86_64_v2_rust-siphasher0.3+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher0.3+serde_json-devel-0.3.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher0.3+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher0.3+serde_json-devel}"
SRC_URI[x86_64_v2_rust-siphasher0.3+serde_json-devel.sha256sum] = "5b8e755e2630f7e5242f863f8cd5169e95ba6186bc7d9b3f9876cba673df10e8"

URI_x86_64_v2_rust-siphasher0.3+serde_no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher0.3+serde_no_std-devel-0.3.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher0.3+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher0.3+serde_no_std-devel}"
SRC_URI[x86_64_v2_rust-siphasher0.3+serde_no_std-devel.sha256sum] = "940b7339975f419feb3176d0e64d6c4b22aed63206bb26ef1346016dd3ee2a4e"

URI_x86_64_v2_rust-siphasher0.3+serde_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher0.3+serde_std-devel-0.3.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher0.3+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher0.3+serde_std-devel}"
SRC_URI[x86_64_v2_rust-siphasher0.3+serde_std-devel.sha256sum] = "77b108d5fb2130262186ad0f3fe6e096a19dc235a87a6c9fddf8101cf7756b14"

URI_x86_64_v2_rust-siphasher0.3+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher0.3+std-devel-0.3.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher0.3+std-devel}"
SRC_URI[x86_64_v2_rust-siphasher0.3+std-devel.sha256sum] = "1f1c7d725744bab87047cbced79efe09f769dab468337addd58a7108830d1f42"

URI_x86_64_v2_rust-siphasher0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher0.3-devel-0.3.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher0.3-devel}"
SRC_URI[x86_64_v2_rust-siphasher0.3-devel.sha256sum] = "b394fbc09e4b3d84edd1f486a7aa5ad799c163cb3f1602b61a2d65ed5233b127"

URI_aarch64_rust-siphasher0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher0.3+default-devel-0.3.11-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher0.3+default-devel}"
SRC_URI[aarch64_rust-siphasher0.3+default-devel.sha256sum] = "9bb7f0009daf54a4d13bd4a4eca3715722764713e4adc3e443b75ec627906bdf"

URI_aarch64_rust-siphasher0.3+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher0.3+serde-devel-0.3.11-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher0.3+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher0.3+serde-devel}"
SRC_URI[aarch64_rust-siphasher0.3+serde-devel.sha256sum] = "1d91ea1e0e2f617e9b83fe7fc789f25d19a53e721c789d08479e1af18ea02325"

URI_aarch64_rust-siphasher0.3+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher0.3+serde_json-devel-0.3.11-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher0.3+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher0.3+serde_json-devel}"
SRC_URI[aarch64_rust-siphasher0.3+serde_json-devel.sha256sum] = "dddb0f934a94152b9333d0fc6375880bb4fdfa0766c5b8f4a22b5e7100caa7a1"

URI_aarch64_rust-siphasher0.3+serde_no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher0.3+serde_no_std-devel-0.3.11-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher0.3+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher0.3+serde_no_std-devel}"
SRC_URI[aarch64_rust-siphasher0.3+serde_no_std-devel.sha256sum] = "d709a097c6b105e3ead6838c0395d265ec8d97baccaa5c629621d91b7c55adc4"

URI_aarch64_rust-siphasher0.3+serde_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher0.3+serde_std-devel-0.3.11-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher0.3+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher0.3+serde_std-devel}"
SRC_URI[aarch64_rust-siphasher0.3+serde_std-devel.sha256sum] = "53c80739836830f7efe7af582ba19587a5503b143d2136a0f0bcf0cf232592d3"

URI_aarch64_rust-siphasher0.3+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher0.3+std-devel-0.3.11-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher0.3+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher0.3+std-devel}"
SRC_URI[aarch64_rust-siphasher0.3+std-devel.sha256sum] = "c76bb52205ab437a19ad7b7acd10afaf4079b05cb802ba3d879ee392dd0d21d2"

URI_aarch64_rust-siphasher0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher0.3-devel-0.3.11-3.el10_0.noarch.rpm;name=aarch64_rust-siphasher0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher0.3-devel}"
SRC_URI[aarch64_rust-siphasher0.3-devel.sha256sum] = "2370b170f56805ce12eab656cb63a9eedce8d9285df267e6255375fe083d614c"

RDEPENDS:rust-siphasher0.3+default-devel = " \
 cargo \
 rust-siphasher0.3+std-devel \
 rust-siphasher0.3-devel \
 "
RDEPENDS:rust-siphasher0.3+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher0.3-devel \
 "
RDEPENDS:rust-siphasher0.3+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-siphasher0.3-devel \
 "
RDEPENDS:rust-siphasher0.3+serde_no_std-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher0.3-devel \
 "
RDEPENDS:rust-siphasher0.3+serde_std-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-siphasher0.3+std-devel \
 rust-siphasher0.3-devel \
 "
RDEPENDS:rust-siphasher0.3+std-devel = " \
 cargo \
 rust-siphasher0.3-devel \
 "
RDEPENDS:rust-siphasher0.3-devel = " \
 cargo \
 "
