# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-syntect"
PV = "5.3.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-syntect+bincode-devel \
 rust-syntect+default-devel \
 rust-syntect+default-fancy-devel \
 rust-syntect+default-onig-devel \
 rust-syntect+default-syntaxes-devel \
 rust-syntect+default-themes-devel \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+fancy-regex-devel \
 rust-syntect+flate2-devel \
 rust-syntect+fnv-devel \
 rust-syntect+html-devel \
 rust-syntect+metadata-devel \
 rust-syntect+onig-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+regex-fancy-devel \
 rust-syntect+regex-onig-devel \
 rust-syntect+regex-syntax-devel \
 rust-syntect+yaml-load-devel \
 rust-syntect+yaml-rust-devel \
 rust-syntect-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-syntect-5.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b4da71642d27ab88888ec9d77e87505227e818cb46633f0f48e568e001d25909"

URI_x86_64_v2_rust-syntect+bincode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+bincode-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+bincode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+bincode-devel}"
SRC_URI[x86_64_v2_rust-syntect+bincode-devel.sha256sum] = "f0e7d02eba78a17a3203062dddbdab81837e0dfd3b94ec3d499cdc93a3cc4714"

URI_x86_64_v2_rust-syntect+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-devel.sha256sum] = "49233ab3f50499953caf1566365aa898f2bfae448a08a29e9bfac97732fc42c9"

URI_x86_64_v2_rust-syntect+default-fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-fancy-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-fancy-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-fancy-devel.sha256sum] = "04523257710f34c2a6881b046ad6f574a19df5af773f0fc121680203749df097"

URI_x86_64_v2_rust-syntect+default-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-onig-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-onig-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-onig-devel.sha256sum] = "e0661726d81163fad309208a3ce8d06fa13cf10800c707131f69f235f1cc3709"

URI_x86_64_v2_rust-syntect+default-syntaxes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-syntaxes-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-syntaxes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-syntaxes-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-syntaxes-devel.sha256sum] = "a11772d70d15c3d704d5fb7d64a6ffee3a3acb23d2e154297ed5e79a42c7aa80"

URI_x86_64_v2_rust-syntect+default-themes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+default-themes-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+default-themes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+default-themes-devel}"
SRC_URI[x86_64_v2_rust-syntect+default-themes-devel.sha256sum] = "d63f2974f0cd5009c08f2c4c7e5c772e7389156c6f20a21554ab428d195862d9"

URI_x86_64_v2_rust-syntect+dump-create-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+dump-create-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+dump-create-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+dump-create-devel}"
SRC_URI[x86_64_v2_rust-syntect+dump-create-devel.sha256sum] = "a36d87718374ff75b94e7b6a30926d3363d9de597f850d31f2a545700df1127a"

URI_x86_64_v2_rust-syntect+dump-load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+dump-load-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+dump-load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+dump-load-devel}"
SRC_URI[x86_64_v2_rust-syntect+dump-load-devel.sha256sum] = "054721ce2e4afc56fa451c20624e144079ce14f5e91db441464fdaf3da4e54c4"

URI_x86_64_v2_rust-syntect+fancy-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+fancy-regex-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+fancy-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+fancy-regex-devel}"
SRC_URI[x86_64_v2_rust-syntect+fancy-regex-devel.sha256sum] = "7be3c7e1204d8bbbc98968cd089e42b29520ecd05b31baf08c96968093961683"

URI_x86_64_v2_rust-syntect+flate2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+flate2-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+flate2-devel}"
SRC_URI[x86_64_v2_rust-syntect+flate2-devel.sha256sum] = "b6523ac7c3b46374b247b7191451ead3a49ba501c033115f4567517381589396"

URI_x86_64_v2_rust-syntect+fnv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+fnv-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+fnv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+fnv-devel}"
SRC_URI[x86_64_v2_rust-syntect+fnv-devel.sha256sum] = "201942df183276f753faa4b8221b614d3c59be14ea66b3b3944ee3fe5efdfe8b"

URI_x86_64_v2_rust-syntect+html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+html-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+html-devel}"
SRC_URI[x86_64_v2_rust-syntect+html-devel.sha256sum] = "62098e3ec0e17efe3931f7ad515e1ca8bfa677491e2eea43d01ff0e79822a24e"

URI_x86_64_v2_rust-syntect+metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+metadata-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+metadata-devel}"
SRC_URI[x86_64_v2_rust-syntect+metadata-devel.sha256sum] = "5ca3e0a1a973fc797b5a1df60b5bf429ccc28efd793574572749971020db0ca7"

URI_x86_64_v2_rust-syntect+onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+onig-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+onig-devel}"
SRC_URI[x86_64_v2_rust-syntect+onig-devel.sha256sum] = "060cd6df2ac191c142b58f8aa58b7162fda25c0cb95ee9759941bd312abee3b7"

URI_x86_64_v2_rust-syntect+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+parsing-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+parsing-devel}"
SRC_URI[x86_64_v2_rust-syntect+parsing-devel.sha256sum] = "86f9cb7ff9dc76b3fc67ac28b0dad4689702dc674a58506ca9f06d63a552e547"

URI_x86_64_v2_rust-syntect+plist-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+plist-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+plist-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+plist-devel}"
SRC_URI[x86_64_v2_rust-syntect+plist-devel.sha256sum] = "96a6abac00a6a0237b9a4d74b405c9360e8ff4cc86cf9edc73e29a6c9358dd2c"

URI_x86_64_v2_rust-syntect+plist-load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+plist-load-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+plist-load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+plist-load-devel}"
SRC_URI[x86_64_v2_rust-syntect+plist-load-devel.sha256sum] = "9d9c04a38a1086eb2f72481f937a43ba4b5512b4f9ab1493db8afa56bbc7db42"

URI_x86_64_v2_rust-syntect+regex-fancy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+regex-fancy-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+regex-fancy-devel}"
SRC_URI[x86_64_v2_rust-syntect+regex-fancy-devel.sha256sum] = "8906454e7235ff24abbdc6a09d0371946897f56993374c3e2b41c187d7e2214d"

URI_x86_64_v2_rust-syntect+regex-onig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+regex-onig-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+regex-onig-devel}"
SRC_URI[x86_64_v2_rust-syntect+regex-onig-devel.sha256sum] = "6f2c2ab0190b760e6a88966e46a267a8907d7716cde6872ad8e4c2759eb5f56d"

URI_x86_64_v2_rust-syntect+regex-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+regex-syntax-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+regex-syntax-devel}"
SRC_URI[x86_64_v2_rust-syntect+regex-syntax-devel.sha256sum] = "74d286a574386d99a9927ff3ce12304f2ac1bb5149eb306d31476e4767f3a66e"

URI_x86_64_v2_rust-syntect+yaml-load-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+yaml-load-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+yaml-load-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+yaml-load-devel}"
SRC_URI[x86_64_v2_rust-syntect+yaml-load-devel.sha256sum] = "2e30051085d44d36effed1e556fc6bc9498cae9b62b8b1905b781e9151214642"

URI_x86_64_v2_rust-syntect+yaml-rust-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect+yaml-rust-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect+yaml-rust-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect+yaml-rust-devel}"
SRC_URI[x86_64_v2_rust-syntect+yaml-rust-devel.sha256sum] = "ad47b91c04ceb0ddd40b3fbf8c74fbd700337df031abbfc047596059706649d2"

URI_x86_64_v2_rust-syntect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-syntect-devel-5.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-syntect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-syntect-devel}"
SRC_URI[x86_64_v2_rust-syntect-devel.sha256sum] = "f629629c306a446c265c0d73bdc93a96eedb7dfa191660744a35bb834e4dea80"

URI_aarch64_rust-syntect+bincode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+bincode-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+bincode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+bincode-devel}"
SRC_URI[aarch64_rust-syntect+bincode-devel.sha256sum] = "4eeaf366855b9b166fba88bf02f00cdc78c29ef45d411bbe26bd74ff0476c677"

URI_aarch64_rust-syntect+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-devel}"
SRC_URI[aarch64_rust-syntect+default-devel.sha256sum] = "669119e16fabd6f79d7a4cb1e21b8db2adfce8cd6ac5107fe7cf1536bf3db19d"

URI_aarch64_rust-syntect+default-fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-fancy-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+default-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-fancy-devel}"
SRC_URI[aarch64_rust-syntect+default-fancy-devel.sha256sum] = "8b2c1f7c0f20f14192e6e3ef78f0446003cb0664c4bad05f67bd0e8a07ae4f1f"

URI_aarch64_rust-syntect+default-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-onig-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+default-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-onig-devel}"
SRC_URI[aarch64_rust-syntect+default-onig-devel.sha256sum] = "d69ece4bc4d9738828ffae5cadc35ee558c780820facac8f17fd097620e1f912"

URI_aarch64_rust-syntect+default-syntaxes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-syntaxes-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+default-syntaxes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-syntaxes-devel}"
SRC_URI[aarch64_rust-syntect+default-syntaxes-devel.sha256sum] = "a1fb4ba035788f46c36678604deedbf7eb2ce1ad6e5f371f58ded3648f0ea8a2"

URI_aarch64_rust-syntect+default-themes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+default-themes-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+default-themes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+default-themes-devel}"
SRC_URI[aarch64_rust-syntect+default-themes-devel.sha256sum] = "43a5d746959513c3e3b02ea376f1450e57cd4604f4748562de1737a9cb6dd401"

URI_aarch64_rust-syntect+dump-create-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+dump-create-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+dump-create-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+dump-create-devel}"
SRC_URI[aarch64_rust-syntect+dump-create-devel.sha256sum] = "365b83daf71d5d286370e388f591e420447d1cc22438e47bd651f4848051b943"

URI_aarch64_rust-syntect+dump-load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+dump-load-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+dump-load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+dump-load-devel}"
SRC_URI[aarch64_rust-syntect+dump-load-devel.sha256sum] = "fe8c63f3f5012924c92ced6b31916fbea1393c000fe3d82026bb93739a893431"

URI_aarch64_rust-syntect+fancy-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+fancy-regex-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+fancy-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+fancy-regex-devel}"
SRC_URI[aarch64_rust-syntect+fancy-regex-devel.sha256sum] = "2cb3ae27705ad99389b4e53c7d44a83099f3ce085fe9e1007b2f0b07cc9145fb"

URI_aarch64_rust-syntect+flate2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+flate2-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+flate2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+flate2-devel}"
SRC_URI[aarch64_rust-syntect+flate2-devel.sha256sum] = "d90c9bfb0bad5722b3a8ad233c360f33aa7901267cfc4bbcb94256d1cf5ec5e5"

URI_aarch64_rust-syntect+fnv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+fnv-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+fnv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+fnv-devel}"
SRC_URI[aarch64_rust-syntect+fnv-devel.sha256sum] = "b66adfa50d4a1771ee992fc4a47973b35ff928b93144e970e8b072b5ebfdec73"

URI_aarch64_rust-syntect+html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+html-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+html-devel}"
SRC_URI[aarch64_rust-syntect+html-devel.sha256sum] = "760734cd105620b502fe4881e881051e762d7b3ba83fc31ee2586aaad45a7429"

URI_aarch64_rust-syntect+metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+metadata-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+metadata-devel}"
SRC_URI[aarch64_rust-syntect+metadata-devel.sha256sum] = "4d4db3fd02da44496b0aa2fef1d5dc3910016be191bc7982ec51307488a3de70"

URI_aarch64_rust-syntect+onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+onig-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+onig-devel}"
SRC_URI[aarch64_rust-syntect+onig-devel.sha256sum] = "dc35f111b743586df67d9fe6b1ace06846587aebc6242a9841813fa342d513f6"

URI_aarch64_rust-syntect+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+parsing-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+parsing-devel}"
SRC_URI[aarch64_rust-syntect+parsing-devel.sha256sum] = "bab79b273e4dc6cbf71398f343d9b5591026fc1ec8458996d4b77022f4b2db3f"

URI_aarch64_rust-syntect+plist-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+plist-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+plist-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+plist-devel}"
SRC_URI[aarch64_rust-syntect+plist-devel.sha256sum] = "310ff00c80ce5ac0e6cd29a1830a231bd2c92fbcb1cc55e541033d475583a009"

URI_aarch64_rust-syntect+plist-load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+plist-load-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+plist-load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+plist-load-devel}"
SRC_URI[aarch64_rust-syntect+plist-load-devel.sha256sum] = "722990a0026ceb77edddbfe11dfe9c40003f93f8352b1c03a300a90dcf354f0a"

URI_aarch64_rust-syntect+regex-fancy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+regex-fancy-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+regex-fancy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+regex-fancy-devel}"
SRC_URI[aarch64_rust-syntect+regex-fancy-devel.sha256sum] = "6b92414e08d0d21e60d36d7733cc9690a6a550b7cb8755f42445d6985fffb3e8"

URI_aarch64_rust-syntect+regex-onig-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+regex-onig-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+regex-onig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+regex-onig-devel}"
SRC_URI[aarch64_rust-syntect+regex-onig-devel.sha256sum] = "b6c13110ba6181e242db8c79e1b65c64c9ffb49b6cc2e54fa9feb5d1a7bd9ca4"

URI_aarch64_rust-syntect+regex-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+regex-syntax-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+regex-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+regex-syntax-devel}"
SRC_URI[aarch64_rust-syntect+regex-syntax-devel.sha256sum] = "641c348553fcc4cd825b8aae83b96efac827bda16aeb1183d28014eb7b5400a4"

URI_aarch64_rust-syntect+yaml-load-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+yaml-load-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+yaml-load-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+yaml-load-devel}"
SRC_URI[aarch64_rust-syntect+yaml-load-devel.sha256sum] = "6130fcac62a003de51ef65194bb971fa9abf997b977db9745dce04765d2be5ff"

URI_aarch64_rust-syntect+yaml-rust-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect+yaml-rust-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect+yaml-rust-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect+yaml-rust-devel}"
SRC_URI[aarch64_rust-syntect+yaml-rust-devel.sha256sum] = "e809824e9688138fa8ce55b5e7e850860ba9df535540d252b09bf3d9ff855ec6"

URI_aarch64_rust-syntect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-syntect-devel-5.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-syntect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-syntect-devel}"
SRC_URI[aarch64_rust-syntect-devel.sha256sum] = "b1aec88a2e1f1c5f87af181c7ad1c1f16c7811e0bf820ed732033c4da4919697"

RDEPENDS:rust-syntect+bincode-devel = " \
 cargo \
 rust-bincode1+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-devel = " \
 cargo \
 rust-syntect+default-onig-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-fancy-devel = " \
 cargo \
 rust-syntect+default-syntaxes-devel \
 rust-syntect+default-themes-devel \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+html-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+regex-fancy-devel \
 rust-syntect+yaml-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-onig-devel = " \
 cargo \
 rust-syntect+default-syntaxes-devel \
 rust-syntect+default-themes-devel \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+html-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-load-devel \
 rust-syntect+regex-onig-devel \
 rust-syntect+yaml-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-syntaxes-devel = " \
 cargo \
 rust-syntect+dump-load-devel \
 rust-syntect+parsing-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+default-themes-devel = " \
 cargo \
 rust-syntect+dump-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+dump-create-devel = " \
 cargo \
 rust-syntect+bincode-devel \
 rust-syntect+flate2-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+dump-load-devel = " \
 cargo \
 rust-syntect+bincode-devel \
 rust-syntect+flate2-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+fancy-regex-devel = " \
 cargo \
 rust-fancy-regex+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+flate2-devel = " \
 cargo \
 rust-flate2+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+fnv-devel = " \
 cargo \
 rust-fnv+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+html-devel = " \
 cargo \
 rust-syntect+parsing-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+metadata-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-syntect+parsing-devel \
 rust-syntect+plist-load-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+onig-devel = " \
 cargo \
 rust-onig-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+parsing-devel = " \
 cargo \
 rust-syntect+dump-create-devel \
 rust-syntect+dump-load-devel \
 rust-syntect+fnv-devel \
 rust-syntect+regex-syntax-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+plist-devel = " \
 cargo \
 rust-plist+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+plist-load-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-syntect+plist-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+regex-fancy-devel = " \
 cargo \
 rust-syntect+fancy-regex-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+regex-onig-devel = " \
 cargo \
 rust-syntect+onig-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+regex-syntax-devel = " \
 cargo \
 rust-regex-syntax+default-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+yaml-load-devel = " \
 cargo \
 rust-syntect+parsing-devel \
 rust-syntect+yaml-rust-devel \
 rust-syntect-devel \
 "
RDEPENDS:rust-syntect+yaml-rust-devel = " \
 cargo \
 rust-syntect-devel \
 rust-yaml-rust+default-devel \
 "
RDEPENDS:rust-syntect-devel = " \
 cargo \
 rust-once_cell+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-thiserror+default-devel \
 rust-walkdir+default-devel \
 "
