# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-semver"
PV = "1.0.28"
PR = "1.el10_2"
PACKAGES = " \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-semver+std-devel \
 rust-semver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-semver-1.0.28-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96d5e0744ed263dedb6facbeaf15b4e367ff34f516ba26556422f584f19dba40"

URI_x86_64_v2_rust-semver+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+default-devel-1.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+default-devel}"
SRC_URI[x86_64_v2_rust-semver+default-devel.sha256sum] = "0b6ae5c0a6defb7a57a3b53da2281f3d1ea4d9156684e021240c7a39a22b62a8"

URI_x86_64_v2_rust-semver+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+serde-devel-1.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+serde-devel}"
SRC_URI[x86_64_v2_rust-semver+serde-devel.sha256sum] = "f8bcd6fb6c8cbe6d7098e9fc8efe3ce739828859943acaf641ecfec403e860af"

URI_x86_64_v2_rust-semver+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver+std-devel-1.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver+std-devel}"
SRC_URI[x86_64_v2_rust-semver+std-devel.sha256sum] = "db518b1b45425a9bafdf6f5052db316d24e457838183a5ec73152be537ac0203"

URI_x86_64_v2_rust-semver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-semver-devel-1.0.28-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-semver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-semver-devel}"
SRC_URI[x86_64_v2_rust-semver-devel.sha256sum] = "c206a23d49886929dffde74acb5b824a79bf1aec745ca6cb3115d50910f365ee"

URI_aarch64_rust-semver+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+default-devel-1.0.28-1.el10_2.noarch.rpm;name=aarch64_rust-semver+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+default-devel}"
SRC_URI[aarch64_rust-semver+default-devel.sha256sum] = "a52218fc698713d0fab5ed7086e9c8254c5887bb30b97da3326a23b24b31ed61"

URI_aarch64_rust-semver+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+serde-devel-1.0.28-1.el10_2.noarch.rpm;name=aarch64_rust-semver+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+serde-devel}"
SRC_URI[aarch64_rust-semver+serde-devel.sha256sum] = "46ebd9454839a0eef2b7a7961649262a16d62bb7de6ddd10f781d31d6c453ff3"

URI_aarch64_rust-semver+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver+std-devel-1.0.28-1.el10_2.noarch.rpm;name=aarch64_rust-semver+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver+std-devel}"
SRC_URI[aarch64_rust-semver+std-devel.sha256sum] = "585a6d05bd74f50443783680a90922c2c46b5a3ea660a0609eb25c32c9ea6497"

URI_aarch64_rust-semver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-semver-devel-1.0.28-1.el10_2.noarch.rpm;name=aarch64_rust-semver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-semver-devel}"
SRC_URI[aarch64_rust-semver-devel.sha256sum] = "d8fc1c3144c0f427ecf46b92df598737b0dbf3236b3fbcf15341f9b971d17def"

RDEPENDS:rust-semver+default-devel = " \
 cargo \
 rust-semver+std-devel \
 rust-semver-devel \
 "
RDEPENDS:rust-semver+serde-devel = " \
 cargo \
 rust-semver-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-semver+std-devel = " \
 cargo \
 rust-semver-devel \
 "
RDEPENDS:rust-semver-devel = " \
 cargo \
 rust \
 "
