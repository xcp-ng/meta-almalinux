# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-brukerapi"
PV = "0.1.10"
PR = "1.el10_2"
PACKAGES = " \
 python-brukerapi-doc \
 python3-brukerapi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-brukerapi-0.1.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f49f3a6a26cc0cf5dc5b4f3d6007feb3e8491a2f7d1b8b5e10169ec2782f497c"

URI_x86_64_v2_python-brukerapi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-brukerapi-doc-0.1.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-brukerapi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-brukerapi-doc}"
SRC_URI[x86_64_v2_python-brukerapi-doc.sha256sum] = "b74b0d0550e21dce86ae24148ff0b0b7e7c45b6cd1dc0fa0112528927d6e972a"

URI_x86_64_v2_python3-brukerapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-brukerapi-0.1.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-brukerapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-brukerapi}"
SRC_URI[x86_64_v2_python3-brukerapi.sha256sum] = "d6d02a116cc87410ecb7c901b665a63068a2eead79623ccc637b297528eb6352"

URI_aarch64_python-brukerapi-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-brukerapi-doc-0.1.10-1.el10_2.noarch.rpm;name=aarch64_python-brukerapi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-brukerapi-doc}"
SRC_URI[aarch64_python-brukerapi-doc.sha256sum] = "70e76050dd76bcc7cf1c14e6fd03f86a59fe8aa57ffcfe7086e7181514f56721"

URI_aarch64_python3-brukerapi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-brukerapi-0.1.10-1.el10_2.noarch.rpm;name=aarch64_python3-brukerapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-brukerapi}"
SRC_URI[aarch64_python3-brukerapi.sha256sum] = "722ea2a2e1b03e9f429a42b1518db351b3526c2ed692d695a20ea9880ab6b572"

RDEPENDS:python-brukerapi-doc = " \
 "
RDEPENDS:python3-brukerapi = " \
 python3 \
 python3-numpy \
 python3-pyyaml \
 "
