# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdiamond"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kdiamond \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdiamond-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bf25d8c98efb827bb02f9480a898c271e18f70a3f6a5962ac95b94cd6209bf2"

URI_x86_64_v2_kdiamond = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdiamond-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdiamond;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdiamond}"
SRC_URI[x86_64_v2_kdiamond.sha256sum] = "90af868e8b6f0d12bf5f5166b50adf5042e60eed5b1600735e5b4d121ff9ba3b"

URI_aarch64_kdiamond = "${EPEL_MIRROR}/aarch64/Packages/k/kdiamond-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kdiamond;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdiamond}"
SRC_URI[aarch64_kdiamond.sha256sum] = "129ab96e77409cffba85d665b36b10deeae2bc1be527103766d2723c9e6749c7"

RDEPENDS:kdiamond = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
