# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ansitok"
PV = "0.2.0"
PR = "10.el10_3"
PACKAGES = " \
 rust-ansitok+default-devel \
 rust-ansitok+std-devel \
 rust-ansitok-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ansitok-0.2.0-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b0d7878cbb8a637652516d41c8d26227def26032c586fb43a7afbe77cf58c2a"

URI_x86_64_v2_rust-ansitok+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansitok+default-devel-0.2.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansitok+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansitok+default-devel}"
SRC_URI[x86_64_v2_rust-ansitok+default-devel.sha256sum] = "470971b09f3370a66b7d0d43fc278a00ae60f9697839d6dbeb431e7ef4cfa44f"

URI_x86_64_v2_rust-ansitok+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansitok+std-devel-0.2.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansitok+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansitok+std-devel}"
SRC_URI[x86_64_v2_rust-ansitok+std-devel.sha256sum] = "aef12eb38e474fb86bb405771a940a2e63ffd020b54bc331018e017e3d09f6ed"

URI_x86_64_v2_rust-ansitok-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ansitok-devel-0.2.0-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ansitok-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ansitok-devel}"
SRC_URI[x86_64_v2_rust-ansitok-devel.sha256sum] = "c640a44aeca89ef08eac48a2ca2c8b46b169bec13b3feedc810ba3a75ddfc2d7"

URI_aarch64_rust-ansitok+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansitok+default-devel-0.2.0-10.el10_3.noarch.rpm;name=aarch64_rust-ansitok+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansitok+default-devel}"
SRC_URI[aarch64_rust-ansitok+default-devel.sha256sum] = "0eec964ed248c5c7d2384e237d0ecefe1d426e5fd751000d2369edf11c16ee57"

URI_aarch64_rust-ansitok+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansitok+std-devel-0.2.0-10.el10_3.noarch.rpm;name=aarch64_rust-ansitok+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansitok+std-devel}"
SRC_URI[aarch64_rust-ansitok+std-devel.sha256sum] = "a05267458617b1b25316f30bbdfa2c86c27833ca06d697d78e2a8622a7d17a75"

URI_aarch64_rust-ansitok-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ansitok-devel-0.2.0-10.el10_3.noarch.rpm;name=aarch64_rust-ansitok-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ansitok-devel}"
SRC_URI[aarch64_rust-ansitok-devel.sha256sum] = "9fc29399df5392c609322a0a3f70c9cc4cde2dbd26761ae64558e06b27a46bbc"

RDEPENDS:rust-ansitok+default-devel = " \
 cargo \
 rust-ansitok+std-devel \
 rust-ansitok-devel \
 "
RDEPENDS:rust-ansitok+std-devel = " \
 cargo \
 rust-ansitok-devel \
 rust-nom7+std-devel \
 "
RDEPENDS:rust-ansitok-devel = " \
 cargo \
 rust-nom7+default-devel \
 rust-vte+default-devel \
 "
