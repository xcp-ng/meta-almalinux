# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-LibBuilder"
PV = "0.09"
PR = "3.el10_1"
PACKAGES = " \
 perl-ExtUtils-LibBuilder \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-LibBuilder-0.09-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8256008d440cff6f9c451e88a04bed220a41fdd2f60cb815e2e01d3f00ed6ad"

URI_x86_64_v2_perl-ExtUtils-LibBuilder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-LibBuilder-0.09-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-LibBuilder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-ExtUtils-LibBuilder}"
SRC_URI[x86_64_v2_perl-ExtUtils-LibBuilder.sha256sum] = "20fa5486ca881c19c96dd93179d4c3609e28e16ec504c502ac0aa9243128abdc"

URI_aarch64_perl-ExtUtils-LibBuilder = "${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-LibBuilder-0.09-3.el10_1.noarch.rpm;name=aarch64_perl-ExtUtils-LibBuilder;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-ExtUtils-LibBuilder}"
SRC_URI[aarch64_perl-ExtUtils-LibBuilder.sha256sum] = "21c7f64f0d7d5c80da456754092d324a919f5222367d078edef579f8a977c687"

RDEPENDS:perl-ExtUtils-LibBuilder = " \
 perl-ExtUtils-CBuilder \
 perl-File-Temp \
 perl-PathTools \
 perl-base \
 perl-libs \
 "
