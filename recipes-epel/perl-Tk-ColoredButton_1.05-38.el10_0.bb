# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tk-ColoredButton"
PV = "1.05"
PR = "38.el10_0"
PACKAGES = " \
 perl-Tk-ColoredButton \
 perl-Tk-ColoredButton-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tk-ColoredButton-1.05-38.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2de2e9f6263729d4e2970b61046aff4ad0657b7595e556c9849b8b88b27d67d9"

URI_x86_64_v2_perl-Tk-ColoredButton = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tk-ColoredButton-1.05-38.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tk-ColoredButton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tk-ColoredButton}"
SRC_URI[x86_64_v2_perl-Tk-ColoredButton.sha256sum] = "804050e4536ff668d539d43f6b61123fdedfc4aee34dfa835fb6e93f9224852c"

URI_x86_64_v2_perl-Tk-ColoredButton-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tk-ColoredButton-tests-1.05-38.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tk-ColoredButton-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tk-ColoredButton-tests}"
SRC_URI[x86_64_v2_perl-Tk-ColoredButton-tests.sha256sum] = "dbe460dcb602267aad6f9598765f1d15f5070d1cc682028ed0eb65333c5401cb"

URI_aarch64_perl-Tk-ColoredButton = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tk-ColoredButton-1.05-38.el10_0.noarch.rpm;name=aarch64_perl-Tk-ColoredButton;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tk-ColoredButton}"
SRC_URI[aarch64_perl-Tk-ColoredButton.sha256sum] = "41a929fb91f900c9cc4f6fd51d61cddf120ae7ea790ca76c3fde5dc7bd694d66"

URI_aarch64_perl-Tk-ColoredButton-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tk-ColoredButton-tests-1.05-38.el10_0.noarch.rpm;name=aarch64_perl-Tk-ColoredButton-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tk-ColoredButton-tests}"
SRC_URI[aarch64_perl-Tk-ColoredButton-tests.sha256sum] = "e154ddb95bdc69a0cabacf3350fa911e006f6bcb434e52e8be4f048322277e28"

RDEPENDS:perl-Tk-ColoredButton = " \
 perl-Carp \
 perl-English \
 perl-Tk \
 perl-Tk-Canvas-GradientColor \
 perl-base \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Tk-ColoredButton-tests = " \
 bash \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tk-ColoredButton \
 "
