# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_with_macros"
PV = "3.16.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_with_macros+default-devel \
 rust-serde_with_macros+schemars_0_8-devel \
 rust-serde_with_macros-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-serde_with_macros-3.16.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9f4328ab347d149b359fb3bb4dbcbb5745000bf9c004a9d4637ff39e3be22914"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with_macros+default-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with_macros+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_with_macros+default-devel.sha256sum] = "fe0fbad917cda200d5e5a436316884b7aba5844b402884172ccdb29ff892377c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with_macros+schemars_0_8-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with_macros+schemars_0_8-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_with_macros+schemars_0_8-devel.sha256sum] = "19207552b778557698c06b4ba11edb1485da0e9c82c938c23b4a470f4de64f0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with_macros-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with_macros-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_with_macros-devel.sha256sum] = "f0d409b1182d7fc960704747a22cd2a1d4ce3da6f7e399565916b71f3e9da14d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with_macros+default-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with_macros+default-devel;unpack=0"
SRC_URI[aarch64_rust-serde_with_macros+default-devel.sha256sum] = "a3a13c8a9ae6ee88a05754c4b0b04556e86b21378793c71b87be602b9a956047"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with_macros+schemars_0_8-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with_macros+schemars_0_8-devel;unpack=0"
SRC_URI[aarch64_rust-serde_with_macros+schemars_0_8-devel.sha256sum] = "4e65f8f7ed463f540cb05c8929ff65a5296fde51c733b3a43bc831f189e981ad"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with_macros-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with_macros-devel;unpack=0"
SRC_URI[aarch64_rust-serde_with_macros-devel.sha256sum] = "b6e24d7f3f2f08b9efafa4ca8585aa1e3baf5049ac8158e2610187cebfd11b5f"

RDEPENDS:rust-serde_with_macros+default-devel = " \
 cargo \
 rust-serde_with_macros-devel \
 "
RDEPENDS:rust-serde_with_macros+schemars_0_8-devel = " \
 cargo \
 rust-serde_with_macros-devel \
 "
RDEPENDS:rust-serde_with_macros-devel = " \
 cargo \
 rust \
 rust-darling+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 "
