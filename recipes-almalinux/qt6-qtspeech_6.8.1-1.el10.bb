# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtspeech"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtspeech \
 qt6-qtspeech-devel \
 qt6-qtspeech-examples \
 qt6-qtspeech-speechd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtspeech-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51db67c1162d17a13fe1f876f83d2d066008bd952ab8eba36762b1912da7ac3d"

URI_x86_64_v2_qt6-qtspeech = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtspeech-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtspeech;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtspeech}"
SRC_URI[x86_64_v2_qt6-qtspeech.sha256sum] = "e2d0cfc929e924b1bfb69ab8c27d4f242896711e9c7a2920126db09c99fb2dc6"

URI_x86_64_v2_qt6-qtspeech-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtspeech-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtspeech-devel}"
SRC_URI[x86_64_v2_qt6-qtspeech-devel.sha256sum] = "760b164bbedc0578928c59d5e0926d883a71e7db74c7623297cb3794453037b5"

URI_x86_64_v2_qt6-qtspeech-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtspeech-examples-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtspeech-examples}"
SRC_URI[x86_64_v2_qt6-qtspeech-examples.sha256sum] = "cdaa313855af4b396affabba205076bad75d82bb4cd93afb3912814787c9ce5a"

URI_x86_64_v2_qt6-qtspeech-speechd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtspeech-speechd-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtspeech-speechd}"
SRC_URI[x86_64_v2_qt6-qtspeech-speechd.sha256sum] = "fa823e754c056ed56d688340b39303e413670937fd4dc5b07ed43fa6e0b18ca4"

URI_aarch64_qt6-qtspeech = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtspeech-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtspeech;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtspeech}"
SRC_URI[aarch64_qt6-qtspeech.sha256sum] = "7057ddf76de919f7223d71956e1f831638200f7b6529daec1b7d656359e2bf46"

URI_aarch64_qt6-qtspeech-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtspeech-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtspeech-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtspeech-devel}"
SRC_URI[aarch64_qt6-qtspeech-devel.sha256sum] = "e96039fd22a114524294abcc33e2ef2c23216625b89772b1425fb8a9e7517e26"

URI_aarch64_qt6-qtspeech-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtspeech-examples-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtspeech-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtspeech-examples}"
SRC_URI[aarch64_qt6-qtspeech-examples.sha256sum] = "129e618aabccd94713bc2d3b2c34e1cab89d6929efdd611569a9f688bf4bea67"

URI_aarch64_qt6-qtspeech-speechd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtspeech-speechd-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtspeech-speechd;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtspeech-speechd}"
SRC_URI[aarch64_qt6-qtspeech-speechd.sha256sum] = "cfec61e3be002115805ae86d19173b1175f01fa4cc4dbd7993016ac9261c1e09"

RDEPENDS:qt6-qtspeech = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:qt6-qtspeech-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtmultimedia-devel \
 qt6-qtspeech \
 "
RDEPENDS:qt6-qtspeech-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
RDEPENDS:qt6-qtspeech-speechd = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtspeech \
 speech-dispatcher-libs \
 "
