# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-protocol"
PV = "0.48.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-protocol+async-client-devel \
 rust-gix-protocol+blocking-client-devel \
 rust-gix-protocol+default-devel \
 rust-gix-protocol+document-features-devel \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol+serde-devel \
 rust-gix-protocol-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-protocol-0.48.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2379361d8cd90b72551e8202443524b8d463708601dfd049e4e0372d71b80254"

URI_x86_64_v2_rust-gix-protocol+async-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+async-client-devel-0.48.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+async-client-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+async-client-devel.sha256sum] = "453176736d05027f521282789a19af9f2597fc943bc83597a8d6de762399e19a"

URI_x86_64_v2_rust-gix-protocol+blocking-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+blocking-client-devel-0.48.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+blocking-client-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+blocking-client-devel.sha256sum] = "ba80664fc678a3bf34c2d343173f13a1f5eb97595f057a26572364df10d14122"

URI_x86_64_v2_rust-gix-protocol+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+default-devel-0.48.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+default-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+default-devel.sha256sum] = "7bab96ab9a3d5c23bc89dcfb5749b91cab31e8dd6cd59373a7467723e85d9b85"

URI_x86_64_v2_rust-gix-protocol+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+document-features-devel-0.48.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+document-features-devel.sha256sum] = "e4125ecfaa12ba98e31fb7c6a849dc0bfd7f14696212aab32abd4940e30befb2"

URI_x86_64_v2_rust-gix-protocol+fetch-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+fetch-devel-0.48.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+fetch-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+fetch-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+fetch-devel.sha256sum] = "a73345fde542e57cf766d9ca15f03c46955289334819c5852feed29915ddec6a"

URI_x86_64_v2_rust-gix-protocol+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+handshake-devel-0.48.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+handshake-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+handshake-devel.sha256sum] = "ceb2fb607f9c5a5f71adb663588ff8539a1b1fab0683d7386341ef7293aa1976"

URI_x86_64_v2_rust-gix-protocol+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol+serde-devel-0.48.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol+serde-devel.sha256sum] = "3f3ce16c339405074d8b149ed5639e202d0771997fb54eafeb5deae11d6d3fe8"

URI_x86_64_v2_rust-gix-protocol-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-protocol-devel-0.48.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-protocol-devel}"
SRC_URI[x86_64_v2_rust-gix-protocol-devel.sha256sum] = "ffac4cad1dff130f21a19c723a72d5cea5a444ad88b5b8bca0336a07c5cecd7d"

URI_aarch64_rust-gix-protocol+async-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+async-client-devel-0.48.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-protocol+async-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+async-client-devel}"
SRC_URI[aarch64_rust-gix-protocol+async-client-devel.sha256sum] = "eefd239987bea97f7ad4362fb12cabb9fa97e5e9831613ded513d1deb3ecba75"

URI_aarch64_rust-gix-protocol+blocking-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+blocking-client-devel-0.48.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-protocol+blocking-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+blocking-client-devel}"
SRC_URI[aarch64_rust-gix-protocol+blocking-client-devel.sha256sum] = "9d49487fccd0536f0d9c7262e494f4feb9fb445773c598740b2f8f5312e77dc1"

URI_aarch64_rust-gix-protocol+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+default-devel-0.48.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-protocol+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+default-devel}"
SRC_URI[aarch64_rust-gix-protocol+default-devel.sha256sum] = "00418abe8238ed9d989a11d26e363d5d4e81a4b9579ae4bd5d348790a4ff8e77"

URI_aarch64_rust-gix-protocol+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+document-features-devel-0.48.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-protocol+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+document-features-devel}"
SRC_URI[aarch64_rust-gix-protocol+document-features-devel.sha256sum] = "4f4a1a8c07bb155dca378f3780294414933e953083ba5e2424053d60ce36cda3"

URI_aarch64_rust-gix-protocol+fetch-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+fetch-devel-0.48.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-protocol+fetch-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+fetch-devel}"
SRC_URI[aarch64_rust-gix-protocol+fetch-devel.sha256sum] = "3d6a434b1e591ce53acde4a656d6b147565aac1dc916999d0ecda93723255f24"

URI_aarch64_rust-gix-protocol+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+handshake-devel-0.48.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-protocol+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+handshake-devel}"
SRC_URI[aarch64_rust-gix-protocol+handshake-devel.sha256sum] = "5e10e5bb6d7bca6f44239ebc19d1165e80759ced3e8a2bc972b050df407dc543"

URI_aarch64_rust-gix-protocol+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol+serde-devel-0.48.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-protocol+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol+serde-devel}"
SRC_URI[aarch64_rust-gix-protocol+serde-devel.sha256sum] = "82dcacefa04ccf768795f4cd8e3cd1f91685e96894a3084aca17bf1d1e224f1b"

URI_aarch64_rust-gix-protocol-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-protocol-devel-0.48.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-protocol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-protocol-devel}"
SRC_URI[aarch64_rust-gix-protocol-devel.sha256sum] = "46389b4736b522840a29ff69dbbc41ab7d1d77e9288c3ed7cd67d63f619dca56"

RDEPENDS:rust-gix-protocol+async-client-devel = " \
 cargo \
 rust-async-trait+default-devel \
 rust-futures-io+default-devel \
 rust-futures-lite+default-devel \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol-devel \
 rust-gix-transport+async-client-devel \
 "
RDEPENDS:rust-gix-protocol+blocking-client-devel = " \
 cargo \
 rust-gix-protocol+fetch-devel \
 rust-gix-protocol+handshake-devel \
 rust-gix-protocol-devel \
 rust-gix-transport+blocking-client-devel \
 rust-maybe-async+is_sync-devel \
 "
RDEPENDS:rust-gix-protocol+default-devel = " \
 cargo \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+fetch-devel = " \
 cargo \
 rust-gix-lock+default-devel \
 rust-gix-negotiate+default-devel \
 rust-gix-object+default-devel \
 rust-gix-protocol-devel \
 rust-gix-refspec+default-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-protocol+handshake-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-protocol-devel \
 "
RDEPENDS:rust-gix-protocol+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-protocol-devel \
 rust-gix-shallow+serde-devel \
 rust-gix-transport+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-protocol-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-date+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-hash+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-shallow+default-devel \
 rust-gix-transport+default-devel \
 rust-gix-utils+default-devel \
 rust-maybe-async+default-devel \
 rust-thiserror+default-devel \
 rust-winnow0.6+default-devel \
 rust-winnow0.6+simd-devel \
 "
