# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-disks"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-disks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-disks-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "963e1497eff802218054881b91b038f818acddc8b9ed1475aec07a81494b4d97"

URI_x86_64_v2_plasma-disks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-disks-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-disks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-disks}"
SRC_URI[x86_64_v2_plasma-disks.sha256sum] = "378fbc470edca61d774e24f9dd5f739545ec5d305c7c469c879d076fe315ee27"

URI_aarch64_plasma-disks = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-disks-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-disks;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-disks}"
SRC_URI[aarch64_plasma-disks.sha256sum] = "42793ce628ea30f404b43de802680360c8c96bcbfa750c1831ed934228219b73"

RDEPENDS:plasma-disks = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kservice \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 smartmontools \
 "
