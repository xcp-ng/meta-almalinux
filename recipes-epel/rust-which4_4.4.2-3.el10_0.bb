# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-which4"
PV = "4.4.2"
PR = "3.el10_0"
PACKAGES = " \
 rust-which4+default-devel \
 rust-which4+regex-devel \
 rust-which4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-which4-4.4.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc93e2e90ba336a3be177fe9f276d56245f5a2c90146e6eaf81b3df7b748b3c3"

URI_x86_64_v2_rust-which4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which4+default-devel-4.4.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which4+default-devel}"
SRC_URI[x86_64_v2_rust-which4+default-devel.sha256sum] = "7f952dfcb54f00a7ca003b3633efdc01d139cd47f4257397dfb8a1eea420cf01"

URI_x86_64_v2_rust-which4+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which4+regex-devel-4.4.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which4+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which4+regex-devel}"
SRC_URI[x86_64_v2_rust-which4+regex-devel.sha256sum] = "440d6aa05336f6ac8c7409a305a1392526487f263aec177abefcf7785dcbc80d"

URI_x86_64_v2_rust-which4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-which4-devel-4.4.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-which4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-which4-devel}"
SRC_URI[x86_64_v2_rust-which4-devel.sha256sum] = "9d5f48453cbbd4464959b197f064e5dcd1ddee2651e0c76b5de5423647cb36a3"

URI_aarch64_rust-which4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which4+default-devel-4.4.2-3.el10_0.noarch.rpm;name=aarch64_rust-which4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which4+default-devel}"
SRC_URI[aarch64_rust-which4+default-devel.sha256sum] = "388cd398518a462c6e1e0a9d523ebe9de2d1b09ab02af0d8530cb7fcead24e21"

URI_aarch64_rust-which4+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which4+regex-devel-4.4.2-3.el10_0.noarch.rpm;name=aarch64_rust-which4+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which4+regex-devel}"
SRC_URI[aarch64_rust-which4+regex-devel.sha256sum] = "a1c4203366e57018c4aec433767a22ca9c7d9e12dfdf6609095a5138449d02c0"

URI_aarch64_rust-which4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-which4-devel-4.4.2-3.el10_0.noarch.rpm;name=aarch64_rust-which4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-which4-devel}"
SRC_URI[aarch64_rust-which4-devel.sha256sum] = "24206de69ca369de078145d7733d5444c919ee0e45e5d13066bc6330a35568fe"

RDEPENDS:rust-which4+default-devel = " \
 cargo \
 rust-which4-devel \
 "
RDEPENDS:rust-which4+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-which4-devel \
 "
RDEPENDS:rust-which4-devel = " \
 cargo \
 rust \
 rust-either+default-devel \
 rust-home+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
