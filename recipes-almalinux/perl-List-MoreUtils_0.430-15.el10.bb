# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-List-MoreUtils"
PV = "0.430"
PR = "15.el10"
PACKAGES = " \
 perl-List-MoreUtils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-List-MoreUtils-0.430-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dabdb15091ad691bdef67fc7f5433e394f0fd53e8eae746a43ec5f23f720054"

URI_x86_64_v2_perl-List-MoreUtils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-List-MoreUtils-0.430-15.el10.noarch.rpm;name=x86_64_v2_perl-List-MoreUtils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-List-MoreUtils}"
SRC_URI[x86_64_v2_perl-List-MoreUtils.sha256sum] = "cd1ca19e99d5d12b625ab67a30b88f590ebc7fe518f8edc579154c9307e07696"

URI_aarch64_perl-List-MoreUtils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-List-MoreUtils-0.430-15.el10.noarch.rpm;name=aarch64_perl-List-MoreUtils;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-List-MoreUtils}"
SRC_URI[aarch64_perl-List-MoreUtils.sha256sum] = "cd1ca19e99d5d12b625ab67a30b88f590ebc7fe518f8edc579154c9307e07696"

RDEPENDS:perl-List-MoreUtils = " \
 perl-Carp \
 perl-Exporter-Tiny \
 perl-List-MoreUtils \
 perl-List-MoreUtils-XS \
 perl-libs \
 perl-parent \
 perl-vars \
 "
