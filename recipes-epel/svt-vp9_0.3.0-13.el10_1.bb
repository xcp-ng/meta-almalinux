# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "svt-vp9"
PV = "0.3.0"
PR = "13.el10_1"
PACKAGES:x86_64_v2 = " \
 gstreamer1-svt-vp9 \
 svt-vp9 \
 svt-vp9-devel \
 svt-vp9-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/s/svt-vp9-0.3.0-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5caa30618b9419a839bee3fb4c1466365fef591b8a0f5d1b21d908f5c7062143"

URI_x86_64_v2_gstreamer1-svt-vp9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gstreamer1-svt-vp9-0.3.0-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-svt-vp9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-svt-vp9}"
SRC_URI[x86_64_v2_gstreamer1-svt-vp9.sha256sum] = "ece491f63268497502cef330759c36ec00ca959b9c48c201d6d570ac17f06ef6"

URI_x86_64_v2_svt-vp9 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svt-vp9-0.3.0-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svt-vp9;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svt-vp9}"
SRC_URI[x86_64_v2_svt-vp9.sha256sum] = "6ae7d1f91fdcbf3b15f13ec08db7c91eace8889174ec89f4a07752d4bd73ed69"

URI_x86_64_v2_svt-vp9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svt-vp9-devel-0.3.0-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svt-vp9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svt-vp9-devel}"
SRC_URI[x86_64_v2_svt-vp9-devel.sha256sum] = "c36e448475cc0f54083c468501fda4cab51d76ca038dc9eb3060c6a81c1e7d25"

URI_x86_64_v2_svt-vp9-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/svt-vp9-libs-0.3.0-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_svt-vp9-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_svt-vp9-libs}"
SRC_URI[x86_64_v2_svt-vp9-libs.sha256sum] = "02ea6a740536f851cd13666469601e9a6edc372ce9d8dda87d23700a6e7ba906"

RDEPENDS:gstreamer1-svt-vp9 = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 svt-vp9-libs \
 "
RDEPENDS:svt-vp9 = " \
 glibc \
 svt-vp9-libs \
 "
RDEPENDS:svt-vp9-devel = " \
 pkgconf-pkg-config \
 svt-vp9-libs \
 "
RDEPENDS:svt-vp9-libs = " \
 glibc \
 "
