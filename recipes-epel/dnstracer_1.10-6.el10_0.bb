# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnstracer"
PV = "1.10"
PR = "6.el10_0"
PACKAGES = " \
 dnstracer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnstracer-1.10-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f3fa1ab2ee89d27b70e56f6f5117ae6965132f9dfccb8a3cf10307e06d72f14"

URI_x86_64_v2_dnstracer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnstracer-1.10-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnstracer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnstracer}"
SRC_URI[x86_64_v2_dnstracer.sha256sum] = "9c3b1ac5a2e33d81cef40c041c717a8335c9b49d69eb2cf2eb516b3b6b36405d"

URI_aarch64_dnstracer = "${EPEL_MIRROR}/aarch64/Packages/d/dnstracer-1.10-6.el10_0.aarch64.rpm;name=aarch64_dnstracer;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnstracer}"
SRC_URI[aarch64_dnstracer.sha256sum] = "279997ae17743f6fb342e09facb90a1d1a99719d07ec37425f478ae514f1a4fe"

RDEPENDS:dnstracer = " \
 glibc \
 "
