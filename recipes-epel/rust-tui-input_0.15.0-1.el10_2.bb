# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tui-input"
PV = "0.15.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tui-input+default-devel \
 rust-tui-input+ratatui-crossterm-devel \
 rust-tui-input+ratatui-termion-devel \
 rust-tui-input-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tui-input-0.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa477acde4f2c2ff93395ea6b2a42c1d5c0cb6eba0586217f36604d019d6efe8"

URI_x86_64_v2_rust-tui-input+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-input+default-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-input+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tui-input+default-devel}"
SRC_URI[x86_64_v2_rust-tui-input+default-devel.sha256sum] = "cbbe94673cbab6f02969cf54e80c62f2527a897f78976ed6a3413c2839ae5c2a"

URI_x86_64_v2_rust-tui-input+ratatui-crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-input+ratatui-crossterm-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-input+ratatui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tui-input+ratatui-crossterm-devel}"
SRC_URI[x86_64_v2_rust-tui-input+ratatui-crossterm-devel.sha256sum] = "0ceda446fe7dfd4a3c6dbe75e7c3bc97d1a4b371e469cdcd58ec198a0a76b504"

URI_x86_64_v2_rust-tui-input+ratatui-termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-input+ratatui-termion-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-input+ratatui-termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tui-input+ratatui-termion-devel}"
SRC_URI[x86_64_v2_rust-tui-input+ratatui-termion-devel.sha256sum] = "62300e8c126078fb8885f6511a95843be837f4e53ab95a38668e039917fdec8e"

URI_x86_64_v2_rust-tui-input-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tui-input-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tui-input-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tui-input-devel}"
SRC_URI[x86_64_v2_rust-tui-input-devel.sha256sum] = "1125a1812f26e2f00bc90f10bbabe3cd7e990d9f700daebc01b945204502980b"

URI_aarch64_rust-tui-input+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-input+default-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-tui-input+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tui-input+default-devel}"
SRC_URI[aarch64_rust-tui-input+default-devel.sha256sum] = "7e91f91fd0faecea3c4a3a23dce0db2ed47ee689c5b80bb334bb4f2a9101009e"

URI_aarch64_rust-tui-input+ratatui-crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-input+ratatui-crossterm-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-tui-input+ratatui-crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tui-input+ratatui-crossterm-devel}"
SRC_URI[aarch64_rust-tui-input+ratatui-crossterm-devel.sha256sum] = "f5b4f02d596e5cc5c05ef95e5727b352ec0b4a215e23a8799193c67d16a1f971"

URI_aarch64_rust-tui-input+ratatui-termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-input+ratatui-termion-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-tui-input+ratatui-termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tui-input+ratatui-termion-devel}"
SRC_URI[aarch64_rust-tui-input+ratatui-termion-devel.sha256sum] = "3c8d6630ef86c7b482676e8be5f1e2552e1f75b7c7ab27d73023e7bedbb33f52"

URI_aarch64_rust-tui-input-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tui-input-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-tui-input-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tui-input-devel}"
SRC_URI[aarch64_rust-tui-input-devel.sha256sum] = "4c23941042ee15a5bee8676468c4afcf1e0314eea21066ee4d1350690f99cb3f"

RDEPENDS:rust-tui-input+default-devel = " \
 cargo \
 rust-tui-input+ratatui-crossterm-devel \
 rust-tui-input-devel \
 "
RDEPENDS:rust-tui-input+ratatui-crossterm-devel = " \
 cargo \
 rust-ratatui+crossterm-devel \
 rust-ratatui+default-devel \
 rust-tui-input-devel \
 "
RDEPENDS:rust-tui-input+ratatui-termion-devel = " \
 cargo \
 rust-ratatui+crossterm-devel \
 rust-ratatui+default-devel \
 rust-ratatui+termion-devel \
 rust-tui-input-devel \
 "
RDEPENDS:rust-tui-input-devel = " \
 cargo \
 rust-unicode-width+default-devel \
 "
