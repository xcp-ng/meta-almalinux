# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "image-builder"
PV = "52.1"
PR = "1.el10_2"
PACKAGES = " \
 image-builder \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/image-builder-52.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0402ef70b01ab45fd72e266c60c78bd610a4e2797b66d711d5c9a052cae3abff"

URI_x86_64_v2_image-builder = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/image-builder-52.1-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_image-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_image-builder}"
SRC_URI[x86_64_v2_image-builder.sha256sum] = "a54fecef6bfab1a13b7d12d4608c7e617237f8f963a878d868aa0f6ffbfcccf9"

URI_aarch64_image-builder = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/image-builder-52.1-1.el10_2.aarch64.rpm;name=aarch64_image-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_image-builder}"
SRC_URI[aarch64_image-builder.sha256sum] = "4a8ad1ddad58ccdc2923d4c3bc2d1faaa30d7207986edc112a655b34d1a38df7"

RDEPENDS:image-builder = " \
 glibc \
 gpgme \
 libvirt-libs \
 libxcrypt \
 osbuild \
 osbuild-depsolve-dnf \
 osbuild-luks2 \
 osbuild-lvm2 \
 osbuild-ostree \
 "
