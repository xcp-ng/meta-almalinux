# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-openprinting-ipp-usb"
PV = "0.9.27"
PR = "7.el10"
PACKAGES = " \
 ipp-usb \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-github-openprinting-ipp-usb-0.9.27-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a324625c160e72f11a1ae55ad0702a4dde3d8f60293026d7cf2762029edd9057"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipp-usb-0.9.27-7.el10.x86_64_v2.rpm;name=x86_64_v2_ipp-usb;unpack=0"
SRC_URI[x86_64_v2_ipp-usb.sha256sum] = "427bf5f2a78580a33f26ef25090afb0c62042a23d7e2e288073b4eda2fcb47fd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipp-usb-0.9.27-7.el10.aarch64.rpm;name=aarch64_ipp-usb;unpack=0"
SRC_URI[aarch64_ipp-usb.sha256sum] = "c8fe7654e173a5ca92dbde7a95d616c53efa32cbbf5fee1274d9863ffc370ecd"

RDEPENDS:ipp-usb = " \
 avahi-libs \
 bash \
 glibc \
 libusb1 \
 systemd \
 systemd-udev \
 "
