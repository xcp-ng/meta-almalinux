# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-packetline"
PV = "0.18.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-packetline+async-io-devel \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-packetline+default-devel \
 rust-gix-packetline+document-features-devel \
 rust-gix-packetline+serde-devel \
 rust-gix-packetline-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-packetline-0.18.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19ea0bec35ae457da76f620567f38bb4c21516f3e6e02a156d307aa031b6ed29"

URI_x86_64_v2_rust-gix-packetline+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+async-io-devel-0.18.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+async-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+async-io-devel.sha256sum] = "075efdb5e8cf58047494e4394566cee36c392b1c0e3e60cfc0288d43b13df3a7"

URI_x86_64_v2_rust-gix-packetline+blocking-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+blocking-io-devel-0.18.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+blocking-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+blocking-io-devel.sha256sum] = "ebfb12d587a62e4a07adaba31c5ba5fffdd93b8a96b76bdb08368163e2f0cbf8"

URI_x86_64_v2_rust-gix-packetline+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+default-devel-0.18.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+default-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+default-devel.sha256sum] = "ce2ffd0e9a05d7307af35762848d3d6b7c03585bbdfa9262e1caa1cec239c49a"

URI_x86_64_v2_rust-gix-packetline+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+document-features-devel-0.18.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+document-features-devel.sha256sum] = "3cfe7748ec68c9a05265b7fa1b407da1ed166586f6755af43709f132979e7cd2"

URI_x86_64_v2_rust-gix-packetline+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+serde-devel-0.18.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+serde-devel.sha256sum] = "43e46b474d9f594c23a952d21d235b1f3ef96c9acc45658e5bb9423d7808eb34"

URI_x86_64_v2_rust-gix-packetline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-devel-0.18.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-devel.sha256sum] = "4451a1b415657d5d8f015950abb33288386acc4fa583d7a9b091f6aa9cc02586"

URI_aarch64_rust-gix-packetline+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+async-io-devel-0.18.3-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+async-io-devel}"
SRC_URI[aarch64_rust-gix-packetline+async-io-devel.sha256sum] = "ce78064aadbf2d48f2a3b1cccb8d5e1cb07f1f24b9da0fd9dec96a20c6f41f15"

URI_aarch64_rust-gix-packetline+blocking-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+blocking-io-devel-0.18.3-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+blocking-io-devel}"
SRC_URI[aarch64_rust-gix-packetline+blocking-io-devel.sha256sum] = "78efb40bac82a93f78cfd080eed42ce380bafcf897c41616686f1d27579a6597"

URI_aarch64_rust-gix-packetline+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+default-devel-0.18.3-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+default-devel}"
SRC_URI[aarch64_rust-gix-packetline+default-devel.sha256sum] = "adbc01f0c98203f7b33ffb4b5f1424ed7cab79b7480cf704041f7e5b166f1a25"

URI_aarch64_rust-gix-packetline+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+document-features-devel-0.18.3-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+document-features-devel}"
SRC_URI[aarch64_rust-gix-packetline+document-features-devel.sha256sum] = "6309f86095bc904877adbc1b1c1d2f28fab970578b9ada2107e4aac1bc159c26"

URI_aarch64_rust-gix-packetline+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+serde-devel-0.18.3-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+serde-devel}"
SRC_URI[aarch64_rust-gix-packetline+serde-devel.sha256sum] = "9e586d0c55cd3bb9ff60fba3080c462ee40b59998a428dff2798cf6001858697"

URI_aarch64_rust-gix-packetline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-devel-0.18.3-1.el10_0.noarch.rpm;name=aarch64_rust-gix-packetline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-devel}"
SRC_URI[aarch64_rust-gix-packetline-devel.sha256sum] = "058fa6680762f74fd67caed56758aa191b3f0d5da653f7ec415f80faba5689f4"

RDEPENDS:rust-gix-packetline+async-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-futures-lite+default-devel \
 rust-gix-packetline-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-gix-packetline+blocking-io-devel = " \
 cargo \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+default-devel = " \
 cargo \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-packetline-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-packetline-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-faster-hex+default-devel \
 rust-gix-trace+default-devel \
 rust-thiserror+default-devel \
 "
