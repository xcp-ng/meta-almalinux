# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "postgresql18"
PV = "18.4"
PR = "1.el10_2"
PACKAGES = " \
 postgresql18 \
 postgresql18-contrib \
 postgresql18-docs \
 postgresql18-plperl \
 postgresql18-plpython3 \
 postgresql18-private-devel \
 postgresql18-private-libs \
 postgresql18-server \
 postgresql18-server-devel \
 postgresql18-static \
 postgresql18-test \
 postgresql18-test-rpm-macros \
 postgresql18-upgrade \
 postgresql18-upgrade-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/postgresql18-18.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0456d59cfedc629cd2145e75271859fb4eb16ee9ec8984fe20335cb0145450e"

URI_x86_64_v2_postgresql18 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18}"
SRC_URI[x86_64_v2_postgresql18.sha256sum] = "82096761bb4497f97a56a4903c7465135d0523174eb6a782370038e7c19f3ab0"

URI_x86_64_v2_postgresql18-contrib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-contrib-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-contrib}"
SRC_URI[x86_64_v2_postgresql18-contrib.sha256sum] = "6f0afb3fa4c71476ad93fd74424cdaad542ec52bc45884db98b0c31f404886fa"

URI_x86_64_v2_postgresql18-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-docs-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-docs}"
SRC_URI[x86_64_v2_postgresql18-docs.sha256sum] = "3daa9751b0ae65c170e648744b756c97a28d70f018f7df06127021bc6c5c2284"

URI_x86_64_v2_postgresql18-plperl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-plperl-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-plperl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-plperl}"
SRC_URI[x86_64_v2_postgresql18-plperl.sha256sum] = "386a8973db026feb4044ed4439e38bc49284a218e4f23f94d4c68095a0428de4"

URI_x86_64_v2_postgresql18-plpython3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-plpython3-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-plpython3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-plpython3}"
SRC_URI[x86_64_v2_postgresql18-plpython3.sha256sum] = "d63c40121b2d9d4bcdd5eeaf07f81624e6752d1e2edbb018822af561f7770799"

URI_x86_64_v2_postgresql18-private-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-private-devel-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-private-devel}"
SRC_URI[x86_64_v2_postgresql18-private-devel.sha256sum] = "d70cb83a70e4fa7e823805ad8b168627d43adc79cce752e75c0127d6c720e9d3"

URI_x86_64_v2_postgresql18-private-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-private-libs-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-private-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-private-libs}"
SRC_URI[x86_64_v2_postgresql18-private-libs.sha256sum] = "306dcd7b016eeceef7674632b9d1bf6c1c485bcf65cda256514038ebeb07060a"

URI_x86_64_v2_postgresql18-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-server-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-server}"
SRC_URI[x86_64_v2_postgresql18-server.sha256sum] = "1ec150d8522056d1cb224718840492db2497675d4ccaca1797396691483c0dde"

URI_x86_64_v2_postgresql18-server-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-server-devel-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-server-devel}"
SRC_URI[x86_64_v2_postgresql18-server-devel.sha256sum] = "ee918307c9348394ad3bfe7c96f6bab5fcb27d03656989f65230697f9b982ac8"

URI_x86_64_v2_postgresql18-static = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-static-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-static}"
SRC_URI[x86_64_v2_postgresql18-static.sha256sum] = "2d163ec5fd9ea65ef359919f21c3e5217395dcb8f21a3e901b141737cd1641ea"

URI_x86_64_v2_postgresql18-test = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-test-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-test}"
SRC_URI[x86_64_v2_postgresql18-test.sha256sum] = "ef8bc17dd914e66f23688e93f17ed14ada8c9d54c225b23ba8193a3fbbfda6dc"

URI_x86_64_v2_postgresql18-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/postgresql18-test-rpm-macros-18.4-1.el10_2.noarch.rpm;name=x86_64_v2_postgresql18-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-test-rpm-macros}"
SRC_URI[x86_64_v2_postgresql18-test-rpm-macros.sha256sum] = "4d87699d4229bfaf3026a04e43a4777d01fe8bab2ec1a9f1835a23f5ec702773"

URI_x86_64_v2_postgresql18-upgrade = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-upgrade-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-upgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-upgrade}"
SRC_URI[x86_64_v2_postgresql18-upgrade.sha256sum] = "89d6ca29b7a3276b804d8c751af09cd6318b2fd27da92dd45fc42c59f79c4e56"

URI_x86_64_v2_postgresql18-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/postgresql18-upgrade-devel-18.4-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_postgresql18-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_postgresql18-upgrade-devel}"
SRC_URI[x86_64_v2_postgresql18-upgrade-devel.sha256sum] = "ab0a4d798e5ecea5099ad9d597f82ef4af6c4ddc6c293241bb5aeff07fb36a2e"

URI_aarch64_postgresql18 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18}"
SRC_URI[aarch64_postgresql18.sha256sum] = "196d440b30242708a84af913e2c4a8d7e61fca0666d240b090271e3c3767a69e"

URI_aarch64_postgresql18-contrib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-contrib-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-contrib}"
SRC_URI[aarch64_postgresql18-contrib.sha256sum] = "7f7ae3e6ebaad9e0a72676c76d7c8658f39537bc226efd3576177fab84f9cdd8"

URI_aarch64_postgresql18-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-docs-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-docs}"
SRC_URI[aarch64_postgresql18-docs.sha256sum] = "a6b6cd89596fdcbd07065de60334b610f2af814033512a331a48d3adceafcb18"

URI_aarch64_postgresql18-plperl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-plperl-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-plperl;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-plperl}"
SRC_URI[aarch64_postgresql18-plperl.sha256sum] = "dbffecf83a5b1b8fc43deace967d8c644d856104056aa799d8c970ce9d7e7d88"

URI_aarch64_postgresql18-plpython3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-plpython3-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-plpython3;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-plpython3}"
SRC_URI[aarch64_postgresql18-plpython3.sha256sum] = "94bed68a9cd932903562a408a231d47720318afebc21253fb9f02e5a9eb72369"

URI_aarch64_postgresql18-private-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-private-devel-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-private-devel}"
SRC_URI[aarch64_postgresql18-private-devel.sha256sum] = "c01c320cc74e1fadfcfc5d708d1d4355a9f44fe9410609eaae4fc19d36119424"

URI_aarch64_postgresql18-private-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-private-libs-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-private-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-private-libs}"
SRC_URI[aarch64_postgresql18-private-libs.sha256sum] = "82963e72ff59e4dbb578bf55bc114d2a731966ffbc96cd61b72448131a11dd55"

URI_aarch64_postgresql18-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-server-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-server}"
SRC_URI[aarch64_postgresql18-server.sha256sum] = "1fcde8936b494b93f3d26cb9ed7d230e27723b4aaeea6b6da0369445a54dee51"

URI_aarch64_postgresql18-server-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-server-devel-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-server-devel}"
SRC_URI[aarch64_postgresql18-server-devel.sha256sum] = "aefc41c8f2466c99d1b022edea35391df71ca9a169971a84ac758211fbecc0e9"

URI_aarch64_postgresql18-static = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-static-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-static}"
SRC_URI[aarch64_postgresql18-static.sha256sum] = "17c8660005d574803e62e7a8404ee89b57eb91d59727c7ba2dce0feec531bfbe"

URI_aarch64_postgresql18-test = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-test-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-test}"
SRC_URI[aarch64_postgresql18-test.sha256sum] = "9043b779ccca395b679600a40db4c7b377fdd368df6302459ebd8445b0360af4"

URI_aarch64_postgresql18-test-rpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/postgresql18-test-rpm-macros-18.4-1.el10_2.noarch.rpm;name=aarch64_postgresql18-test-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-test-rpm-macros}"
SRC_URI[aarch64_postgresql18-test-rpm-macros.sha256sum] = "4d87699d4229bfaf3026a04e43a4777d01fe8bab2ec1a9f1835a23f5ec702773"

URI_aarch64_postgresql18-upgrade = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-upgrade-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-upgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-upgrade}"
SRC_URI[aarch64_postgresql18-upgrade.sha256sum] = "0ea79efaab231a0dcfd7ece23b6dd9bdd938bcab2397cf3ea5a664c7891d1b79"

URI_aarch64_postgresql18-upgrade-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/postgresql18-upgrade-devel-18.4-1.el10_2.aarch64.rpm;name=aarch64_postgresql18-upgrade-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_postgresql18-upgrade-devel}"
SRC_URI[aarch64_postgresql18-upgrade-devel.sha256sum] = "0f872d729168456ae4775924f030a87921d70ffaddb6ad5bffd5cc7a8451b802"

RDEPENDS:postgresql18 = " \
 glibc \
 libzstd \
 lz4-libs \
 openssl-libs \
 postgresql18-private-libs \
 readline \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-contrib = " \
 glibc \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openssl-libs \
 perl-libs \
 postgresql18 \
 postgresql18-private-libs \
 python3-libs \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-docs = " \
 glibc \
 postgresql18 \
 "
RDEPENDS:postgresql18-plperl = " \
 glibc \
 perl-libs \
 postgresql18-server \
 "
RDEPENDS:postgresql18-plpython3 = " \
 glibc \
 postgresql18-server \
 python3-libs \
 "
RDEPENDS:postgresql18-private-devel = " \
 openssl-devel \
 pkgconf-pkg-config \
 postgresql18-private-libs \
 "
RDEPENDS:postgresql18-private-libs = " \
 glibc \
 krb5-libs \
 openldap \
 openssl-libs \
 "
RDEPENDS:postgresql18-server = " \
 bash \
 glibc \
 krb5-libs \
 libicu \
 libxml2 \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 postgresql18 \
 postgresql18-private-libs \
 systemd \
 systemd-libs \
 util-linux \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-server-devel = " \
 bash \
 glibc \
 krb5-devel \
 libicu-devel \
 postgresql18-private-devel \
 postgresql18-private-libs \
 "
RDEPENDS:postgresql18-static = " \
 postgresql18-server-devel \
 "
RDEPENDS:postgresql18-test = " \
 bash \
 glibc \
 postgresql18-contrib \
 postgresql18-server \
 postgresql18-server-devel \
 "
RDEPENDS:postgresql18-test-rpm-macros = " \
 postgresql18-server \
 "
RDEPENDS:postgresql18-upgrade = " \
 glibc \
 krb5-libs \
 libicu \
 libselinux \
 libxml2 \
 libxslt \
 libzstd \
 lz4-libs \
 openldap \
 openssl-libs \
 pam-libs \
 perl-libs \
 postgresql18-private-libs \
 postgresql18-server \
 python3-libs \
 tcl \
 uuid \
 zlib-ng-compat \
 "
RDEPENDS:postgresql18-upgrade-devel = " \
 bash \
 glibc \
 postgresql18-private-libs \
 postgresql18-upgrade \
 "
