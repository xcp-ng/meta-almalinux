# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libEMF"
PV = "1.0.13"
PR = "15.el10_0"
PACKAGES = " \
 libEMF \
 libEMF-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libEMF-1.0.13-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0e48f3ccaa35a3c66d906df9a47de03c77bcf53954dc81fc0ff68110837b732"

URI_x86_64_v2_libEMF = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libEMF-1.0.13-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libEMF;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libEMF}"
SRC_URI[x86_64_v2_libEMF.sha256sum] = "7806bb0de561039af38931e256482db0b914edbed1012f5db3c82befb8bc0abf"

URI_x86_64_v2_libEMF-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libEMF-devel-1.0.13-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libEMF-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libEMF-devel}"
SRC_URI[x86_64_v2_libEMF-devel.sha256sum] = "49b9c89775e0976a62fb738197dc066a75c90b8056a1cb07ba5040750f61bc5d"

URI_aarch64_libEMF = "${EPEL_MIRROR}/aarch64/Packages/l/libEMF-1.0.13-15.el10_0.aarch64.rpm;name=aarch64_libEMF;unpack=0"
SRC_URI:append = " ${URI_aarch64_libEMF}"
SRC_URI[aarch64_libEMF.sha256sum] = "59a9ca7089426ce7a4da316da1f7f0259ce08eae4431e177fa729c74fa33711d"

URI_aarch64_libEMF-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libEMF-devel-1.0.13-15.el10_0.aarch64.rpm;name=aarch64_libEMF-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libEMF-devel}"
SRC_URI[aarch64_libEMF-devel.sha256sum] = "c317af5e862983fd69159388256eccf6df5c7a2b2d7b268ba3320a47df7cbe40"

RDEPENDS:libEMF = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libEMF-devel = " \
 libEMF \
 libstdc++-devel \
 "
