# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgoldrunner"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kgoldrunner \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgoldrunner-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "65743d2f017f8be33171bc2e302ebb7a635c3d94aa4e9d065ce37f34d28e447a"

URI_x86_64_v2_kgoldrunner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgoldrunner-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgoldrunner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgoldrunner}"
SRC_URI[x86_64_v2_kgoldrunner.sha256sum] = "5bb975c58d7a903d1ccfc1ec0a634a309c8198e425ceead84b841d42cf6c2966"

URI_aarch64_kgoldrunner = "${EPEL_MIRROR}/aarch64/Packages/k/kgoldrunner-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kgoldrunner;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgoldrunner}"
SRC_URI[aarch64_kgoldrunner.sha256sum] = "f9d18397aa3e7de11e6db63b6f87c19ed28823b37acd50be5a0399f9471c6202"

RDEPENDS:kgoldrunner = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
