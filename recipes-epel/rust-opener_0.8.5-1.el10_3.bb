# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-opener"
PV = "0.8.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-opener+default-devel \
 rust-opener-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-opener-0.8.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c0156f87965561b6ee15442ddbbde3012c73004659d5d669ddd40d6f44574aa"

URI_x86_64_v2_rust-opener+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-opener+default-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-opener+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-opener+default-devel}"
SRC_URI[x86_64_v2_rust-opener+default-devel.sha256sum] = "437640621c9ee473fb292d86915697edb5b3a32146653427bc08913d54db4038"

URI_x86_64_v2_rust-opener-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-opener-devel-0.8.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-opener-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-opener-devel}"
SRC_URI[x86_64_v2_rust-opener-devel.sha256sum] = "bd7ebb5805f90c660310cbe5c1b39db1b073ffc08d90e337af588b881c814dfd"

URI_aarch64_rust-opener+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-opener+default-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-opener+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-opener+default-devel}"
SRC_URI[aarch64_rust-opener+default-devel.sha256sum] = "dc0fc3f61d5e7e00713200f213ed575294c3a813666a4e1ee12492fb316f6372"

URI_aarch64_rust-opener-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-opener-devel-0.8.5-1.el10_3.noarch.rpm;name=aarch64_rust-opener-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-opener-devel}"
SRC_URI[aarch64_rust-opener-devel.sha256sum] = "1bfb4ee7683ac4de2bc676437c10091ed2b6a5ea9fd5eaaf796163d0d00d0f17"

RDEPENDS:rust-opener+default-devel = " \
 cargo \
 rust-opener-devel \
 "
RDEPENDS:rust-opener-devel = " \
 cargo \
 rust-bstr+default-devel \
 "
