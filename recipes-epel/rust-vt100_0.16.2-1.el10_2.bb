# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vt100"
PV = "0.16.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-vt100+default-devel \
 rust-vt100-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vt100-0.16.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7c8b4598a75cba91815a8726acf46859e23e8922f9fbd7300f051c81e99f657"

URI_x86_64_v2_rust-vt100+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vt100+default-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vt100+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vt100+default-devel}"
SRC_URI[x86_64_v2_rust-vt100+default-devel.sha256sum] = "a4fba98b1032f7f5564b1abd7582fcc22cb68799efb98a7c336389da9832f023"

URI_x86_64_v2_rust-vt100-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vt100-devel-0.16.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vt100-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vt100-devel}"
SRC_URI[x86_64_v2_rust-vt100-devel.sha256sum] = "2474296ed8b5d86927e7225534df65b6855172d6a12eb1b375a126a365acb1fd"

URI_aarch64_rust-vt100+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vt100+default-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-vt100+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vt100+default-devel}"
SRC_URI[aarch64_rust-vt100+default-devel.sha256sum] = "0fecf486cc2673b2b95b5364691695cf085034613737c4b8f67f1c4d937ae39f"

URI_aarch64_rust-vt100-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vt100-devel-0.16.2-1.el10_2.noarch.rpm;name=aarch64_rust-vt100-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vt100-devel}"
SRC_URI[aarch64_rust-vt100-devel.sha256sum] = "b760313b95c54a452248320cf3a56f62f7355399d167c64b89c58a6a5d7946c4"

RDEPENDS:rust-vt100+default-devel = " \
 cargo \
 rust-vt100-devel \
 "
RDEPENDS:rust-vt100-devel = " \
 cargo \
 rust \
 rust-itoa+default-devel \
 rust-unicode-width+default-devel \
 rust-vte+default-devel \
 "
