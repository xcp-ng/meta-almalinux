# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tcpdump"
PE = "14"
PV = "4.99.4"
PR = "10.el10"
PACKAGES = " \
 tcpdump \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tcpdump-4.99.4-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e289048eaad62cad7b8c4ab6f56de3133e83d1f0fdc9e158ab7ac39fedbb2e60"

URI_x86_64_v2_tcpdump = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tcpdump-4.99.4-10.el10.x86_64_v2.rpm;name=x86_64_v2_tcpdump;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcpdump}"
SRC_URI[x86_64_v2_tcpdump.sha256sum] = "a34c68440381ad3a7ca23869f9161bde5e7aad39cd14df329ace56f7f6b2eb2b"

URI_aarch64_tcpdump = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tcpdump-4.99.4-10.el10.aarch64.rpm;name=aarch64_tcpdump;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcpdump}"
SRC_URI[aarch64_tcpdump.sha256sum] = "a27ee3b54b3f5874772cd55d6d5b63a9d436cc23838308850d6f12da130e7b8a"

RDEPENDS:tcpdump = " \
 bash \
 glibc \
 libpcap \
 openssl-libs \
 shadow-utils \
 "
