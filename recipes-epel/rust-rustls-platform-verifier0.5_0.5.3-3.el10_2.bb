# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustls-platform-verifier0.5"
PV = "0.5.3"
PR = "3.el10_2"
PACKAGES = " \
 rust-rustls-platform-verifier0.5+base64-devel \
 rust-rustls-platform-verifier0.5+cert-logging-devel \
 rust-rustls-platform-verifier0.5+dbg-devel \
 rust-rustls-platform-verifier0.5+default-devel \
 rust-rustls-platform-verifier0.5+ffi-testing-devel \
 rust-rustls-platform-verifier0.5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustls-platform-verifier0.5-0.5.3-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7bcc83864a728f1767024f9fe76817395eaeb2a9626a78f694a2d80962283d5f"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+base64-devel-0.5.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+base64-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+base64-devel.sha256sum] = "73bd2e50bd810e96014313ab80b2319f2bd9baa296a15bc98c4641902d1cebb6"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+cert-logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+cert-logging-devel-0.5.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+cert-logging-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+cert-logging-devel.sha256sum] = "8a16e15e27dc4269c157d30aa8c2ed22c6b449f6118185da26c9f6fd97b4441b"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+dbg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+dbg-devel-0.5.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+dbg-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+dbg-devel.sha256sum] = "0b1a085f08325b78c4e15d6bf689cae22b5fa0b9717e0a670192dd8bdcadd7b4"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+default-devel-0.5.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+default-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+default-devel.sha256sum] = "ca5a36bc5b66911b4654b04f8222ee2e4e03ca71b6d25a1cf36cf132fc57c940"

URI_x86_64_v2_rust-rustls-platform-verifier0.5+ffi-testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5+ffi-testing-devel-0.5.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5+ffi-testing-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5+ffi-testing-devel.sha256sum] = "f4a5cefac0d20640c447716de0b6b22c6a4e355c81e1d05e08f0a4ec62c0d65d"

URI_x86_64_v2_rust-rustls-platform-verifier0.5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustls-platform-verifier0.5-devel-0.5.3-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustls-platform-verifier0.5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustls-platform-verifier0.5-devel}"
SRC_URI[x86_64_v2_rust-rustls-platform-verifier0.5-devel.sha256sum] = "6b47efcfcffd13ca99c0e350b3163247c943787c00cc2c1519ad1a4768af4996"

URI_aarch64_rust-rustls-platform-verifier0.5+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+base64-devel-0.5.3-3.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+base64-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+base64-devel.sha256sum] = "c816f5eb7b3ddc1cc2695268bc8a7b6cb0405448e5bc89b423a5b8b97976b8d7"

URI_aarch64_rust-rustls-platform-verifier0.5+cert-logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+cert-logging-devel-0.5.3-3.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+cert-logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+cert-logging-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+cert-logging-devel.sha256sum] = "f024fd27638fd46976e58d23b13db07b7a680c855098fe196f23f94228913c56"

URI_aarch64_rust-rustls-platform-verifier0.5+dbg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+dbg-devel-0.5.3-3.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+dbg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+dbg-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+dbg-devel.sha256sum] = "da3075c1b30f8959ab718da982e1a27d46f07dd43fa11560745d8d230d00095a"

URI_aarch64_rust-rustls-platform-verifier0.5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+default-devel-0.5.3-3.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+default-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+default-devel.sha256sum] = "2d5b628a8372df0b2c8d331ff85a9d1eb1b78c0a64cb8041836a18d542eb7af5"

URI_aarch64_rust-rustls-platform-verifier0.5+ffi-testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5+ffi-testing-devel-0.5.3-3.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5+ffi-testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5+ffi-testing-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5+ffi-testing-devel.sha256sum] = "753a3a1bca16edafd75b0a285c58fb1aa3824fa808b419d571812e8c4325fe91"

URI_aarch64_rust-rustls-platform-verifier0.5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustls-platform-verifier0.5-devel-0.5.3-3.el10_2.noarch.rpm;name=aarch64_rust-rustls-platform-verifier0.5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustls-platform-verifier0.5-devel}"
SRC_URI[aarch64_rust-rustls-platform-verifier0.5-devel.sha256sum] = "c29e7b61b2401cfa41d058d13d11c8e371acf3d3a8c39ba5b7e8a77f384893c0"

RDEPENDS:rust-rustls-platform-verifier0.5+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5+cert-logging-devel = " \
 cargo \
 rust-rustls-platform-verifier0.5+base64-devel \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5+dbg-devel = " \
 cargo \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5+default-devel = " \
 cargo \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5+ffi-testing-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-rustls-platform-verifier0.5-devel \
 "
RDEPENDS:rust-rustls-platform-verifier0.5-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-once_cell+default-devel \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-rustls-native-certs+default-devel \
 rust-rustls-webpki-devel \
 "
