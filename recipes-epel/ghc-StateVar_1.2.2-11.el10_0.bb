# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-StateVar"
PV = "1.2.2"
PR = "11.el10_0"
PACKAGES = " \
 ghc-StateVar \
 ghc-StateVar-devel \
 ghc-StateVar-doc \
 ghc-StateVar-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-StateVar-1.2.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8e155a2159682f634c3488a76c21998ebc217b4b40708f0287ed5236b026c57"

URI_x86_64_v2_ghc-StateVar = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-StateVar-1.2.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-StateVar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-StateVar}"
SRC_URI[x86_64_v2_ghc-StateVar.sha256sum] = "deadb04e47e81101a9cb720aa733861c298b990d577e88db7dfdf875a6ab22ef"

URI_x86_64_v2_ghc-StateVar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-StateVar-devel-1.2.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-StateVar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-StateVar-devel}"
SRC_URI[x86_64_v2_ghc-StateVar-devel.sha256sum] = "07fa5f984f712f447586ff099e169a395a58ca857952eb92949d059c72f44888"

URI_x86_64_v2_ghc-StateVar-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-StateVar-doc-1.2.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-StateVar-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-StateVar-doc}"
SRC_URI[x86_64_v2_ghc-StateVar-doc.sha256sum] = "452ad484795812a28190acd4edd6e860185d0b97cae45e04136c956ce09e2215"

URI_x86_64_v2_ghc-StateVar-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-StateVar-prof-1.2.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-StateVar-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-StateVar-prof}"
SRC_URI[x86_64_v2_ghc-StateVar-prof.sha256sum] = "18658f2fc910180e6bf33fdb1b4d83fc2ddd4fd8c720cbf0ed93786ccadfe516"

URI_aarch64_ghc-StateVar = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-StateVar-1.2.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-StateVar;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-StateVar}"
SRC_URI[aarch64_ghc-StateVar.sha256sum] = "0355b394c5e8f0c01a40e1f19c50f623af56f83d40e6e18d3b2fc9391b6a0303"

URI_aarch64_ghc-StateVar-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-StateVar-devel-1.2.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-StateVar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-StateVar-devel}"
SRC_URI[aarch64_ghc-StateVar-devel.sha256sum] = "888d93e56c6930e828fcd861e500790b8ece0a700dc0e1c98e7e7397fa7c46d8"

URI_aarch64_ghc-StateVar-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-StateVar-doc-1.2.2-11.el10_0.noarch.rpm;name=aarch64_ghc-StateVar-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-StateVar-doc}"
SRC_URI[aarch64_ghc-StateVar-doc.sha256sum] = "bffccc56846e63e738c7c32191454382e335f4cba1f2c08a8e41489dbb929954"

URI_aarch64_ghc-StateVar-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-StateVar-prof-1.2.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-StateVar-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-StateVar-prof}"
SRC_URI[aarch64_ghc-StateVar-prof.sha256sum] = "3aacc7d9ffe442e04defa56045d219297271bc12b00d59d98393d77d473a65b0"

RDEPENDS:ghc-StateVar = " \
 ghc-array \
 ghc-base \
 ghc-ghc-bignum \
 ghc-stm \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-StateVar-devel = " \
 ghc-StateVar \
 ghc-base-devel \
 ghc-compiler \
 ghc-stm-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-StateVar-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-StateVar-prof = " \
 ghc-StateVar-devel \
 ghc-base-prof \
 ghc-stm-prof \
 ghc-transformers-prof \
 "
