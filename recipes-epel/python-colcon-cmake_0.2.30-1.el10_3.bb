# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-cmake"
PV = "0.2.30"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-cmake \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-cmake-0.2.30-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "804d5cf92a1d6386fceb6251227ec6bda8be5313c2b4e1f46bac14299c642ffe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-cmake-0.2.30-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-cmake;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-cmake.sha256sum] = "235be51ad5dd0ea2f9f017b8def706098093d6ced42f505273038e9bb88e68b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-cmake-0.2.30-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-cmake;unpack=0"
SRC_URI[aarch64_python3-colcon-cmake.sha256sum] = "24b6dd87ea77120a8729ec4296a16e648a7090c87a2fb94b18bec486ad58a801"

RDEPENDS:python3-colcon-cmake = " \
 python3 \
 python3-colcon-core \
 python3-colcon-library-path \
 python3-colcon-test-result \
 python3-packaging \
 "
