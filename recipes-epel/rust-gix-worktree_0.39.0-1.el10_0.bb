# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree"
PV = "0.39.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree+default-devel \
 rust-gix-worktree+document-features-devel \
 rust-gix-worktree+serde-devel \
 rust-gix-worktree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-0.39.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36656cedcb184dde117c6c2966da72254f3afbb092240994a3011000d0d1d921"

URI_x86_64_v2_rust-gix-worktree+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+attributes-devel-0.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+attributes-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+attributes-devel.sha256sum] = "69e87579e34f7faed5187a84bb31f4700662be9516adb52507a1d561d7b726e4"

URI_x86_64_v2_rust-gix-worktree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+default-devel-0.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+default-devel.sha256sum] = "308ff65f7559fa276e29387054788aec72290bfd4eccb3a73c5c412a6396dbed"

URI_x86_64_v2_rust-gix-worktree+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+document-features-devel-0.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+document-features-devel.sha256sum] = "72f46e6628bb66c91ee18c3533e844abd09fb209e9a83a079c869e0151453a12"

URI_x86_64_v2_rust-gix-worktree+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree+serde-devel-0.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree+serde-devel.sha256sum] = "a760a1b0a8a0d96c9b48b79c2f326ff965323289cce581bb39694ebd42b635bb"

URI_x86_64_v2_rust-gix-worktree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-devel-0.39.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-devel.sha256sum] = "8d6eafc27138fbe2f538d0640212c7d7d8bebe6a2c11f7a736e0bfab33e47466"

URI_aarch64_rust-gix-worktree+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+attributes-devel-0.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-worktree+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+attributes-devel}"
SRC_URI[aarch64_rust-gix-worktree+attributes-devel.sha256sum] = "0962f5036876acc8f04d878c6af5caa77e9db8c8fa9d12d491f8e18001d93e30"

URI_aarch64_rust-gix-worktree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+default-devel-0.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-worktree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+default-devel}"
SRC_URI[aarch64_rust-gix-worktree+default-devel.sha256sum] = "5bdbc9edb335cffe4807af4b307ef680aebcfed4c114ffddadabfed818d23751"

URI_aarch64_rust-gix-worktree+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+document-features-devel-0.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-worktree+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+document-features-devel}"
SRC_URI[aarch64_rust-gix-worktree+document-features-devel.sha256sum] = "2b35a09cba53a5bb47bf28ad4d11eaa47cc96689f9cef60342c0f371ab5c727c"

URI_aarch64_rust-gix-worktree+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree+serde-devel-0.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-worktree+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree+serde-devel}"
SRC_URI[aarch64_rust-gix-worktree+serde-devel.sha256sum] = "aef47b764bb74d03024a4f74cef1b50883f690e2c4e0bed7f4f38e4b0461b493"

URI_aarch64_rust-gix-worktree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-devel-0.39.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-worktree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-devel}"
SRC_URI[aarch64_rust-gix-worktree-devel.sha256sum] = "a423a41cfac2d62e24dc843c057c0b11bb07063b4cdd3f006ba49478554bc531"

RDEPENDS:rust-gix-worktree+attributes-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-validate+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+default-devel = " \
 cargo \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix-worktree+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-hash+serde-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-index+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-worktree-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-worktree-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-features+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-ignore+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 "
