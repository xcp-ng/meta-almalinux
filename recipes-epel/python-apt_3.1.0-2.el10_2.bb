# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-apt"
PV = "3.1.0"
PR = "2.el10_2"
PACKAGES = " \
 python3-apt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-apt-3.1.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d2fc0e947f83769fd1b1985ae49324afc1fcf5b8d837c53f01d5eb666a08205"

URI_x86_64_v2_python3-apt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-apt-3.1.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-apt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-apt}"
SRC_URI[x86_64_v2_python3-apt.sha256sum] = "63713360f81e6802a800ce7eac4b9b73d33190024fe8c563980a701e7abcf7fc"

URI_aarch64_python3-apt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-apt-3.1.0-2.el10_2.aarch64.rpm;name=aarch64_python3-apt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-apt}"
SRC_URI[aarch64_python3-apt.sha256sum] = "be42aec8c79a8051dbee9e076caf6ff80815cd85a2f885466fa4a9f53cc1dc44"

RDEPENDS:python3-apt = " \
 apt-libs \
 dpkg \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
