# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Object-Remote"
PV = "0.005001"
PR = "2.el10_3"
PACKAGES = " \
 perl-Object-Remote \
 perl-Object-Remote-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Object-Remote-0.005001-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea09412ce521b9d4995500f85d455bf054c47e81d73a301f5cc3dd6b4ad5e847"

URI_x86_64_v2_perl-Object-Remote = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Object-Remote-0.005001-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Object-Remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Object-Remote}"
SRC_URI[x86_64_v2_perl-Object-Remote.sha256sum] = "a537e85a29f117088fc469905ae99a8d330255eb7d1799b6da8cdc7e35c47c16"

URI_x86_64_v2_perl-Object-Remote-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Object-Remote-tests-0.005001-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Object-Remote-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Object-Remote-tests}"
SRC_URI[x86_64_v2_perl-Object-Remote-tests.sha256sum] = "4ebffad8f3441cb4739c36e698c75e1df812f6bf9c34d8e8c514a33601ee3faf"

URI_aarch64_perl-Object-Remote = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Object-Remote-0.005001-2.el10_3.noarch.rpm;name=aarch64_perl-Object-Remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Object-Remote}"
SRC_URI[aarch64_perl-Object-Remote.sha256sum] = "fd58fff4b3db178df0166dcb18ad38a0a2a1837382afd8e44470c71a288e9145"

URI_aarch64_perl-Object-Remote-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Object-Remote-tests-0.005001-2.el10_3.noarch.rpm;name=aarch64_perl-Object-Remote-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Object-Remote-tests}"
SRC_URI[aarch64_perl-Object-Remote-tests.sha256sum] = "69cbd9a242376c2a681e850b30f19bb49f628b552d12bb300d4a885cb9832af8"

RDEPENDS:perl-Object-Remote = " \
 openssh-clients \
 perl-Algorithm-C3 \
 perl-B \
 perl-Carp \
 perl-Class-C3 \
 perl-Data-Dumper \
 perl-Devel-GlobalDestruction \
 perl-Eval-WithLexicals \
 perl-Exporter \
 perl-FileHandle \
 perl-Future \
 perl-IO \
 perl-IPC-Open3 \
 perl-JSON-PP \
 perl-Log-Contextual \
 perl-MRO-Compat \
 perl-Module-Runtime \
 perl-Moo \
 perl-Object-Remote \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-String-ShellQuote \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-ReadLine \
 perl-Tie \
 perl-Time-HiRes \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-strictures \
 sudo \
 "
RDEPENDS:perl-Object-Remote-tests = " \
 bash \
 perl-Errno \
 perl-FindBin \
 perl-Object-Remote \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tie \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
