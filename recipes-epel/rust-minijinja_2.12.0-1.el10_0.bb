# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-minijinja"
PV = "2.12.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+custom_syntax-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+default-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+fuel-devel \
 rust-minijinja+indexmap-devel \
 rust-minijinja+internal_debug-devel \
 rust-minijinja+internal_safe_search-devel \
 rust-minijinja+json-devel \
 rust-minijinja+key_interning-devel \
 rust-minijinja+loop_controls-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja+preserve_order-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+serde_json-devel \
 rust-minijinja+speedups-devel \
 rust-minijinja+stacker-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja+unstable_machinery_serde-devel \
 rust-minijinja+urlencode-devel \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-minijinja-2.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a18ea904522d80919cb679350c90c1af55b0074195fda9c228f6ed87f2cfcda8"

URI_x86_64_v2_rust-minijinja+adjacent_loop_items-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+adjacent_loop_items-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+adjacent_loop_items-devel}"
SRC_URI[x86_64_v2_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "529246540f879c8cfe54d6f9f0c0c22c51f802dd4ea3b9f48518d233d0e29932"

URI_x86_64_v2_rust-minijinja+builtins-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+builtins-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+builtins-devel}"
SRC_URI[x86_64_v2_rust-minijinja+builtins-devel.sha256sum] = "f5e15463696250623289f716c44553e9abf274420d54a8344b980ba7e760fa55"

URI_x86_64_v2_rust-minijinja+custom_syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+custom_syntax-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+custom_syntax-devel}"
SRC_URI[x86_64_v2_rust-minijinja+custom_syntax-devel.sha256sum] = "30a3b17a4a1d5dad060f69bedc7bde5a3e761d6164ee72a683099e01c18af302"

URI_x86_64_v2_rust-minijinja+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+debug-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+debug-devel}"
SRC_URI[x86_64_v2_rust-minijinja+debug-devel.sha256sum] = "fe65317d9bd0fff914316162dc1eed2b73de0efbab044d433977b01708498181"

URI_x86_64_v2_rust-minijinja+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+default-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+default-devel}"
SRC_URI[x86_64_v2_rust-minijinja+default-devel.sha256sum] = "1df9cdc77435485700dc8ee209269947121bbac53072f776d068513531d32371"

URI_x86_64_v2_rust-minijinja+deserialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+deserialization-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+deserialization-devel}"
SRC_URI[x86_64_v2_rust-minijinja+deserialization-devel.sha256sum] = "1e5e6e24c4133121d984363cd70217b487b28d94ca7b85d625f36b4de4fed141"

URI_x86_64_v2_rust-minijinja+fuel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+fuel-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+fuel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+fuel-devel}"
SRC_URI[x86_64_v2_rust-minijinja+fuel-devel.sha256sum] = "2482c2c980685d2eb71e7c7544174d8386264b840511ed4c200c3082acc03fa3"

URI_x86_64_v2_rust-minijinja+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+indexmap-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+indexmap-devel}"
SRC_URI[x86_64_v2_rust-minijinja+indexmap-devel.sha256sum] = "4c142013c832cc2e8b3f0a24c24af6bb187a2fc4cdca4761975b8f8a886d48f4"

URI_x86_64_v2_rust-minijinja+internal_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_debug-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+internal_debug-devel}"
SRC_URI[x86_64_v2_rust-minijinja+internal_debug-devel.sha256sum] = "4bd7378ef02424b6cdeeb5c7124b6ae8ea49bbe41b82db6940d710aca5c4cb79"

URI_x86_64_v2_rust-minijinja+internal_safe_search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+internal_safe_search-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+internal_safe_search-devel}"
SRC_URI[x86_64_v2_rust-minijinja+internal_safe_search-devel.sha256sum] = "ed8fd5c998a4efc9deb7e2798d8a4671b36a52a8aa11726136b94b0d8428f047"

URI_x86_64_v2_rust-minijinja+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+json-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+json-devel}"
SRC_URI[x86_64_v2_rust-minijinja+json-devel.sha256sum] = "2f9a61683afc73f12ed68f37b4231eb2417a3de44fd5948b76a0f3681a30a011"

URI_x86_64_v2_rust-minijinja+key_interning-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+key_interning-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+key_interning-devel}"
SRC_URI[x86_64_v2_rust-minijinja+key_interning-devel.sha256sum] = "3818c7ba9021230ebfb97903dfe96904b68c59d51e4034244da6936a235867b3"

URI_x86_64_v2_rust-minijinja+loop_controls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+loop_controls-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+loop_controls-devel}"
SRC_URI[x86_64_v2_rust-minijinja+loop_controls-devel.sha256sum] = "5489713d529fb5276d48585b43343d78160ef58eb141242add007481b28817c8"

URI_x86_64_v2_rust-minijinja+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+macros-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+macros-devel}"
SRC_URI[x86_64_v2_rust-minijinja+macros-devel.sha256sum] = "a957e40476ed0988ff677a004d3432d59fa69164e130191863c64a6f46a62c6d"

URI_x86_64_v2_rust-minijinja+multi_template-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+multi_template-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+multi_template-devel}"
SRC_URI[x86_64_v2_rust-minijinja+multi_template-devel.sha256sum] = "5ff272b092c5c5318403dad91fbdb332f7364c2f227b5538428601d04b25d6d8"

URI_x86_64_v2_rust-minijinja+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+percent-encoding-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-minijinja+percent-encoding-devel.sha256sum] = "e3f7fe6cafe1588438e86fa27937ff72d31d8f6932aa1a79745bcba3de3364e8"

URI_x86_64_v2_rust-minijinja+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+preserve_order-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-minijinja+preserve_order-devel.sha256sum] = "6c7d424a3e3aa5ef2fe529a7d0230ba40d71587f7dece48373be729a3c7dac6c"

URI_x86_64_v2_rust-minijinja+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+serde-devel}"
SRC_URI[x86_64_v2_rust-minijinja+serde-devel.sha256sum] = "fbeb9e4524b6b2c9a6482bc4b24154760b9bd1018157939b458afe284887d296"

URI_x86_64_v2_rust-minijinja+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+serde_json-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+serde_json-devel}"
SRC_URI[x86_64_v2_rust-minijinja+serde_json-devel.sha256sum] = "ac583bc3e79f9162bb0c491c4d70bdf71e8b67641a12db9522bbaaec29bf773f"

URI_x86_64_v2_rust-minijinja+speedups-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+speedups-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+speedups-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+speedups-devel}"
SRC_URI[x86_64_v2_rust-minijinja+speedups-devel.sha256sum] = "fb32f09784bc2ad407c7b50e09cafe0079d1f82f17a86020a0bc2b994d6bc680"

URI_x86_64_v2_rust-minijinja+stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+stacker-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+stacker-devel}"
SRC_URI[x86_64_v2_rust-minijinja+stacker-devel.sha256sum] = "a73bfbbea2d8eb3c80e918df05ccc1f13a2e48948053019fe8224168c32df370"

URI_x86_64_v2_rust-minijinja+std_collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+std_collections-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+std_collections-devel}"
SRC_URI[x86_64_v2_rust-minijinja+std_collections-devel.sha256sum] = "9d18ec2c249cbdfb8515cf8808cc1b9469505972f3b972cef785180d9ac12739"

URI_x86_64_v2_rust-minijinja+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicase-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicase-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicase-devel.sha256sum] = "ce3fdc3acc539df65fa28922fb2628494c618c69f658776e6c9d0434326edfd0"

URI_x86_64_v2_rust-minijinja+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicode-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicode-devel.sha256sum] = "31563baeedfeef63e758c923f58060db954b5885a242b3dbc6174b26bd58848d"

URI_x86_64_v2_rust-minijinja+unicode-ident-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unicode-ident-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unicode-ident-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unicode-ident-devel.sha256sum] = "e7cbcd9d5391c5a247dbf305029e5d6f51a77de55513fb4e212b05367d2155ba"

URI_x86_64_v2_rust-minijinja+unstable_machinery-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unstable_machinery-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery-devel.sha256sum] = "1540a3c1c88e4fd5ddf9bd3f13666bf0d9b94daa931b9041400fa92050383d23"

URI_x86_64_v2_rust-minijinja+unstable_machinery_serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+unstable_machinery_serde-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+unstable_machinery_serde-devel}"
SRC_URI[x86_64_v2_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "9bd233cfcb544267ece4fc291a3ab39df73e0b1a002365b4b41e400a9fa35855"

URI_x86_64_v2_rust-minijinja+urlencode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+urlencode-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+urlencode-devel}"
SRC_URI[x86_64_v2_rust-minijinja+urlencode-devel.sha256sum] = "a9706a040dd07bb8fe61d8f4ddad99f29427a36bbdf97a8303f49e4c7483200c"

URI_x86_64_v2_rust-minijinja+v_htmlescape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja+v_htmlescape-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja+v_htmlescape-devel}"
SRC_URI[x86_64_v2_rust-minijinja+v_htmlescape-devel.sha256sum] = "64b6ed6d31c9851be34aea9ce578fb81ce0eaf0c6ce6cbe5e7261c98cee2ad8e"

URI_x86_64_v2_rust-minijinja-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-minijinja-devel-2.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-minijinja-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-minijinja-devel}"
SRC_URI[x86_64_v2_rust-minijinja-devel.sha256sum] = "88434528c25b057d0a0a6a2c2026b26e62d022d2ef4cd490a7f77e453cd9f4f1"

URI_aarch64_rust-minijinja+adjacent_loop_items-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+adjacent_loop_items-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+adjacent_loop_items-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+adjacent_loop_items-devel}"
SRC_URI[aarch64_rust-minijinja+adjacent_loop_items-devel.sha256sum] = "b564f627c62d57352d0110ff341c490d04cdff30d73fd5a3f1d0435ba26dc21c"

URI_aarch64_rust-minijinja+builtins-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+builtins-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+builtins-devel}"
SRC_URI[aarch64_rust-minijinja+builtins-devel.sha256sum] = "b3bc46d9d65f4071788730f28a7019a920480a7e31676e80f011e55cc436723e"

URI_aarch64_rust-minijinja+custom_syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+custom_syntax-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+custom_syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+custom_syntax-devel}"
SRC_URI[aarch64_rust-minijinja+custom_syntax-devel.sha256sum] = "472e283179b0c2b3a1424959828dafe9a1864647640013fba6c95d3f5a893a9e"

URI_aarch64_rust-minijinja+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+debug-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+debug-devel}"
SRC_URI[aarch64_rust-minijinja+debug-devel.sha256sum] = "dd1a0c261a43b6ef722ef875f63424082541f04e390e693014c2419fcae64be9"

URI_aarch64_rust-minijinja+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+default-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+default-devel}"
SRC_URI[aarch64_rust-minijinja+default-devel.sha256sum] = "57593dda4d4467bd4c250451709b2cecb4b0071e084c9c09aa211db374e30c98"

URI_aarch64_rust-minijinja+deserialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+deserialization-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+deserialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+deserialization-devel}"
SRC_URI[aarch64_rust-minijinja+deserialization-devel.sha256sum] = "b373042a8b87609b40ecc27ed5b41568fe1c25c8c96472eac7ca7cf5e6846529"

URI_aarch64_rust-minijinja+fuel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+fuel-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+fuel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+fuel-devel}"
SRC_URI[aarch64_rust-minijinja+fuel-devel.sha256sum] = "480c8f2bfe639af56260f5048a57aa60baa77f40ce08fac63ee28ff66f52c3a5"

URI_aarch64_rust-minijinja+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+indexmap-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+indexmap-devel}"
SRC_URI[aarch64_rust-minijinja+indexmap-devel.sha256sum] = "0cbfe38b4d020f9617ff4bca632339786117e6d59a6accce960e0659630455be"

URI_aarch64_rust-minijinja+internal_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_debug-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+internal_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+internal_debug-devel}"
SRC_URI[aarch64_rust-minijinja+internal_debug-devel.sha256sum] = "4a4f4d091b56bb054171a90cb692ef4cdeb46accfddf5eac46895239d4364d97"

URI_aarch64_rust-minijinja+internal_safe_search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+internal_safe_search-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+internal_safe_search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+internal_safe_search-devel}"
SRC_URI[aarch64_rust-minijinja+internal_safe_search-devel.sha256sum] = "d181fa6ef5c4b41a409e5bf7eb9a11ff8150e1f7f4ce3c74f7e13bda5d8aa594"

URI_aarch64_rust-minijinja+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+json-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+json-devel}"
SRC_URI[aarch64_rust-minijinja+json-devel.sha256sum] = "0159f57ea59da1df6becc17ff31fb1df8d37ba793cb2b9f5de346297dc6b3bdc"

URI_aarch64_rust-minijinja+key_interning-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+key_interning-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+key_interning-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+key_interning-devel}"
SRC_URI[aarch64_rust-minijinja+key_interning-devel.sha256sum] = "3bd72387748feb4b4a00edcd668028f42939accc2d6fd3ba58e3acec02c8ff08"

URI_aarch64_rust-minijinja+loop_controls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+loop_controls-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+loop_controls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+loop_controls-devel}"
SRC_URI[aarch64_rust-minijinja+loop_controls-devel.sha256sum] = "81670d92b74df3d68eeabe31683dbff5c03d65fe7f2b761b62d6bbcfe7cab6f4"

URI_aarch64_rust-minijinja+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+macros-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+macros-devel}"
SRC_URI[aarch64_rust-minijinja+macros-devel.sha256sum] = "370c71b9a48e8cad7ff80dadd70d2946029b4d10f158620a424f5ddf435e3723"

URI_aarch64_rust-minijinja+multi_template-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+multi_template-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+multi_template-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+multi_template-devel}"
SRC_URI[aarch64_rust-minijinja+multi_template-devel.sha256sum] = "d85756f21327fb97ea6b0a5918c01a078985a33e5b14b0d49f2a19e71277ca01"

URI_aarch64_rust-minijinja+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+percent-encoding-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+percent-encoding-devel}"
SRC_URI[aarch64_rust-minijinja+percent-encoding-devel.sha256sum] = "e10d25f58b38261b2c549cdeaa07e95f21329e2b243fe723ae122bf8680ebee9"

URI_aarch64_rust-minijinja+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+preserve_order-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+preserve_order-devel}"
SRC_URI[aarch64_rust-minijinja+preserve_order-devel.sha256sum] = "74560252b622fa28c94c9acb4244c1d0df57db243a65c0001901d87c4e147e93"

URI_aarch64_rust-minijinja+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+serde-devel}"
SRC_URI[aarch64_rust-minijinja+serde-devel.sha256sum] = "1fc18022aefd2c1197ce81d6046427ba28ced3024f9515e457e61a0615e8c935"

URI_aarch64_rust-minijinja+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+serde_json-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+serde_json-devel}"
SRC_URI[aarch64_rust-minijinja+serde_json-devel.sha256sum] = "0116a13bafe35a2d47eca29c5e9d564f4153d4a62d67dc877a13f3ad6917630f"

URI_aarch64_rust-minijinja+speedups-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+speedups-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+speedups-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+speedups-devel}"
SRC_URI[aarch64_rust-minijinja+speedups-devel.sha256sum] = "6c618adc49f73d4eab3ecdfaada0b4a8028ac7a1e404c2d3b421c5b9ca6bcf86"

URI_aarch64_rust-minijinja+stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+stacker-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+stacker-devel}"
SRC_URI[aarch64_rust-minijinja+stacker-devel.sha256sum] = "cf1c6fb67158bdc4759528a9bf9686b24d7b2d5a6aa1561faa8b552fd76ee14a"

URI_aarch64_rust-minijinja+std_collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+std_collections-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+std_collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+std_collections-devel}"
SRC_URI[aarch64_rust-minijinja+std_collections-devel.sha256sum] = "ab11ed82ad6c206399e2c159909837ad388c8b3b2aa116af18aadd8377e522da"

URI_aarch64_rust-minijinja+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicase-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicase-devel}"
SRC_URI[aarch64_rust-minijinja+unicase-devel.sha256sum] = "89f8a87c31922b425359960dc23360bb77aaa7d2e1a1f556f8090dc1bc799933"

URI_aarch64_rust-minijinja+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicode-devel}"
SRC_URI[aarch64_rust-minijinja+unicode-devel.sha256sum] = "7611b632ab44562429d66ba968e1fab63f7f08b10b6afc253143d5924d68d86c"

URI_aarch64_rust-minijinja+unicode-ident-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unicode-ident-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+unicode-ident-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unicode-ident-devel}"
SRC_URI[aarch64_rust-minijinja+unicode-ident-devel.sha256sum] = "061a46d18a3f8246c574ec211001c8fdc55caafba46b3c07514d41af9070f79d"

URI_aarch64_rust-minijinja+unstable_machinery-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unstable_machinery-devel}"
SRC_URI[aarch64_rust-minijinja+unstable_machinery-devel.sha256sum] = "e439958834d007b10eb83b8ae8d450de628918dfca75dbff55e7b5477da09938"

URI_aarch64_rust-minijinja+unstable_machinery_serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+unstable_machinery_serde-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+unstable_machinery_serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+unstable_machinery_serde-devel}"
SRC_URI[aarch64_rust-minijinja+unstable_machinery_serde-devel.sha256sum] = "64efd8d3dea3e779fe11c4e2b792e54c9fc38593162f09a156f589c3e0501cec"

URI_aarch64_rust-minijinja+urlencode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+urlencode-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+urlencode-devel}"
SRC_URI[aarch64_rust-minijinja+urlencode-devel.sha256sum] = "27c7a984256d4d1d149ef8832c81c0a93f1adb5789d47e278483c10250309dea"

URI_aarch64_rust-minijinja+v_htmlescape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja+v_htmlescape-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja+v_htmlescape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja+v_htmlescape-devel}"
SRC_URI[aarch64_rust-minijinja+v_htmlescape-devel.sha256sum] = "c8b75c6886c2da8fa35e8f33b2cbce09a04f0d7e3e33c5c46fb4e038352ace8f"

URI_aarch64_rust-minijinja-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-minijinja-devel-2.12.0-1.el10_0.noarch.rpm;name=aarch64_rust-minijinja-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-minijinja-devel}"
SRC_URI[aarch64_rust-minijinja-devel.sha256sum] = "c5f10a726d63477fe75cb76e8a16204d76b15456dd81daaae6a9d032e0fbf9be"

RDEPENDS:rust-minijinja+adjacent_loop_items-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+builtins-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+custom_syntax-devel = " \
 cargo \
 rust-aho-corasick-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+default-devel = " \
 cargo \
 rust-minijinja+adjacent_loop_items-devel \
 rust-minijinja+builtins-devel \
 rust-minijinja+debug-devel \
 rust-minijinja+deserialization-devel \
 rust-minijinja+macros-devel \
 rust-minijinja+multi_template-devel \
 rust-minijinja+serde-devel \
 rust-minijinja+std_collections-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+deserialization-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+fuel-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+indexmap-devel = " \
 cargo \
 rust-indexmap+default-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_debug-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+internal_safe_search-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+json-devel = " \
 cargo \
 rust-minijinja+serde_json-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+key_interning-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+loop_controls-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+macros-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+multi_template-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+percent-encoding-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-minijinja+preserve_order-devel = " \
 cargo \
 rust-minijinja+indexmap-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+serde_json-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-minijinja+speedups-devel = " \
 cargo \
 rust-minijinja+v_htmlescape-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+stacker-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-stacker+default-devel \
 "
RDEPENDS:rust-minijinja+std_collections-devel = " \
 cargo \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicase-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicase+default-devel \
 "
RDEPENDS:rust-minijinja+unicode-devel = " \
 cargo \
 rust-minijinja+unicase-devel \
 rust-minijinja+unicode-ident-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unicode-ident-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-unicode-ident+default-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery-devel = " \
 cargo \
 rust-minijinja+internal_debug-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+unstable_machinery_serde-devel = " \
 cargo \
 rust-minijinja+unstable_machinery-devel \
 rust-minijinja-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-minijinja+urlencode-devel = " \
 cargo \
 rust-minijinja+percent-encoding-devel \
 rust-minijinja-devel \
 "
RDEPENDS:rust-minijinja+v_htmlescape-devel = " \
 cargo \
 rust-minijinja-devel \
 rust-v_htmlescape+default-devel \
 "
RDEPENDS:rust-minijinja-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 "
