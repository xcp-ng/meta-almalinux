# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby4.0"
PV = "4.0.6"
PR = "36.el10_2"
PACKAGES = " \
 ruby4.0 \
 ruby4.0-devel \
 ruby4.0-doc \
 ruby4.0-rubygem-mysql2 \
 ruby4.0-rubygem-pg \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ruby4.0-4.0.6-36.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca8f9c43dcd540279f38b83540d8bd9837bd1144350e8fdbc8eca3014c196ef4"

URI_x86_64_v2_ruby4.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-4.0.6-36.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby4.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0}"
SRC_URI[x86_64_v2_ruby4.0.sha256sum] = "94b094a1919485424920161e872e7a4bd58498cae5f957f6e6352f90b5be9935"
RPROVIDES:ruby4.0:x86_64_v2 = "virtual/ruby_release_ virtual/ruby_runtime_executable_"

URI_x86_64_v2_ruby4.0-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-devel-4.0.6-36.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0-devel}"
SRC_URI[x86_64_v2_ruby4.0-devel.sha256sum] = "c74306d509c1e0cdbe3f8c521b712779d940a78230c94df2f07ee0b5de234acc"

URI_x86_64_v2_ruby4.0-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ruby4.0-doc-4.0.6-36.el10_2.noarch.rpm;name=x86_64_v2_ruby4.0-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0-doc}"
SRC_URI[x86_64_v2_ruby4.0-doc.sha256sum] = "10b9f69dd32723f605cbc08edd0d11d6f4c657671bda53ce633749a396f52e1b"

URI_x86_64_v2_ruby4.0-rubygem-mysql2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-rubygem-mysql2-0.5.7-36.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-rubygem-mysql2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0-rubygem-mysql2}"
SRC_URI[x86_64_v2_ruby4.0-rubygem-mysql2.sha256sum] = "af4de3e8f367563ea9519e03af7d68777d76aa94da73702f8c1f5f23cceb8e75"

URI_x86_64_v2_ruby4.0-rubygem-pg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ruby4.0-rubygem-pg-1.6.3-36.el10_2.x86_64_v2.rpm;name=x86_64_v2_ruby4.0-rubygem-pg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ruby4.0-rubygem-pg}"
SRC_URI[x86_64_v2_ruby4.0-rubygem-pg.sha256sum] = "ef1db25adb551dd018c2c5a5c142e0fc0cf7d3149cbf9f749140d2ac69d2f45a"

URI_aarch64_ruby4.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-4.0.6-36.el10_2.aarch64.rpm;name=aarch64_ruby4.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0}"
SRC_URI[aarch64_ruby4.0.sha256sum] = "e176ec3f59a5409d2be7f3097664c96c40f20d426c5a3e1fa2b34d1a84c5fa77"
RPROVIDES:ruby4.0:aarch64 = "virtual/ruby_release_ virtual/ruby_runtime_executable_"

URI_aarch64_ruby4.0-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-devel-4.0.6-36.el10_2.aarch64.rpm;name=aarch64_ruby4.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0-devel}"
SRC_URI[aarch64_ruby4.0-devel.sha256sum] = "f93f75479436ecb8ce989d81e80c13b36f5ce4ce89b9d87e8eaa57afe7e12b8a"

URI_aarch64_ruby4.0-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ruby4.0-doc-4.0.6-36.el10_2.noarch.rpm;name=aarch64_ruby4.0-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0-doc}"
SRC_URI[aarch64_ruby4.0-doc.sha256sum] = "10b9f69dd32723f605cbc08edd0d11d6f4c657671bda53ce633749a396f52e1b"

URI_aarch64_ruby4.0-rubygem-mysql2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-rubygem-mysql2-0.5.7-36.el10_2.aarch64.rpm;name=aarch64_ruby4.0-rubygem-mysql2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0-rubygem-mysql2}"
SRC_URI[aarch64_ruby4.0-rubygem-mysql2.sha256sum] = "6e2bf05d760c6812499fd0a116046c8ae6a337df7a990ded72463c977894afb6"

URI_aarch64_ruby4.0-rubygem-pg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ruby4.0-rubygem-pg-1.6.3-36.el10_2.aarch64.rpm;name=aarch64_ruby4.0-rubygem-pg;unpack=0"
SRC_URI:append = " ${URI_aarch64_ruby4.0-rubygem-pg}"
SRC_URI[aarch64_ruby4.0-rubygem-pg.sha256sum] = "e8f51d0d756c253dde61e694aaac5f976563b26b04d5fc4975c4306bb5a9886f"

RDEPENDS:ruby4.0 = " \
 glibc \
 gmp \
 libffi \
 libgcc \
 libxcrypt \
 libyaml \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:ruby4.0-devel = " \
 pkgconf-pkg-config \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-doc = " \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-rubygem-mysql2 = " \
 glibc \
 mariadb-connector-c \
 ruby4.0 \
 "
RDEPENDS:ruby4.0-rubygem-pg = " \
 glibc \
 libpq \
 ruby4.0 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/ruby_release_ rpm/virtual/ruby_runtime_executable_"

PROVIDES:append:aarch64 = " rpm/virtual/ruby_release_ rpm/virtual/ruby_runtime_executable_"
