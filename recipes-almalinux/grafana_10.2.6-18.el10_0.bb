# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana"
PV = "10.2.6"
PR = "18.el10_0"
PACKAGES = " \
 grafana \
 grafana-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-10.2.6-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "88055c8804f926a779127eafcf8e581ef8f200706cf3254f2f8da7110bb8aad6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-10.2.6-18.el10_0.x86_64_v2.rpm;name=x86_64_v2_grafana;unpack=0"
SRC_URI[x86_64_v2_grafana.sha256sum] = "a26511a398151ba667d8965eec2e12224a2611349d0a2cdc6dfcb0a983fbbde1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-selinux-10.2.6-18.el10_0.x86_64_v2.rpm;name=x86_64_v2_grafana-selinux;unpack=0"
SRC_URI[x86_64_v2_grafana-selinux.sha256sum] = "2e18a3d8bb97c81accad3e7538cdb5dacd4b8d3386e04f803d0701004626ec1c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-10.2.6-18.el10_0.aarch64.rpm;name=aarch64_grafana;unpack=0"
SRC_URI[aarch64_grafana.sha256sum] = "cfd2c31b34484b2374707c81592b9aab838f01470cc64841f5d304ad71052487"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-selinux-10.2.6-18.el10_0.aarch64.rpm;name=aarch64_grafana-selinux;unpack=0"
SRC_URI[aarch64_grafana-selinux.sha256sum] = "b7096c901537476eaf5b615c12185a62a9e7e99d735ba1aefa53d46abf12018f"

RDEPENDS:grafana = " \
 bash \
 glibc \
 grafana-selinux \
 shadow-utils \
 shared-mime-info \
 systemd \
 "
RDEPENDS:grafana-selinux = " \
 bash \
 grafana \
 initscripts-service \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
