# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "TurboGears2"
PV = "2.4.3"
PR = "18.el10_0"
PACKAGES = " \
 python3-TurboGears2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/TurboGears2-2.4.3-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "766bbe0bcb07642da097016a8a10879d32e677e77dcc26f90dcc1cd2cb51d532"

URI_x86_64_v2_python3-TurboGears2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-TurboGears2-2.4.3-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-TurboGears2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-TurboGears2}"
SRC_URI[x86_64_v2_python3-TurboGears2.sha256sum] = "89c26530da2af0f5f98ea0c9779718afcc4b45719256bfbc319a6a78917c6e67"

URI_aarch64_python3-TurboGears2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-TurboGears2-2.4.3-18.el10_0.noarch.rpm;name=aarch64_python3-TurboGears2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-TurboGears2}"
SRC_URI[aarch64_python3-TurboGears2.sha256sum] = "a752d2cf559626a137cbdcf287ef602e156bc847d621a1f8d98c5ffa0fcc7258"

RDEPENDS:python3-TurboGears2 = " \
 python3 \
 python3-backlash \
 python3-chameleon \
 python3-crank \
 python3-decorator \
 python3-formencode \
 python3-genshi \
 python3-jinja2 \
 python3-kajiki \
 python3-mako \
 python3-markupsafe \
 python3-paste-deploy \
 python3-repoze-lru \
 python3-repoze-tm2 \
 python3-repoze-who \
 python3-repoze-who-plugins-sa \
 python3-tw2-forms \
 python3-webob \
 python3-zope-sqlalchemy \
 "
