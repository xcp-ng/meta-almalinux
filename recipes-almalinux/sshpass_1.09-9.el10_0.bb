# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sshpass"
PV = "1.09"
PR = "9.el10_0"
PACKAGES = " \
 sshpass \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sshpass-1.09-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd1c6c1f54a3a843b520d8cd4da3c2bb0b0055d24e0f000a6e7def582a88cc78"

URI_x86_64_v2_sshpass = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sshpass-1.09-9.el10_0.x86_64_v2.rpm;name=x86_64_v2_sshpass;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sshpass}"
SRC_URI[x86_64_v2_sshpass.sha256sum] = "16c103fa6649f6b55ed2c57199926b358a053794358868991ab2f05a2c01de79"

URI_aarch64_sshpass = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sshpass-1.09-9.el10_0.aarch64.rpm;name=aarch64_sshpass;unpack=0"
SRC_URI:append = " ${URI_aarch64_sshpass}"
SRC_URI[aarch64_sshpass.sha256sum] = "be18704ebeaf5432b43ea3b99e9b20232730ba4dba8dc524dbffaa6964d78035"

RDEPENDS:sshpass = " \
 glibc \
 "
