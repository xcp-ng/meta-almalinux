# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hyphen-mn"
PV = "0.20100531"
PR = "29.el10"
PACKAGES = " \
 hyphen-mn \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hyphen-mn-0.20100531-29.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "624e4fd43da1f348904dc90d07593aad58445c778397084facf75148ff95397c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hyphen-mn-0.20100531-29.el10.noarch.rpm;name=x86_64_v2_hyphen-mn;unpack=0"
SRC_URI[x86_64_v2_hyphen-mn.sha256sum] = "90f8e582d1d7b25347b1cbce3f0d703bdf040c60535dac18337c416fd580b75f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hyphen-mn-0.20100531-29.el10.noarch.rpm;name=aarch64_hyphen-mn;unpack=0"
SRC_URI[aarch64_hyphen-mn.sha256sum] = "90f8e582d1d7b25347b1cbce3f0d703bdf040c60535dac18337c416fd580b75f"

RDEPENDS:hyphen-mn = " \
 hyphen \
 "
