# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocm-filesystem"
PV = "7.2.0"
PR = "7.el10_3"
PACKAGES = " \
 rocm-filesystem \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rocm-filesystem-7.2.0-7.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e5a078425e7bc83f4560bec8760d3a7c8c3caf6b27fe92d071795fabe4ac5351"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocm-filesystem-7.2.0-7.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rocm-filesystem;unpack=0"
SRC_URI[x86_64_v2_rocm-filesystem.sha256sum] = "801008c007abb2aa7a13f25babf94765f7a464b4cf575d1cc6c81b7fcd1ed006"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rocm-filesystem-7.2.0-7.el10_3.noarch.rpm;name=aarch64_rocm-filesystem;unpack=0"
SRC_URI[aarch64_rocm-filesystem.sha256sum] = "a8e144f717a4eb0a3d4104733db6551fc72af67e26eb75195c9e919bf26b38d4"

RDEPENDS:rocm-filesystem = " \
 "
