# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libabigail"
PV = "2.9"
PR = "1.el10"
PACKAGES = " \
 libabigail \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/libabigail-2.9-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec847ef289a3222c2e603b2c148c640abb5847125a63c9e834e22301104f182b"

URI_x86_64_v2_libabigail = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libabigail-2.9-1.el10.x86_64_v2.rpm;name=x86_64_v2_libabigail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libabigail}"
SRC_URI[x86_64_v2_libabigail.sha256sum] = "8bc0021e79851da6ae71d4d001cfc89ea7a8eed94b736011c3692a6f5bedc470"

URI_aarch64_libabigail = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libabigail-2.9-1.el10.aarch64.rpm;name=aarch64_libabigail;unpack=0"
SRC_URI:append = " ${URI_aarch64_libabigail}"
SRC_URI[aarch64_libabigail.sha256sum] = "6a293e793c0ad4609173dd16fac7fddcc2d3a117990dae1ac942b2611ef49557"

RDEPENDS:libabigail = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbpf \
 libgcc \
 libstdc++ \
 libxml2 \
 virtual/libctf.so.0_LIBCTF_1.0__64bit_ \
 virtual/libctf.so.0_LIBCTF_1.1__64bit_ \
 virtual/libctf.so.0_LIBCTF_1.2__64bit_ \
 virtual/libctf.so.0___64bit_ \
 xz-libs \
 "
