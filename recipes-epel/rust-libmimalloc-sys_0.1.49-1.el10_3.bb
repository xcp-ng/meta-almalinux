# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libmimalloc-sys"
PV = "0.1.49"
PR = "1.el10_3"
PACKAGES = " \
 rust-libmimalloc-sys+arena-devel \
 rust-libmimalloc-sys+cty-devel \
 rust-libmimalloc-sys+debug-devel \
 rust-libmimalloc-sys+debug_in_debug-devel \
 rust-libmimalloc-sys+default-devel \
 rust-libmimalloc-sys+extended-devel \
 rust-libmimalloc-sys+local_dynamic_tls-devel \
 rust-libmimalloc-sys+no_thp-devel \
 rust-libmimalloc-sys+override-devel \
 rust-libmimalloc-sys+secure-devel \
 rust-libmimalloc-sys+v2-devel \
 rust-libmimalloc-sys+win_direct_tls-devel \
 rust-libmimalloc-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libmimalloc-sys-0.1.49-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ffc7955fd94523bb77036397322adfd3ac785d0f12487c19707f845049509287"

URI_x86_64_v2_rust-libmimalloc-sys+arena-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+arena-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+arena-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+arena-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+arena-devel.sha256sum] = "ba845c6b8551cff9e2e493770849aded1970bccbec8dcc5fc0a6e4e6a550ee61"

URI_x86_64_v2_rust-libmimalloc-sys+cty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+cty-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+cty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+cty-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+cty-devel.sha256sum] = "227e3b87deb503805f15c6f87f87c0f8341921aba920c6eca9d06d9d3e0a11db"

URI_x86_64_v2_rust-libmimalloc-sys+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+debug-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+debug-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+debug-devel.sha256sum] = "c68bd174386ff7b5a9f634ef77703342661512eac880fb7f0798d780dd322218"

URI_x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+debug_in_debug-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel.sha256sum] = "afbf68965d7c605fca9074be49056d3ede15cbc8a0d863b94490d9cec6b8480e"

URI_x86_64_v2_rust-libmimalloc-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+default-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+default-devel.sha256sum] = "c1f6812056138c784067246898284e4f7bf39faf0b3b9571daa5473c5ef9b06f"

URI_x86_64_v2_rust-libmimalloc-sys+extended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+extended-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+extended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+extended-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+extended-devel.sha256sum] = "bbe174c1f5f0c7efba92533b837957c6e82191bf882a55b443314c2d8a9ac150"

URI_x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+local_dynamic_tls-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel.sha256sum] = "e91e693918ab62f048539675dcaf0948ff4107d75a9ec7074357bc259dfd7595"

URI_x86_64_v2_rust-libmimalloc-sys+no_thp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+no_thp-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+no_thp-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+no_thp-devel.sha256sum] = "26612a39fc3898a49f2f0479b9d99ddc99fa9abf0c8ce789bd0c6ab88f5c1d22"

URI_x86_64_v2_rust-libmimalloc-sys+override-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+override-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+override-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+override-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+override-devel.sha256sum] = "551b5ff7a5d02a62c3924012b14bf5caba455018ef560aff2db1e91497f84969"

URI_x86_64_v2_rust-libmimalloc-sys+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+secure-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+secure-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+secure-devel.sha256sum] = "93267a91d175db172d109252e7344c1d3b8004d4009efd9d4a0b658076ecd102"

URI_x86_64_v2_rust-libmimalloc-sys+v2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+v2-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+v2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+v2-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+v2-devel.sha256sum] = "f6823821072a6d216bd519ccc68bc61ce3eb08e51fd53e1387ac4702b2164049"

URI_x86_64_v2_rust-libmimalloc-sys+win_direct_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+win_direct_tls-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+win_direct_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+win_direct_tls-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+win_direct_tls-devel.sha256sum] = "1d37110b260b9da9750a11035463583e93f44b64874680fad88078b5afc4f43d"

URI_x86_64_v2_rust-libmimalloc-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys-devel-0.1.49-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys-devel.sha256sum] = "c011adcfbbece80e17542c9f2afa6438bc6030562ea6e6298f4612e68d68db1d"

URI_aarch64_rust-libmimalloc-sys+arena-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+arena-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+arena-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+arena-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+arena-devel.sha256sum] = "714124b698e94bb9807d628bfe7118df016e96480a0248090d8eccb9da4674b2"

URI_aarch64_rust-libmimalloc-sys+cty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+cty-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+cty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+cty-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+cty-devel.sha256sum] = "b63b44bcf7133f255bd31974badd799d59df520eae8c644351665a6f94dfe282"

URI_aarch64_rust-libmimalloc-sys+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+debug-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+debug-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+debug-devel.sha256sum] = "698995da4317e196b276de5594aaedff8356d5b968aae3dda325c9d5277df30f"

URI_aarch64_rust-libmimalloc-sys+debug_in_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+debug_in_debug-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+debug_in_debug-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+debug_in_debug-devel.sha256sum] = "3e362219de926b4901005a45a45317075b576ca34e505ce8c7fbd4d520a7d599"

URI_aarch64_rust-libmimalloc-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+default-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+default-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+default-devel.sha256sum] = "9bc2664ce0e259bcff132d44cceeecc0c531b30929eeb3ad042404348d275b0c"

URI_aarch64_rust-libmimalloc-sys+extended-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+extended-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+extended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+extended-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+extended-devel.sha256sum] = "8c6104fc0a3e3f1427438b3c2dc66501e5fb1d8008c3001316e8e57d82259586"

URI_aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+local_dynamic_tls-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel.sha256sum] = "ccafaa463e0ae1f1cf8675b421f0207f69b4dd6af3558651525b5ba2f5056bd8"

URI_aarch64_rust-libmimalloc-sys+no_thp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+no_thp-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+no_thp-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+no_thp-devel.sha256sum] = "da5ff91bd0ba726e56e85f1ee9d9cf5814169f3c7d5f85dd91cee6a1dd98c0cd"

URI_aarch64_rust-libmimalloc-sys+override-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+override-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+override-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+override-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+override-devel.sha256sum] = "f972a5e730dda9030fe323fa355deb9f7a46ba86d6ae5b4ff683ded11d521b3a"

URI_aarch64_rust-libmimalloc-sys+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+secure-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+secure-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+secure-devel.sha256sum] = "3123d09fe48a205757865115629c423ad8ad1ff39ed325f5023dfa15514e75ce"

URI_aarch64_rust-libmimalloc-sys+v2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+v2-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+v2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+v2-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+v2-devel.sha256sum] = "4a6bed240e476d976c57f101ae04408f7d328d7e4bc74d413bf8c2987a38e005"

URI_aarch64_rust-libmimalloc-sys+win_direct_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+win_direct_tls-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys+win_direct_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+win_direct_tls-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+win_direct_tls-devel.sha256sum] = "81ba672f45703f4cbac2ba8358a075e8aa8bc60b3c64fb5840bf12f8683ceb93"

URI_aarch64_rust-libmimalloc-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys-devel-0.1.49-1.el10_3.noarch.rpm;name=aarch64_rust-libmimalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys-devel.sha256sum] = "db750d56d53bdbdc51987f033ac2b43117a32858a5fee9d442013ce93801a4f6"

RDEPENDS:rust-libmimalloc-sys+arena-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+cty-devel = " \
 cargo \
 rust-cty+default-devel \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+debug-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+debug_in_debug-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+default-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+extended-devel = " \
 cargo \
 rust-libmimalloc-sys+cty-devel \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+local_dynamic_tls-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+no_thp-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+override-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+secure-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+v2-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+win_direct_tls-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 "
