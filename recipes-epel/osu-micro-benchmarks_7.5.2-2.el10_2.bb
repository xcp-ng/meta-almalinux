# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "osu-micro-benchmarks"
PV = "7.5.2"
PR = "2.el10_2"
PACKAGES = " \
 osu-micro-benchmarks-common \
 osu-micro-benchmarks-mpich \
 osu-micro-benchmarks-openmpi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/osu-micro-benchmarks-7.5.2-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c049b501ff736a0f1e735a8774a51568015f56e46d75dd19b6e07c30de0f792"

URI_x86_64_v2_osu-micro-benchmarks-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/osu-micro-benchmarks-common-7.5.2-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_osu-micro-benchmarks-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osu-micro-benchmarks-common}"
SRC_URI[x86_64_v2_osu-micro-benchmarks-common.sha256sum] = "b6fbe3c84dce6c8619685f19e52f8bf7039b8ac5bd392c1e856fe2b54252e1da"

URI_x86_64_v2_osu-micro-benchmarks-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/osu-micro-benchmarks-mpich-7.5.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_osu-micro-benchmarks-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osu-micro-benchmarks-mpich}"
SRC_URI[x86_64_v2_osu-micro-benchmarks-mpich.sha256sum] = "d84af44b97ac5c8ff54b81c49b77218ca134e384368efaf34f95c5cd77fab463"

URI_x86_64_v2_osu-micro-benchmarks-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/osu-micro-benchmarks-openmpi-7.5.2-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_osu-micro-benchmarks-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_osu-micro-benchmarks-openmpi}"
SRC_URI[x86_64_v2_osu-micro-benchmarks-openmpi.sha256sum] = "c2d0208a2c0401eaaf1968145be0b76b9309ee8eda8c6a652f3a0b911bbf44cc"

URI_aarch64_osu-micro-benchmarks-common = "${EPEL_MIRROR}/aarch64/Packages/o/osu-micro-benchmarks-common-7.5.2-2.el10_2.noarch.rpm;name=aarch64_osu-micro-benchmarks-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_osu-micro-benchmarks-common}"
SRC_URI[aarch64_osu-micro-benchmarks-common.sha256sum] = "731860d05cb4d44eb522bcd907341496f6f2c8bc24df7b9647f1538552d1d901"

URI_aarch64_osu-micro-benchmarks-mpich = "${EPEL_MIRROR}/aarch64/Packages/o/osu-micro-benchmarks-mpich-7.5.2-2.el10_2.aarch64.rpm;name=aarch64_osu-micro-benchmarks-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_osu-micro-benchmarks-mpich}"
SRC_URI[aarch64_osu-micro-benchmarks-mpich.sha256sum] = "761dce5bbd75a5bd18844d9c569b15955b4a8fd4160e615c6560cad7c2fffd99"

URI_aarch64_osu-micro-benchmarks-openmpi = "${EPEL_MIRROR}/aarch64/Packages/o/osu-micro-benchmarks-openmpi-7.5.2-2.el10_2.aarch64.rpm;name=aarch64_osu-micro-benchmarks-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_osu-micro-benchmarks-openmpi}"
SRC_URI[aarch64_osu-micro-benchmarks-openmpi.sha256sum] = "e027f7f98074a42f72487c5ac1235c8f7a8699d2defb218ade607a500047750b"

RDEPENDS:osu-micro-benchmarks-common = " \
 "
RDEPENDS:osu-micro-benchmarks-mpich = " \
 glibc \
 mpich \
 osu-micro-benchmarks-common \
 "
RDEPENDS:osu-micro-benchmarks-openmpi = " \
 glibc \
 openmpi \
 osu-micro-benchmarks-common \
 "
