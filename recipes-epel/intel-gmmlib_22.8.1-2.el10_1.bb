# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-gmmlib"
PV = "22.8.1"
PR = "2.el10_1"
PACKAGES = " \
 intel-gmmlib \
 intel-gmmlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-gmmlib-22.8.1-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c96db43731272736569bc50a33c15d55ce3d072057ec406131392b3a0dfd03e6"

URI_x86_64_v2_intel-gmmlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-22.8.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gmmlib}"
SRC_URI[x86_64_v2_intel-gmmlib.sha256sum] = "93287cbc601245930185bd276e0fa6622af7f22db3ad02ce213dfb995ed5b9e0"

URI_x86_64_v2_intel-gmmlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-devel-22.8.1-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gmmlib-devel}"
SRC_URI[x86_64_v2_intel-gmmlib-devel.sha256sum] = "aba404311adc733c7aebefe38ac69cdb4b57722632dba1622971d3585d1c3352"

URI_aarch64_intel-gmmlib = "${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-22.8.1-2.el10_1.aarch64.rpm;name=aarch64_intel-gmmlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gmmlib}"
SRC_URI[aarch64_intel-gmmlib.sha256sum] = "02bfcf8c5521c8f592afdb917f324e2b7c6b625c00d87dc6bec9d804a0e48453"

URI_aarch64_intel-gmmlib-devel = "${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-devel-22.8.1-2.el10_1.aarch64.rpm;name=aarch64_intel-gmmlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gmmlib-devel}"
SRC_URI[aarch64_intel-gmmlib-devel.sha256sum] = "b091b22661f744e75ee2db0dff288e9863f8f0d4d448ceffade82bea3b166d8e"

RDEPENDS:intel-gmmlib = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-gmmlib-devel = " \
 intel-gmmlib \
 pkgconf-pkg-config \
 "
