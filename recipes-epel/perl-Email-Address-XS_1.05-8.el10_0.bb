# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Email-Address-XS"
PV = "1.05"
PR = "8.el10_0"
PACKAGES = " \
 perl-Email-Address-XS \
 perl-Email-Address-XS-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Email-Address-XS-1.05-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c22a5d4c02d5187296c5a7ac927a1bcc4dea4721f0ed028c9486739501c25b8b"

URI_x86_64_v2_perl-Email-Address-XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Email-Address-XS-1.05-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Email-Address-XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Email-Address-XS}"
SRC_URI[x86_64_v2_perl-Email-Address-XS.sha256sum] = "be35e99780c774540932d90a763fc3af7bff1a023767aa902d6bba376062dbe5"

URI_x86_64_v2_perl-Email-Address-XS-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Email-Address-XS-tests-1.05-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Email-Address-XS-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Email-Address-XS-tests}"
SRC_URI[x86_64_v2_perl-Email-Address-XS-tests.sha256sum] = "efaa14630403ed7bd059c52e9da2386fe99de4a0da4125ead6d03fd9c692854a"

URI_aarch64_perl-Email-Address-XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Email-Address-XS-1.05-8.el10_0.aarch64.rpm;name=aarch64_perl-Email-Address-XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Email-Address-XS}"
SRC_URI[aarch64_perl-Email-Address-XS.sha256sum] = "bcd81282b7b6161792035777753cd304a44f2fdb6704d8463f2bbaf940690615"

URI_aarch64_perl-Email-Address-XS-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Email-Address-XS-tests-1.05-8.el10_0.aarch64.rpm;name=aarch64_perl-Email-Address-XS-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Email-Address-XS-tests}"
SRC_URI[aarch64_perl-Email-Address-XS-tests.sha256sum] = "2480a7b8386d09cbd9aa863e2ec0e60df14bcfbbec31ab61130a9422b3300dc2"

RDEPENDS:perl-Email-Address-XS = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-base \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Email-Address-XS-tests = " \
 bash \
 perl-Carp \
 perl-Email-Address-XS \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-overload \
 "
