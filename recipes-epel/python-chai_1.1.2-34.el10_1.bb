# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-chai"
PV = "1.1.2"
PR = "34.el10_1"
PACKAGES = " \
 python3-chai \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-chai-1.1.2-34.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dd6e15a0f88d106452d1621030d7b094b1bb9b497e83e47c05287616ef51593"

URI_x86_64_v2_python3-chai = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-chai-1.1.2-34.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-chai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-chai}"
SRC_URI[x86_64_v2_python3-chai.sha256sum] = "7bb8bd3ada11dc9ef079152bd38a9bcc1396bdb420291faf0ee6fe91f34faf66"

URI_aarch64_python3-chai = "${EPEL_MIRROR}/aarch64/Packages/p/python3-chai-1.1.2-34.el10_1.noarch.rpm;name=aarch64_python3-chai;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-chai}"
SRC_URI[aarch64_python3-chai.sha256sum] = "024056163d3c890ccf5163ea8798cf3b38f65ef17277ecf81d5257c7e9e86efe"

RDEPENDS:python3-chai = " \
 python3 \
 "
