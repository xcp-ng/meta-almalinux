# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-microsoft-sql"
PV = "2.6.4"
PR = "1.el10"
PACKAGES = " \
 ansible-collection-microsoft-sql \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-collection-microsoft-sql-2.6.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "db182acaae4a921815973dcdec24bc68eba3aa0a83fea9e24248a908550a7de7"

URI_x86_64_v2_ansible-collection-microsoft-sql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-collection-microsoft-sql-2.6.4-1.el10.noarch.rpm;name=x86_64_v2_ansible-collection-microsoft-sql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-collection-microsoft-sql}"
SRC_URI[x86_64_v2_ansible-collection-microsoft-sql.sha256sum] = "aa278af83c29319777440fc069f018d536e518868318716d1f6e74cd2241d6c3"

URI_aarch64_ansible-collection-microsoft-sql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-collection-microsoft-sql-2.6.4-1.el10.noarch.rpm;name=aarch64_ansible-collection-microsoft-sql;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-collection-microsoft-sql}"
SRC_URI[aarch64_ansible-collection-microsoft-sql.sha256sum] = "aa278af83c29319777440fc069f018d536e518868318716d1f6e74cd2241d6c3"

RDEPENDS:ansible-collection-microsoft-sql = " \
 ansible-core \
 bash \
 rhel-system-roles \
 "
