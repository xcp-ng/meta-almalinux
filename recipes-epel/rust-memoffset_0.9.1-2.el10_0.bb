# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memoffset"
PV = "0.9.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-memoffset+default-devel \
 rust-memoffset+unstable_const-devel \
 rust-memoffset+unstable_offset_of-devel \
 rust-memoffset-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memoffset-0.9.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e720ba182bc0b71de37e832c750a0bcbd00145ea42d6ec57bb46fb0662add04"

URI_x86_64_v2_rust-memoffset+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memoffset+default-devel-0.9.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memoffset+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memoffset+default-devel}"
SRC_URI[x86_64_v2_rust-memoffset+default-devel.sha256sum] = "0f3c000fdc15a50256686917f93dd111753ea9d3716bae36f7ea3da8804c8782"

URI_x86_64_v2_rust-memoffset+unstable_const-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memoffset+unstable_const-devel-0.9.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memoffset+unstable_const-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memoffset+unstable_const-devel}"
SRC_URI[x86_64_v2_rust-memoffset+unstable_const-devel.sha256sum] = "0aebb2d366c2c7f878551fed8240129ab3b75c087b957f678f288f57feec5084"

URI_x86_64_v2_rust-memoffset+unstable_offset_of-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memoffset+unstable_offset_of-devel-0.9.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memoffset+unstable_offset_of-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memoffset+unstable_offset_of-devel}"
SRC_URI[x86_64_v2_rust-memoffset+unstable_offset_of-devel.sha256sum] = "3976a46ab8de335208260893251af65293d2442f787c815da46b5119a5544330"

URI_x86_64_v2_rust-memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memoffset-devel-0.9.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memoffset-devel}"
SRC_URI[x86_64_v2_rust-memoffset-devel.sha256sum] = "2182a7017a515caeaf8c581b570d7cd9626e27c2de97cb399e3d5637024d5822"

URI_aarch64_rust-memoffset+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memoffset+default-devel-0.9.1-2.el10_0.noarch.rpm;name=aarch64_rust-memoffset+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memoffset+default-devel}"
SRC_URI[aarch64_rust-memoffset+default-devel.sha256sum] = "1ed9f44e4b66c48defbfaa65b12865a18b51523f03554df140424e584d6dc237"

URI_aarch64_rust-memoffset+unstable_const-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memoffset+unstable_const-devel-0.9.1-2.el10_0.noarch.rpm;name=aarch64_rust-memoffset+unstable_const-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memoffset+unstable_const-devel}"
SRC_URI[aarch64_rust-memoffset+unstable_const-devel.sha256sum] = "4d4bb7284072c6bca2e2b707f6b8e6dcc4294d76ca7a30090407bf89da4a0369"

URI_aarch64_rust-memoffset+unstable_offset_of-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memoffset+unstable_offset_of-devel-0.9.1-2.el10_0.noarch.rpm;name=aarch64_rust-memoffset+unstable_offset_of-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memoffset+unstable_offset_of-devel}"
SRC_URI[aarch64_rust-memoffset+unstable_offset_of-devel.sha256sum] = "15188f55a2a4270cf051f8597a787bc21b4aab37d764064050456d9a343e2721"

URI_aarch64_rust-memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memoffset-devel-0.9.1-2.el10_0.noarch.rpm;name=aarch64_rust-memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memoffset-devel}"
SRC_URI[aarch64_rust-memoffset-devel.sha256sum] = "6a7883b7758f561ae491bce53ead0822dad36f18f5e4ad9704dd72fcfe103c61"

RDEPENDS:rust-memoffset+default-devel = " \
 cargo \
 rust-memoffset-devel \
 "
RDEPENDS:rust-memoffset+unstable_const-devel = " \
 cargo \
 rust-memoffset-devel \
 "
RDEPENDS:rust-memoffset+unstable_offset_of-devel = " \
 cargo \
 rust-memoffset-devel \
 "
RDEPENDS:rust-memoffset-devel = " \
 cargo \
 rust-autocfg+default-devel \
 "
