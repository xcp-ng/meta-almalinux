# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgit2_1.9"
PV = "1.9.7"
PR = "1.el10_3"
PACKAGES = " \
 libgit2_1.9 \
 libgit2_1.9-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libgit2_1.9-1.9.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "501037909e89a4ead757777a23eb32788389eb88504fc75d6ca1c8db4235cf9f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgit2_1.9-1.9.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgit2_1.9;unpack=0"
SRC_URI[x86_64_v2_libgit2_1.9.sha256sum] = "32e459c68886a46fda17d86c7f546959d8391127eaa8a49e3990f8356e5a431e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgit2_1.9-devel-1.9.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgit2_1.9-devel;unpack=0"
SRC_URI[x86_64_v2_libgit2_1.9-devel.sha256sum] = "8d8f4d4b5680ee939f62f5c162ef6d2d199316271fb195c7268d52a75eda61c1"
RPROVIDES:libgit2_1.9-devel:append:x86_64_v2 = " virtual/pkgconfig_libgit2_"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libgit2_1.9-1.9.7-1.el10_3.aarch64.rpm;name=aarch64_libgit2_1.9;unpack=0"
SRC_URI[aarch64_libgit2_1.9.sha256sum] = "70f08b16c3e770a1f1ca77878ece6ed81105f57f09cc5ca19966a819c03ef1d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libgit2_1.9-devel-1.9.7-1.el10_3.aarch64.rpm;name=aarch64_libgit2_1.9-devel;unpack=0"
SRC_URI[aarch64_libgit2_1.9-devel.sha256sum] = "cec8535ffdef9a836b6b31f79106387bf65d392f41bc290496452b4931ce24c8"
RPROVIDES:libgit2_1.9-devel:append:aarch64 = " virtual/pkgconfig_libgit2_"

RDEPENDS:libgit2_1.9 = " \
 glibc \
 libssh2 \
 llhttp \
 openssl-libs \
 pcre2 \
 zlib-ng-compat \
 "
RDEPENDS:libgit2_1.9-devel = " \
 cmake-filesystem \
 libgit2_1.9 \
 libssh2-devel \
 openssl-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
