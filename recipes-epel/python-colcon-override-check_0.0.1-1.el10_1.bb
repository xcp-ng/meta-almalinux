# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-override-check"
PV = "0.0.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-override-check \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-override-check-0.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cf0a65d03d1c45afb008a033a4038b52b64ca088d4c84b8edaacfcb1514aaa3d"

URI_x86_64_v2_python3-colcon-override-check = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-override-check-0.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-override-check;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-override-check}"
SRC_URI[x86_64_v2_python3-colcon-override-check.sha256sum] = "948b47b978456b09f1d3dbeda870ba7261e630c090fd5d9866a5a24d4996de9d"

URI_aarch64_python3-colcon-override-check = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-override-check-0.0.1-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-override-check;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-override-check}"
SRC_URI[aarch64_python3-colcon-override-check.sha256sum] = "4b3648cf245174252b3b518e9a2da501c15c3c187cfca0df1fb9215d96305074"

RDEPENDS:python3-colcon-override-check = " \
 python3 \
 python3-colcon-core \
 python3-colcon-installed-package-information \
 "
