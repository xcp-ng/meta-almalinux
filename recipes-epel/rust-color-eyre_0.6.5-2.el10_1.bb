# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-color-eyre"
PV = "0.6.5"
PR = "2.el10_1"
PACKAGES = " \
 rust-color-eyre+capture-spantrace-devel \
 rust-color-eyre+color-spantrace-devel \
 rust-color-eyre+default-devel \
 rust-color-eyre+issue-url-devel \
 rust-color-eyre+tracing-error-devel \
 rust-color-eyre+track-caller-devel \
 rust-color-eyre+url-devel \
 rust-color-eyre-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-color-eyre-0.6.5-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "23fada67374c859439f6a8f24050751ffac47537df096baae646292623ea71db"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-eyre+capture-spantrace-devel-0.6.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-eyre+capture-spantrace-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color-eyre+capture-spantrace-devel.sha256sum] = "0b28c2dd054d12dfdca248436250ba82989703ac6fb42cc166530b47e51fff32"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-eyre+color-spantrace-devel-0.6.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-eyre+color-spantrace-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color-eyre+color-spantrace-devel.sha256sum] = "707139e1757acf137667a153b86ab081b18b417e68ca12561f912538072e03c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-eyre+default-devel-0.6.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-eyre+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color-eyre+default-devel.sha256sum] = "cd97cc610853a5f24b6991ee245b95fddeab3ac52ee01218e75b0347d04f2aa1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-eyre+issue-url-devel-0.6.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-eyre+issue-url-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color-eyre+issue-url-devel.sha256sum] = "02e9cfc0115ca4a5f3dd63f2bab0d24eab7532a328fe1cbd122f6d25a25af6b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-eyre+tracing-error-devel-0.6.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-eyre+tracing-error-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color-eyre+tracing-error-devel.sha256sum] = "86ff2a9fc2653e56365f849f269a67c44a76bd5650873edcfe0c6b87f00bbf34"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-eyre+track-caller-devel-0.6.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-eyre+track-caller-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color-eyre+track-caller-devel.sha256sum] = "584810da9a4c376d322dd335704997c03f21100dad3d6ab4101d9fb0f7ca7d90"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-eyre+url-devel-0.6.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-eyre+url-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color-eyre+url-devel.sha256sum] = "55e1405795ef26f554f3d5495279a4cb87522031bff3d5066cae549d58938994"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-eyre-devel-0.6.5-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-eyre-devel;unpack=0"
SRC_URI[x86_64_v2_rust-color-eyre-devel.sha256sum] = "abaabb501ffb56ef137dd057befd6539de1af3b80c04e44542ef67fe375c74ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color-eyre+capture-spantrace-devel-0.6.5-2.el10_1.noarch.rpm;name=aarch64_rust-color-eyre+capture-spantrace-devel;unpack=0"
SRC_URI[aarch64_rust-color-eyre+capture-spantrace-devel.sha256sum] = "a59724938c81c0fca9b27b3c5e0b4d27c084ddb8e44c12e17161791b50bd9a60"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color-eyre+color-spantrace-devel-0.6.5-2.el10_1.noarch.rpm;name=aarch64_rust-color-eyre+color-spantrace-devel;unpack=0"
SRC_URI[aarch64_rust-color-eyre+color-spantrace-devel.sha256sum] = "070805ce8aec5f3f6d21715ef984bfd4110786208365e2d082b633b132246eff"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color-eyre+default-devel-0.6.5-2.el10_1.noarch.rpm;name=aarch64_rust-color-eyre+default-devel;unpack=0"
SRC_URI[aarch64_rust-color-eyre+default-devel.sha256sum] = "ddfa736a9eab4981f8baa2c4e0ab092adde7e44863689b73296f38ed0a777f81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color-eyre+issue-url-devel-0.6.5-2.el10_1.noarch.rpm;name=aarch64_rust-color-eyre+issue-url-devel;unpack=0"
SRC_URI[aarch64_rust-color-eyre+issue-url-devel.sha256sum] = "22273b092f715a5a36c626e200c42f0856c2542aa26f0d22f7e41373906e46d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color-eyre+tracing-error-devel-0.6.5-2.el10_1.noarch.rpm;name=aarch64_rust-color-eyre+tracing-error-devel;unpack=0"
SRC_URI[aarch64_rust-color-eyre+tracing-error-devel.sha256sum] = "4bbb82011eccdddd9241d28256772c4bd5eadd410b1a111978202173e03d6723"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color-eyre+track-caller-devel-0.6.5-2.el10_1.noarch.rpm;name=aarch64_rust-color-eyre+track-caller-devel;unpack=0"
SRC_URI[aarch64_rust-color-eyre+track-caller-devel.sha256sum] = "380d78d2712dd5be8a9e2abbaf2297944dc2b4e67d9615ac3efa11112df88d7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color-eyre+url-devel-0.6.5-2.el10_1.noarch.rpm;name=aarch64_rust-color-eyre+url-devel;unpack=0"
SRC_URI[aarch64_rust-color-eyre+url-devel.sha256sum] = "0c38d303585cf2b5551d555fb327e8c52d50c08ec2b7e94f2fb7ecf3b61ae1bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-color-eyre-devel-0.6.5-2.el10_1.noarch.rpm;name=aarch64_rust-color-eyre-devel;unpack=0"
SRC_URI[aarch64_rust-color-eyre-devel.sha256sum] = "5353c4fc03947431ad38339ca13a23dcb93ea8340fe68d6a86c23b4f35181ccd"

RDEPENDS:rust-color-eyre+capture-spantrace-devel = " \
 cargo \
 rust-color-eyre+color-spantrace-devel \
 rust-color-eyre+tracing-error-devel \
 rust-color-eyre-devel \
 "
RDEPENDS:rust-color-eyre+color-spantrace-devel = " \
 cargo \
 rust-color-eyre-devel \
 rust-color-spantrace+default-devel \
 "
RDEPENDS:rust-color-eyre+default-devel = " \
 cargo \
 rust-color-eyre+capture-spantrace-devel \
 rust-color-eyre+track-caller-devel \
 rust-color-eyre-devel \
 "
RDEPENDS:rust-color-eyre+issue-url-devel = " \
 cargo \
 rust-color-eyre+url-devel \
 rust-color-eyre-devel \
 "
RDEPENDS:rust-color-eyre+tracing-error-devel = " \
 cargo \
 rust-color-eyre-devel \
 rust-tracing-error+default-devel \
 "
RDEPENDS:rust-color-eyre+track-caller-devel = " \
 cargo \
 rust-color-eyre-devel \
 "
RDEPENDS:rust-color-eyre+url-devel = " \
 cargo \
 rust-color-eyre-devel \
 rust-url+default-devel \
 "
RDEPENDS:rust-color-eyre-devel = " \
 cargo \
 rust \
 rust-backtrace+default-devel \
 rust-eyre+default-devel \
 rust-indenter+default-devel \
 rust-once_cell+default-devel \
 rust-owo-colors+default-devel \
 "
