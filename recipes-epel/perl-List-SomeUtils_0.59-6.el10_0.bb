# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-List-SomeUtils"
PV = "0.59"
PR = "6.el10_0"
PACKAGES = " \
 perl-List-SomeUtils \
 perl-List-SomeUtils-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-List-SomeUtils-0.59-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9640afbee17533a570a78c83bd8fbc3aaf660e9f84cc98373fa5bac675bc898"

URI_x86_64_v2_perl-List-SomeUtils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-List-SomeUtils-0.59-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-List-SomeUtils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-List-SomeUtils}"
SRC_URI[x86_64_v2_perl-List-SomeUtils.sha256sum] = "a67201df89fb7e560325c54b82fa8dff6c914bd26dee4b06c1efa41f53dd8ffd"

URI_x86_64_v2_perl-List-SomeUtils-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-List-SomeUtils-tests-0.59-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-List-SomeUtils-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-List-SomeUtils-tests}"
SRC_URI[x86_64_v2_perl-List-SomeUtils-tests.sha256sum] = "53bec26e9a003902838a095e764c038c92cbf7567de766b598327aa3ea9a74c0"

URI_aarch64_perl-List-SomeUtils = "${EPEL_MIRROR}/aarch64/Packages/p/perl-List-SomeUtils-0.59-6.el10_0.noarch.rpm;name=aarch64_perl-List-SomeUtils;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-List-SomeUtils}"
SRC_URI[aarch64_perl-List-SomeUtils.sha256sum] = "ea6b7119d431657cd21fa4a3875ede6bdf6bcba9cec5efe23b0adc5a275cba73"

URI_aarch64_perl-List-SomeUtils-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-List-SomeUtils-tests-0.59-6.el10_0.noarch.rpm;name=aarch64_perl-List-SomeUtils-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-List-SomeUtils-tests}"
SRC_URI[aarch64_perl-List-SomeUtils-tests.sha256sum] = "46d7cb7502c6122f51757f8dae79cc9f49461f548cef5895247774caf2249148"

RDEPENDS:perl-List-SomeUtils = " \
 perl-Carp \
 perl-Exporter \
 perl-Module-Implementation \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-List-SomeUtils-tests = " \
 bash \
 perl-Carp \
 perl-Exporter \
 perl-ExtUtils-MakeMaker \
 perl-List-SomeUtils \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Test-Harness \
 perl-Test-LeakTrace \
 perl-Test-Simple \
 perl-Tie \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
