# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-codespan-reporting"
PV = "0.11.1"
PR = "12.el10_0"
PACKAGES = " \
 rust-codespan-reporting+ascii-only-devel \
 rust-codespan-reporting+default-devel \
 rust-codespan-reporting+serde-devel \
 rust-codespan-reporting+serialization-devel \
 rust-codespan-reporting-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-codespan-reporting-0.11.1-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e84b99aeb409ecea238c80b96571c8f84770169fc2c44aaca6c22763f2b6b91"

URI_x86_64_v2_rust-codespan-reporting+ascii-only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+ascii-only-devel-0.11.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+ascii-only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+ascii-only-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+ascii-only-devel.sha256sum] = "f15f26f41f7bb5b5911ffc851f1c394a781646e842953bd74250a9866c2caaf7"

URI_x86_64_v2_rust-codespan-reporting+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+default-devel-0.11.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+default-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+default-devel.sha256sum] = "1d7ca2e72511d6a95a6c08a4a8b6e5ab6db2c0d6b5637c0cb8ddd91d29884fa0"

URI_x86_64_v2_rust-codespan-reporting+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+serde-devel-0.11.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+serde-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+serde-devel.sha256sum] = "25e086f3402d268b696defe1a37fd5a93409a015eb646efe6686206597b2eb00"

URI_x86_64_v2_rust-codespan-reporting+serialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+serialization-devel-0.11.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+serialization-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+serialization-devel.sha256sum] = "c0574a522cbfa8a8fedf0a84cfc71fd4893f0261e87a889d879c7a32fa6de635"

URI_x86_64_v2_rust-codespan-reporting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting-devel-0.11.1-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting-devel.sha256sum] = "0cc806f2a0f0d3fa5f4264c1b714072aaceb45a5cfd0f60754339b1baf4a53fb"

URI_aarch64_rust-codespan-reporting+ascii-only-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+ascii-only-devel-0.11.1-12.el10_0.noarch.rpm;name=aarch64_rust-codespan-reporting+ascii-only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+ascii-only-devel}"
SRC_URI[aarch64_rust-codespan-reporting+ascii-only-devel.sha256sum] = "c843d46b145223aae96f8179b3ea006d053f62a3f1e2ffc045a45328b4d74f81"

URI_aarch64_rust-codespan-reporting+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+default-devel-0.11.1-12.el10_0.noarch.rpm;name=aarch64_rust-codespan-reporting+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+default-devel}"
SRC_URI[aarch64_rust-codespan-reporting+default-devel.sha256sum] = "ba1cc7f967521fa5bd2dda69cdba85bc26c01d2b7cd2864433ca55c338657d40"

URI_aarch64_rust-codespan-reporting+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+serde-devel-0.11.1-12.el10_0.noarch.rpm;name=aarch64_rust-codespan-reporting+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+serde-devel}"
SRC_URI[aarch64_rust-codespan-reporting+serde-devel.sha256sum] = "28294f1c14e447635782c92de5189b739c809aa4c5c7123cf6c6ffde52051d7c"

URI_aarch64_rust-codespan-reporting+serialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+serialization-devel-0.11.1-12.el10_0.noarch.rpm;name=aarch64_rust-codespan-reporting+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+serialization-devel}"
SRC_URI[aarch64_rust-codespan-reporting+serialization-devel.sha256sum] = "075ac4bfdc8cd0fb94244972ec5d2c42bbec5f18c4dcc3e8fe5c521112d50889"

URI_aarch64_rust-codespan-reporting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting-devel-0.11.1-12.el10_0.noarch.rpm;name=aarch64_rust-codespan-reporting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting-devel}"
SRC_URI[aarch64_rust-codespan-reporting-devel.sha256sum] = "33d48bf6be25542b7b02f525f2c42d92fa09a65c88ad43dbd02d85d2b574816e"

RDEPENDS:rust-codespan-reporting+ascii-only-devel = " \
 cargo \
 rust-codespan-reporting-devel \
 "
RDEPENDS:rust-codespan-reporting+default-devel = " \
 cargo \
 rust-codespan-reporting-devel \
 "
RDEPENDS:rust-codespan-reporting+serde-devel = " \
 cargo \
 rust-codespan-reporting-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-codespan-reporting+serialization-devel = " \
 cargo \
 rust-codespan-reporting+serde-devel \
 rust-codespan-reporting-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-codespan-reporting-devel = " \
 cargo \
 rust-termcolor+default-devel \
 rust-unicode-width0.1+default-devel \
 "
