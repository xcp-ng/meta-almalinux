# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DB_File"
PV = "1.859"
PR = "512.el10_0"
PACKAGES = " \
 perl-DB_File \
 perl-DB_File-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-DB_File-1.859-512.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2852f04dbf8fcee7e5f191cec0ddb3dabd05ab9307f61db69528758b1f7bc236"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DB_File-1.859-512.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-DB_File;unpack=0"
SRC_URI[x86_64_v2_perl-DB_File.sha256sum] = "7061f03b5f496572cca6a1be7d55bd89f98cacbe231677b04fa6a429d25719c0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-DB_File-tests-1.859-512.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-DB_File-tests;unpack=0"
SRC_URI[x86_64_v2_perl-DB_File-tests.sha256sum] = "fb9bb4ab9fff50e0f3ac265ff782ba8dbb39afd3885ae2b12333cb8d79a5e273"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DB_File-1.859-512.el10_0.aarch64.rpm;name=aarch64_perl-DB_File;unpack=0"
SRC_URI[aarch64_perl-DB_File.sha256sum] = "702351fb775a8b912cc7ecec185cb23a73346e88005540b37354a9febc5c45e3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-DB_File-tests-1.859-512.el10_0.aarch64.rpm;name=aarch64_perl-DB_File-tests;unpack=0"
SRC_URI[aarch64_perl-DB_File-tests.sha256sum] = "f390bf84c075c207f7c425245661f7454c41ab954b4b2cbc34f7e4e5fab8ac74"

RDEPENDS:perl-DB_File = " \
 glibc \
 libdb \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-PathTools \
 perl-libs \
 "
RDEPENDS:perl-DB_File-tests = " \
 bash \
 perl-DB_File \
 perl-Fcntl \
 perl-File-Temp \
 perl-Symbol \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-threads \
 "
