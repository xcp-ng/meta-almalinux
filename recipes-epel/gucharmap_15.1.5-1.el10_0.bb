# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gucharmap"
PV = "15.1.5"
PR = "1.el10_0"
PACKAGES = " \
 gucharmap \
 gucharmap-devel \
 gucharmap-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gucharmap-15.1.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "77e407f3ec1c7afaad09639b363fa6f683a56d6dc57720a2cceeb3c2ea3f24b2"

URI_x86_64_v2_gucharmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gucharmap-15.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gucharmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gucharmap}"
SRC_URI[x86_64_v2_gucharmap.sha256sum] = "781cb0e1502a2fdbbe03605b6885b3c2e62307fe57dcc560737e74ad5bb7eb8d"

URI_x86_64_v2_gucharmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gucharmap-devel-15.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gucharmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gucharmap-devel}"
SRC_URI[x86_64_v2_gucharmap-devel.sha256sum] = "ee07920d0adf2c7141f291e74981426ae27910c315df334875f60338b0bf57d1"

URI_x86_64_v2_gucharmap-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gucharmap-libs-15.1.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gucharmap-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gucharmap-libs}"
SRC_URI[x86_64_v2_gucharmap-libs.sha256sum] = "a5c0d3f62f7ac4cf8b0af7f2ea9f7aa23399a336e8d492b3e088a6768000f5c6"

URI_aarch64_gucharmap = "${EPEL_MIRROR}/aarch64/Packages/g/gucharmap-15.1.5-1.el10_0.aarch64.rpm;name=aarch64_gucharmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_gucharmap}"
SRC_URI[aarch64_gucharmap.sha256sum] = "c486a6283a40099c2214232ef7fe8118a2d4081c2449633c1a7ff3306b628f6c"

URI_aarch64_gucharmap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gucharmap-devel-15.1.5-1.el10_0.aarch64.rpm;name=aarch64_gucharmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gucharmap-devel}"
SRC_URI[aarch64_gucharmap-devel.sha256sum] = "09ce3eae0b1f96f80df5c7e90fdd8d3e4b5366c92cdd04dcb1a88c7bf8032e16"

URI_aarch64_gucharmap-libs = "${EPEL_MIRROR}/aarch64/Packages/g/gucharmap-libs-15.1.5-1.el10_0.aarch64.rpm;name=aarch64_gucharmap-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gucharmap-libs}"
SRC_URI[aarch64_gucharmap-libs.sha256sum] = "d5a066818a62a945f9f502c06ac1b5737d852256b602dd3c91b7434b9a5e8fde"

RDEPENDS:gucharmap = " \
 atk \
 glib2 \
 glibc \
 gtk3 \
 gucharmap-libs \
 pango \
 "
RDEPENDS:gucharmap-devel = " \
 glib2-devel \
 gtk3-devel \
 gucharmap-libs \
 pcre2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gucharmap-libs = " \
 atk \
 cairo \
 glib2 \
 glibc \
 gtk3 \
 pango \
 pcre2 \
 "
