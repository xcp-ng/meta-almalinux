# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-py3dns"
PV = "4.0.0"
PR = "11.el10_0"
PACKAGES = " \
 python3-py3dns \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-py3dns-4.0.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c76ae5a0b5a873528a19df0644c2c0e3c9c2e1acb2bd486519856d742fb36300"

URI_x86_64_v2_python3-py3dns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-py3dns-4.0.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-py3dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-py3dns}"
SRC_URI[x86_64_v2_python3-py3dns.sha256sum] = "6ba9ac0ecbcea94b001792fc44d6b21f9a74c95fe312be484e93928ab1a04da0"

URI_aarch64_python3-py3dns = "${EPEL_MIRROR}/aarch64/Packages/p/python3-py3dns-4.0.0-11.el10_0.noarch.rpm;name=aarch64_python3-py3dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-py3dns}"
SRC_URI[aarch64_python3-py3dns.sha256sum] = "abadee18f41ca3ce454d4cd3c7adf4659801e59beaf756e1580c5e29b2402fa8"

RDEPENDS:python3-py3dns = " \
 python3 \
 "
