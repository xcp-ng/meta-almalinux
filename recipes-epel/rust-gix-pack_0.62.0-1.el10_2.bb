# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-pack"
PV = "0.62.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-pack+default-devel \
 rust-gix-pack+document-features-devel \
 rust-gix-pack+generate-devel \
 rust-gix-pack+object-cache-dynamic-devel \
 rust-gix-pack+pack-cache-lru-dynamic-devel \
 rust-gix-pack+pack-cache-lru-static-devel \
 rust-gix-pack+serde-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-pack-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-pack-0.62.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "83f640575d4cf7192c516ee44232a5852565ab32502d68306d1291ff0b7304f9"

URI_x86_64_v2_rust-gix-pack+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+default-devel-0.62.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+default-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+default-devel.sha256sum] = "cc0eeb1421d464f65607133e792554de3f7768fa081b962941d85d4c4cef704b"

URI_x86_64_v2_rust-gix-pack+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+document-features-devel-0.62.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+document-features-devel.sha256sum] = "886e1a33c3fcb2464ab75e46672f148080f475d2106947e4e5fae52409eab280"

URI_x86_64_v2_rust-gix-pack+generate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+generate-devel-0.62.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+generate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+generate-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+generate-devel.sha256sum] = "b17c6a30e88376c054eba45741dfa1384c50a3359a7cfe2db19cfb548af0bf47"

URI_x86_64_v2_rust-gix-pack+object-cache-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+object-cache-dynamic-devel-0.62.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+object-cache-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+object-cache-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+object-cache-dynamic-devel.sha256sum] = "6bdb6e205f6c963ac7b477c37e8db9f7313195cbb7d215cce6a379e5ecb538cd"

URI_x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+pack-cache-lru-dynamic-devel-0.62.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+pack-cache-lru-dynamic-devel.sha256sum] = "4b54ebe8384b2ffbcd89b268bd99dabdb0855e20cdc00e713c490b93d39f751a"

URI_x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+pack-cache-lru-static-devel-0.62.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+pack-cache-lru-static-devel.sha256sum] = "235bc5606eb3a8c95121b5d8eb300903cf38808804e8e8cf1a98d415a2ee9375"

URI_x86_64_v2_rust-gix-pack+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+serde-devel-0.62.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+serde-devel.sha256sum] = "ffff62053203364cd6235f10c79c0c07e696fd685c37f5c3d1f637abdd71ef51"

URI_x86_64_v2_rust-gix-pack+streaming-input-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack+streaming-input-devel-0.62.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack+streaming-input-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack+streaming-input-devel}"
SRC_URI[x86_64_v2_rust-gix-pack+streaming-input-devel.sha256sum] = "c014d9eae617e40934cf45e9a94f8ceaa1d844670ab7255149195c18510d59d6"

URI_x86_64_v2_rust-gix-pack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-pack-devel-0.62.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-pack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-pack-devel}"
SRC_URI[x86_64_v2_rust-gix-pack-devel.sha256sum] = "dbb48c675aed7e281fa7a8a652a29a08a45de5662950bd539d253e109dea99af"

URI_aarch64_rust-gix-pack+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+default-devel-0.62.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pack+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+default-devel}"
SRC_URI[aarch64_rust-gix-pack+default-devel.sha256sum] = "efca2d0f005fd32d3949dc6d204a85065337fd15f997a2bc9f7126cb6391a214"

URI_aarch64_rust-gix-pack+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+document-features-devel-0.62.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pack+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+document-features-devel}"
SRC_URI[aarch64_rust-gix-pack+document-features-devel.sha256sum] = "38b3ef774d955a8d4af75abe1d5412226d75b0092d3d99dfcdc133f1ffb6a389"

URI_aarch64_rust-gix-pack+generate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+generate-devel-0.62.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pack+generate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+generate-devel}"
SRC_URI[aarch64_rust-gix-pack+generate-devel.sha256sum] = "9157cdbe0e0c5a04aa3b98e3329d56bfd8182b8dbc7bd8058772233ad7ff788f"

URI_aarch64_rust-gix-pack+object-cache-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+object-cache-dynamic-devel-0.62.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pack+object-cache-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+object-cache-dynamic-devel}"
SRC_URI[aarch64_rust-gix-pack+object-cache-dynamic-devel.sha256sum] = "b4165821928bc7c0874ec6a2103c3c471525f69cbd383a8905ebdf11fd808fc6"

URI_aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+pack-cache-lru-dynamic-devel-0.62.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel}"
SRC_URI[aarch64_rust-gix-pack+pack-cache-lru-dynamic-devel.sha256sum] = "11a2617dd6d765c7f3115924eab6a6cfeae31b8aa1a2e2850c3588bf5cbc0eda"

URI_aarch64_rust-gix-pack+pack-cache-lru-static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+pack-cache-lru-static-devel-0.62.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pack+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+pack-cache-lru-static-devel}"
SRC_URI[aarch64_rust-gix-pack+pack-cache-lru-static-devel.sha256sum] = "90f51dbd8c59fd7af6b2f593ebaaa86c675102bae1b7af1f49b2fafb96ff20ac"

URI_aarch64_rust-gix-pack+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+serde-devel-0.62.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pack+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+serde-devel}"
SRC_URI[aarch64_rust-gix-pack+serde-devel.sha256sum] = "6933b291b007ca87c581d3def5fd70e51180f8c47d4923424fdd0d6c6d5aab7f"

URI_aarch64_rust-gix-pack+streaming-input-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack+streaming-input-devel-0.62.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pack+streaming-input-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack+streaming-input-devel}"
SRC_URI[aarch64_rust-gix-pack+streaming-input-devel.sha256sum] = "b4f3ab28fb1dfae2a5273ccc9c60b9cf8244fa239b17104230657cb4931dd606"

URI_aarch64_rust-gix-pack-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-pack-devel-0.62.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-pack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-pack-devel}"
SRC_URI[aarch64_rust-gix-pack-devel.sha256sum] = "929a7135f8ed3b6fa1997dd380753eb9aa94be4d932ad1cca9d15175759f044f"

RDEPENDS:rust-gix-pack+default-devel = " \
 cargo \
 rust-gix-pack+generate-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+generate-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-pack-devel \
 rust-gix-traverse+default-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-pack+object-cache-dynamic-devel = " \
 cargo \
 rust-clru+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+pack-cache-lru-dynamic-devel = " \
 cargo \
 rust-clru+default-devel \
 rust-gix-pack-devel \
 "
RDEPENDS:rust-gix-pack+pack-cache-lru-static-devel = " \
 cargo \
 rust-gix-pack-devel \
 rust-uluru+default-devel \
 "
RDEPENDS:rust-gix-pack+serde-devel = " \
 cargo \
 rust-gix-object+serde-devel \
 rust-gix-pack-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-pack+streaming-input-devel = " \
 cargo \
 rust-gix-pack-devel \
 rust-gix-tempfile-devel \
 rust-parking_lot-devel \
 "
RDEPENDS:rust-gix-pack-devel = " \
 cargo \
 rust \
 rust-gix-chunk+default-devel \
 rust-gix-features+crc32-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-features+zlib-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-memmap2+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
