# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksystemlog"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 ksystemlog \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/ksystemlog-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a063f181ed5f1c6437b976928f9c68fbea09d8c9204cd7c45699f5a9f00039e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksystemlog-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksystemlog;unpack=0"
SRC_URI[x86_64_v2_ksystemlog.sha256sum] = "f913ca3bda60194898deb5f5c9750685579be43732e7c39f4cd451f8e5202412"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/ksystemlog-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_ksystemlog;unpack=0"
SRC_URI[aarch64_ksystemlog.sha256sum] = "005eddb0a15c53077060b23141d57ff8027ecc5d5302709816234d8e2e19f1c2"

RDEPENDS:ksystemlog = " \
 audit-libs \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
