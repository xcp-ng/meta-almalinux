# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-word-wrap"
PV = "0.5"
PR = "7.el10_0"
PACKAGES = " \
 ghc-word-wrap \
 ghc-word-wrap-devel \
 ghc-word-wrap-doc \
 ghc-word-wrap-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-word-wrap-0.5-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d011794b5b5b61037c17995dfccd4ff0b691801937c794e4815e516fc6185297"

URI_x86_64_v2_ghc-word-wrap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-word-wrap-0.5-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-word-wrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-word-wrap}"
SRC_URI[x86_64_v2_ghc-word-wrap.sha256sum] = "3da535ca624687ff3686f819014ba9aa0927128d38e4fa28d427c1e8bd1df6b3"

URI_x86_64_v2_ghc-word-wrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-word-wrap-devel-0.5-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-word-wrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-word-wrap-devel}"
SRC_URI[x86_64_v2_ghc-word-wrap-devel.sha256sum] = "b4d339cccf591b422ced6cb025487cd668f830ce31476ebf962f307486c3848b"

URI_x86_64_v2_ghc-word-wrap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-word-wrap-doc-0.5-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-word-wrap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-word-wrap-doc}"
SRC_URI[x86_64_v2_ghc-word-wrap-doc.sha256sum] = "5e02a98e143068f7d35228008495376f8524f1cc1566d3125ac94fda9fb3391a"

URI_x86_64_v2_ghc-word-wrap-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-word-wrap-prof-0.5-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-word-wrap-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-word-wrap-prof}"
SRC_URI[x86_64_v2_ghc-word-wrap-prof.sha256sum] = "6d2d39ac91f32693fbc5cce60a2eaa7fa5a2db4e42ca9e9835a820544e294675"

URI_aarch64_ghc-word-wrap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-word-wrap-0.5-7.el10_0.aarch64.rpm;name=aarch64_ghc-word-wrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-word-wrap}"
SRC_URI[aarch64_ghc-word-wrap.sha256sum] = "7c7a500767c940fc236b36501fae934ea44ea6300f36a703e0df77b6c025a36c"

URI_aarch64_ghc-word-wrap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-word-wrap-devel-0.5-7.el10_0.aarch64.rpm;name=aarch64_ghc-word-wrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-word-wrap-devel}"
SRC_URI[aarch64_ghc-word-wrap-devel.sha256sum] = "ad30e270511c43d2af90d6f86551e1cbf343be24f9032eb281c1d108b898e921"

URI_aarch64_ghc-word-wrap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-word-wrap-doc-0.5-7.el10_0.noarch.rpm;name=aarch64_ghc-word-wrap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-word-wrap-doc}"
SRC_URI[aarch64_ghc-word-wrap-doc.sha256sum] = "36c1a855748db8fa5e6f7d5c095b7caf182d98c17c93724a35adc4595331ee32"

URI_aarch64_ghc-word-wrap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-word-wrap-prof-0.5-7.el10_0.aarch64.rpm;name=aarch64_ghc-word-wrap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-word-wrap-prof}"
SRC_URI[aarch64_ghc-word-wrap-prof.sha256sum] = "5f8748b75e53dd169d8a3aa35e69099013d0cb1ac25a3e7f1e6e4f9ab0af7dfd"

RDEPENDS:ghc-word-wrap = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-word-wrap-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-text-devel \
 ghc-word-wrap \
 "
RDEPENDS:ghc-word-wrap-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-word-wrap-prof = " \
 ghc-base-prof \
 ghc-text-prof \
 ghc-word-wrap-devel \
 "
