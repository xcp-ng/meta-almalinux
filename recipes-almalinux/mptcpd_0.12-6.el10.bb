# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mptcpd"
PV = "0.12"
PR = "6.el10"
PACKAGES = " \
 mptcpd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mptcpd-0.12-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c644d4fcb875c6e3393bc1091a9442adbb3e7a51bef40c1bd11f6e283239a4e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mptcpd-0.12-6.el10.x86_64_v2.rpm;name=x86_64_v2_mptcpd;unpack=0"
SRC_URI[x86_64_v2_mptcpd.sha256sum] = "4dcc69b9a974c04810279ff40fba62c98a13aa12b089e88a82b2ae82dfd3950c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mptcpd-0.12-6.el10.aarch64.rpm;name=aarch64_mptcpd;unpack=0"
SRC_URI[aarch64_mptcpd.sha256sum] = "c485a28a56cbe25e6d62c3945900508cd6a85c2f7360688c98afe30c93e6c59c"

RDEPENDS:mptcpd = " \
 glibc \
 libell \
 systemd \
 "
