# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-CheckBin"
PV = "0.04"
PR = "23.el10_0"
PACKAGES = " \
 perl-Devel-CheckBin \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Devel-CheckBin-0.04-23.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c2b676090c2defa021b449ce38b180c5f841ec1411286e76c30aa7388f4b587b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Devel-CheckBin-0.04-23.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Devel-CheckBin;unpack=0"
SRC_URI[x86_64_v2_perl-Devel-CheckBin.sha256sum] = "d80b5163ba48a9c4c508c4e17fd9a00a9b664811e1d613e74199f028366b384d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Devel-CheckBin-0.04-23.el10_0.noarch.rpm;name=aarch64_perl-Devel-CheckBin;unpack=0"
SRC_URI[aarch64_perl-Devel-CheckBin.sha256sum] = "418ccbdb254fd4a61b356ac36fd2501f08d896d690b9e3f4bb60238b3afd07e4"

RDEPENDS:perl-Devel-CheckBin = " \
 perl-Exporter \
 perl-ExtUtils-MakeMaker \
 perl-PathTools \
 perl-libs \
 perl-parent \
 "
