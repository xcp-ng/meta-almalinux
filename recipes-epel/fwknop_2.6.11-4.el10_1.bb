# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fwknop"
PV = "2.6.11"
PR = "4.el10_1"
PACKAGES = " \
 fwknop \
 fwknop-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fwknop-2.6.11-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7beb27464a09622ff55abe6e8c4cdf6b7a0b12e1fed1b5b72b797251a617d4b"

URI_x86_64_v2_fwknop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fwknop-2.6.11-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fwknop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwknop}"
SRC_URI[x86_64_v2_fwknop.sha256sum] = "464459fd6aab6112206d4734300e3fc581a35d67852d9c99b055a84511c7a116"

URI_x86_64_v2_fwknop-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fwknop-devel-2.6.11-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fwknop-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fwknop-devel}"
SRC_URI[x86_64_v2_fwknop-devel.sha256sum] = "373d945fd01bc63fbe3a8d5a6463417ea0696be0dbcbe9c523dd668a78542ee8"

URI_aarch64_fwknop = "${EPEL_MIRROR}/aarch64/Packages/f/fwknop-2.6.11-4.el10_1.aarch64.rpm;name=aarch64_fwknop;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwknop}"
SRC_URI[aarch64_fwknop.sha256sum] = "1bcc8da586a12e008646d05f7dfccd45cae7b86c1f6f1403fbc8052ed38baa09"

URI_aarch64_fwknop-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fwknop-devel-2.6.11-4.el10_1.aarch64.rpm;name=aarch64_fwknop-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fwknop-devel}"
SRC_URI[aarch64_fwknop-devel.sha256sum] = "cc012e09009684addb622b64ec177eff96418602b24aed7fe5932104b644ba8b"

RDEPENDS:fwknop = " \
 bash \
 glibc \
 gpgme \
 libpcap \
 logrotate \
 systemd \
 "
RDEPENDS:fwknop-devel = " \
 fwknop \
 gnupg2 \
 gpgme \
 "
