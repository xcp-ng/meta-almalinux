# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libaio"
PV = "0.3.111"
PR = "22.el10"
PACKAGES = " \
 libaio \
 libaio-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libaio-0.3.111-22.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "892fcbc315c718ff3d9bd5c2a0df021253c02886136a4a81cec531ba2fed893b"

URI_x86_64_v2_libaio = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libaio-0.3.111-22.el10.x86_64_v2.rpm;name=x86_64_v2_libaio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaio}"
SRC_URI[x86_64_v2_libaio.sha256sum] = "0f28f8d1b4db56ff3dad35aba14fa7648faf3ba5cea3b0f9d4a40f0ede15d782"

URI_x86_64_v2_libaio-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libaio-devel-0.3.111-22.el10.x86_64_v2.rpm;name=x86_64_v2_libaio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaio-devel}"
SRC_URI[x86_64_v2_libaio-devel.sha256sum] = "e4ab03f413a634cc8ca1a1dcdf720943d8aaa10598c30da8599225cd0f9ac42e"

URI_aarch64_libaio = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libaio-0.3.111-22.el10.aarch64.rpm;name=aarch64_libaio;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaio}"
SRC_URI[aarch64_libaio.sha256sum] = "2eef74326ce5569904ad9ddb78e92b41cae54bab5c96531c6d035c9e87aea4a8"

URI_aarch64_libaio-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libaio-devel-0.3.111-22.el10.aarch64.rpm;name=aarch64_libaio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaio-devel}"
SRC_URI[aarch64_libaio-devel.sha256sum] = "ee8b187b51b2a693e45bfbfc13b7cce52f6db48fc5983a45093b68f3ae45f3a7"

RDEPENDS:libaio = " \
 glibc \
 "
RDEPENDS:libaio-devel = " \
 libaio \
 "
