# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnetfilter_queue"
PV = "1.0.5"
PR = "9.el10"
PACKAGES = " \
 libnetfilter_queue \
 libnetfilter_queue-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnetfilter_queue-1.0.5-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51d24c324cfdafd53bb06e4c6c93c4842a6b0971463a77268a20a3ce73616b07"

URI_x86_64_v2_libnetfilter_queue = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnetfilter_queue-1.0.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_libnetfilter_queue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetfilter_queue}"
SRC_URI[x86_64_v2_libnetfilter_queue.sha256sum] = "e7602b114fdc7d3966219947e44db56cfcbfb2c55e37b496b7842300ef2c1247"

URI_x86_64_v2_libnetfilter_queue-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnetfilter_queue-devel-1.0.5-9.el10.x86_64_v2.rpm;name=x86_64_v2_libnetfilter_queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetfilter_queue-devel}"
SRC_URI[x86_64_v2_libnetfilter_queue-devel.sha256sum] = "468554689ae503f8c9d7d003c7450c4ed2e65121b34810452d26c89f5ddccc41"

URI_aarch64_libnetfilter_queue = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnetfilter_queue-1.0.5-9.el10.aarch64.rpm;name=aarch64_libnetfilter_queue;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetfilter_queue}"
SRC_URI[aarch64_libnetfilter_queue.sha256sum] = "e5ce201d6a551ff911d824a477c0a037cd755730c2480e40aaf5b5e5da48cc37"

URI_aarch64_libnetfilter_queue-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnetfilter_queue-devel-1.0.5-9.el10.aarch64.rpm;name=aarch64_libnetfilter_queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetfilter_queue-devel}"
SRC_URI[aarch64_libnetfilter_queue-devel.sha256sum] = "890f608bf8bae6d998cb48a9b7593330652107f507e422d21286a4c16134084e"

RDEPENDS:libnetfilter_queue = " \
 glibc \
 libmnl \
 libnfnetlink \
 "
RDEPENDS:libnetfilter_queue-devel = " \
 kernel-headers \
 libnetfilter_queue \
 libnfnetlink-devel \
 pkgconf-pkg-config \
 "
