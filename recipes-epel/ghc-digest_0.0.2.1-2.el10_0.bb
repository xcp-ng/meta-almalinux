# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-digest"
PV = "0.0.2.1"
PR = "2.el10_0"
PACKAGES = " \
 ghc-digest \
 ghc-digest-devel \
 ghc-digest-doc \
 ghc-digest-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-digest-0.0.2.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b92c3b682461d2ef71e3ed9a7043bef1b8a4e6740c5ebd624207d85f26692aca"

URI_x86_64_v2_ghc-digest = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-digest-0.0.2.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-digest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-digest}"
SRC_URI[x86_64_v2_ghc-digest.sha256sum] = "4637b6273ec78feaf9026c912a263b773411f40de358f2ef45d5d853aa2539fc"

URI_x86_64_v2_ghc-digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-digest-devel-0.0.2.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-digest-devel}"
SRC_URI[x86_64_v2_ghc-digest-devel.sha256sum] = "5d0a0a4bbff925b715174b89638892b67b4702c4403e2bd1ca1149c53d476fe0"

URI_x86_64_v2_ghc-digest-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-digest-doc-0.0.2.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-digest-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-digest-doc}"
SRC_URI[x86_64_v2_ghc-digest-doc.sha256sum] = "539a53a3713e113c31ccec30d0e1d86a00d2e3cecc09a821f6c85bd937595968"

URI_x86_64_v2_ghc-digest-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-digest-prof-0.0.2.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-digest-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-digest-prof}"
SRC_URI[x86_64_v2_ghc-digest-prof.sha256sum] = "d2576609108a584095726add66b2f4432b374a768022c0086a68a48eac04d47a"

URI_aarch64_ghc-digest = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-digest-0.0.2.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-digest;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-digest}"
SRC_URI[aarch64_ghc-digest.sha256sum] = "db380c3f38caba009a3bc2e00c401e6f2ad2eb34c644e205121f61654bed25a8"

URI_aarch64_ghc-digest-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-digest-devel-0.0.2.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-digest-devel}"
SRC_URI[aarch64_ghc-digest-devel.sha256sum] = "6bf78fcbfc822374b16239fa9eaca1c5b8f4ffe7e0a2140ccb392331d6e77ff5"

URI_aarch64_ghc-digest-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-digest-doc-0.0.2.1-2.el10_0.noarch.rpm;name=aarch64_ghc-digest-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-digest-doc}"
SRC_URI[aarch64_ghc-digest-doc.sha256sum] = "6ce008f33aa1e3ad1d7b21c2112f5635edb5fbc13640e43fba67626a385102a6"

URI_aarch64_ghc-digest-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-digest-prof-0.0.2.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-digest-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-digest-prof}"
SRC_URI[aarch64_ghc-digest-prof.sha256sum] = "5a0c4bc5a9f03223ffd2e632c242e40d5ff6d34f5743bce0ef4a316de054fcf3"

RDEPENDS:ghc-digest = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-digest-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-digest \
 zlib-ng-compat-devel \
 "
RDEPENDS:ghc-digest-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-digest-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-digest-devel \
 "
