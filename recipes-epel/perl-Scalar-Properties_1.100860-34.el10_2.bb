# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Scalar-Properties"
PV = "1.100860"
PR = "34.el10_2"
PACKAGES = " \
 perl-Scalar-Properties \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Scalar-Properties-1.100860-34.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d5bbd4fbbe886e82fa942b31ec294c20570eebd78f1620a3c7cee922c95f113"

URI_x86_64_v2_perl-Scalar-Properties = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Scalar-Properties-1.100860-34.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Scalar-Properties;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Scalar-Properties}"
SRC_URI[x86_64_v2_perl-Scalar-Properties.sha256sum] = "ff308ae9b4f84c170044335bd7837572e1ad98b8983d2927c1cdee630d26da4d"

URI_aarch64_perl-Scalar-Properties = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Scalar-Properties-1.100860-34.el10_2.noarch.rpm;name=aarch64_perl-Scalar-Properties;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Scalar-Properties}"
SRC_URI[aarch64_perl-Scalar-Properties.sha256sum] = "14fa2d119e79d6ddfae1d7886a5d4429018be884a280271f9b47e88b53c8beeb"

RDEPENDS:perl-Scalar-Properties = " \
 perl-libs \
 perl-overload \
 "
