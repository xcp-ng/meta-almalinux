# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fastfetch"
PV = "2.68.1"
PR = "1.el10_3"
PACKAGES = " \
 fastfetch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fastfetch-2.68.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d1d8acecc7b332836431fd2b638ee86d575268894602a501fd321c9a34a6a241"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fastfetch-2.68.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fastfetch;unpack=0"
SRC_URI[x86_64_v2_fastfetch.sha256sum] = "2e91ee7d93a0978c9727106676c257f396cd14e5eb29ecc44fc6de001ffde0f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fastfetch-2.68.1-1.el10_3.aarch64.rpm;name=aarch64_fastfetch;unpack=0"
SRC_URI[aarch64_fastfetch.sha256sum] = "4f79d93f6f94aaf9aa7b0aa291aae2d8eda34cdaf5648edd18acf69d373411a8"

RDEPENDS:fastfetch = " \
 glibc \
 libgcc \
 yyjson \
 "
