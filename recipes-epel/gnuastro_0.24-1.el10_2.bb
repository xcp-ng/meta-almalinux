# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnuastro"
PV = "0.24"
PR = "1.el10_2"
PACKAGES = " \
 gnuastro \
 gnuastro-devel \
 gnuastro-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/gnuastro-0.24-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0de29d887c8e7f38b107cdf16935a94a37830396310c76b7f0e6412c6270e306"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuastro;unpack=0"
SRC_URI[x86_64_v2_gnuastro.sha256sum] = "15f5a00d7740c846f1873ab745646a703e83458edc2ce04595bbb1065655b95d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-devel-0.24-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gnuastro-devel;unpack=0"
SRC_URI[x86_64_v2_gnuastro-devel.sha256sum] = "7296b96409eef0dd2c81fe9df78edb022cb4ebf740ec572597747eb4264383e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnuastro-doc-0.24-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnuastro-doc;unpack=0"
SRC_URI[x86_64_v2_gnuastro-doc.sha256sum] = "a32fe799e272889186f0ccb092352b633a392af9faf953e95afeb2ac695316b9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-0.24-1.el10_2.aarch64.rpm;name=aarch64_gnuastro;unpack=0"
SRC_URI[aarch64_gnuastro.sha256sum] = "0eb2bed5787d8af1fbae639088b0ac2bda650985527dc5c6af38734ea2778196"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-devel-0.24-1.el10_2.aarch64.rpm;name=aarch64_gnuastro-devel;unpack=0"
SRC_URI[aarch64_gnuastro-devel.sha256sum] = "7a664be6dfa7a7ff3ffc401706424c8b64b477267800a2b32639c4049768928c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/gnuastro-doc-0.24-1.el10_2.noarch.rpm;name=aarch64_gnuastro-doc;unpack=0"
SRC_URI[aarch64_gnuastro-doc.sha256sum] = "4ef658f60863050ae400e96bda585779d8a9586dd6d867d65839980c493a6fb0"

RDEPENDS:gnuastro = " \
 bash \
 cfitsio \
 glibc \
 gsl \
 libgit2_1.9 \
 libjpeg-turbo \
 libtiff \
 wcslib \
 zlib-ng-compat \
 "
RDEPENDS:gnuastro-devel = " \
 cfitsio-devel \
 gnuastro \
 gsl-devel \
 libjpeg-turbo-devel \
 libtiff-devel \
 pkgconf-pkg-config \
 virtual/pkgconfig_libgit2_ \
 wcslib-devel \
 "
RDEPENDS:gnuastro-doc = " \
 "
