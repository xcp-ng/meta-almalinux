# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwindowsystem"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kwindowsystem \
 kf6-kwindowsystem-devel \
 kf6-kwindowsystem-doc \
 kf6-kwindowsystem-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kwindowsystem-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e96d2cf1ecff346fd96b6db22696ff2294b31e41f848292d57fc264ace6d3645"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem;unpack=0"
SRC_URI[x86_64_v2_kf6-kwindowsystem.sha256sum] = "0cfdccf8a3bf5050f90e542dc3a49e8c4b17211077b42cc34e988395e0a878b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kwindowsystem-devel.sha256sum] = "c4071a5c3f4cd91d0e3a52369c691b39609fd5d99b0163b4b59b41156633e998"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwindowsystem-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kwindowsystem-doc.sha256sum] = "cb9285b71d4eeee77d0fa8e87c1f028f29e1d7bc612b226ffa3d6d0a2b56d0a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwindowsystem-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kwindowsystem-html.sha256sum] = "e866dc8d0f3144a9667217d3adb84bbc452c27d6dc51aed2858a0e06afd0395f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwindowsystem;unpack=0"
SRC_URI[aarch64_kf6-kwindowsystem.sha256sum] = "2e204c938d36f323e936f82e28e7e2a1753e2e16bcefc3637af654d5cfc7272f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kwindowsystem-devel;unpack=0"
SRC_URI[aarch64_kf6-kwindowsystem-devel.sha256sum] = "ee3c539b648c3383dde1b1838de49b205613a255925c3874fd674ffe393bde77"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwindowsystem-doc;unpack=0"
SRC_URI[aarch64_kf6-kwindowsystem-doc.sha256sum] = "e596c42476bfbdadfc177fa7a7103ef7ab5478f43cec76dfc509fb02456a724a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kwindowsystem-html;unpack=0"
SRC_URI[aarch64_kf6-kwindowsystem-html.sha256sum] = "d26e3a6055233c1a54c7b6fa49cbac6a1887a39eff292b4d1d622f3209be1010"

RDEPENDS:kf6-kwindowsystem = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libXfixes \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xcb-util-keysyms \
 "
RDEPENDS:kf6-kwindowsystem-devel = " \
 cmake-filesystem \
 kf6-kwindowsystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwindowsystem-doc = " \
 "
RDEPENDS:kf6-kwindowsystem-html = " \
 "
