# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "meson"
PV = "1.7.2"
PR = "1.el10.alma.1"
PACKAGES = " \
 meson \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/meson-1.7.2-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c338468ec3bba75624e33748c579c19d63fd0cfd4e1f20ca2ccbfc5faaca3bc"

URI_x86_64_v2_meson = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/meson-1.7.2-1.el10.alma.1.noarch.rpm;name=x86_64_v2_meson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_meson}"
SRC_URI[x86_64_v2_meson.sha256sum] = "184cd0bb4fefbef4c6e51dd2548d89aa5804ed272fe0c1fbe91c9bcdd2f964ed"

URI_aarch64_meson = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/meson-1.7.2-1.el10.alma.1.noarch.rpm;name=aarch64_meson;unpack=0"
SRC_URI:append = " ${URI_aarch64_meson}"
SRC_URI[aarch64_meson.sha256sum] = "184cd0bb4fefbef4c6e51dd2548d89aa5804ed272fe0c1fbe91c9bcdd2f964ed"

RDEPENDS:meson = " \
 ninja-build \
 python3 \
 python3-setuptools \
 "
