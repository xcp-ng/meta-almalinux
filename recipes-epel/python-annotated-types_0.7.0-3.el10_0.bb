# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-annotated-types"
PV = "0.7.0"
PR = "3.el10_0"
PACKAGES = " \
 python3-annotated-types \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-annotated-types-0.7.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16f03a8ce6dab443e299d203ecf14412708eab0187cdcbf0c90c266c897b6435"

URI_x86_64_v2_python3-annotated-types = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-annotated-types-0.7.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-annotated-types;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-annotated-types}"
SRC_URI[x86_64_v2_python3-annotated-types.sha256sum] = "49ebf8494e2deb8ffbad4adb9484143ef982b65724eefd764f77f5bc508f379e"

URI_aarch64_python3-annotated-types = "${EPEL_MIRROR}/aarch64/Packages/p/python3-annotated-types-0.7.0-3.el10_0.noarch.rpm;name=aarch64_python3-annotated-types;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-annotated-types}"
SRC_URI[aarch64_python3-annotated-types.sha256sum] = "d9acdd86b02467247b9f505f3da7d8f482b01f4e70536b8fc923500607eab142"

RDEPENDS:python3-annotated-types = " \
 python3 \
 "
