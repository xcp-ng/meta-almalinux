# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-wayland2"
PV = "1.0.1"
PR = "1.el10_2"
PACKAGES = " \
 egl-wayland2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/egl-wayland2-1.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bea763b941d8e7046f4eefbd3bf273eb6f0d16b0ac260e1aff4faca469d6b586"

URI_x86_64_v2_egl-wayland2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland2-1.0.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_egl-wayland2}"
SRC_URI[x86_64_v2_egl-wayland2.sha256sum] = "d2459dc69aa42c61242cb2be39b05475ceed600800ccf977d5213e0496c99043"

URI_aarch64_egl-wayland2 = "${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland2-1.0.1-1.el10_2.aarch64.rpm;name=aarch64_egl-wayland2;unpack=0"
SRC_URI:append = " ${URI_aarch64_egl-wayland2}"
SRC_URI[aarch64_egl-wayland2.sha256sum] = "3175e23d2584c012715f8fed25891ef02c204c01f801accc641b71dcbc735edc"

RDEPENDS:egl-wayland2 = " \
 glibc \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 mesa-libgbm \
 "
