# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "messagelib"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 messagelib \
 messagelib-devel \
 messagelib-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/messagelib-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fddf8231714394fad68cc0a622d299ce96fd492df2573e143c83dee286e741c"

URI_x86_64_v2_messagelib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib}"
SRC_URI[x86_64_v2_messagelib.sha256sum] = "2e4b0cdd92fe3256a5008a760f243c9b967e426dafea6ebe71164b6212878bfa"

URI_x86_64_v2_messagelib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib-devel}"
SRC_URI[x86_64_v2_messagelib-devel.sha256sum] = "ec80b5e82e89c5dce330f2cf07a1d0be0b0a9047cbc4ee37869d31731669385b"

URI_x86_64_v2_messagelib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_messagelib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_messagelib-doc}"
SRC_URI[x86_64_v2_messagelib-doc.sha256sum] = "0d9dbba7674e00e45b1dfb652fb2add9013c5be078382be96fda35cd7e5a1632"

URI_aarch64_messagelib = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_messagelib;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib}"
SRC_URI[aarch64_messagelib.sha256sum] = "04b33a51083092fffc259749f9dd7bc2e523da3d1c50a960940b9f9c67668db4"

URI_aarch64_messagelib-devel = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_messagelib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib-devel}"
SRC_URI[aarch64_messagelib-devel.sha256sum] = "5c81016c1c3e4331bc4af639c7ee5b7800c4226e07b647edfca6c76dc02b8471"

URI_aarch64_messagelib-doc = "${EPEL_MIRROR}/aarch64/Packages/m/messagelib-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_messagelib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_messagelib-doc}"
SRC_URI[aarch64_messagelib-doc.sha256sum] = "e2e89c0d8260f854044e7dddc7ab88657da3198e5f6481fdda429a7503fdb44a"

RDEPENDS:messagelib = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgmepp \
 grantleetheme \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 kmbox \
 kmime \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgravatar \
 libkdepim \
 libkleo \
 libstdc++ \
 openssl-libs \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:messagelib-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcontacts-devel \
 kidentitymanagement-devel \
 kmime-devel \
 libkleo-devel \
 messagelib \
 pimcommon-devel \
 qt6-qtwebengine-devel \
 "
RDEPENDS:messagelib-doc = " \
 "
