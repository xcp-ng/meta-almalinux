# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kactivitymanagerd"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kactivitymanagerd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kactivitymanagerd-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b299b105d965a7fdb71824299385c9f61323362408de524d05ce632c830117f"

URI_x86_64_v2_kactivitymanagerd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kactivitymanagerd-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kactivitymanagerd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kactivitymanagerd}"
SRC_URI[x86_64_v2_kactivitymanagerd.sha256sum] = "ac9bf0d17530cb8ea7c4c54db714fcf041653b4bfef69ef6b807b368eea8ff6c"

URI_aarch64_kactivitymanagerd = "${EPEL_MIRROR}/aarch64/Packages/k/kactivitymanagerd-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kactivitymanagerd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kactivitymanagerd}"
SRC_URI[aarch64_kactivitymanagerd.sha256sum] = "2fcc3828c4e00c6c293e73f3661b119ee9954a959885abaadcbdf892f8e3861f"

RDEPENDS:kactivitymanagerd = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kservice \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
