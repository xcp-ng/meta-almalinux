# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-termcolor"
PV = "1.4.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-termcolor+default-devel \
 rust-termcolor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-termcolor-1.4.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7e24699a5afb2914ac7537955da3b1bb53e99b3b13dab9cfdb742ee86974166"

URI_x86_64_v2_rust-termcolor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termcolor+default-devel-1.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termcolor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termcolor+default-devel}"
SRC_URI[x86_64_v2_rust-termcolor+default-devel.sha256sum] = "3f3ee361b858ef7e53d6005f59f0ad8083e01ef96fb17dab1349088e9bfca703"

URI_x86_64_v2_rust-termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-termcolor-devel-1.4.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-termcolor-devel}"
SRC_URI[x86_64_v2_rust-termcolor-devel.sha256sum] = "ce2a65f9329e1ca8677ef8da42ed848edfcd08369ac7360e7fef431b70f92545"

URI_aarch64_rust-termcolor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termcolor+default-devel-1.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-termcolor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termcolor+default-devel}"
SRC_URI[aarch64_rust-termcolor+default-devel.sha256sum] = "57ef25329a21a9b109ed309bc8c8d2f75916c171f7c0ff263bb02714e0a8ecd1"

URI_aarch64_rust-termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-termcolor-devel-1.4.1-3.el10_0.noarch.rpm;name=aarch64_rust-termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-termcolor-devel}"
SRC_URI[aarch64_rust-termcolor-devel.sha256sum] = "ed991431a9cd5bd2847bb6fd8ae06730b1666e7db559bcc6e6fcc97fad586cea"

RDEPENDS:rust-termcolor+default-devel = " \
 cargo \
 rust-termcolor-devel \
 "
RDEPENDS:rust-termcolor-devel = " \
 cargo \
 "
