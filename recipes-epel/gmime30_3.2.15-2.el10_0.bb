# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gmime30"
PV = "3.2.15"
PR = "2.el10_0"
PACKAGES = " \
 gmime30 \
 gmime30-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gmime30-3.2.15-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa23e6aa994eed3835432d8a42a253b296077ab21e29c76664bb7e90acb3c17f"

URI_x86_64_v2_gmime30 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gmime30-3.2.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gmime30;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmime30}"
SRC_URI[x86_64_v2_gmime30.sha256sum] = "f9f798cdc502cc697398c4de6dc027bebd099fd7745455be6970dc5c3603b1bb"

URI_x86_64_v2_gmime30-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gmime30-devel-3.2.15-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gmime30-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gmime30-devel}"
SRC_URI[x86_64_v2_gmime30-devel.sha256sum] = "0406d5511246224648eee5c97e79d1b31515b6e44141399f08cb2eb9d8f5e6ce"

URI_aarch64_gmime30 = "${EPEL_MIRROR}/aarch64/Packages/g/gmime30-3.2.15-2.el10_0.aarch64.rpm;name=aarch64_gmime30;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmime30}"
SRC_URI[aarch64_gmime30.sha256sum] = "913cfe836d95896324756e4d9941f3904c550fa0b838b614ba041b8c9cc4c07b"

URI_aarch64_gmime30-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gmime30-devel-3.2.15-2.el10_0.aarch64.rpm;name=aarch64_gmime30-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gmime30-devel}"
SRC_URI[aarch64_gmime30-devel.sha256sum] = "651f82d3c17157fc2e147890cd359685c8d9d463b4d7c7b7fcd8cf5efca7ed08"

RDEPENDS:gmime30 = " \
 glib2 \
 glibc \
 gpgme \
 libgpg-error \
 zlib-ng-compat \
 "
RDEPENDS:gmime30-devel = " \
 glib2-devel \
 gmime30 \
 pkgconf-pkg-config \
 "
