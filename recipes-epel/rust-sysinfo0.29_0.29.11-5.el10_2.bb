# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sysinfo0.29"
PV = "0.29.11"
PR = "5.el10_2"
PACKAGES = " \
 rust-sysinfo0.29+c-interface-devel \
 rust-sysinfo0.29+debug-devel \
 rust-sysinfo0.29+default-devel \
 rust-sysinfo0.29+multithread-devel \
 rust-sysinfo0.29+rayon-devel \
 rust-sysinfo0.29+serde-devel \
 rust-sysinfo0.29-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sysinfo0.29-0.29.11-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03bb8a07b50454623bffa81894f93a2cf4312bdefe19e090925b7767dedcc2f9"

URI_x86_64_v2_rust-sysinfo0.29+c-interface-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+c-interface-devel-0.29.11-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+c-interface-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+c-interface-devel.sha256sum] = "ccba5533a2452e33efb83c59be76f390fea52c8c6286235358921e9e608d86d0"

URI_x86_64_v2_rust-sysinfo0.29+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+debug-devel-0.29.11-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+debug-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+debug-devel.sha256sum] = "dacfc94fdbd09cb496fe25921ba42d3ed1ecb3ea542a8160c4ee3288d26d3540"

URI_x86_64_v2_rust-sysinfo0.29+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+default-devel-0.29.11-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+default-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+default-devel.sha256sum] = "20b52d39886160f8631f6a8b80b84fb95bda66776f785bdd7224d7f0ccf4cfbf"

URI_x86_64_v2_rust-sysinfo0.29+multithread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+multithread-devel-0.29.11-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+multithread-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+multithread-devel.sha256sum] = "718e070ac57eb44f8f98b4babd8d23c63a49e53d1a045c8436d6d441abcd24f0"

URI_x86_64_v2_rust-sysinfo0.29+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+rayon-devel-0.29.11-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+rayon-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+rayon-devel.sha256sum] = "341b08498f61dda316d5c4fa7efc50a5ae6ecbe4a7d6786453c6ae022c73cafd"

URI_x86_64_v2_rust-sysinfo0.29+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29+serde-devel-0.29.11-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29+serde-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29+serde-devel.sha256sum] = "004aa7235609ae62f73a22ad32e4624cbb07b28862e8ccf295350abeccff8c25"

URI_x86_64_v2_rust-sysinfo0.29-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sysinfo0.29-devel-0.29.11-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sysinfo0.29-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sysinfo0.29-devel}"
SRC_URI[x86_64_v2_rust-sysinfo0.29-devel.sha256sum] = "d24b49e14719f7969c2bc825cace552b38c777d7b02b3dda32c2030a6ab1a432"

URI_aarch64_rust-sysinfo0.29+c-interface-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+c-interface-devel-0.29.11-5.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.29+c-interface-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+c-interface-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+c-interface-devel.sha256sum] = "a2e25c74f8c308198d136fbcddb44ec7854df6876e03f2f766e1d9dcfe36cc12"

URI_aarch64_rust-sysinfo0.29+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+debug-devel-0.29.11-5.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.29+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+debug-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+debug-devel.sha256sum] = "eac79844130b11ec83bc6355e885b3e078447655b6c8bd3b2ee8d5b8b4a616df"

URI_aarch64_rust-sysinfo0.29+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+default-devel-0.29.11-5.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.29+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+default-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+default-devel.sha256sum] = "66b24d4b00f05ae5ad54102c2d518afa9c539b3012bcff969f8df108c49cffa3"

URI_aarch64_rust-sysinfo0.29+multithread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+multithread-devel-0.29.11-5.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.29+multithread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+multithread-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+multithread-devel.sha256sum] = "39df774f9c8bf3f7aeef1f7796e50f91e228076ce5fb894fb26eb59a9410504d"

URI_aarch64_rust-sysinfo0.29+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+rayon-devel-0.29.11-5.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.29+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+rayon-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+rayon-devel.sha256sum] = "5e2f57b9ff7dcb306bfe380d24727b05d4c63a0a6918c5198a3308a94804ee5c"

URI_aarch64_rust-sysinfo0.29+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29+serde-devel-0.29.11-5.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.29+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29+serde-devel}"
SRC_URI[aarch64_rust-sysinfo0.29+serde-devel.sha256sum] = "dee1bcf57e42df2a76ac419349f27ceda79f6eaca050582316cfe2accab93409"

URI_aarch64_rust-sysinfo0.29-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sysinfo0.29-devel-0.29.11-5.el10_2.noarch.rpm;name=aarch64_rust-sysinfo0.29-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sysinfo0.29-devel}"
SRC_URI[aarch64_rust-sysinfo0.29-devel.sha256sum] = "8a7dc1fcb7a27655f74ad630f4feb5d21f94080c89d890ea47661daf5217021d"

RDEPENDS:rust-sysinfo0.29+c-interface-devel = " \
 cargo \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+debug-devel = " \
 cargo \
 rust-libc+extra_traits-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+default-devel = " \
 cargo \
 rust-sysinfo0.29+multithread-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+multithread-devel = " \
 cargo \
 rust-sysinfo0.29+rayon-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+rayon-devel = " \
 cargo \
 rust-rayon+default-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-sysinfo0.29-devel \
 "
RDEPENDS:rust-sysinfo0.29-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-once_cell+default-devel \
 "
