# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmodbus"
PV = "3.1.12"
PR = "1.el10_2"
PACKAGES = " \
 libmodbus \
 libmodbus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmodbus-3.1.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d844a9f0ec4bff052d6b62f5f78d63381b8e5f0cf5f140925a82bec186e6901"

URI_x86_64_v2_libmodbus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmodbus-3.1.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmodbus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmodbus}"
SRC_URI[x86_64_v2_libmodbus.sha256sum] = "c672a5a7f3b09523073187b086989d125229b7c21bf2f656a2c4fc919e5d65ae"

URI_x86_64_v2_libmodbus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmodbus-devel-3.1.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmodbus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmodbus-devel}"
SRC_URI[x86_64_v2_libmodbus-devel.sha256sum] = "7a1edebdc4fda5574d29b0bd2dfce070e23dc558ccfac828e71193b1eaa018d6"

URI_aarch64_libmodbus = "${EPEL_MIRROR}/aarch64/Packages/l/libmodbus-3.1.12-1.el10_2.aarch64.rpm;name=aarch64_libmodbus;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmodbus}"
SRC_URI[aarch64_libmodbus.sha256sum] = "e287be3bf41c5a45e6c1d79ea027d30de7efac0effb780ad9dedcfa90e25f50c"

URI_aarch64_libmodbus-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmodbus-devel-3.1.12-1.el10_2.aarch64.rpm;name=aarch64_libmodbus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmodbus-devel}"
SRC_URI[aarch64_libmodbus-devel.sha256sum] = "021ca214ec8b74a1d4a616706e9921d5d41b5409faaac8a9abb36ef485c84f78"

RDEPENDS:libmodbus = " \
 glibc \
 "
RDEPENDS:libmodbus-devel = " \
 libmodbus \
 pkgconf-pkg-config \
 "
