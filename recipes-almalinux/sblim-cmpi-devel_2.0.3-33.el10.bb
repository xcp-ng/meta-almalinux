# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sblim-cmpi-devel"
PV = "2.0.3"
PR = "33.el10"
PACKAGES = " \
 libcmpiCppImpl0 \
 sblim-cmpi-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sblim-cmpi-devel-2.0.3-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd1c5cdeeaa2177ae06884063cd51b14c03e0e104da513b8160871a08e2204f6"

URI_x86_64_v2_libcmpiCppImpl0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcmpiCppImpl0-2.0.3-33.el10.x86_64_v2.rpm;name=x86_64_v2_libcmpiCppImpl0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcmpiCppImpl0}"
SRC_URI[x86_64_v2_libcmpiCppImpl0.sha256sum] = "19ae61a9139add24b945efe44617eb3dbf6306471419ab2b272dcea386784004"

URI_x86_64_v2_sblim-cmpi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/sblim-cmpi-devel-2.0.3-33.el10.x86_64_v2.rpm;name=x86_64_v2_sblim-cmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sblim-cmpi-devel}"
SRC_URI[x86_64_v2_sblim-cmpi-devel.sha256sum] = "afb5a826c2f3523bb4bff4181c21fab6fe8c109414a807b5c2e0c1cad56625d9"

URI_aarch64_libcmpiCppImpl0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcmpiCppImpl0-2.0.3-33.el10.aarch64.rpm;name=aarch64_libcmpiCppImpl0;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcmpiCppImpl0}"
SRC_URI[aarch64_libcmpiCppImpl0.sha256sum] = "dbb9ec4981e6ae1feb79716fdd5416b245e94c6452b0dd044c81cf1147e381da"

URI_aarch64_sblim-cmpi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/sblim-cmpi-devel-2.0.3-33.el10.aarch64.rpm;name=aarch64_sblim-cmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sblim-cmpi-devel}"
SRC_URI[aarch64_sblim-cmpi-devel.sha256sum] = "9bbbc8a4fc0190fcfa49102ac56425881f3ac5730b0fbc059b33dd2eb6672e80"

RDEPENDS:libcmpiCppImpl0 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:sblim-cmpi-devel = " \
 "
