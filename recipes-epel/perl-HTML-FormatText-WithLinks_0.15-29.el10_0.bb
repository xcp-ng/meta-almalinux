# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTML-FormatText-WithLinks"
PV = "0.15"
PR = "29.el10_0"
PACKAGES = " \
 perl-HTML-FormatText-WithLinks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-HTML-FormatText-WithLinks-0.15-29.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "263c3948ea0b414ccb4c82d94cb1278567ff75d9f4e62a8b0ac1e1ec5832381a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTML-FormatText-WithLinks-0.15-29.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTML-FormatText-WithLinks;unpack=0"
SRC_URI[x86_64_v2_perl-HTML-FormatText-WithLinks.sha256sum] = "d6bb372e701858efac8943be0fa2f05835294fd9a101b8be355b95cf37e75550"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-HTML-FormatText-WithLinks-0.15-29.el10_0.noarch.rpm;name=aarch64_perl-HTML-FormatText-WithLinks;unpack=0"
SRC_URI[aarch64_perl-HTML-FormatText-WithLinks.sha256sum] = "804f78c4f98b19a0fa72a2119a37bb0f49a502049f034debe57010cb58964fad"

RDEPENDS:perl-HTML-FormatText-WithLinks = " \
 perl-HTML-Formatter \
 perl-HTML-Tree \
 perl-URI \
 perl-base \
 perl-libs \
 perl-vars \
 "
