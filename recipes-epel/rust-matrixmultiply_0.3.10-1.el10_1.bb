# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matrixmultiply"
PV = "0.3.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-matrixmultiply+cgemm-devel \
 rust-matrixmultiply+constconf-devel \
 rust-matrixmultiply+default-devel \
 rust-matrixmultiply+num_cpus-devel \
 rust-matrixmultiply+once_cell-devel \
 rust-matrixmultiply+std-devel \
 rust-matrixmultiply+thread-tree-devel \
 rust-matrixmultiply+threading-devel \
 rust-matrixmultiply-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matrixmultiply-0.3.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2300a54835c14f11fa81322b7103332dede2bb3dde47e8908ec247b17bcdea3"

URI_x86_64_v2_rust-matrixmultiply+cgemm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixmultiply+cgemm-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixmultiply+cgemm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixmultiply+cgemm-devel}"
SRC_URI[x86_64_v2_rust-matrixmultiply+cgemm-devel.sha256sum] = "b607230219074abeb05bd99a91d88e3200f93b98d6745dd86fdc8f0989158675"

URI_x86_64_v2_rust-matrixmultiply+constconf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixmultiply+constconf-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixmultiply+constconf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixmultiply+constconf-devel}"
SRC_URI[x86_64_v2_rust-matrixmultiply+constconf-devel.sha256sum] = "4b3d293e3fe0d46309b7c96cbe77eac729b2cdba705592ece9d002052d6a2360"

URI_x86_64_v2_rust-matrixmultiply+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixmultiply+default-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixmultiply+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixmultiply+default-devel}"
SRC_URI[x86_64_v2_rust-matrixmultiply+default-devel.sha256sum] = "cb1aa5bd4c9250f95b06d159dc3f0d18fec3861664342c7c6a44860df350c4ce"

URI_x86_64_v2_rust-matrixmultiply+num_cpus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixmultiply+num_cpus-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixmultiply+num_cpus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixmultiply+num_cpus-devel}"
SRC_URI[x86_64_v2_rust-matrixmultiply+num_cpus-devel.sha256sum] = "4745bdf56be8bf071004bd0ebcefa93587c6267e21b1344ad2590a30cd880ebb"

URI_x86_64_v2_rust-matrixmultiply+once_cell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixmultiply+once_cell-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixmultiply+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixmultiply+once_cell-devel}"
SRC_URI[x86_64_v2_rust-matrixmultiply+once_cell-devel.sha256sum] = "493ecad0d81de1172307aa33dff54201acb130733e85f1f041e02bb4d7c27f0a"

URI_x86_64_v2_rust-matrixmultiply+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixmultiply+std-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixmultiply+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixmultiply+std-devel}"
SRC_URI[x86_64_v2_rust-matrixmultiply+std-devel.sha256sum] = "b3f852cbc5385c989a24b39af79e707962063142cb91a118c5bb8ac006ae566b"

URI_x86_64_v2_rust-matrixmultiply+thread-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixmultiply+thread-tree-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixmultiply+thread-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixmultiply+thread-tree-devel}"
SRC_URI[x86_64_v2_rust-matrixmultiply+thread-tree-devel.sha256sum] = "87ee347477a7fe02770d4ba79f9c1427f0c3efbb797a7072741765a613eb0b6f"

URI_x86_64_v2_rust-matrixmultiply+threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixmultiply+threading-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixmultiply+threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixmultiply+threading-devel}"
SRC_URI[x86_64_v2_rust-matrixmultiply+threading-devel.sha256sum] = "f67b916aa959f020c63d72a859cb9220762034624e0e0d21cf43c7d701087d7f"

URI_x86_64_v2_rust-matrixmultiply-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matrixmultiply-devel-0.3.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matrixmultiply-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matrixmultiply-devel}"
SRC_URI[x86_64_v2_rust-matrixmultiply-devel.sha256sum] = "8663836daba26948ec4dbac8361d095005261a25657f7ae8190e7628998a709f"

URI_aarch64_rust-matrixmultiply+cgemm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixmultiply+cgemm-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-matrixmultiply+cgemm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixmultiply+cgemm-devel}"
SRC_URI[aarch64_rust-matrixmultiply+cgemm-devel.sha256sum] = "8296d2bda8ebb3d0e14a3642543f85f4a7edd77af6aed1ac6b65e7cb24f02f27"

URI_aarch64_rust-matrixmultiply+constconf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixmultiply+constconf-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-matrixmultiply+constconf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixmultiply+constconf-devel}"
SRC_URI[aarch64_rust-matrixmultiply+constconf-devel.sha256sum] = "08256fd6286713ad3014db4127bc08c6df8d68c7b004fb1dbcf3d62cedb7897d"

URI_aarch64_rust-matrixmultiply+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixmultiply+default-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-matrixmultiply+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixmultiply+default-devel}"
SRC_URI[aarch64_rust-matrixmultiply+default-devel.sha256sum] = "f51010bc11f54b7d96deeb3bb5ff0ecea8ad203ac3f5a8fa5144aedbac064007"

URI_aarch64_rust-matrixmultiply+num_cpus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixmultiply+num_cpus-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-matrixmultiply+num_cpus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixmultiply+num_cpus-devel}"
SRC_URI[aarch64_rust-matrixmultiply+num_cpus-devel.sha256sum] = "bebfb103f62f3d63eac9f63bde1df45c547103a084e619e8559bb21339cc9818"

URI_aarch64_rust-matrixmultiply+once_cell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixmultiply+once_cell-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-matrixmultiply+once_cell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixmultiply+once_cell-devel}"
SRC_URI[aarch64_rust-matrixmultiply+once_cell-devel.sha256sum] = "ef62f261f79c62b8f186988d5aa28f3d24787fc0a89004a3b834142f03675a74"

URI_aarch64_rust-matrixmultiply+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixmultiply+std-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-matrixmultiply+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixmultiply+std-devel}"
SRC_URI[aarch64_rust-matrixmultiply+std-devel.sha256sum] = "ea55fed98daf03499fdf4172c2c0183cf1e8f8348a9b8df8074f6d24da5e0988"

URI_aarch64_rust-matrixmultiply+thread-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixmultiply+thread-tree-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-matrixmultiply+thread-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixmultiply+thread-tree-devel}"
SRC_URI[aarch64_rust-matrixmultiply+thread-tree-devel.sha256sum] = "d82addae899d66a4e2198ec25640a591d99528a3b71d8ee99e01a5384b11e6d3"

URI_aarch64_rust-matrixmultiply+threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixmultiply+threading-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-matrixmultiply+threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixmultiply+threading-devel}"
SRC_URI[aarch64_rust-matrixmultiply+threading-devel.sha256sum] = "21311a1e62d480352f4749595cd646ac62d6337b58fab62476b9be35ac09e289"

URI_aarch64_rust-matrixmultiply-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matrixmultiply-devel-0.3.10-1.el10_1.noarch.rpm;name=aarch64_rust-matrixmultiply-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matrixmultiply-devel}"
SRC_URI[aarch64_rust-matrixmultiply-devel.sha256sum] = "43f2bfcca4c21456a2e04b310e472b4517d9c8fef8ecc8e83ef0f0c80e6b9606"

RDEPENDS:rust-matrixmultiply+cgemm-devel = " \
 cargo \
 rust-matrixmultiply-devel \
 "
RDEPENDS:rust-matrixmultiply+constconf-devel = " \
 cargo \
 rust-matrixmultiply-devel \
 "
RDEPENDS:rust-matrixmultiply+default-devel = " \
 cargo \
 rust-matrixmultiply+std-devel \
 rust-matrixmultiply-devel \
 "
RDEPENDS:rust-matrixmultiply+num_cpus-devel = " \
 cargo \
 rust-matrixmultiply-devel \
 rust-num_cpus+default-devel \
 "
RDEPENDS:rust-matrixmultiply+once_cell-devel = " \
 cargo \
 rust-matrixmultiply-devel \
 rust-once_cell+default-devel \
 "
RDEPENDS:rust-matrixmultiply+std-devel = " \
 cargo \
 rust-matrixmultiply-devel \
 "
RDEPENDS:rust-matrixmultiply+thread-tree-devel = " \
 cargo \
 rust-matrixmultiply-devel \
 rust-thread-tree+default-devel \
 "
RDEPENDS:rust-matrixmultiply+threading-devel = " \
 cargo \
 rust-matrixmultiply+num_cpus-devel \
 rust-matrixmultiply+once_cell-devel \
 rust-matrixmultiply+std-devel \
 rust-matrixmultiply+thread-tree-devel \
 rust-matrixmultiply-devel \
 "
RDEPENDS:rust-matrixmultiply-devel = " \
 bash \
 cargo \
 python3 \
 rust-autocfg+default-devel \
 rust-rawpointer+default-devel \
 "
