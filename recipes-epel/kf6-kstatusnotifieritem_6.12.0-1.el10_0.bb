# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kstatusnotifieritem"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kstatusnotifieritem \
 kf6-kstatusnotifieritem-devel \
 kf6-kstatusnotifieritem-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kstatusnotifieritem-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "430a123da3abe95eb02e773479e53681f2f19d407fd3e448dc6b84d7e73c3e49"

URI_x86_64_v2_kf6-kstatusnotifieritem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem.sha256sum] = "64d2ff0d878d3c1bdc1d26de7e2a22a1e5481d975e08f634255b3e3bbc84a5db"

URI_x86_64_v2_kf6-kstatusnotifieritem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-devel}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-devel.sha256sum] = "b880f0c72f09aba43b8062acb0057e6b3f49eff11d413d94f3af8b1cdfd8f711"

URI_x86_64_v2_kf6-kstatusnotifieritem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kstatusnotifieritem-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kstatusnotifieritem-doc}"
SRC_URI[x86_64_v2_kf6-kstatusnotifieritem-doc.sha256sum] = "25aa9cfe1c77a39ac1a62ead8c9f4b6bac3622fa7caf77c19ab94dcf4c712a56"

URI_aarch64_kf6-kstatusnotifieritem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem}"
SRC_URI[aarch64_kf6-kstatusnotifieritem.sha256sum] = "7149879e0fe9119eb06651ee715bdcea75a1f89ba1cfde1818968ee2dc5a1047"

URI_aarch64_kf6-kstatusnotifieritem-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kstatusnotifieritem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-devel}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-devel.sha256sum] = "f291f8206debbfdf45f67fda0309a908d6c5f91ad21225a15d45aa57e83df738"

URI_aarch64_kf6-kstatusnotifieritem-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kstatusnotifieritem-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kstatusnotifieritem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kstatusnotifieritem-doc}"
SRC_URI[aarch64_kf6-kstatusnotifieritem-doc.sha256sum] = "59d76a49115f1ca37db5cfcc00ec42e9995c3335a69f966b83635f76f5bea488"

RDEPENDS:kf6-kstatusnotifieritem = " \
 glibc \
 kf6-filesystem \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kstatusnotifieritem-devel = " \
 cmake-filesystem \
 kf6-kstatusnotifieritem \
 "
RDEPENDS:kf6-kstatusnotifieritem-doc = " \
 "
