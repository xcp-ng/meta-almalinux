# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete_nushell"
PV = "4.5.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-clap_complete_nushell+default-devel \
 rust-clap_complete_nushell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete_nushell-4.5.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87894a3593b13586f352048fa6f71bef9f39abb515cb2b6aa6cee04e78e004f2"

URI_x86_64_v2_rust-clap_complete_nushell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_nushell+default-devel-4.5.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_nushell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_nushell+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_nushell+default-devel.sha256sum] = "4e3e510392ef96dcd3f5d3e4148f56c891383d6c38fb9a06771914b125a963f8"

URI_x86_64_v2_rust-clap_complete_nushell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete_nushell-devel-4.5.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete_nushell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete_nushell-devel}"
SRC_URI[x86_64_v2_rust-clap_complete_nushell-devel.sha256sum] = "f1d6f81091e66a4961e6f71914bd0b0fc69f496ed28710f29327b4f6f2a3db5d"

URI_aarch64_rust-clap_complete_nushell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_nushell+default-devel-4.5.10-1.el10_1.noarch.rpm;name=aarch64_rust-clap_complete_nushell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_nushell+default-devel}"
SRC_URI[aarch64_rust-clap_complete_nushell+default-devel.sha256sum] = "1970794f14b3aed02c385e357168e169ef018816a4d42fdd522d88b6f2cff494"

URI_aarch64_rust-clap_complete_nushell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete_nushell-devel-4.5.10-1.el10_1.noarch.rpm;name=aarch64_rust-clap_complete_nushell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete_nushell-devel}"
SRC_URI[aarch64_rust-clap_complete_nushell-devel.sha256sum] = "a2a2e716b8ef79e0155b5e0c4a7b9278707d7964a68eaf5142fad2d5dce82f49"

RDEPENDS:rust-clap_complete_nushell+default-devel = " \
 cargo \
 rust-clap_complete_nushell-devel \
 "
RDEPENDS:rust-clap_complete_nushell-devel = " \
 cargo \
 rust \
 rust-clap+std-devel \
 rust-clap-devel \
 rust-clap_complete+default-devel \
 "
