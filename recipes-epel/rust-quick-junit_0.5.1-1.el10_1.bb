# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-junit"
PV = "0.5.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-quick-junit+default-devel \
 rust-quick-junit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-junit-0.5.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31a8b1f9ffc667752e1ed2e8f89ef1de365676a563c416f30415498fa621d151"

URI_x86_64_v2_rust-quick-junit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-junit+default-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-junit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-junit+default-devel}"
SRC_URI[x86_64_v2_rust-quick-junit+default-devel.sha256sum] = "1634da50d959b1292096567ce89eb0a918970239c6d5e288923f89f31434af2a"

URI_x86_64_v2_rust-quick-junit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-junit-devel-0.5.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-junit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-junit-devel}"
SRC_URI[x86_64_v2_rust-quick-junit-devel.sha256sum] = "db957c42afc87d8330380530934d48f3c9bf0d30d5d9e3a9a2fc5c060e279a84"

URI_aarch64_rust-quick-junit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-junit+default-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-quick-junit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-junit+default-devel}"
SRC_URI[aarch64_rust-quick-junit+default-devel.sha256sum] = "1a4f313169c3c601eecf4cf79ff771b6ed6c8beb168334acf94c7a7ff36c10d3"

URI_aarch64_rust-quick-junit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-junit-devel-0.5.1-1.el10_1.noarch.rpm;name=aarch64_rust-quick-junit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-junit-devel}"
SRC_URI[aarch64_rust-quick-junit-devel.sha256sum] = "fcc5999cf2f18d3cfeff8fefce0a96c987970b1f0dbec62fcaca00863a1116a2"

RDEPENDS:rust-quick-junit+default-devel = " \
 cargo \
 rust-quick-junit-devel \
 "
RDEPENDS:rust-quick-junit-devel = " \
 bash \
 cargo \
 rust \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-indexmap+default-devel \
 rust-newtype-uuid+default-devel \
 rust-quick-xml0.37+default-devel \
 rust-strip-ansi-escapes+default-devel \
 rust-thiserror+default-devel \
 rust-uuid+default-devel \
 "
