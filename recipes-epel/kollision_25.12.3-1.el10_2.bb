# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kollision"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kollision \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kollision-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1ea535898762d8b1d458dd5c1499ac8b2a0397471947a9c0c0df4b98bf058c4"

URI_x86_64_v2_kollision = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kollision-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kollision;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kollision}"
SRC_URI[x86_64_v2_kollision.sha256sum] = "fdb0d0c8d062e4416f4932233063b2801c14c54b1f0c7cf8ef0a405587fbbbc0"

URI_aarch64_kollision = "${EPEL_MIRROR}/aarch64/Packages/k/kollision-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kollision;unpack=0"
SRC_URI:append = " ${URI_aarch64_kollision}"
SRC_URI[aarch64_kollision.sha256sum] = "a5facc8ed9f4ad02fa2459e048d33da164ff9339b9a8cd4eb53fa3927a3766c0"

RDEPENDS:kollision = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
