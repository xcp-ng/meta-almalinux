# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-heapless0.8"
PV = "0.8.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-heapless0.8+default-devel \
 rust-heapless0.8+mpmc_large-devel \
 rust-heapless0.8+portable-atomic-critical-section-devel \
 rust-heapless0.8+portable-atomic-devel \
 rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel \
 rust-heapless0.8+serde-devel \
 rust-heapless0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-heapless0.8-0.8.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "864f379800cc3244cc650266384c1edac286b5828419d6704ab9ab40e6013cee"

URI_x86_64_v2_rust-heapless0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.8+default-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.8+default-devel}"
SRC_URI[x86_64_v2_rust-heapless0.8+default-devel.sha256sum] = "a11c9e2970559e8accce55838523fa6444001df2ad812c552b877c265bcd1a75"
RPROVIDES:rust-heapless0.8+default-devel:x86_64_v2 = "virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

URI_x86_64_v2_rust-heapless0.8+mpmc_large-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.8+mpmc_large-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.8+mpmc_large-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.8+mpmc_large-devel}"
SRC_URI[x86_64_v2_rust-heapless0.8+mpmc_large-devel.sha256sum] = "1d379ca5bda13ff40447d518dbdfa0e1d2dbcfe23e1d494285a4bfc4a407edde"

URI_x86_64_v2_rust-heapless0.8+portable-atomic-critical-section-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.8+portable-atomic-critical-section-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.8+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.8+portable-atomic-critical-section-devel}"
SRC_URI[x86_64_v2_rust-heapless0.8+portable-atomic-critical-section-devel.sha256sum] = "8567402da19b59ed9f10220b52e9f0db5e95560762dc262154dc61496fab9e21"

URI_x86_64_v2_rust-heapless0.8+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.8+portable-atomic-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.8+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.8+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-heapless0.8+portable-atomic-devel.sha256sum] = "23ea6a7fbda4b23f867288cd6cba50d15fdba2af51bdcc6cc7bbc898c346a8c7"

URI_x86_64_v2_rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel}"
SRC_URI[x86_64_v2_rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel.sha256sum] = "a216f2d505417e3d383a1080d052165467fb6025fc2a27cd5865bcb920cd0007"

URI_x86_64_v2_rust-heapless0.8+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.8+serde-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.8+serde-devel}"
SRC_URI[x86_64_v2_rust-heapless0.8+serde-devel.sha256sum] = "f600d39b9cfa03c7b05fd3dde9addccaf3641d42192f2cb879c11933ab395c8b"

URI_x86_64_v2_rust-heapless0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-heapless0.8-devel-0.8.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-heapless0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-heapless0.8-devel}"
SRC_URI[x86_64_v2_rust-heapless0.8-devel.sha256sum] = "b3a081b6259ddecc604c7d4a48ef49efef6ee6cad07089dd5d6016a2e0459267"

URI_aarch64_rust-heapless0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.8+default-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-heapless0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.8+default-devel}"
SRC_URI[aarch64_rust-heapless0.8+default-devel.sha256sum] = "bbe5a0078a3b735ea5ed672b3b637e5d5ba814a57e16eda1558da68a956c555e"
RPROVIDES:rust-heapless0.8+default-devel:aarch64 = "virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

URI_aarch64_rust-heapless0.8+mpmc_large-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.8+mpmc_large-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-heapless0.8+mpmc_large-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.8+mpmc_large-devel}"
SRC_URI[aarch64_rust-heapless0.8+mpmc_large-devel.sha256sum] = "5df698e8dd3a2eeac6fe40b1e9d5f3d21ba6aae8869b77c2fc64ddae1e22a158"

URI_aarch64_rust-heapless0.8+portable-atomic-critical-section-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.8+portable-atomic-critical-section-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-heapless0.8+portable-atomic-critical-section-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.8+portable-atomic-critical-section-devel}"
SRC_URI[aarch64_rust-heapless0.8+portable-atomic-critical-section-devel.sha256sum] = "12adba640451537bb9172021f5296725e48975fdfdce16d3f1f2fffb74a5c4a4"

URI_aarch64_rust-heapless0.8+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.8+portable-atomic-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-heapless0.8+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.8+portable-atomic-devel}"
SRC_URI[aarch64_rust-heapless0.8+portable-atomic-devel.sha256sum] = "cf4ff682547c8ea9a59699a7ebcc5658db2e7ec64d0117578e1ab16a8cb772b3"

URI_aarch64_rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel}"
SRC_URI[aarch64_rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel.sha256sum] = "728e960223e32e54d8338d417ab1686841aa85a649d9527eca97084b7a41076f"

URI_aarch64_rust-heapless0.8+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.8+serde-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-heapless0.8+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.8+serde-devel}"
SRC_URI[aarch64_rust-heapless0.8+serde-devel.sha256sum] = "891a80adfb6ba773f21b436d78ef7e5e295bce0eb56c763a445c366a26970f3b"

URI_aarch64_rust-heapless0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-heapless0.8-devel-0.8.0-1.el10_3.noarch.rpm;name=aarch64_rust-heapless0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-heapless0.8-devel}"
SRC_URI[aarch64_rust-heapless0.8-devel.sha256sum] = "c6040df8f3c1bd1b47a4445463521cbde6e60e8d37a43ec9538d7a95220cab58"

RDEPENDS:rust-heapless0.8+default-devel = " \
 cargo \
 rust-heapless0.8-devel \
 "
RDEPENDS:rust-heapless0.8+mpmc_large-devel = " \
 cargo \
 rust-heapless0.8-devel \
 "
RDEPENDS:rust-heapless0.8+portable-atomic-critical-section-devel = " \
 cargo \
 rust-heapless0.8+portable-atomic-devel \
 rust-heapless0.8-devel \
 rust-portable-atomic+critical-section-devel \
 rust-portable-atomic+default-devel \
 "
RDEPENDS:rust-heapless0.8+portable-atomic-devel = " \
 cargo \
 rust-heapless0.8-devel \
 rust-portable-atomic+default-devel \
 "
RDEPENDS:rust-heapless0.8+portable-atomic-unsafe-assume-single-core-devel = " \
 cargo \
 rust-heapless0.8+portable-atomic-devel \
 rust-heapless0.8-devel \
 rust-portable-atomic+default-devel \
 rust-portable-atomic+unsafe-assume-single-core-devel \
 "
RDEPENDS:rust-heapless0.8+serde-devel = " \
 cargo \
 rust-heapless0.8-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-heapless0.8-devel = " \
 cargo \
 rust-hash32+default-devel \
 rust-stable_deref_trait-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_heapless/default__ge_0.0.0_with_crate_heapless/default__lt_1.0.0~"
