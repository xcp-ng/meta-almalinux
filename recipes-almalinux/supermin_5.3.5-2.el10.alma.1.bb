# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "supermin"
PV = "5.3.5"
PR = "2.el10.alma.1"
PACKAGES = " \
 supermin \
 supermin-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/supermin-5.3.5-2.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3259d2a0144a4b560d190330704d709481dd5d7b02c8889695d88f4f67bd71a4"

URI_x86_64_v2_supermin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/supermin-5.3.5-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_supermin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supermin}"
SRC_URI[x86_64_v2_supermin.sha256sum] = "f55029a8c96083281385b6c3fcb528d03581adae6694b089d8309e6be6fc2eb3"

URI_x86_64_v2_supermin-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/supermin-devel-5.3.5-2.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_supermin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_supermin-devel}"
SRC_URI[x86_64_v2_supermin-devel.sha256sum] = "43eebfdca9a8ad2eae4e6b42062c163aa23f72105e2ec77aebd864eb4d8bf4ba"

URI_aarch64_supermin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/supermin-5.3.5-2.el10.alma.1.aarch64.rpm;name=aarch64_supermin;unpack=0"
SRC_URI:append = " ${URI_aarch64_supermin}"
SRC_URI[aarch64_supermin.sha256sum] = "1c626dfd4eebdf5b87e72224aaead1f7209f33b87fa47c0b7aa5c4f94f96b93c"

URI_aarch64_supermin-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/supermin-devel-5.3.5-2.el10.alma.1.aarch64.rpm;name=aarch64_supermin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_supermin-devel}"
SRC_URI[aarch64_supermin-devel.sha256sum] = "733b4ca617fc3f914a7f74db55cea58d322a26b5ad69f797fe2dcfe235a8ffb1"

RDEPENDS:supermin = " \
 cpio \
 e2fsprogs \
 e2fsprogs-libs \
 glibc \
 libcom_err \
 rpm \
 rpm-libs \
 tar \
 util-linux \
 "
RDEPENDS:supermin-devel = " \
 bash \
 dnf \
 dnf-plugins-core \
 findutils \
 rpm-build \
 supermin \
 "
