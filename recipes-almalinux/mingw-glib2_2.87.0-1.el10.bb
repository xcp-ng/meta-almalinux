# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-glib2"
PV = "2.87.0"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 mingw32-glib2 \
 mingw32-glib2-static \
 mingw64-glib2 \
 mingw64-glib2-static \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-glib2-2.87.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "192550377df8dbc8078c05280599a2082065f9fdae654276b5a2b65b845de6f3"

URI_x86_64_v2_mingw32-glib2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-glib2-2.87.0-1.el10.noarch.rpm;name=x86_64_v2_mingw32-glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-glib2}"
SRC_URI[x86_64_v2_mingw32-glib2.sha256sum] = "71f0696f3c21329d4b6bd97eac360cc9494b2a9a6514c8284de7460c2aebba0c"

URI_x86_64_v2_mingw32-glib2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-glib2-static-2.87.0-1.el10.noarch.rpm;name=x86_64_v2_mingw32-glib2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-glib2-static}"
SRC_URI[x86_64_v2_mingw32-glib2-static.sha256sum] = "bf1ab4eb25d4a23ceada04fabbab6ef9341eeea3e63c26dc72e5a48bf6396040"

URI_x86_64_v2_mingw64-glib2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-glib2-2.87.0-1.el10.noarch.rpm;name=x86_64_v2_mingw64-glib2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-glib2}"
SRC_URI[x86_64_v2_mingw64-glib2.sha256sum] = "42ed093bc3dc8f1fc68c689c21d0a4564f64be06967ea58288c572bee38fed74"

URI_x86_64_v2_mingw64-glib2-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-glib2-static-2.87.0-1.el10.noarch.rpm;name=x86_64_v2_mingw64-glib2-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-glib2-static}"
SRC_URI[x86_64_v2_mingw64-glib2-static.sha256sum] = "f037d4e7d160fa4ad0236a023dfa1dcfa15df8271ab9d34b0ff381254eec7224"

RDEPENDS:mingw32-glib2 = " \
 bash \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-gettext \
 mingw32-libffi \
 mingw32-libgcc \
 mingw32-pcre2 \
 mingw32-zlib \
 python3 \
 "
RDEPENDS:mingw32-glib2-static = " \
 mingw32-gettext-static \
 mingw32-glib2 \
 "
RDEPENDS:mingw64-glib2 = " \
 bash \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-gettext \
 mingw64-libffi \
 mingw64-pcre2 \
 mingw64-zlib \
 python3 \
 "
RDEPENDS:mingw64-glib2-static = " \
 mingw64-gettext-static \
 mingw64-glib2 \
 "
