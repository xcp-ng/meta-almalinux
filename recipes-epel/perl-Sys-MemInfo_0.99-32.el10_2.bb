# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-MemInfo"
PV = "0.99"
PR = "32.el10_2"
PACKAGES = " \
 perl-Sys-MemInfo \
 perl-Sys-MemInfo-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-MemInfo-0.99-32.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e8d68cacfc1a3701284cf5457b5b3b5128a171c4e7405c1ddd3fe7161ffb6a5"

URI_x86_64_v2_perl-Sys-MemInfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-MemInfo-0.99-32.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-MemInfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-MemInfo}"
SRC_URI[x86_64_v2_perl-Sys-MemInfo.sha256sum] = "1fdbcf47ad7b16b772a808505b688f2de9d28997566159aef75e6ba8ce9ccd30"

URI_x86_64_v2_perl-Sys-MemInfo-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-MemInfo-tests-0.99-32.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sys-MemInfo-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-MemInfo-tests}"
SRC_URI[x86_64_v2_perl-Sys-MemInfo-tests.sha256sum] = "f648298acd2a3ecda44aad5a4f859fe05e7ce515310f2e9dc3cf7d855f80240f"

URI_aarch64_perl-Sys-MemInfo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-MemInfo-0.99-32.el10_2.aarch64.rpm;name=aarch64_perl-Sys-MemInfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-MemInfo}"
SRC_URI[aarch64_perl-Sys-MemInfo.sha256sum] = "370694e29b532f34ff4afa92b1a7dd174d1ca47be8aaf26425c7ac6ba0a873df"

URI_aarch64_perl-Sys-MemInfo-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-MemInfo-tests-0.99-32.el10_2.noarch.rpm;name=aarch64_perl-Sys-MemInfo-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-MemInfo-tests}"
SRC_URI[aarch64_perl-Sys-MemInfo-tests.sha256sum] = "ba6523350534f45fbd68f20059fd7b4296631a5d19c262995739c912da3e1f4f"

RDEPENDS:perl-Sys-MemInfo = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Sys-MemInfo-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Sys-MemInfo \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
