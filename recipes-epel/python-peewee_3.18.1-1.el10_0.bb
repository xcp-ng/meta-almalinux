# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-peewee"
PV = "3.18.1"
PR = "1.el10_0"
PACKAGES = " \
 python-peewee-docs \
 python3-peewee \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-peewee-3.18.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "87c6d2381013a1dc95bf28b56009de82fc8f91f85f5ff762b514799701ae6c32"

URI_x86_64_v2_python-peewee-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-peewee-docs-3.18.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-peewee-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-peewee-docs}"
SRC_URI[x86_64_v2_python-peewee-docs.sha256sum] = "df28582441afc4eba5caa3063341c7e280a1c2cdd04ec0dc54c20437dd423e1a"

URI_x86_64_v2_python3-peewee = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-peewee-3.18.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-peewee;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-peewee}"
SRC_URI[x86_64_v2_python3-peewee.sha256sum] = "adb4c935e131b6006f26a52793c67731430b34f7e5485841f1db4d3b0a0385e3"

URI_aarch64_python-peewee-docs = "${EPEL_MIRROR}/aarch64/Packages/p/python-peewee-docs-3.18.1-1.el10_0.aarch64.rpm;name=aarch64_python-peewee-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-peewee-docs}"
SRC_URI[aarch64_python-peewee-docs.sha256sum] = "251e1616f8b940e808151ba0d5a29ab41d3dd28424b7ccf4ac8815592906cc6f"

URI_aarch64_python3-peewee = "${EPEL_MIRROR}/aarch64/Packages/p/python3-peewee-3.18.1-1.el10_0.aarch64.rpm;name=aarch64_python3-peewee;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-peewee}"
SRC_URI[aarch64_python3-peewee.sha256sum] = "61e07625ba5b0128888304c243f18ee7d3e8900e32e2b93ddfb3095f8674c967"

RDEPENDS:python-peewee-docs = " \
 "
RDEPENDS:python3-peewee = " \
 glibc \
 python3 \
 sqlite-libs \
 "
