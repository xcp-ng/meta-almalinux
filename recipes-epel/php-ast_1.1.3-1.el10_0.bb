# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-ast"
PV = "1.1.3"
PR = "1.el10_0"
PACKAGES = " \
 php-ast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-ast-1.1.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2edd1377cc4146924abf5f1e3d772dfd30c7a9905ededc56ca362c8b283c656a"

URI_x86_64_v2_php-ast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-ast-1.1.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-ast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ast}"
SRC_URI[x86_64_v2_php-ast.sha256sum] = "6b4e612920036fae0e3b1ed3e7dcb61a4a0f55a4cd2ee7eb686c1a70728dacfb"

URI_aarch64_php-ast = "${EPEL_MIRROR}/aarch64/Packages/p/php-ast-1.1.3-1.el10_0.aarch64.rpm;name=aarch64_php-ast;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ast}"
SRC_URI[aarch64_php-ast.sha256sum] = "ebbba7d91eabc928a1ce47685d571a9dc590f7a8359cc25a5cad548ee5e1df49"

RDEPENDS:php-ast = " \
 glibc \
 php-common \
 "
