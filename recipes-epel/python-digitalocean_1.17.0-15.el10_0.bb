# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-digitalocean"
PV = "1.17.0"
PR = "15.el10_0"
PACKAGES = " \
 python3-digitalocean \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-digitalocean-1.17.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66af77959ec639402a2781dafc2d105d4b6647cc726a7c2bf0384aa5c57e059b"

URI_x86_64_v2_python3-digitalocean = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-digitalocean-1.17.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-digitalocean;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-digitalocean}"
SRC_URI[x86_64_v2_python3-digitalocean.sha256sum] = "dcaadf922d014358dabf6a791f54e5079654828c7ee0a1b7158f72794318c896"

URI_aarch64_python3-digitalocean = "${EPEL_MIRROR}/aarch64/Packages/p/python3-digitalocean-1.17.0-15.el10_0.noarch.rpm;name=aarch64_python3-digitalocean;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-digitalocean}"
SRC_URI[aarch64_python3-digitalocean.sha256sum] = "2c9fed2f0892ea43641b3f69969553f1edf0208717fd38b36692f0c94d5ca4db"

RDEPENDS:python3-digitalocean = " \
 python3 \
 python3-jsonpickle \
 python3-requests \
 "
