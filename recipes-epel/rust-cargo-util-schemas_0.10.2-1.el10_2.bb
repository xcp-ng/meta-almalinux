# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util-schemas"
PV = "0.10.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-cargo-util-schemas+default-devel \
 rust-cargo-util-schemas-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-schemas-0.10.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bb974a68469b398a1b40e28e0ba7031451fc10d48245c77cfe5319dc7847d40"

URI_x86_64_v2_rust-cargo-util-schemas+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-schemas+default-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-schemas+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util-schemas+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-util-schemas+default-devel.sha256sum] = "9c8cfab5b0f12e9a609a864896e0c505a5ccd60d19553aa37e0d9faaea09aeac"

URI_x86_64_v2_rust-cargo-util-schemas-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-schemas-devel-0.10.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-schemas-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-util-schemas-devel}"
SRC_URI[x86_64_v2_rust-cargo-util-schemas-devel.sha256sum] = "7157f56440265a6f60a031a1cd05cd7e6cc6524f42874276572b4565c32febe5"

URI_aarch64_rust-cargo-util-schemas+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-schemas+default-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-util-schemas+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util-schemas+default-devel}"
SRC_URI[aarch64_rust-cargo-util-schemas+default-devel.sha256sum] = "c1c453062281892d1cb5df1847bbc3ab29ed2a89f9ee4cf0349f758a2fab174c"

URI_aarch64_rust-cargo-util-schemas-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-schemas-devel-0.10.2-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-util-schemas-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-util-schemas-devel}"
SRC_URI[aarch64_rust-cargo-util-schemas-devel.sha256sum] = "42b0357bbf38a46ff811a8dd8c7c9855cc8f5c1184e9ba1d15707757a5358869"

RDEPENDS:rust-cargo-util-schemas+default-devel = " \
 cargo \
 rust-cargo-util-schemas-devel \
 "
RDEPENDS:rust-cargo-util-schemas-devel = " \
 cargo \
 rust \
 rust-semver+default-devel \
 rust-semver+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde-untagged+default-devel \
 rust-serde-value+default-devel \
 rust-thiserror+default-devel \
 rust-toml0.9+serde-devel \
 rust-toml0.9-devel \
 rust-unicode-xid+default-devel \
 rust-url+default-devel \
 "
