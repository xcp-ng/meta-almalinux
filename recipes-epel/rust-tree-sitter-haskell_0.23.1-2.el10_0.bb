# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-haskell"
PV = "0.23.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-tree-sitter-haskell+default-devel \
 rust-tree-sitter-haskell-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-haskell-0.23.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ae55e5120d697db9a6a7391a9396beaa3e0e190f441ff2cd299d7210442cc00"

URI_x86_64_v2_rust-tree-sitter-haskell+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-haskell+default-devel-0.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-haskell+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-haskell+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-haskell+default-devel.sha256sum] = "0ea0a0eaf2f720376becd48f41f2f3ef057fac8b0dba0879921a1604f95c9027"

URI_x86_64_v2_rust-tree-sitter-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-haskell-devel-0.23.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-haskell-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-haskell-devel.sha256sum] = "3c9f1c76ba71e91f0b79b031612957684a22f52373605b7694af8360e8289daf"

URI_aarch64_rust-tree-sitter-haskell+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-haskell+default-devel-0.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-haskell+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-haskell+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-haskell+default-devel.sha256sum] = "123f4fedac352da8a9165c3933c71ffe0ea1b1e140a1eb210e67d6dd4aa72cda"

URI_aarch64_rust-tree-sitter-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-haskell-devel-0.23.1-2.el10_0.noarch.rpm;name=aarch64_rust-tree-sitter-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-haskell-devel}"
SRC_URI[aarch64_rust-tree-sitter-haskell-devel.sha256sum] = "22cdc169579e25fea381bea76a1eca231daaec6c9ec82da38793cbd1e16bdde9"

RDEPENDS:rust-tree-sitter-haskell+default-devel = " \
 cargo \
 rust-tree-sitter-haskell-devel \
 "
RDEPENDS:rust-tree-sitter-haskell-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
