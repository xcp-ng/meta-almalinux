# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bdftopcf"
PV = "1.1.2"
PR = "1.el10_0"
PACKAGES = " \
 bdftopcf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bdftopcf-1.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39ae5b4e89193a753555dc9e2e65f5dfc6c8078e6335a42477f6a1b2b65feef2"

URI_x86_64_v2_bdftopcf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bdftopcf-1.1.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bdftopcf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bdftopcf}"
SRC_URI[x86_64_v2_bdftopcf.sha256sum] = "33f62a9cd8e50f7ae66c742a38dbb45666dc0ab4b43fccaa77be97f15300da5c"

URI_aarch64_bdftopcf = "${EPEL_MIRROR}/aarch64/Packages/b/bdftopcf-1.1.2-1.el10_0.aarch64.rpm;name=aarch64_bdftopcf;unpack=0"
SRC_URI:append = " ${URI_aarch64_bdftopcf}"
SRC_URI[aarch64_bdftopcf.sha256sum] = "ef32d147180c5da8ba94a8a74b474945791f41e85fed737d9404fd99231e98d9"

RDEPENDS:bdftopcf = " \
 glibc \
 "
