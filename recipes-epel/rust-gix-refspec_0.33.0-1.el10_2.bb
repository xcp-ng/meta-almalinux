# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-refspec"
PV = "0.33.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-refspec+default-devel \
 rust-gix-refspec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-refspec-0.33.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbf2e58221ab52a7db210c0bd3b7b9e28d75dbd5e9ff45e0c76d22357a8736ea"

URI_x86_64_v2_rust-gix-refspec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec+default-devel-0.33.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec+default-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec+default-devel.sha256sum] = "17cecd9541c8d6ce462f859452e9b6cc5eaf169404ae305c790ca84bae9585fd"

URI_x86_64_v2_rust-gix-refspec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-refspec-devel-0.33.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-refspec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-refspec-devel}"
SRC_URI[x86_64_v2_rust-gix-refspec-devel.sha256sum] = "b4a38a50badd0da02169ff9b47005da2c9dc942c3cdc37e421db5e6766e022ff"

URI_aarch64_rust-gix-refspec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec+default-devel-0.33.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-refspec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec+default-devel}"
SRC_URI[aarch64_rust-gix-refspec+default-devel.sha256sum] = "428d360d25088e58fb2e0a51ff6d139ddea58821d6130cc805237f0911b733d9"

URI_aarch64_rust-gix-refspec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-refspec-devel-0.33.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-refspec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-refspec-devel}"
SRC_URI[aarch64_rust-gix-refspec-devel.sha256sum] = "d4cd12e8808a718c90073875cec14f81286634cbd206c2fc5e18025feb51a656"

RDEPENDS:rust-gix-refspec+default-devel = " \
 cargo \
 rust-gix-refspec-devel \
 "
RDEPENDS:rust-gix-refspec-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-revision-devel \
 rust-gix-validate+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
