# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "CalcMySky"
PV = "0.4.0"
PR = "1.el10_2"
PACKAGES = " \
 CalcMySky \
 CalcMySky-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/c/CalcMySky-0.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "49002f1587ac9b31a7936f6d4066b7dade5e9ec50eb8648928a8c2dd6e8da41a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CalcMySky-0.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CalcMySky;unpack=0"
SRC_URI[x86_64_v2_CalcMySky.sha256sum] = "a7ac8431225965813f03fc84626845deac7e7ad543e999dc50da5c080072a406"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/CalcMySky-devel-0.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_CalcMySky-devel;unpack=0"
SRC_URI[x86_64_v2_CalcMySky-devel.sha256sum] = "d948088bebf5a7703009c6d073d694219584fc291d2efe9a5425cf0252ff40c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/CalcMySky-0.4.0-1.el10_2.aarch64.rpm;name=aarch64_CalcMySky;unpack=0"
SRC_URI[aarch64_CalcMySky.sha256sum] = "2089cd557833880224e01b2f25b74e3fc0ce9396ab2dd406ae6abc11719c4872"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/c/CalcMySky-devel-0.4.0-1.el10_2.aarch64.rpm;name=aarch64_CalcMySky-devel;unpack=0"
SRC_URI[aarch64_CalcMySky-devel.sha256sum] = "1151f76d9418f3e02570b43222b38d8e1dab42dbbd660ec097e72261355be2b1"

RDEPENDS:CalcMySky = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:CalcMySky-devel = " \
 CalcMySky \
 cmake-filesystem \
 "
