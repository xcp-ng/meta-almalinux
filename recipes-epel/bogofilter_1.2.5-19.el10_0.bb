# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bogofilter"
PV = "1.2.5"
PR = "19.el10_0"
PACKAGES = " \
 bogofilter \
 bogofilter-bogoupgrade \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bogofilter-1.2.5-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "975787719ac15fc004a4bed58d0a37cea90af53165a6393b38443d4519c85e03"

URI_x86_64_v2_bogofilter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bogofilter-1.2.5-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bogofilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bogofilter}"
SRC_URI[x86_64_v2_bogofilter.sha256sum] = "569a3cda527e90142f9137e697ec3b52a3de64a11ca7972818b065e36c75fc51"

URI_x86_64_v2_bogofilter-bogoupgrade = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bogofilter-bogoupgrade-1.2.5-19.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bogofilter-bogoupgrade;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bogofilter-bogoupgrade}"
SRC_URI[x86_64_v2_bogofilter-bogoupgrade.sha256sum] = "28c74ea089b321aa24e552177c7d382bcbca2bc9baf54a21d16714405622afd6"

URI_aarch64_bogofilter = "${EPEL_MIRROR}/aarch64/Packages/b/bogofilter-1.2.5-19.el10_0.aarch64.rpm;name=aarch64_bogofilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_bogofilter}"
SRC_URI[aarch64_bogofilter.sha256sum] = "35f6cc47a175522552aa8aa89d6467200f302fb36f4f663bf3b45b866ca0a8e5"

URI_aarch64_bogofilter-bogoupgrade = "${EPEL_MIRROR}/aarch64/Packages/b/bogofilter-bogoupgrade-1.2.5-19.el10_0.aarch64.rpm;name=aarch64_bogofilter-bogoupgrade;unpack=0"
SRC_URI:append = " ${URI_aarch64_bogofilter-bogoupgrade}"
SRC_URI[aarch64_bogofilter-bogoupgrade.sha256sum] = "5fd61e0872f8d0ddc7efc6a02f298cc6db8c861c014c87b32aca8a6a51bb5782"

RDEPENDS:bogofilter = " \
 bash \
 glibc \
 sqlite-libs \
 "
RDEPENDS:bogofilter-bogoupgrade = " \
 bogofilter \
 perl-Pod-Usage \
 perl-filetest \
 perl-interpreter \
 perl-libs \
 "
