# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-expat"
PV = "1.5.2"
PR = "2.el10_0"
PACKAGES = " \
 lua-expat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-expat-1.5.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64dd84c271a23ffe01cb541651383815efa70f646e744f1d92f44645d0acf2cf"

URI_x86_64_v2_lua-expat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-expat-1.5.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-expat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-expat}"
SRC_URI[x86_64_v2_lua-expat.sha256sum] = "85a86ee1d53e3bf2529f42b515206f8f72dae125e71bd9b3107a24c16cd51d83"

URI_aarch64_lua-expat = "${EPEL_MIRROR}/aarch64/Packages/l/lua-expat-1.5.2-2.el10_0.aarch64.rpm;name=aarch64_lua-expat;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-expat}"
SRC_URI[aarch64_lua-expat.sha256sum] = "3d93a0ba218994819b7d88114ba7744ce7d4d21db515a2ddf2b5bb92f4896c6c"

RDEPENDS:lua-expat = " \
 expat \
 glibc \
 lua-libs \
 "
