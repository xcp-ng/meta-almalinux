# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyqt6"
PV = "6.10.0"
PR = "1.el10"
PACKAGES = " \
 python-pyqt6-doc \
 python-pyqt6-rpm-macros \
 python3-pyqt6 \
 python3-pyqt6-base \
 python3-pyqt6-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pyqt6-6.10.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5613d79c59052bf29ce3714540b6433ba34ef9d196229eefb82d317a8fd825f3"

URI_x86_64_v2_python-pyqt6-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python-pyqt6-doc-6.10.0-1.el10.noarch.rpm;name=x86_64_v2_python-pyqt6-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyqt6-doc}"
SRC_URI[x86_64_v2_python-pyqt6-doc.sha256sum] = "f3cc3a09436be0b5accd5344ec2e83db5e10f7239bd5e30f312fa65231ca2077"

URI_x86_64_v2_python-pyqt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-pyqt6-rpm-macros-6.10.0-1.el10.noarch.rpm;name=x86_64_v2_python-pyqt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyqt6-rpm-macros}"
SRC_URI[x86_64_v2_python-pyqt6-rpm-macros.sha256sum] = "f617c4b17e6c8519d24ae9a3b4954741788af8f1ebb3b0292f069b1a41bad3f1"

URI_x86_64_v2_python3-pyqt6 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyqt6-6.10.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6}"
SRC_URI[x86_64_v2_python3-pyqt6.sha256sum] = "f4750a9221f7231f3b15031e5d4a599478d81c0d210e72133a4a016e6dedd9c8"

URI_x86_64_v2_python3-pyqt6-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyqt6-base-6.10.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-base}"
SRC_URI[x86_64_v2_python3-pyqt6-base.sha256sum] = "b59a54e0f3efa5cf2550bea77e00f81f39dc37f982801030586d3d1a47faea15"

URI_x86_64_v2_python3-pyqt6-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pyqt6-devel-6.10.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-pyqt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyqt6-devel}"
SRC_URI[x86_64_v2_python3-pyqt6-devel.sha256sum] = "dd70063422ea1e86f9a0ce4eeb0208b7f3943cb756d338772de60ab83e33fc8c"

URI_aarch64_python-pyqt6-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python-pyqt6-doc-6.10.0-1.el10.noarch.rpm;name=aarch64_python-pyqt6-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyqt6-doc}"
SRC_URI[aarch64_python-pyqt6-doc.sha256sum] = "f3cc3a09436be0b5accd5344ec2e83db5e10f7239bd5e30f312fa65231ca2077"

URI_aarch64_python-pyqt6-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-pyqt6-rpm-macros-6.10.0-1.el10.noarch.rpm;name=aarch64_python-pyqt6-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyqt6-rpm-macros}"
SRC_URI[aarch64_python-pyqt6-rpm-macros.sha256sum] = "f617c4b17e6c8519d24ae9a3b4954741788af8f1ebb3b0292f069b1a41bad3f1"

URI_aarch64_python3-pyqt6 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyqt6-6.10.0-1.el10.aarch64.rpm;name=aarch64_python3-pyqt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6}"
SRC_URI[aarch64_python3-pyqt6.sha256sum] = "3944964df558086874e8a5e988ea5f122cf04fbe729e0fd347b7cc74abe84a5a"

URI_aarch64_python3-pyqt6-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyqt6-base-6.10.0-1.el10.aarch64.rpm;name=aarch64_python3-pyqt6-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-base}"
SRC_URI[aarch64_python3-pyqt6-base.sha256sum] = "e050c5de5e18dd2257cd2e85fe3829ca1d4277d70d25fdc320938782096bebbb"

URI_aarch64_python3-pyqt6-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pyqt6-devel-6.10.0-1.el10.aarch64.rpm;name=aarch64_python3-pyqt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyqt6-devel}"
SRC_URI[aarch64_python3-pyqt6-devel.sha256sum] = "05cd433738f0aab1277b7f8b14e8d30adf1bb739e7be164f4e1dbb718176f2a0"

RDEPENDS:python-pyqt6-doc = " \
 "
RDEPENDS:python-pyqt6-rpm-macros = " \
 "
RDEPENDS:python3-pyqt6 = " \
 glibc \
 libstdc++ \
 python3 \
 python3-pyqt6-base \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtconnectivity \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qt6-qtpositioning \
 qt6-qtquick3d \
 qt6-qtremoteobjects \
 qt6-qtsensors \
 qt6-qtserialport \
 qt6-qtspeech \
 qt6-qtsvg \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-help \
 qt6-qtwebchannel \
 qt6-qtwebsockets \
 "
RDEPENDS:python3-pyqt6-base = " \
 bash \
 dbus-libs \
 glibc \
 libgcc \
 libstdc++ \
 python-pyqt6-rpm-macros \
 python3 \
 python3-dbus \
 python3-libs \
 python3-pyqt6-sip \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:python3-pyqt6-devel = " \
 python3-pyqt6 \
 qt6-qtbase-devel \
 "
