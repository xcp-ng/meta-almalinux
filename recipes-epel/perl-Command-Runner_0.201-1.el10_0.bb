# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Command-Runner"
PV = "0.201"
PR = "1.el10_0"
PACKAGES = " \
 perl-Command-Runner \
 perl-Command-Runner-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Command-Runner-0.201-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88395e3e5e0e2366d4695a14cb8e1b41125e20dbb856ecb995acb8890b8791bb"

URI_x86_64_v2_perl-Command-Runner = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Command-Runner-0.201-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Command-Runner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Command-Runner}"
SRC_URI[x86_64_v2_perl-Command-Runner.sha256sum] = "4aab0fbccbdfa01dca200339d58d2ab90f067f0a84dfac16fbf54d09c837c164"

URI_x86_64_v2_perl-Command-Runner-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Command-Runner-tests-0.201-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Command-Runner-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Command-Runner-tests}"
SRC_URI[x86_64_v2_perl-Command-Runner-tests.sha256sum] = "5ca6cf7dad49dd1f3284ea584a24a38175694ecaea5e7ab835be7afe96ec7bed"

URI_aarch64_perl-Command-Runner = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Command-Runner-0.201-1.el10_0.noarch.rpm;name=aarch64_perl-Command-Runner;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Command-Runner}"
SRC_URI[aarch64_perl-Command-Runner.sha256sum] = "c46f593a58d84c39f826df2e5a7259c1ecca861395d0abd12706a0f09f29344d"

URI_aarch64_perl-Command-Runner-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Command-Runner-tests-0.201-1.el10_0.noarch.rpm;name=aarch64_perl-Command-Runner-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Command-Runner-tests}"
SRC_URI[aarch64_perl-Command-Runner-tests.sha256sum] = "afa70b375cd12565b248afcd87ef933f8c0d4ecd4bbf6fe389d31012f9abc98c"

RDEPENDS:perl-Command-Runner = " \
 perl-Capture-Tiny \
 perl-Exporter \
 perl-File-pushd \
 perl-IO \
 perl-POSIX \
 perl-String-ShellQuote \
 perl-Time-HiRes \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Command-Runner-tests = " \
 bash \
 perl-Command-Runner \
 perl-File-Temp \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
