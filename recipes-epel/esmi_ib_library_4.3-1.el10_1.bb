# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "esmi_ib_library"
PV = "4.3"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 e_smi_tool \
 esmi_ib_library \
 esmi_ib_library-devel \
 esmi_ib_library-doc \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/e/esmi_ib_library-4.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22d2d26fca9a29e52b54e93b20093f954b960e24e3afe358b0d8f3975847b98a"

URI_x86_64_v2_e_smi_tool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/e_smi_tool-4.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_e_smi_tool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_e_smi_tool}"
SRC_URI[x86_64_v2_e_smi_tool.sha256sum] = "529385c1c9e39c756bb0d07d5aae90756a132c1da41981da77affb76ecf1c560"

URI_x86_64_v2_esmi_ib_library = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/esmi_ib_library-4.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_esmi_ib_library;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_esmi_ib_library}"
SRC_URI[x86_64_v2_esmi_ib_library.sha256sum] = "47cdf0e3b8c92aefdd8f6c6e8ae19c390d1b2ecae2c4e2074e093afc3042d6e8"

URI_x86_64_v2_esmi_ib_library-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/esmi_ib_library-devel-4.3-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_esmi_ib_library-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_esmi_ib_library-devel}"
SRC_URI[x86_64_v2_esmi_ib_library-devel.sha256sum] = "82692038b87d0a4558ed539485e4792583f97a5dc4327f1fde68fdb6850ab484"

URI_x86_64_v2_esmi_ib_library-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/esmi_ib_library-doc-4.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_esmi_ib_library-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_esmi_ib_library-doc}"
SRC_URI[x86_64_v2_esmi_ib_library-doc.sha256sum] = "400db0f219479641ef9562970cc9582a6724c745300d6b7dba3e3521ac237fd4"

RDEPENDS:e_smi_tool = " \
 esmi_ib_library \
 glibc \
 "
RDEPENDS:esmi_ib_library = " \
 glibc \
 "
RDEPENDS:esmi_ib_library-devel = " \
 esmi_ib_library \
 "
RDEPENDS:esmi_ib_library-doc = " \
 "
