# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "words"
PV = "3.0"
PR = "47.el10"
PACKAGES = " \
 words \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/words-3.0-47.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4212a68baa1242c16c3dff93efec6cd1522630c59ea39b6b894855b110f67cbc"

URI_x86_64_v2_words = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/words-3.0-47.el10.noarch.rpm;name=x86_64_v2_words;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_words}"
SRC_URI[x86_64_v2_words.sha256sum] = "9bfa8ea239e4e3901c8f5422cf1245b4d3f81f875f1c4a3432a202bc2750ca16"

URI_aarch64_words = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/words-3.0-47.el10.noarch.rpm;name=aarch64_words;unpack=0"
SRC_URI:append = " ${URI_aarch64_words}"
SRC_URI[aarch64_words.sha256sum] = "9bfa8ea239e4e3901c8f5422cf1245b4d3f81f875f1c4a3432a202bc2750ca16"

RDEPENDS:words = " \
 "
