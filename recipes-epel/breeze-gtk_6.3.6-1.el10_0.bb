# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "breeze-gtk"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 breeze-gtk \
 breeze-gtk-common \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/breeze-gtk-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e11a5bdd829cbea39b3e5bd86d91488017311dfd20e721f451be53325b25219a"

URI_x86_64_v2_breeze-gtk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk}"
SRC_URI[x86_64_v2_breeze-gtk.sha256sum] = "a412814be00594b279e2b9b10a7adf98591c71dc6abbd3fd2bec81f6760fb0e3"

URI_x86_64_v2_breeze-gtk-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-common-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-common}"
SRC_URI[x86_64_v2_breeze-gtk-common.sha256sum] = "1641c52d3c987b51177ccc371d6702e25487073b4976065bd8642cafe148daea"

URI_x86_64_v2_breeze-gtk-gtk2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk2-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk2}"
SRC_URI[x86_64_v2_breeze-gtk-gtk2.sha256sum] = "597a7afd860f0becb8c404de5965e7210e890d9703c6612a8b68a031d4e0328b"

URI_x86_64_v2_breeze-gtk-gtk3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk3-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk3}"
SRC_URI[x86_64_v2_breeze-gtk-gtk3.sha256sum] = "a22b988f40ac7e8a565adabe04658817cb04e08ded913bc6476b5bc188eedb8d"

URI_x86_64_v2_breeze-gtk-gtk4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-gtk-gtk4-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-gtk-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_breeze-gtk-gtk4}"
SRC_URI[x86_64_v2_breeze-gtk-gtk4.sha256sum] = "f49cb908359ab3732c45864f39a6004a54bc672166cd70070b5acd6a8468e8d7"

URI_aarch64_breeze-gtk = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-6.3.6-1.el10_0.noarch.rpm;name=aarch64_breeze-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk}"
SRC_URI[aarch64_breeze-gtk.sha256sum] = "a5350ce81242c2569162316c6041c6184f28ecc0b043ac656fe7fa5b21ea4bea"

URI_aarch64_breeze-gtk-common = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-common-6.3.6-1.el10_0.noarch.rpm;name=aarch64_breeze-gtk-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-common}"
SRC_URI[aarch64_breeze-gtk-common.sha256sum] = "8d4394ef6bc7458a7ed4e1616a4c3c391809edf4ca88c12acf0ec02351fa65d1"

URI_aarch64_breeze-gtk-gtk2 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk2-6.3.6-1.el10_0.noarch.rpm;name=aarch64_breeze-gtk-gtk2;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk2}"
SRC_URI[aarch64_breeze-gtk-gtk2.sha256sum] = "a83840a15bb8e17ef112c989df1df5a172c2e50dba43e2cfafeb9e3cc4830375"

URI_aarch64_breeze-gtk-gtk3 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk3-6.3.6-1.el10_0.noarch.rpm;name=aarch64_breeze-gtk-gtk3;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk3}"
SRC_URI[aarch64_breeze-gtk-gtk3.sha256sum] = "5fa62d578f4c550ac99f24b001b1a3d39be557de1046b2bf22d72b9710d06758"

URI_aarch64_breeze-gtk-gtk4 = "${EPEL_MIRROR}/aarch64/Packages/b/breeze-gtk-gtk4-6.3.6-1.el10_0.noarch.rpm;name=aarch64_breeze-gtk-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_breeze-gtk-gtk4}"
SRC_URI[aarch64_breeze-gtk-gtk4.sha256sum] = "cb9e18acaeb0916246dcef3ae521739c94c702ab9c739a7a04f535af400baaae"

RDEPENDS:breeze-gtk = " \
 breeze-gtk-gtk2 \
 breeze-gtk-gtk3 \
 breeze-gtk-gtk4 \
 "
RDEPENDS:breeze-gtk-common = " \
 "
RDEPENDS:breeze-gtk-gtk2 = " \
 breeze-gtk-common \
 gtk2-engines \
 "
RDEPENDS:breeze-gtk-gtk3 = " \
 breeze-gtk-common \
 "
RDEPENDS:breeze-gtk-gtk4 = " \
 breeze-gtk-common \
 "
