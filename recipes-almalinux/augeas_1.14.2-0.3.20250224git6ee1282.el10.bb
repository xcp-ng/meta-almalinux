# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "augeas"
PV = "1.14.2"
PR = "0.3.20250224git6ee1282.el10"
PACKAGES = " \
 augeas \
 augeas-devel \
 augeas-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/augeas-1.14.2-0.3.20250224git6ee1282.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f0eafa1a9c9eb5491e2658d183198c99653ddc41bd3f3229c82f9c8ce887f711"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/augeas-1.14.2-0.3.20250224git6ee1282.el10.x86_64_v2.rpm;name=x86_64_v2_augeas;unpack=0"
SRC_URI[x86_64_v2_augeas.sha256sum] = "4e278d44044a210d75029f5b7577afa945b8441eb84b837e5f5f5c852af63e6b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/augeas-devel-1.14.2-0.3.20250224git6ee1282.el10.x86_64_v2.rpm;name=x86_64_v2_augeas-devel;unpack=0"
SRC_URI[x86_64_v2_augeas-devel.sha256sum] = "0720c920f3f10044ade1e886d0086ad3d936630a00d05aeed14ad82fd94d3721"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/augeas-libs-1.14.2-0.3.20250224git6ee1282.el10.x86_64_v2.rpm;name=x86_64_v2_augeas-libs;unpack=0"
SRC_URI[x86_64_v2_augeas-libs.sha256sum] = "7c4f8e481c3878959545bdb953d891838f435e7eb3201f6211293827a7215c18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/augeas-1.14.2-0.3.20250224git6ee1282.el10.aarch64.rpm;name=aarch64_augeas;unpack=0"
SRC_URI[aarch64_augeas.sha256sum] = "8e0b89e7ec6ddcda374d80a2e976c2b21b890033da42ff65f0249ac8b43c4ceb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/augeas-devel-1.14.2-0.3.20250224git6ee1282.el10.aarch64.rpm;name=aarch64_augeas-devel;unpack=0"
SRC_URI[aarch64_augeas-devel.sha256sum] = "c88283bfafaa15454adf7845d2fef667b5feb23ec8375b914bc9aace5a3ae9b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/augeas-libs-1.14.2-0.3.20250224git6ee1282.el10.aarch64.rpm;name=aarch64_augeas-libs;unpack=0"
SRC_URI[aarch64_augeas-libs.sha256sum] = "05afd0ca2f3187dca843e23b1a766a3e7dfc98d03e348068fb7a0914b26b4d04"

RDEPENDS:augeas = " \
 augeas-libs \
 glibc \
 libgcc \
 readline \
 "
RDEPENDS:augeas-devel = " \
 augeas-libs \
 libselinux-devel \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:augeas-libs = " \
 glibc \
 libselinux \
 libxml2 \
 "
