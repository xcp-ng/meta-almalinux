# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xapian-bindings"
PV = "1.4.23"
PR = "1.el10_2"
PACKAGES = " \
 python3-xapian \
 tcl-xapian \
 xapian-bindings \
 xapian-bindings-ruby \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xapian-bindings-1.4.23-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7aee825ff8dabb600116097dcf3b74d51b2a852f428c62d62392576ac80c887"

URI_x86_64_v2_python3-xapian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xapian-1.4.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-xapian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xapian}"
SRC_URI[x86_64_v2_python3-xapian.sha256sum] = "9a4c2c4bfba23cc38f9bf1f32afde934a3028aea64e4f25900c891c144379f9e"

URI_x86_64_v2_tcl-xapian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tcl-xapian-1.4.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tcl-xapian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tcl-xapian}"
SRC_URI[x86_64_v2_tcl-xapian.sha256sum] = "009f6e8d3cde83ddd5bf918494395d63996f1880141cfc99478a990c58c2ff3b"

URI_x86_64_v2_xapian-bindings = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xapian-bindings-1.4.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xapian-bindings;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xapian-bindings}"
SRC_URI[x86_64_v2_xapian-bindings.sha256sum] = "0db111ed37738d14a26d80cd5190efc616d0c467d1a806178d1418240ed598f1"

URI_x86_64_v2_xapian-bindings-ruby = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xapian-bindings-ruby-1.4.23-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xapian-bindings-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xapian-bindings-ruby}"
SRC_URI[x86_64_v2_xapian-bindings-ruby.sha256sum] = "31a9ba6219f4668f6d0e50875bda6e16a836b94683c428b0c72e3b7243d9b74c"

URI_aarch64_python3-xapian = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xapian-1.4.23-1.el10_2.aarch64.rpm;name=aarch64_python3-xapian;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xapian}"
SRC_URI[aarch64_python3-xapian.sha256sum] = "e6eb1a247d86f7901cc973b7913ae0936f66ea3912f36a21c5faed3617c1ecbe"

URI_aarch64_tcl-xapian = "${EPEL_MIRROR}/aarch64/Packages/t/tcl-xapian-1.4.23-1.el10_2.aarch64.rpm;name=aarch64_tcl-xapian;unpack=0"
SRC_URI:append = " ${URI_aarch64_tcl-xapian}"
SRC_URI[aarch64_tcl-xapian.sha256sum] = "ccd45783f77cb369b7d11ad6f575f97cbf9fbe461df7c67d333ab145144704ee"

URI_aarch64_xapian-bindings = "${EPEL_MIRROR}/aarch64/Packages/x/xapian-bindings-1.4.23-1.el10_2.aarch64.rpm;name=aarch64_xapian-bindings;unpack=0"
SRC_URI:append = " ${URI_aarch64_xapian-bindings}"
SRC_URI[aarch64_xapian-bindings.sha256sum] = "a44311118fcee48fb30da620118572df37cb08c4258896f8365442c61aeae0b8"

URI_aarch64_xapian-bindings-ruby = "${EPEL_MIRROR}/aarch64/Packages/x/xapian-bindings-ruby-1.4.23-1.el10_2.aarch64.rpm;name=aarch64_xapian-bindings-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_xapian-bindings-ruby}"
SRC_URI[aarch64_xapian-bindings-ruby.sha256sum] = "9f828ccb586831f413c9ef8b61b486b7d4b724f10a478615730f014780b9b559"

RDEPENDS:python3-xapian = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 xapian-bindings \
 xapian-core-libs \
 "
RDEPENDS:tcl-xapian = " \
 glibc \
 libgcc \
 libstdc++ \
 tcl \
 xapian-bindings \
 xapian-core-libs \
 "
RDEPENDS:xapian-bindings = " \
 "
RDEPENDS:xapian-bindings-ruby = " \
 glibc \
 libgcc \
 libstdc++ \
 ruby-libs \
 xapian-bindings \
 xapian-core-libs \
 "
