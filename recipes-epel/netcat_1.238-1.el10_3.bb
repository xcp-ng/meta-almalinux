# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netcat"
PV = "1.238"
PR = "1.el10_3"
PACKAGES = " \
 netcat \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/netcat-1.238-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "531e6137e017c282f700cc0296c97a099d0d94c3d3ba1083e1e77a45e8205b13"

URI_x86_64_v2_netcat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netcat-1.238-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netcat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netcat}"
SRC_URI[x86_64_v2_netcat.sha256sum] = "018fc0456066f8c2e75a9a1f64dc1022d091196411a9015e77ed5b391cf13f14"

URI_aarch64_netcat = "${EPEL_MIRROR}/aarch64/Packages/n/netcat-1.238-1.el10_3.aarch64.rpm;name=aarch64_netcat;unpack=0"
SRC_URI:append = " ${URI_aarch64_netcat}"
SRC_URI[aarch64_netcat.sha256sum] = "b0df43ee0153518fe06d3f59817d3087701d2378c78ab52d334fd8e9b956d38d"

RDEPENDS:netcat = " \
 alternatives \
 bash \
 glibc \
 libbsd \
 libretls \
 "
