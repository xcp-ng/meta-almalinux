# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit"
PV = "334.1"
PR = "1.el10_0"
PACKAGES = " \
 cockpit \
 cockpit-bridge \
 cockpit-doc \
 cockpit-packagekit \
 cockpit-storaged \
 cockpit-system \
 cockpit-ws \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cockpit-334.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "612f1f1fef5f53fb4a370e7ca89ccd4ed3b4cd0b8734e74ee337e7d6d4dfd700"

URI_x86_64_v2_cockpit = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-334.1-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_cockpit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit}"
SRC_URI[x86_64_v2_cockpit.sha256sum] = "839fcd85eef484c4ee8268fc678c0faff065bd74b97693de50e29986cdd03611"

URI_x86_64_v2_cockpit-bridge = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-bridge-334.1-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_cockpit-bridge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-bridge}"
SRC_URI[x86_64_v2_cockpit-bridge.sha256sum] = "bee856d80783a974ba91669885e68ad9aa8aa03fd5b111004c0e7455578cd905"

URI_x86_64_v2_cockpit-doc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-doc-334.1-1.el10_0.noarch.rpm;name=x86_64_v2_cockpit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-doc}"
SRC_URI[x86_64_v2_cockpit-doc.sha256sum] = "b2e228883d996b69298df7734fc0a20336b078ef59bb7e2dd7dba488884a702f"

URI_x86_64_v2_cockpit-packagekit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-packagekit-334.1-1.el10_0.noarch.rpm;name=x86_64_v2_cockpit-packagekit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-packagekit}"
SRC_URI[x86_64_v2_cockpit-packagekit.sha256sum] = "fff5d1d467cd9c14a4bbcba9b65b22eb44e2529125c39145890cc9da80c7f44b"

URI_x86_64_v2_cockpit-storaged = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-storaged-334.1-1.el10_0.noarch.rpm;name=x86_64_v2_cockpit-storaged;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-storaged}"
SRC_URI[x86_64_v2_cockpit-storaged.sha256sum] = "cea145daa44422bb14b81a21bf28f4831a7706b3303c8a639e451f92f8813f2e"

URI_x86_64_v2_cockpit-system = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-system-334.1-1.el10_0.noarch.rpm;name=x86_64_v2_cockpit-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-system}"
SRC_URI[x86_64_v2_cockpit-system.sha256sum] = "8e2f14345959e1ecef823f57ac65b971abc56d81eae731454bb816343934b3d1"

URI_x86_64_v2_cockpit-ws = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-334.1-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cockpit-ws}"
SRC_URI[x86_64_v2_cockpit-ws.sha256sum] = "e6a0123a6036463f4f8c0b4dfeaf47acd4645ed3d97fa84c7dbd76b501a064b2"

URI_aarch64_cockpit = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-334.1-1.el10_0.aarch64.rpm;name=aarch64_cockpit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit}"
SRC_URI[aarch64_cockpit.sha256sum] = "b719cf901b399a3e1a75ff362338b6903876afec83f0500b179739d453d5c870"

URI_aarch64_cockpit-bridge = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-bridge-334.1-1.el10_0.aarch64.rpm;name=aarch64_cockpit-bridge;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-bridge}"
SRC_URI[aarch64_cockpit-bridge.sha256sum] = "69b281657d68b2c3c74d42b3bf2b865c1ac9af6a75dd389300fd00cbc2b966f6"

URI_aarch64_cockpit-doc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-doc-334.1-1.el10_0.noarch.rpm;name=aarch64_cockpit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-doc}"
SRC_URI[aarch64_cockpit-doc.sha256sum] = "b2e228883d996b69298df7734fc0a20336b078ef59bb7e2dd7dba488884a702f"

URI_aarch64_cockpit-packagekit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-packagekit-334.1-1.el10_0.noarch.rpm;name=aarch64_cockpit-packagekit;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-packagekit}"
SRC_URI[aarch64_cockpit-packagekit.sha256sum] = "fff5d1d467cd9c14a4bbcba9b65b22eb44e2529125c39145890cc9da80c7f44b"

URI_aarch64_cockpit-storaged = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-storaged-334.1-1.el10_0.noarch.rpm;name=aarch64_cockpit-storaged;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-storaged}"
SRC_URI[aarch64_cockpit-storaged.sha256sum] = "cea145daa44422bb14b81a21bf28f4831a7706b3303c8a639e451f92f8813f2e"

URI_aarch64_cockpit-system = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-system-334.1-1.el10_0.noarch.rpm;name=aarch64_cockpit-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-system}"
SRC_URI[aarch64_cockpit-system.sha256sum] = "8e2f14345959e1ecef823f57ac65b971abc56d81eae731454bb816343934b3d1"

URI_aarch64_cockpit-ws = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-334.1-1.el10_0.aarch64.rpm;name=aarch64_cockpit-ws;unpack=0"
SRC_URI:append = " ${URI_aarch64_cockpit-ws}"
SRC_URI[aarch64_cockpit-ws.sha256sum] = "e1b59a32af95f2b89b3dcc202b8361c21c8019016937909c5c5b182d9a35f3b5"

RDEPENDS:cockpit = " \
 cockpit-bridge \
 cockpit-system \
 cockpit-ws \
 "
RDEPENDS:cockpit-bridge = " \
 python3 \
 "
RDEPENDS:cockpit-doc = " \
 "
RDEPENDS:cockpit-packagekit = " \
 PackageKit \
 cockpit-bridge \
 polkit \
 "
RDEPENDS:cockpit-storaged = " \
 bash \
 cockpit-system \
 python3 \
 python3-dbus \
 udisks2 \
 "
RDEPENDS:cockpit-system = " \
 NetworkManager \
 cockpit-bridge \
 grep \
 libpwquality \
 shadow-utils \
 sos \
 sudo \
 virtual//usr/bin/date \
 "
RDEPENDS:cockpit-ws = " \
 bash \
 glib-networking \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 krb5-libs \
 libgcc \
 libxcrypt \
 openssl \
 pam-libs \
 policycoreutils \
 selinux-policy \
 systemd-libs \
 "
