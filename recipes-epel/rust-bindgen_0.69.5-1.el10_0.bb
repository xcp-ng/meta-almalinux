# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bindgen"
PV = "0.69.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-bindgen+__cli-devel \
 rust-bindgen+__testing_only_extra_assertions-devel \
 rust-bindgen+__testing_only_libclang_16-devel \
 rust-bindgen+__testing_only_libclang_9-devel \
 rust-bindgen+default-devel \
 rust-bindgen+experimental-devel \
 rust-bindgen+logging-devel \
 rust-bindgen+prettyplease-devel \
 rust-bindgen+runtime-devel \
 rust-bindgen+static-devel \
 rust-bindgen+which-rustfmt-devel \
 rust-bindgen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bindgen-0.69.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "010bc4e7f0b4c5db1cdcb0765921b09db4a54b1243983312b398bb5ea72012a5"

URI_x86_64_v2_rust-bindgen+__cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__cli-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__cli-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__cli-devel.sha256sum] = "bed166dc9899112fa4546f3f9df846262ebca92bb81b46cccc3ef95a351346e4"

URI_x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__testing_only_extra_assertions-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__testing_only_extra_assertions-devel.sha256sum] = "9bce3f9da94ce85b68c0023f05ead317ad1ab5ccfe9ccc76abab2666c8fe79c0"

URI_x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__testing_only_libclang_16-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__testing_only_libclang_16-devel.sha256sum] = "1aec921a615036e9b8dd1816a23fddf2860873398d7bfa51fff43e4152275069"

URI_x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+__testing_only_libclang_9-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel}"
SRC_URI[x86_64_v2_rust-bindgen+__testing_only_libclang_9-devel.sha256sum] = "5d159327862756e38773563e90d8ad126b0a3da3b06ade5967a3b86b87698134"

URI_x86_64_v2_rust-bindgen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+default-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+default-devel}"
SRC_URI[x86_64_v2_rust-bindgen+default-devel.sha256sum] = "999b4a7164116ea80bb6b7fe1de4f03f16be4f121b5c1378ccd637ab3b373e80"

URI_x86_64_v2_rust-bindgen+experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+experimental-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+experimental-devel}"
SRC_URI[x86_64_v2_rust-bindgen+experimental-devel.sha256sum] = "2dc5562b0c4489a22492e6446459925ba237e4f173084d983e79d1a4a96ab66d"

URI_x86_64_v2_rust-bindgen+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+logging-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+logging-devel}"
SRC_URI[x86_64_v2_rust-bindgen+logging-devel.sha256sum] = "404bd3bb48d31de6061a662656527b5294f4b2adfe309bc94d2dc3757ff8f917"

URI_x86_64_v2_rust-bindgen+prettyplease-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+prettyplease-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+prettyplease-devel}"
SRC_URI[x86_64_v2_rust-bindgen+prettyplease-devel.sha256sum] = "f693e87ad58258b1890f8a685cbd5a6cc9a948db70784ef5c0757b5b233eb557"

URI_x86_64_v2_rust-bindgen+runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+runtime-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+runtime-devel}"
SRC_URI[x86_64_v2_rust-bindgen+runtime-devel.sha256sum] = "fa2b916983cea96d5b0ef5039e2d727f95c15f57acd79108e307d323c8d94fdb"

URI_x86_64_v2_rust-bindgen+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+static-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+static-devel}"
SRC_URI[x86_64_v2_rust-bindgen+static-devel.sha256sum] = "7e2af873663c925a03ef658b3782e507aa9a4a9610c55d52319cd05b24008eb7"

URI_x86_64_v2_rust-bindgen+which-rustfmt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen+which-rustfmt-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen+which-rustfmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen+which-rustfmt-devel}"
SRC_URI[x86_64_v2_rust-bindgen+which-rustfmt-devel.sha256sum] = "e2845cdbd328ae81cfe955d8c9a64d978673beacea6df848670acd94c40967b6"

URI_x86_64_v2_rust-bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bindgen-devel-0.69.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bindgen-devel}"
SRC_URI[x86_64_v2_rust-bindgen-devel.sha256sum] = "b217ea4c0930ade91cf28ca8edb5ddab6c17d2989cc69091fd9973307666bc07"

URI_aarch64_rust-bindgen+__cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__cli-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+__cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__cli-devel}"
SRC_URI[aarch64_rust-bindgen+__cli-devel.sha256sum] = "385e0841e6033872ca7f92a59baca0400ee1cfb68468c2d386e8ae0236a13f93"

URI_aarch64_rust-bindgen+__testing_only_extra_assertions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__testing_only_extra_assertions-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+__testing_only_extra_assertions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__testing_only_extra_assertions-devel}"
SRC_URI[aarch64_rust-bindgen+__testing_only_extra_assertions-devel.sha256sum] = "f2ec9484b106931556ec6ba4f6257f633e49e54bf8063ef23ad205a2485ec54e"

URI_aarch64_rust-bindgen+__testing_only_libclang_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__testing_only_libclang_16-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+__testing_only_libclang_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__testing_only_libclang_16-devel}"
SRC_URI[aarch64_rust-bindgen+__testing_only_libclang_16-devel.sha256sum] = "dec22043317d14c7ede87b5a88eea558f3179e5bd393bf53f7244fa832fd2588"

URI_aarch64_rust-bindgen+__testing_only_libclang_9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+__testing_only_libclang_9-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+__testing_only_libclang_9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+__testing_only_libclang_9-devel}"
SRC_URI[aarch64_rust-bindgen+__testing_only_libclang_9-devel.sha256sum] = "9d3f5248000bb5f622c148b6312847c433a00679362092c3e65ac844476959f6"

URI_aarch64_rust-bindgen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+default-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+default-devel}"
SRC_URI[aarch64_rust-bindgen+default-devel.sha256sum] = "a41e5998daa124d38b3ec6ad76884f39dedc588954f86bd3d72437a465ce4508"

URI_aarch64_rust-bindgen+experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+experimental-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+experimental-devel}"
SRC_URI[aarch64_rust-bindgen+experimental-devel.sha256sum] = "36d55f056dbb3797ac8555e64befc3fbc3843f7716446bebca62e2fe41e5c3f0"

URI_aarch64_rust-bindgen+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+logging-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+logging-devel}"
SRC_URI[aarch64_rust-bindgen+logging-devel.sha256sum] = "c41fe17c7d1494c8b2eb3a8cd3ce5258d2e543c6bf09a8c7769a0eafe839f26e"

URI_aarch64_rust-bindgen+prettyplease-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+prettyplease-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+prettyplease-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+prettyplease-devel}"
SRC_URI[aarch64_rust-bindgen+prettyplease-devel.sha256sum] = "8f086e823948f7e337ca0cca3240f43aacb2f71020c7f97a0c12aed36f9e8d4f"

URI_aarch64_rust-bindgen+runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+runtime-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+runtime-devel}"
SRC_URI[aarch64_rust-bindgen+runtime-devel.sha256sum] = "d71f46c19e47abb729153eb6d7548e529c7f9d55b3a1ff00fbedeacbc2cd7033"

URI_aarch64_rust-bindgen+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+static-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+static-devel}"
SRC_URI[aarch64_rust-bindgen+static-devel.sha256sum] = "22046295c424f03141d6f4a414f83733fefae25ce5c5fb5c24a09be78ac28517"

URI_aarch64_rust-bindgen+which-rustfmt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen+which-rustfmt-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen+which-rustfmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen+which-rustfmt-devel}"
SRC_URI[aarch64_rust-bindgen+which-rustfmt-devel.sha256sum] = "d91233395a056e6fd7a04aacf6733763a4b465eadf1c761c04839e2f8417603d"

URI_aarch64_rust-bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bindgen-devel-0.69.5-1.el10_0.noarch.rpm;name=aarch64_rust-bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bindgen-devel}"
SRC_URI[aarch64_rust-bindgen-devel.sha256sum] = "c23166cb00f5651f3d2f072dfb36b49338c7667821352df6d758162878b7df23"

RDEPENDS:rust-bindgen+__cli-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+__testing_only_extra_assertions-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+__testing_only_libclang_16-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+__testing_only_libclang_9-devel = " \
 cargo \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+default-devel = " \
 cargo \
 rust-bindgen+logging-devel \
 rust-bindgen+prettyplease-devel \
 rust-bindgen+runtime-devel \
 rust-bindgen+which-rustfmt-devel \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+experimental-devel = " \
 cargo \
 rust-annotate-snippets0.9+color-devel \
 rust-annotate-snippets0.9+default-devel \
 rust-bindgen-devel \
 "
RDEPENDS:rust-bindgen+logging-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-log+default-devel \
 "
RDEPENDS:rust-bindgen+prettyplease-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-prettyplease+default-devel \
 rust-prettyplease+verbatim-devel \
 "
RDEPENDS:rust-bindgen+runtime-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-clang-sys+runtime-devel \
 "
RDEPENDS:rust-bindgen+static-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-clang-sys+static-devel \
 "
RDEPENDS:rust-bindgen+which-rustfmt-devel = " \
 cargo \
 rust-bindgen-devel \
 rust-which4-devel \
 "
RDEPENDS:rust-bindgen-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cexpr+default-devel \
 rust-clang-sys+clang_6_0-devel \
 rust-clang-sys+default-devel \
 rust-itertools0.10-devel \
 rust-lazy_static+default-devel \
 rust-lazycell+default-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-regex+std-devel \
 rust-regex+unicode-perl-devel \
 rust-regex-devel \
 rust-rustc-hash1+default-devel \
 rust-shlex+default-devel \
 rust-syn+default-devel \
 rust-syn+extra-traits-devel \
 rust-syn+full-devel \
 rust-syn+visit-mut-devel \
 "
