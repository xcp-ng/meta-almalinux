# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-lukko"
PV = "0.1.1.3"
PR = "18.el10_0"
PACKAGES = " \
 ghc-lukko \
 ghc-lukko-devel \
 ghc-lukko-doc \
 ghc-lukko-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-lukko-0.1.1.3-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6d01c502a2bfb40590a7ce730d9b89bd5e5a1a96182add0e5f8f5175e951a63"

URI_x86_64_v2_ghc-lukko = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lukko-0.1.1.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lukko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lukko}"
SRC_URI[x86_64_v2_ghc-lukko.sha256sum] = "deac8a84eb8d1584448ba4a3aca4fd217c74a1d7e23a8cdb069a98130ad40df1"

URI_x86_64_v2_ghc-lukko-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lukko-devel-0.1.1.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lukko-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lukko-devel}"
SRC_URI[x86_64_v2_ghc-lukko-devel.sha256sum] = "2bda13b2ee862b376be8e1556dd7f2a81122626e220f1086b226ad9ebb1aaf82"

URI_x86_64_v2_ghc-lukko-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lukko-doc-0.1.1.3-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-lukko-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lukko-doc}"
SRC_URI[x86_64_v2_ghc-lukko-doc.sha256sum] = "1ce6faaca7911bb01ab9a2eb244fb8972b348884404a540b0a5db522832893a0"

URI_x86_64_v2_ghc-lukko-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-lukko-prof-0.1.1.3-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-lukko-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-lukko-prof}"
SRC_URI[x86_64_v2_ghc-lukko-prof.sha256sum] = "77d9ee885c4c561c2d5a6a452dbd3ad2d4a883cd75c40a1ed618f58daacca4de"

URI_aarch64_ghc-lukko = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lukko-0.1.1.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-lukko;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lukko}"
SRC_URI[aarch64_ghc-lukko.sha256sum] = "4ef2c32b217d52491ddb54be7437f060a2ecd8d38d0e03b606c442b60a927ea5"

URI_aarch64_ghc-lukko-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lukko-devel-0.1.1.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-lukko-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lukko-devel}"
SRC_URI[aarch64_ghc-lukko-devel.sha256sum] = "b59d1448fdc31f0f1732c7927b15e935495532bb6a3e78afdddcd6801d48b556"

URI_aarch64_ghc-lukko-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lukko-doc-0.1.1.3-18.el10_0.noarch.rpm;name=aarch64_ghc-lukko-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lukko-doc}"
SRC_URI[aarch64_ghc-lukko-doc.sha256sum] = "36f5e7f9be136a736651cf3b1ee7b29d03c6176b1595e4f6541db92b7c97281c"

URI_aarch64_ghc-lukko-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-lukko-prof-0.1.1.3-18.el10_0.aarch64.rpm;name=aarch64_ghc-lukko-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-lukko-prof}"
SRC_URI[aarch64_ghc-lukko-prof.sha256sum] = "ac29d9386902370a1f8fd1127b3baa1ad3d9f150a38361dbccb6e24681cef254"

RDEPENDS:ghc-lukko = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-lukko-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-lukko \
 "
RDEPENDS:ghc-lukko-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-lukko-prof = " \
 ghc-base-prof \
 ghc-lukko-devel \
 "
