# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-transparency-dev-merkle"
PV = "0.0.1"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-transparency-dev-merkle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-transparency-dev-merkle-0.0.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4a4b86909b1ec4a4c1e73d61d25b13eadba7f036bcd020ec265251e2057dda6"

URI_x86_64_v2_golang-github-transparency-dev-merkle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-transparency-dev-merkle-devel-0.0.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-transparency-dev-merkle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-transparency-dev-merkle-devel}"
SRC_URI[x86_64_v2_golang-github-transparency-dev-merkle-devel.sha256sum] = "e5316436ffdf5d159fc88016d4691cd14acfb31b621238672817831f79d7be3c"

URI_aarch64_golang-github-transparency-dev-merkle-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-transparency-dev-merkle-devel-0.0.1-6.el10_0.noarch.rpm;name=aarch64_golang-github-transparency-dev-merkle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-transparency-dev-merkle-devel}"
SRC_URI[aarch64_golang-github-transparency-dev-merkle-devel.sha256sum] = "8ac551b12d7fdcbfc49d314bffb4e52bd4a0d0d0d4e1f43104adc4aa9e16563b"

RDEPENDS:golang-github-transparency-dev-merkle-devel = " \
 go-filesystem \
 "
