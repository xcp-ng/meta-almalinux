# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mongo-c-driver"
PV = "2.4.0"
PR = "1.el10_3"
PACKAGES = " \
 libbson \
 libbson-devel \
 mongo-c-driver \
 mongo-c-driver-devel \
 mongo-c-driver-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mongo-c-driver-2.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f2a7d69a8f0678ebdf6a2696afe578614d75ac56cc0c5ad7418eeb75e584f3a3"

URI_x86_64_v2_libbson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-2.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbson}"
SRC_URI[x86_64_v2_libbson.sha256sum] = "a76853f83a7834520fdbd014e79cf12da409114c34aa87883fa58069e6c0b797"

URI_x86_64_v2_libbson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libbson-devel-2.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libbson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libbson-devel}"
SRC_URI[x86_64_v2_libbson-devel.sha256sum] = "aa49ad77b91e6bef327c7142368912bcb5e16f904bf15db8f036646fbdd63c77"

URI_x86_64_v2_mongo-c-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-2.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mongo-c-driver}"
SRC_URI[x86_64_v2_mongo-c-driver.sha256sum] = "cf40d64346a0ba94598afc2f2b2eddd23de7c6b9efc590a516dbd0b0f637a4d2"

URI_x86_64_v2_mongo-c-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-devel-2.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mongo-c-driver-devel}"
SRC_URI[x86_64_v2_mongo-c-driver-devel.sha256sum] = "d45cc2260e6d7b8b730fc6db3c81aa58796f8088ff07ad1694be8545b6b77b9d"

URI_x86_64_v2_mongo-c-driver-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mongo-c-driver-libs-2.4.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mongo-c-driver-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mongo-c-driver-libs}"
SRC_URI[x86_64_v2_mongo-c-driver-libs.sha256sum] = "fcfa94d62a0a2c8f90213b89b974f46347753977e40e771a8579a8c44d81eb73"

URI_aarch64_libbson = "${EPEL_MIRROR}/aarch64/Packages/l/libbson-2.4.0-1.el10_3.aarch64.rpm;name=aarch64_libbson;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbson}"
SRC_URI[aarch64_libbson.sha256sum] = "5071f59aaa7f4ea824c44f04f9512b5baf785d6fca95adbfd4b44c75be1cd46b"

URI_aarch64_libbson-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libbson-devel-2.4.0-1.el10_3.aarch64.rpm;name=aarch64_libbson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libbson-devel}"
SRC_URI[aarch64_libbson-devel.sha256sum] = "4585c32003a422a71f39c34aa4d81e62216450bf985ccd8ee12f58996a2c27d0"

URI_aarch64_mongo-c-driver = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-2.4.0-1.el10_3.aarch64.rpm;name=aarch64_mongo-c-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver}"
SRC_URI[aarch64_mongo-c-driver.sha256sum] = "57c9ab0abef1744d9a0695e318703bb77b27f9a533aa5f119b6451e075caad55"

URI_aarch64_mongo-c-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-devel-2.4.0-1.el10_3.aarch64.rpm;name=aarch64_mongo-c-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver-devel}"
SRC_URI[aarch64_mongo-c-driver-devel.sha256sum] = "fa3250e0b2ff56d07cb21d085c3476eb0e37fb5bdfabc6150de0aff6b2c091e6"

URI_aarch64_mongo-c-driver-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mongo-c-driver-libs-2.4.0-1.el10_3.aarch64.rpm;name=aarch64_mongo-c-driver-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mongo-c-driver-libs}"
SRC_URI[aarch64_mongo-c-driver-libs.sha256sum] = "876ce77e6f79f4042d88f646d88bbf09725c94de2db997b99bbc8a7950590981"

RDEPENDS:libbson = " \
 glibc \
 "
RDEPENDS:libbson-devel = " \
 cmake-filesystem \
 libbson \
 pkgconf-pkg-config \
 "
RDEPENDS:mongo-c-driver = " \
 glibc \
 mongo-c-driver-libs \
 "
RDEPENDS:mongo-c-driver-devel = " \
 cmake-filesystem \
 cyrus-sasl-devel \
 libbson-devel \
 libmongocrypt-devel \
 libzstd-devel \
 mongo-c-driver \
 mongo-c-driver-libs \
 openssl-devel \
 pkgconf-pkg-config \
 utf8proc-devel \
 "
RDEPENDS:mongo-c-driver-libs = " \
 cyrus-sasl-lib \
 glibc \
 libbson \
 libmongocrypt \
 libzstd \
 openssl-libs \
 snappy \
 utf8proc \
 zlib-ng-compat \
 "
