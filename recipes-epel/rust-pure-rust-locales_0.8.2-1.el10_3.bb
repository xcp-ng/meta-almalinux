# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pure-rust-locales"
PV = "0.8.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-pure-rust-locales+default-devel \
 rust-pure-rust-locales-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pure-rust-locales-0.8.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19af7f2b53b6a88751e5c34ee4764313aaa9b87755673c9d8e2baad18b5ce60b"

URI_x86_64_v2_rust-pure-rust-locales+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pure-rust-locales+default-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pure-rust-locales+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pure-rust-locales+default-devel}"
SRC_URI[x86_64_v2_rust-pure-rust-locales+default-devel.sha256sum] = "9d902faa30a9fc17aa96bb5c445988f758162cfbbff9aa5045a4fe4839fe6c33"

URI_x86_64_v2_rust-pure-rust-locales-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pure-rust-locales-devel-0.8.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pure-rust-locales-devel}"
SRC_URI[x86_64_v2_rust-pure-rust-locales-devel.sha256sum] = "fa80e88058bd96c74c1858c9a939abdaac07a81abdc10595829b824c42d42199"

URI_aarch64_rust-pure-rust-locales+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pure-rust-locales+default-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-pure-rust-locales+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pure-rust-locales+default-devel}"
SRC_URI[aarch64_rust-pure-rust-locales+default-devel.sha256sum] = "0230be4465143e52a86113bd6864fbcf46197f6da5d80711a3ae2fe4141aea97"

URI_aarch64_rust-pure-rust-locales-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pure-rust-locales-devel-0.8.2-1.el10_3.noarch.rpm;name=aarch64_rust-pure-rust-locales-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pure-rust-locales-devel}"
SRC_URI[aarch64_rust-pure-rust-locales-devel.sha256sum] = "385e51e54d2a4bcb2c3badf9e2be0193a606b9c9898ae383c5ad309e2814b92c"

RDEPENDS:rust-pure-rust-locales+default-devel = " \
 cargo \
 rust-pure-rust-locales-devel \
 "
RDEPENDS:rust-pure-rust-locales-devel = " \
 cargo \
 rust \
 "
