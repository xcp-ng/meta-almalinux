# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_pcg0.2"
PV = "0.2.1"
PR = "11.el10_0"
PACKAGES = " \
 rust-rand_pcg0.2+default-devel \
 rust-rand_pcg0.2+serde-devel \
 rust-rand_pcg0.2+serde1-devel \
 rust-rand_pcg0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_pcg0.2-0.2.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa5b528a339f2a2a7bf39024353b80682fac239e5ff6a3d4483c537eba99edfe"

URI_x86_64_v2_rust-rand_pcg0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.2+default-devel-0.2.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.2+default-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.2+default-devel.sha256sum] = "8afc9a92bb8cbf0564df11f87c2370335a63ec80e5a1742f3f27df44b179ab38"

URI_x86_64_v2_rust-rand_pcg0.2+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.2+serde-devel-0.2.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.2+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.2+serde-devel.sha256sum] = "90a08cf0662a1e53fb94b9f682a642ba7dc846092f3b6c3364786ca2b097a2fc"

URI_x86_64_v2_rust-rand_pcg0.2+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.2+serde1-devel-0.2.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.2+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.2+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.2+serde1-devel.sha256sum] = "bc101c9a9c87d84ee0ec466b150fad1c73483084ac8c20dbdf4f52ae5da73791"

URI_x86_64_v2_rust-rand_pcg0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_pcg0.2-devel-0.2.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_pcg0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_pcg0.2-devel}"
SRC_URI[x86_64_v2_rust-rand_pcg0.2-devel.sha256sum] = "28234d2478d30d5f1364901f6f42680db3a50f332f2dbde020c8fa959ae7b1a8"

URI_aarch64_rust-rand_pcg0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.2+default-devel-0.2.1-11.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.2+default-devel}"
SRC_URI[aarch64_rust-rand_pcg0.2+default-devel.sha256sum] = "7a9136e5e8ecb57e8d67c17cfa4b82662923c65a62ef5a508c5b008a775aab9e"

URI_aarch64_rust-rand_pcg0.2+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.2+serde-devel-0.2.1-11.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg0.2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.2+serde-devel}"
SRC_URI[aarch64_rust-rand_pcg0.2+serde-devel.sha256sum] = "c6368e80b2d05a4be7316e63dae88853a1f746b8c25779e5e4f538542c107545"

URI_aarch64_rust-rand_pcg0.2+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.2+serde1-devel-0.2.1-11.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg0.2+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.2+serde1-devel}"
SRC_URI[aarch64_rust-rand_pcg0.2+serde1-devel.sha256sum] = "cb34a2bcc4019eafc9f03682ce3b6ace3b3070154deaffbf1394c4671d5c8074"

URI_aarch64_rust-rand_pcg0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_pcg0.2-devel-0.2.1-11.el10_0.noarch.rpm;name=aarch64_rust-rand_pcg0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_pcg0.2-devel}"
SRC_URI[aarch64_rust-rand_pcg0.2-devel.sha256sum] = "2988f8dc59834d2bab765d61221c02bd2659572d3b61d234e1df7598f0840236"

RDEPENDS:rust-rand_pcg0.2+default-devel = " \
 cargo \
 rust-rand_pcg0.2-devel \
 "
RDEPENDS:rust-rand_pcg0.2+serde-devel = " \
 cargo \
 rust-rand_pcg0.2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_pcg0.2+serde1-devel = " \
 cargo \
 rust-rand_pcg0.2+serde-devel \
 rust-rand_pcg0.2-devel \
 "
RDEPENDS:rust-rand_pcg0.2-devel = " \
 cargo \
 rust-rand_core0.5+default-devel \
 "
