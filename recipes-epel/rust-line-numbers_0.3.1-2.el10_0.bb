# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-line-numbers"
PV = "0.3.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-line-numbers+default-devel \
 rust-line-numbers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-line-numbers-0.3.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "320b76aa842f494999ada8fa4e5006ba30e3cffa1a941336e01c54f093a3c032"

URI_x86_64_v2_rust-line-numbers+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-line-numbers+default-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-line-numbers+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-line-numbers+default-devel}"
SRC_URI[x86_64_v2_rust-line-numbers+default-devel.sha256sum] = "e5b5e476bfdbf37b85f16cc02e1d174c92105eec64567236428d9339ed5fc652"

URI_x86_64_v2_rust-line-numbers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-line-numbers-devel-0.3.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-line-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-line-numbers-devel}"
SRC_URI[x86_64_v2_rust-line-numbers-devel.sha256sum] = "906c425b6b2b4650a28db84d6960aba8a97ef7e84a519c8f5e5a5ba23223b233"

URI_aarch64_rust-line-numbers+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-line-numbers+default-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-line-numbers+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-line-numbers+default-devel}"
SRC_URI[aarch64_rust-line-numbers+default-devel.sha256sum] = "21af83fe148b00d70ff70f6164651f1d66153f4b982fec8df125070fc584b361"

URI_aarch64_rust-line-numbers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-line-numbers-devel-0.3.1-2.el10_0.noarch.rpm;name=aarch64_rust-line-numbers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-line-numbers-devel}"
SRC_URI[aarch64_rust-line-numbers-devel.sha256sum] = "e6b78cd697f3c0979c8b6b7914d4ad3d92201d8734edebe2536871d096958196"

RDEPENDS:rust-line-numbers+default-devel = " \
 cargo \
 rust-line-numbers-devel \
 "
RDEPENDS:rust-line-numbers-devel = " \
 cargo \
 rust \
 "
