# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "stb"
PV = "0^20260313git904aa67"
PR = "2.el10_3"
PACKAGES = " \
 stb-devel \
 stb-doc \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/stb-0^20260313git904aa67-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ddd27526bb00b2cdd3e779ec622c03f20a60e0ce0bf5a6a01b3f76337546aa8"

URI_x86_64_v2_stb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-devel-0^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb-devel}"
SRC_URI[x86_64_v2_stb-devel.sha256sum] = "3da1c08f74a8339680b8e78aa432cfc5f4662a366dda75247386c661897cb12a"

URI_x86_64_v2_stb-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb-doc-0^20260313git904aa67-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_stb-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb-doc}"
SRC_URI[x86_64_v2_stb-doc.sha256sum] = "5ea8deecf58075cc3aaa394de724fdc806ebdc306afef9e15a253cb4495d7b7e"

URI_x86_64_v2_stb_c_lexer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_c_lexer-devel-0.12^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_c_lexer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_c_lexer-devel}"
SRC_URI[x86_64_v2_stb_c_lexer-devel.sha256sum] = "7ee4071a73532730ddede7697cf612ad8a4ce6adc0fe8a273f3ef40cf3a840bf"

URI_x86_64_v2_stb_connected_components-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_connected_components-devel-0.96^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_connected_components-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_connected_components-devel}"
SRC_URI[x86_64_v2_stb_connected_components-devel.sha256sum] = "0e12be137f391096fa1fdd1f18e6cceb91ee3fca8602ad4e3beec9b788f81543"

URI_x86_64_v2_stb_divide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_divide-devel-0.94^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_divide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_divide-devel}"
SRC_URI[x86_64_v2_stb_divide-devel.sha256sum] = "1806c78ced50d8ae26af679a4fab07ae2fd2f1a47976ec8c7596f9dcb9a36fac"

URI_x86_64_v2_stb_ds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_ds-devel-0.67^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_ds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_ds-devel}"
SRC_URI[x86_64_v2_stb_ds-devel.sha256sum] = "5681b652359d7f86ddad5edbf965f49a85ea659e477022233a62623eba2e0d1d"

URI_x86_64_v2_stb_dxt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_dxt-devel-1.12^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_dxt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_dxt-devel}"
SRC_URI[x86_64_v2_stb_dxt-devel.sha256sum] = "5903f4ba826f43bb6b2e2d47667ea820b5b8e10590eb149da91466afd6f1c653"

URI_x86_64_v2_stb_easy_font-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_easy_font-devel-1.1^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_easy_font-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_easy_font-devel}"
SRC_URI[x86_64_v2_stb_easy_font-devel.sha256sum] = "938c77c809879bba5ae1c3918cf01da517c73e85c265e483c7fa4aa2b28b9ed6"

URI_x86_64_v2_stb_herringbone_wang_tile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_herringbone_wang_tile-devel-0.7^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_herringbone_wang_tile-devel}"
SRC_URI[x86_64_v2_stb_herringbone_wang_tile-devel.sha256sum] = "49ce3deb9a9c6e510b692e31102451ba411a44e00fa8bfd9be65f053ff4ebabc"

URI_x86_64_v2_stb_hexwave-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_hexwave-devel-0.5^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_hexwave-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_hexwave-devel}"
SRC_URI[x86_64_v2_stb_hexwave-devel.sha256sum] = "ff31af97ca2ce314bdc4f6b15bd63ee41841ab811f21d3dcadbdd91714496fb0"

URI_x86_64_v2_stb_image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image-devel-2.30^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image-devel}"
SRC_URI[x86_64_v2_stb_image-devel.sha256sum] = "674f2a8c1062bb17fe301f241b62c1a786014a6f01ee0ce1b7c1baea8816497d"

URI_x86_64_v2_stb_image_resize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize-devel-0.97^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_resize-devel}"
SRC_URI[x86_64_v2_stb_image_resize-devel.sha256sum] = "c2e0f703d4bc097079173ea10b77a52b8321fd6ebd6bd2db1676d7d608d1d4bc"

URI_x86_64_v2_stb_image_resize2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_resize2-devel-2.18^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_resize2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_resize2-devel}"
SRC_URI[x86_64_v2_stb_image_resize2-devel.sha256sum] = "51e370cdef7fcf68afe6fa2bdd6f87d1022f386300b6a660ec14ce5aa04cab20"

URI_x86_64_v2_stb_image_write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_image_write-devel-1.16^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_image_write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_image_write-devel}"
SRC_URI[x86_64_v2_stb_image_write-devel.sha256sum] = "a675123080d6ad07a1f687846de0518c5bf2a1afcfd7890c9df4e205c910e236"

URI_x86_64_v2_stb_leakcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_leakcheck-devel-0.6^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_leakcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_leakcheck-devel}"
SRC_URI[x86_64_v2_stb_leakcheck-devel.sha256sum] = "4614c1032976acd3c8dc61350a1060bf6a05f9d58e68fed1789aea70288d7736"

URI_x86_64_v2_stb_perlin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_perlin-devel-0.5^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_perlin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_perlin-devel}"
SRC_URI[x86_64_v2_stb_perlin-devel.sha256sum] = "29417c20c3fd2b68708a6330a567abd6648adf9a303e23ac3240c53297f7399c"

URI_x86_64_v2_stb_rect_pack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_rect_pack-devel-1.1^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_rect_pack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_rect_pack-devel}"
SRC_URI[x86_64_v2_stb_rect_pack-devel.sha256sum] = "fbe0b3e3711a29f6548e80737b84cae86d6d4e62727ca7fd0f9b2bb5b72d7b8a"

URI_x86_64_v2_stb_sprintf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_sprintf-devel-1.10^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_sprintf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_sprintf-devel}"
SRC_URI[x86_64_v2_stb_sprintf-devel.sha256sum] = "d71145a62cb26f7ad04813483b491094baab1cb3c6bfa361a4d47f18901760b5"

URI_x86_64_v2_stb_textedit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_textedit-devel-1.14^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_textedit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_textedit-devel}"
SRC_URI[x86_64_v2_stb_textedit-devel.sha256sum] = "a4eaa0c2a82cf8e51c65587bd31b51f2cc1c27665bffa9dee987acbd82409cc1"

URI_x86_64_v2_stb_tilemap_editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_tilemap_editor-devel-0.42^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_tilemap_editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_tilemap_editor-devel}"
SRC_URI[x86_64_v2_stb_tilemap_editor-devel.sha256sum] = "79669a596ace6ba6c8be97a51643c157276b1afd6dce870579a00429ed2a239b"

URI_x86_64_v2_stb_truetype-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_truetype-devel-1.26^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_truetype-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_truetype-devel}"
SRC_URI[x86_64_v2_stb_truetype-devel.sha256sum] = "ac238e7533ed07dd45361096496e857fff53abf640249f64949bfae7f2ae98f7"

URI_x86_64_v2_stb_vorbis-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_vorbis-devel-1.22^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_vorbis-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_vorbis-devel}"
SRC_URI[x86_64_v2_stb_vorbis-devel.sha256sum] = "475c84bd8c95d580b820f598b55da3490c82105edad94978d7db52dac776fb3c"

URI_x86_64_v2_stb_voxel_render-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/stb_voxel_render-devel-0.89^20260313git904aa67-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_stb_voxel_render-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_stb_voxel_render-devel}"
SRC_URI[x86_64_v2_stb_voxel_render-devel.sha256sum] = "d63063acc5aa2966e63e0ffb4b283945b05c3493fe951747e8a2b828fcf570d4"

URI_aarch64_stb-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb-devel-0^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb-devel}"
SRC_URI[aarch64_stb-devel.sha256sum] = "c10ffe412c0dfa6fc0e457e92c15c42052ef48f66ca6e6989bb329f8ce23738d"

URI_aarch64_stb-doc = "${EPEL_MIRROR}/aarch64/Packages/s/stb-doc-0^20260313git904aa67-2.el10_3.noarch.rpm;name=aarch64_stb-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb-doc}"
SRC_URI[aarch64_stb-doc.sha256sum] = "076ec4724246592c5e816953c97b0bbee4707e697518f83a2d64944b39303332"

URI_aarch64_stb_c_lexer-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_c_lexer-devel-0.12^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_c_lexer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_c_lexer-devel}"
SRC_URI[aarch64_stb_c_lexer-devel.sha256sum] = "1542a17e1eb4aebb71ef743232a4f1367f15bf114faeab28c1afdb165a7923cf"

URI_aarch64_stb_connected_components-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_connected_components-devel-0.96^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_connected_components-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_connected_components-devel}"
SRC_URI[aarch64_stb_connected_components-devel.sha256sum] = "b0d917f12e7bd88eddc2b606c309e7a47718b1ad3b14f689bb3d8db5b3f003c7"

URI_aarch64_stb_divide-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_divide-devel-0.94^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_divide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_divide-devel}"
SRC_URI[aarch64_stb_divide-devel.sha256sum] = "9cd27dc6bccd56355d256c5d551ff9dfa60e298a752af5941533a5834a0de4af"

URI_aarch64_stb_ds-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_ds-devel-0.67^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_ds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_ds-devel}"
SRC_URI[aarch64_stb_ds-devel.sha256sum] = "c7d523b5baeae4577ceb7e7c2e93ca862da924ec8dd367f9381a1a4da8e435a9"

URI_aarch64_stb_dxt-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_dxt-devel-1.12^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_dxt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_dxt-devel}"
SRC_URI[aarch64_stb_dxt-devel.sha256sum] = "e5af47fb648aef25601cf20bb741a06c70131b8cef2a59d164890f930403839b"

URI_aarch64_stb_easy_font-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_easy_font-devel-1.1^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_easy_font-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_easy_font-devel}"
SRC_URI[aarch64_stb_easy_font-devel.sha256sum] = "4dcaab9f226267bfa394e33abf4424deb06e9634db28a5dbca0cf3b5c8393276"

URI_aarch64_stb_herringbone_wang_tile-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_herringbone_wang_tile-devel-0.7^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_herringbone_wang_tile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_herringbone_wang_tile-devel}"
SRC_URI[aarch64_stb_herringbone_wang_tile-devel.sha256sum] = "1806c06eeddfca91f5f0429edd7625fd6d2c496c77bc64cb68781b6f0c79e282"

URI_aarch64_stb_hexwave-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_hexwave-devel-0.5^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_hexwave-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_hexwave-devel}"
SRC_URI[aarch64_stb_hexwave-devel.sha256sum] = "ee2b888a42d75ac54510e64c313539e28872da2df664ec18c4c14690606d4765"

URI_aarch64_stb_image-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image-devel-2.30^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image-devel}"
SRC_URI[aarch64_stb_image-devel.sha256sum] = "b59fcce80c65afb5bf758304f36ec5bb5b72500bc0ccdc176965805c31d73c34"

URI_aarch64_stb_image_resize-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize-devel-0.97^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_image_resize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_resize-devel}"
SRC_URI[aarch64_stb_image_resize-devel.sha256sum] = "68c4a5de715c9b28d35aa3a553d35b2b9245283e7a380ceeac733cb2145117bb"

URI_aarch64_stb_image_resize2-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_resize2-devel-2.18^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_image_resize2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_resize2-devel}"
SRC_URI[aarch64_stb_image_resize2-devel.sha256sum] = "c915ed6c3b7683d56a627c1bf496f92777374f71da79c3bd6daa6b111c5f892d"

URI_aarch64_stb_image_write-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_image_write-devel-1.16^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_image_write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_image_write-devel}"
SRC_URI[aarch64_stb_image_write-devel.sha256sum] = "33be0692f3ca678dc4d1d587b0bb323445f69675c3fa4d4c13f891788d506e73"

URI_aarch64_stb_leakcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_leakcheck-devel-0.6^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_leakcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_leakcheck-devel}"
SRC_URI[aarch64_stb_leakcheck-devel.sha256sum] = "8def99ab0586e31f95869479cd5a3a5cac121bbdbdd801cd1d4c6e2984b5651f"

URI_aarch64_stb_perlin-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_perlin-devel-0.5^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_perlin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_perlin-devel}"
SRC_URI[aarch64_stb_perlin-devel.sha256sum] = "b303b2cb0e4263d9353618bad95433af09ec6029f75fc20e9360970ad94e31b2"

URI_aarch64_stb_rect_pack-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_rect_pack-devel-1.1^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_rect_pack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_rect_pack-devel}"
SRC_URI[aarch64_stb_rect_pack-devel.sha256sum] = "9b94303bc9695b64358a04cf1bc5011d390bd530175936640b324ef9d8ecd5c7"

URI_aarch64_stb_sprintf-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_sprintf-devel-1.10^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_sprintf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_sprintf-devel}"
SRC_URI[aarch64_stb_sprintf-devel.sha256sum] = "04d11b898be81c04dbd9b9c6a8bb9b424cc4f8cbce25ef1e4cf1066d5922e825"

URI_aarch64_stb_textedit-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_textedit-devel-1.14^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_textedit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_textedit-devel}"
SRC_URI[aarch64_stb_textedit-devel.sha256sum] = "12b70baf0bdb0d264afef078a4e6696c2b859347e4b308b490b216a87f881a2c"

URI_aarch64_stb_tilemap_editor-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_tilemap_editor-devel-0.42^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_tilemap_editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_tilemap_editor-devel}"
SRC_URI[aarch64_stb_tilemap_editor-devel.sha256sum] = "58439a7330d16f11c8bb9702e42e27dc5e6b4a07389e13152afef6cb4221b9aa"

URI_aarch64_stb_truetype-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_truetype-devel-1.26^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_truetype-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_truetype-devel}"
SRC_URI[aarch64_stb_truetype-devel.sha256sum] = "75a5a8be2d3da7700b4ab2903132224a141cf83a34e5de828514a5c65738340e"

URI_aarch64_stb_vorbis-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_vorbis-devel-1.22^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_vorbis-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_vorbis-devel}"
SRC_URI[aarch64_stb_vorbis-devel.sha256sum] = "8054cceeb39f612d7618ddf7cdf365127d1b810a0278770bcd44e8ce13e3a097"

URI_aarch64_stb_voxel_render-devel = "${EPEL_MIRROR}/aarch64/Packages/s/stb_voxel_render-devel-0.89^20260313git904aa67-2.el10_3.aarch64.rpm;name=aarch64_stb_voxel_render-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_stb_voxel_render-devel}"
SRC_URI[aarch64_stb_voxel_render-devel.sha256sum] = "5de7b717d362223441451366f58cd9a0cfb3e9c8a154141f76d5384885250495"

RDEPENDS:stb-devel = " \
 stb_c_lexer-devel \
 stb_connected_components-devel \
 stb_divide-devel \
 stb_ds-devel \
 stb_dxt-devel \
 stb_easy_font-devel \
 stb_herringbone_wang_tile-devel \
 stb_hexwave-devel \
 stb_image-devel \
 stb_image_resize2-devel \
 stb_image_write-devel \
 stb_leakcheck-devel \
 stb_perlin-devel \
 stb_rect_pack-devel \
 stb_sprintf-devel \
 stb_textedit-devel \
 stb_tilemap_editor-devel \
 stb_truetype-devel \
 stb_vorbis-devel \
 stb_voxel_render-devel \
 "
RDEPENDS:stb-doc = " \
 "
RDEPENDS:stb_c_lexer-devel = " \
 "
RDEPENDS:stb_connected_components-devel = " \
 "
RDEPENDS:stb_divide-devel = " \
 "
RDEPENDS:stb_ds-devel = " \
 "
RDEPENDS:stb_dxt-devel = " \
 "
RDEPENDS:stb_easy_font-devel = " \
 "
RDEPENDS:stb_herringbone_wang_tile-devel = " \
 "
RDEPENDS:stb_hexwave-devel = " \
 "
RDEPENDS:stb_image-devel = " \
 "
RDEPENDS:stb_image_resize-devel = " \
 "
RDEPENDS:stb_image_resize2-devel = " \
 "
RDEPENDS:stb_image_write-devel = " \
 "
RDEPENDS:stb_leakcheck-devel = " \
 "
RDEPENDS:stb_perlin-devel = " \
 "
RDEPENDS:stb_rect_pack-devel = " \
 "
RDEPENDS:stb_sprintf-devel = " \
 "
RDEPENDS:stb_textedit-devel = " \
 "
RDEPENDS:stb_tilemap_editor-devel = " \
 "
RDEPENDS:stb_truetype-devel = " \
 "
RDEPENDS:stb_vorbis-devel = " \
 "
RDEPENDS:stb_voxel_render-devel = " \
 "
