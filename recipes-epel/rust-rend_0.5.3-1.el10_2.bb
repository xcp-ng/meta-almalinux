# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rend"
PV = "0.5.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-rend+bytecheck-devel \
 rust-rend+default-devel \
 rust-rend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rend-0.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b80e806b72f7ceb6d60554d71aeca470690b7f97a6e02f2107fca91984a47ea5"

URI_x86_64_v2_rust-rend+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend+bytecheck-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rend+bytecheck-devel.sha256sum] = "96cb9175b2294e512cf05c7e5801e39409ec1907cc9464f5472c651a2ee3aa0c"

URI_x86_64_v2_rust-rend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend+default-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend+default-devel}"
SRC_URI[x86_64_v2_rust-rend+default-devel.sha256sum] = "9beb758a504129983e056753c1130cb4c1a76ce0254bd321ed751fe124e2957d"

URI_x86_64_v2_rust-rend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend-devel}"
SRC_URI[x86_64_v2_rust-rend-devel.sha256sum] = "cef244c60b87c5cba7dac26517a50719cc58f32019eea8f4ad3d0d996ec87d7e"

URI_aarch64_rust-rend+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend+bytecheck-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-rend+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend+bytecheck-devel}"
SRC_URI[aarch64_rust-rend+bytecheck-devel.sha256sum] = "a32e48aedbb208d731b0c649c28b080ffadf925f21befda48685601b33601338"

URI_aarch64_rust-rend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend+default-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-rend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend+default-devel}"
SRC_URI[aarch64_rust-rend+default-devel.sha256sum] = "0f33668d5273721bddc3a9ecaebf13d80594f15d01097fb40b06d62599259128"

URI_aarch64_rust-rend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-rend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend-devel}"
SRC_URI[aarch64_rust-rend-devel.sha256sum] = "746dcc162722cd60ffb2c20b2b90ac443226393c790be67fb65cc86502d4e2f9"

RDEPENDS:rust-rend+bytecheck-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-rend-devel \
 "
RDEPENDS:rust-rend+default-devel = " \
 cargo \
 rust-rend-devel \
 "
RDEPENDS:rust-rend-devel = " \
 cargo \
 "
