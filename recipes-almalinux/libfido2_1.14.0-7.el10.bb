# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libfido2"
PV = "1.14.0"
PR = "7.el10"
PACKAGES = " \
 fido2-tools \
 libfido2 \
 libfido2-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libfido2-1.14.0-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34836fe9e15a44f01eb71f086491cd52569c86288fcfc46b2d9e8f34cd61b9f8"

URI_x86_64_v2_fido2-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/fido2-tools-1.14.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_fido2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fido2-tools}"
SRC_URI[x86_64_v2_fido2-tools.sha256sum] = "129e7a5321475d4f29d67dc93c99a7868ac8bbd3789deaac2005c6b58230622c"

URI_x86_64_v2_libfido2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libfido2-1.14.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libfido2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfido2}"
SRC_URI[x86_64_v2_libfido2.sha256sum] = "c20d37af21563d2495f276d74b5283019a94c4e88a58ab2e029552972d04d6a7"

URI_x86_64_v2_libfido2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfido2-devel-1.14.0-7.el10.x86_64_v2.rpm;name=x86_64_v2_libfido2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfido2-devel}"
SRC_URI[x86_64_v2_libfido2-devel.sha256sum] = "39e83d83429d8297066d89c656de3a91a7a61a3e76edc74910cf687cb7edb6a3"

URI_aarch64_fido2-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/fido2-tools-1.14.0-7.el10.aarch64.rpm;name=aarch64_fido2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_fido2-tools}"
SRC_URI[aarch64_fido2-tools.sha256sum] = "4cb014c16946d0225adf4c0084bf6f8c11f13b0f36e27c7ec3b1342c60322998"

URI_aarch64_libfido2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libfido2-1.14.0-7.el10.aarch64.rpm;name=aarch64_libfido2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfido2}"
SRC_URI[aarch64_libfido2.sha256sum] = "c95bf60c4afadb817105154e8868ba7ad3cd705e59c6f4e6687834bf6dd9f38b"

URI_aarch64_libfido2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfido2-devel-1.14.0-7.el10.aarch64.rpm;name=aarch64_libfido2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfido2-devel}"
SRC_URI[aarch64_libfido2-devel.sha256sum] = "4690b0fce6cd4dcbbf121f5c672894c360024e54635ac0dd16437639ffdcb85d"

RDEPENDS:fido2-tools = " \
 glibc \
 libcbor \
 libfido2 \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libfido2 = " \
 glibc \
 libcbor \
 openssl-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:libfido2-devel = " \
 libfido2 \
 openssl-devel \
 pkgconf-pkg-config \
 "
