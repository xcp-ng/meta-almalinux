# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-deflate64"
PV = "0.1.10"
PR = "1.el10_1"
PACKAGES = " \
 rust-deflate64+default-devel \
 rust-deflate64-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-deflate64-0.1.10-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c7a8a31d10880b263d49f5397d3e6ea7388b85da1a291a88a1b84d3d871ad20"

URI_x86_64_v2_rust-deflate64+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64+default-devel-0.1.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64+default-devel}"
SRC_URI[x86_64_v2_rust-deflate64+default-devel.sha256sum] = "0d81a6208b669b81dda946db9ba684f3ee4f4dd3fd4b2d54a794c328df320246"

URI_x86_64_v2_rust-deflate64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-deflate64-devel-0.1.10-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-deflate64-devel}"
SRC_URI[x86_64_v2_rust-deflate64-devel.sha256sum] = "0c32b7e0eca75765797d441ce593ca11661d13f80d988f510ad730682bade4fd"

URI_aarch64_rust-deflate64+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64+default-devel-0.1.10-1.el10_1.noarch.rpm;name=aarch64_rust-deflate64+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64+default-devel}"
SRC_URI[aarch64_rust-deflate64+default-devel.sha256sum] = "f2de452b20ba9bc5eb5c4b196c8cad7c0655f214ee36533832fdcd03854607ca"

URI_aarch64_rust-deflate64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-deflate64-devel-0.1.10-1.el10_1.noarch.rpm;name=aarch64_rust-deflate64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-deflate64-devel}"
SRC_URI[aarch64_rust-deflate64-devel.sha256sum] = "4bec265037d9008d4a0e9614b1361aaa55e759f91000ecb5c85ada76ff8ac709"

RDEPENDS:rust-deflate64+default-devel = " \
 cargo \
 rust-deflate64-devel \
 "
RDEPENDS:rust-deflate64-devel = " \
 cargo \
 "
