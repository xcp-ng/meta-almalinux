# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nextcloud"
PV = "34.0.4"
PR = "1.el10_3"
PACKAGES = " \
 nextcloud \
 nextcloud-httpd \
 nextcloud-mysql \
 nextcloud-nginx \
 nextcloud-postgresql \
 nextcloud-sqlite \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/nextcloud-34.0.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f32356a4a43dfdb616924866c7242cbc6ef3631652411453bf76588e69b76b1e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-34.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud;unpack=0"
SRC_URI[x86_64_v2_nextcloud.sha256sum] = "a317ec2ff3997028f0462a2198828b47a1857da70ccda50ff3d504aa34a89725"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-httpd-34.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-httpd;unpack=0"
SRC_URI[x86_64_v2_nextcloud-httpd.sha256sum] = "05d90bffc842dd5c5a89860929628c22b96c559ef496f24f00eeff662e09332e"
RPROVIDES:nextcloud-httpd:append:x86_64_v2 = " virtual/nextcloud-webserver_eq_34.0.4-1.el10_3.alma_altarch"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-mysql-34.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-mysql;unpack=0"
SRC_URI[x86_64_v2_nextcloud-mysql.sha256sum] = "ce40a6e172942954c95316bab69b8a9e39c6a323257b152a9635f6b5a6f8ae8d"
RPROVIDES:nextcloud-mysql:append:x86_64_v2 = " virtual/nextcloud-database_eq_34.0.4-1.el10_3.alma_altarch"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-nginx-34.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-nginx;unpack=0"
SRC_URI[x86_64_v2_nextcloud-nginx.sha256sum] = "69cdd07abd2b658a64016a7a0f60117ce61258b1d68c50c33d66c5030491be23"
RPROVIDES:nextcloud-nginx:append:x86_64_v2 = " virtual/nextcloud-webserver_eq_34.0.4-1.el10_3.alma_altarch"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-postgresql-34.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-postgresql;unpack=0"
SRC_URI[x86_64_v2_nextcloud-postgresql.sha256sum] = "cda0c2e85bd439a5a6cbefb0b373b7883ada85499422c7770e95095ea266d363"
RPROVIDES:nextcloud-postgresql:append:x86_64_v2 = " virtual/nextcloud-database_eq_34.0.4-1.el10_3.alma_altarch"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nextcloud-sqlite-34.0.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nextcloud-sqlite;unpack=0"
SRC_URI[x86_64_v2_nextcloud-sqlite.sha256sum] = "500b5d55d30344115a291eaa9821b57ca6d519502f146931d07b57c11a99cdcb"
RPROVIDES:nextcloud-sqlite:append:x86_64_v2 = " virtual/nextcloud-database_eq_34.0.4-1.el10_3.alma_altarch"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-34.0.4-1.el10_3.noarch.rpm;name=aarch64_nextcloud;unpack=0"
SRC_URI[aarch64_nextcloud.sha256sum] = "d2103525425e5c4461b22c7c2f51d712a3a987c8184ffa2932c1002270b7256a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-httpd-34.0.4-1.el10_3.noarch.rpm;name=aarch64_nextcloud-httpd;unpack=0"
SRC_URI[aarch64_nextcloud-httpd.sha256sum] = "7060912be7bf80331c018b30c18da996711df85650b3002906b1366fbe25b432"
RPROVIDES:nextcloud-httpd:append:aarch64 = " virtual/nextcloud-webserver_eq_34.0.4-1.el10_3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-mysql-34.0.4-1.el10_3.noarch.rpm;name=aarch64_nextcloud-mysql;unpack=0"
SRC_URI[aarch64_nextcloud-mysql.sha256sum] = "f25c81090fcd8dbf36f6c09e49c5bfe0e7cd7f9a9bf941c594d87568c2093bb3"
RPROVIDES:nextcloud-mysql:append:aarch64 = " virtual/nextcloud-database_eq_34.0.4-1.el10_3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-nginx-34.0.4-1.el10_3.noarch.rpm;name=aarch64_nextcloud-nginx;unpack=0"
SRC_URI[aarch64_nextcloud-nginx.sha256sum] = "54b98288f7be257f30ebdb3acb24bbab7a63a9e0ae4f4d54e32d13b36dd2f94b"
RPROVIDES:nextcloud-nginx:append:aarch64 = " virtual/nextcloud-webserver_eq_34.0.4-1.el10_3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-postgresql-34.0.4-1.el10_3.noarch.rpm;name=aarch64_nextcloud-postgresql;unpack=0"
SRC_URI[aarch64_nextcloud-postgresql.sha256sum] = "e2f89d0c49d0ac4c559408adcf160b2b3656402dbfa2b5052dbd6639f8db380b"
RPROVIDES:nextcloud-postgresql:append:aarch64 = " virtual/nextcloud-database_eq_34.0.4-1.el10_3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/nextcloud-sqlite-34.0.4-1.el10_3.noarch.rpm;name=aarch64_nextcloud-sqlite;unpack=0"
SRC_URI[aarch64_nextcloud-sqlite.sha256sum] = "8114a697d88745d2c62be220ef847fa828302bb9665f9faa6a1cfce35edd9fe6"
RPROVIDES:nextcloud-sqlite:append:aarch64 = " virtual/nextcloud-database_eq_34.0.4-1.el10_3"

RDEPENDS:nextcloud:x86_64_v2 = " \
 bash \
 ca-certificates \
 php-pecl-imagick \
 php-pecl-memcached \
 php-smbclient \
 systemd \
 virtual//usr/bin/php \
 virtual/nextcloud-database_eq_34.0.4-1.el10_3.alma_altarch \
 virtual/nextcloud-webserver_eq_34.0.4-1.el10_3.alma_altarch \
 virtual/php-bcmath \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gmp \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-opcache \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-pecl-apcu \
 virtual/php-pecl-redis6_or_php-pecl-redis5 \
 virtual/php-process \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-spl \
 virtual/php-xmlwriter \
 virtual/php-zip \
"
RDEPENDS:nextcloud:aarch64 = " \
 bash \
 ca-certificates \
 php-pecl-imagick \
 php-pecl-memcached \
 php-smbclient \
 systemd \
 virtual//usr/bin/php \
 virtual/nextcloud-database_eq_34.0.4-1.el10_3 \
 virtual/nextcloud-webserver_eq_34.0.4-1.el10_3 \
 virtual/php-bcmath \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-dom \
 virtual/php-exif \
 virtual/php-fileinfo \
 virtual/php-filter \
 virtual/php-gd \
 virtual/php-gmp \
 virtual/php-iconv \
 virtual/php-intl \
 virtual/php-json \
 virtual/php-ldap \
 virtual/php-mbstring \
 virtual/php-opcache \
 virtual/php-openssl \
 virtual/php-pcre \
 virtual/php-pdo \
 virtual/php-pecl-apcu \
 virtual/php-pecl-redis6_or_php-pecl-redis5 \
 virtual/php-process \
 virtual/php-session \
 virtual/php-simplexml \
 virtual/php-spl \
 virtual/php-xmlwriter \
 virtual/php-zip \
"
RDEPENDS:nextcloud-httpd = " \
 bash \
 httpd \
 nextcloud \
 virtual/php-fpm \
 "
RDEPENDS:nextcloud-mysql = " \
 nextcloud \
 virtual/php-mysqlnd \
 "
RDEPENDS:nextcloud-nginx = " \
 bash \
 nextcloud \
 nginx \
 virtual/php-fpm \
 "
RDEPENDS:nextcloud-postgresql = " \
 nextcloud \
 virtual/php-pgsql \
 "
RDEPENDS:nextcloud-sqlite = " \
 nextcloud \
 "
