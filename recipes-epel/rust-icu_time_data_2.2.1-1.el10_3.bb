# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_time_data"
PV = "2.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_time_data+default-devel \
 rust-icu_time_data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_time_data-2.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "efbff527f6260399bb73e5219fdcde9cb1ce28b6fad59d1ef588a648fe9bd6ad"

URI_x86_64_v2_rust-icu_time_data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time_data+default-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time_data+default-devel}"
SRC_URI[x86_64_v2_rust-icu_time_data+default-devel.sha256sum] = "e9ed32190657bfde7d82ad3909fe81f5983584e69519f9b41f143893733ac1a0"

URI_x86_64_v2_rust-icu_time_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_time_data-devel-2.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_time_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_time_data-devel}"
SRC_URI[x86_64_v2_rust-icu_time_data-devel.sha256sum] = "a89d74bf4fda9b0dfd444f33262c11556e563c022928a4e804172c628abe3f20"

URI_aarch64_rust-icu_time_data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time_data+default-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time_data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time_data+default-devel}"
SRC_URI[aarch64_rust-icu_time_data+default-devel.sha256sum] = "3c0b53512b970c8df38145dff5dbc77a93a35864120b7c09d50aea2168ed4abb"

URI_aarch64_rust-icu_time_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_time_data-devel-2.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-icu_time_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_time_data-devel}"
SRC_URI[aarch64_rust-icu_time_data-devel.sha256sum] = "ee5c8a99b3451ccbb7d468815b9118124a13d1df49e367eca1dc5919eb348875"

RDEPENDS:rust-icu_time_data+default-devel = " \
 cargo \
 rust-icu_time_data-devel \
 "
RDEPENDS:rust-icu_time_data-devel = " \
 cargo \
 rust \
 "
