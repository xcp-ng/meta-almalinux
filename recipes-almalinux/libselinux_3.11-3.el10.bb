# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libselinux"
PV = "3.11"
PR = "3.el10"
PACKAGES = " \
 libselinux \
 libselinux-devel \
 libselinux-ruby \
 libselinux-static \
 libselinux-utils \
 python3-libselinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libselinux-3.11-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8c1ec0783f3e8d9cc354f0d56f43620fd920be6930fecde5d51a96e39d1f72a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-3.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux;unpack=0"
SRC_URI[x86_64_v2_libselinux.sha256sum] = "6b2869d65574403b69df99afe049dad975e8d6a1d8691dc9e3e0dd8937988b5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-devel-3.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-devel;unpack=0"
SRC_URI[x86_64_v2_libselinux-devel.sha256sum] = "3f8cca91b9e8d8ed417b1911718faa1c99677dc0708f8501ec051099cec8bcc4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-ruby-3.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-ruby;unpack=0"
SRC_URI[x86_64_v2_libselinux-ruby.sha256sum] = "c4b7e50cc6226562e6f2cae0ec9b94ec233a3d96ef7142e2c017342be6e8982e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libselinux-static-3.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-static;unpack=0"
SRC_URI[x86_64_v2_libselinux-static.sha256sum] = "afcbf73c5be3d3489a677cbf3da62bb6d738fc685d5501358cd330772613d9fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-utils-3.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-utils;unpack=0"
SRC_URI[x86_64_v2_libselinux-utils.sha256sum] = "05f73664906bf775085260e353f767d9982c42fb5cc21c8b5145268eca99e99f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libselinux-3.11-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libselinux;unpack=0"
SRC_URI[x86_64_v2_python3-libselinux.sha256sum] = "78e96226ea0e5651e6c493eb0c1a3be4275950867d1b42ef60fabba9687974b3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-3.11-3.el10.aarch64.rpm;name=aarch64_libselinux;unpack=0"
SRC_URI[aarch64_libselinux.sha256sum] = "945cfc297fae4f04b86d9257c8462b4d7445c37e7574aa55147f218537e9a22d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-devel-3.11-3.el10.aarch64.rpm;name=aarch64_libselinux-devel;unpack=0"
SRC_URI[aarch64_libselinux-devel.sha256sum] = "9418bdda40703f768db5f4077a6331207b108f2fef636d51a6dc67c370c23772"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-ruby-3.11-3.el10.aarch64.rpm;name=aarch64_libselinux-ruby;unpack=0"
SRC_URI[aarch64_libselinux-ruby.sha256sum] = "9040a0eed397b109ed329fed8881255ec9d065b8dba43e709a90665a73cdab0b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libselinux-static-3.11-3.el10.aarch64.rpm;name=aarch64_libselinux-static;unpack=0"
SRC_URI[aarch64_libselinux-static.sha256sum] = "d08c609c797a7f1176403d17e4094ed7c8f1c2524dc620fe2156e32718b707df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-utils-3.11-3.el10.aarch64.rpm;name=aarch64_libselinux-utils;unpack=0"
SRC_URI[aarch64_libselinux-utils.sha256sum] = "ebbed9757622a7ab2753f3e359602a1886735eb97d4b58f992eb2e03a16b0706"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libselinux-3.11-3.el10.aarch64.rpm;name=aarch64_python3-libselinux;unpack=0"
SRC_URI[aarch64_python3-libselinux.sha256sum] = "926e424fa3b6600dec4b3a6e4f167902fac671d68abbd61f8e34fbe37a19391c"

RDEPENDS:libselinux = " \
 glibc \
 libgcc \
 libsepol \
 pcre2 \
 "
RDEPENDS:libselinux-devel = " \
 libselinux \
 libsepol-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libselinux-ruby = " \
 glibc \
 libselinux \
 ruby-libs \
 "
RDEPENDS:libselinux-static = " \
 libselinux-devel \
 "
RDEPENDS:libselinux-utils = " \
 glibc \
 libgcc \
 libselinux \
 libsepol \
 pcre2 \
 "
RDEPENDS:python3-libselinux = " \
 glibc \
 libselinux \
 python3 \
 "
