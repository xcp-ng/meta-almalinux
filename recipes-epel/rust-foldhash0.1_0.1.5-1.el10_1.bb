# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foldhash0.1"
PV = "0.1.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-foldhash0.1+default-devel \
 rust-foldhash0.1+std-devel \
 rust-foldhash0.1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foldhash0.1-0.1.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8fcc56f9e424d71a9078fe0578e77563d6676003ac5b4a45a00d95d456548850"

URI_x86_64_v2_rust-foldhash0.1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash0.1+default-devel-0.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash0.1+default-devel}"
SRC_URI[x86_64_v2_rust-foldhash0.1+default-devel.sha256sum] = "5ebda059f6f5336cdcf498026a3ce8b44d72ef16a46a2b55ad0bcc7acbe2a1e2"

URI_x86_64_v2_rust-foldhash0.1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash0.1+std-devel-0.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash0.1+std-devel}"
SRC_URI[x86_64_v2_rust-foldhash0.1+std-devel.sha256sum] = "ce2c101fa9de17da177a41454404f015a69433e24966b3340781c3f1b2f336f5"

URI_x86_64_v2_rust-foldhash0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foldhash0.1-devel-0.1.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foldhash0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foldhash0.1-devel}"
SRC_URI[x86_64_v2_rust-foldhash0.1-devel.sha256sum] = "ed25c153b9123ffa50aac8af7548b8d82d0507b3c77220317f667c0378eb5961"

URI_aarch64_rust-foldhash0.1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash0.1+default-devel-0.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-foldhash0.1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash0.1+default-devel}"
SRC_URI[aarch64_rust-foldhash0.1+default-devel.sha256sum] = "d3a9e171359b565f3d27104c7df3e7fad6851067b3d2205986f8efc6b413b468"

URI_aarch64_rust-foldhash0.1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash0.1+std-devel-0.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-foldhash0.1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash0.1+std-devel}"
SRC_URI[aarch64_rust-foldhash0.1+std-devel.sha256sum] = "7bf1630d73168c8019cb51c2721ca0a0e2cb66ab307b60250c236f6e4cc63f82"

URI_aarch64_rust-foldhash0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foldhash0.1-devel-0.1.5-1.el10_1.noarch.rpm;name=aarch64_rust-foldhash0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foldhash0.1-devel}"
SRC_URI[aarch64_rust-foldhash0.1-devel.sha256sum] = "5e4b59f4258b50255e95a203d8465ea35418829055a7b8fb349dde78a889f3fa"

RDEPENDS:rust-foldhash0.1+default-devel = " \
 cargo \
 rust-foldhash0.1+std-devel \
 rust-foldhash0.1-devel \
 "
RDEPENDS:rust-foldhash0.1+std-devel = " \
 cargo \
 rust-foldhash0.1-devel \
 "
RDEPENDS:rust-foldhash0.1-devel = " \
 cargo \
 rust \
 "
