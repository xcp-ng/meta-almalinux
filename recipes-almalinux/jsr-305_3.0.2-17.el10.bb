# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jsr-305"
PV = "3.0.2"
PR = "17.el10"
PACKAGES = " \
 jsr-305 \
 jsr-305-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jsr-305-3.0.2-17.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "20d57e36d3f72485668302e797fc7ee933b11537dd7f8d8ebeb762a42313817d"

URI_x86_64_v2_jsr-305 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jsr-305-3.0.2-17.el10.noarch.rpm;name=x86_64_v2_jsr-305;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsr-305}"
SRC_URI[x86_64_v2_jsr-305.sha256sum] = "25e06b527dee324df133c78a29f721650cb21804e8c1ca4c11065c85b40cafb0"

URI_x86_64_v2_jsr-305-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/jsr-305-javadoc-3.0.2-17.el10.noarch.rpm;name=x86_64_v2_jsr-305-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jsr-305-javadoc}"
SRC_URI[x86_64_v2_jsr-305-javadoc.sha256sum] = "05ec3149690d13975d63580718b98b60316ecf62cdd79528947340988ce76c84"

URI_aarch64_jsr-305 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jsr-305-3.0.2-17.el10.noarch.rpm;name=aarch64_jsr-305;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsr-305}"
SRC_URI[aarch64_jsr-305.sha256sum] = "25e06b527dee324df133c78a29f721650cb21804e8c1ca4c11065c85b40cafb0"

URI_aarch64_jsr-305-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/jsr-305-javadoc-3.0.2-17.el10.noarch.rpm;name=aarch64_jsr-305-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_jsr-305-javadoc}"
SRC_URI[aarch64_jsr-305-javadoc.sha256sum] = "05ec3149690d13975d63580718b98b60316ecf62cdd79528947340988ce76c84"

RDEPENDS:jsr-305 = " \
 javapackages-filesystem \
 "
RDEPENDS:jsr-305-javadoc = " \
 javapackages-filesystem \
 "
