# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-LWP-UserAgent"
PV = "0.036"
PR = "9.el10_0"
PACKAGES = " \
 perl-Test-LWP-UserAgent \
 perl-Test-LWP-UserAgent-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-LWP-UserAgent-0.036-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1910d126c61cfab99e1b57da704dc8dccac0deefa1ae6e641186725e4a76a297"

URI_x86_64_v2_perl-Test-LWP-UserAgent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-LWP-UserAgent-0.036-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-LWP-UserAgent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-LWP-UserAgent}"
SRC_URI[x86_64_v2_perl-Test-LWP-UserAgent.sha256sum] = "ac9c2f5e5a5116d74f892d073e95eb55df764f593f3d2c7abd5703d1383a508a"

URI_x86_64_v2_perl-Test-LWP-UserAgent-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-LWP-UserAgent-tests-0.036-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-LWP-UserAgent-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-LWP-UserAgent-tests}"
SRC_URI[x86_64_v2_perl-Test-LWP-UserAgent-tests.sha256sum] = "7c97e8bf7283390bc83602d960441eb2b9f5c219b89a61d9c2cb839f6777e35f"

URI_aarch64_perl-Test-LWP-UserAgent = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-LWP-UserAgent-0.036-9.el10_0.noarch.rpm;name=aarch64_perl-Test-LWP-UserAgent;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-LWP-UserAgent}"
SRC_URI[aarch64_perl-Test-LWP-UserAgent.sha256sum] = "c9c415a0310af296e7484b2fb63e8f312eb4faa6bd00028691d31eba0bbc5419"

URI_aarch64_perl-Test-LWP-UserAgent-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-LWP-UserAgent-tests-0.036-9.el10_0.noarch.rpm;name=aarch64_perl-Test-LWP-UserAgent-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-LWP-UserAgent-tests}"
SRC_URI[aarch64_perl-Test-LWP-UserAgent-tests.sha256sum] = "3ed4b2dff05b3cf417797e34b1a68cabe27c4fbd6bbd916c7198a4fefcb4bcf1"

RDEPENDS:perl-Test-LWP-UserAgent = " \
 perl-Carp \
 perl-HTTP-Date \
 perl-HTTP-Message \
 perl-Safe-Isa \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-Try-Tiny \
 perl-URI \
 perl-libs \
 perl-libwww-perl \
 perl-namespace-clean \
 perl-parent \
 "
RDEPENDS:perl-Test-LWP-UserAgent-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-HTTP-Message \
 perl-JSON-MaybeXS \
 perl-Module-Runtime-Conflicts \
 perl-Moose \
 perl-Path-Tiny \
 perl-PathTools \
 perl-Plack \
 perl-Scalar-List-Utils \
 perl-Test-Deep \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-LWP-UserAgent \
 perl-Test-Needs \
 perl-Test-Simple \
 perl-Test-Warnings \
 perl-URI \
 perl-if \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-libwww-perl \
 perl-overload \
 "
