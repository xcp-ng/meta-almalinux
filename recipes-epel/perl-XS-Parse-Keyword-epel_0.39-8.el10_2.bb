# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XS-Parse-Keyword-epel"
PV = "0.39"
PR = "8.el10_2"
PACKAGES = " \
 perl-XS-Parse-Keyword-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-XS-Parse-Keyword-epel-0.39-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30f835d787152844e4e61d55a2ac668c65c6d5174eeb76f52c9762a0048dc662"

URI_x86_64_v2_perl-XS-Parse-Keyword-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-XS-Parse-Keyword-tests-0.39-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-XS-Parse-Keyword-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XS-Parse-Keyword-tests}"
SRC_URI[x86_64_v2_perl-XS-Parse-Keyword-tests.sha256sum] = "6cf182bd0deaaacd42a9613dffb9018b9e0eb357036fcc03d902338c7d3744df"

URI_aarch64_perl-XS-Parse-Keyword-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-XS-Parse-Keyword-tests-0.39-8.el10_2.aarch64.rpm;name=aarch64_perl-XS-Parse-Keyword-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XS-Parse-Keyword-tests}"
SRC_URI[aarch64_perl-XS-Parse-Keyword-tests.sha256sum] = "6176a35f2847df9a2d33839b71a2c300526393886fc6dfcad257c23440958a49"

RDEPENDS:perl-XS-Parse-Keyword-tests = " \
 bash \
 glibc \
 perl-B \
 perl-Test-Harness \
 perl-Test2-Suite \
 perl-XS-Parse-Keyword \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
