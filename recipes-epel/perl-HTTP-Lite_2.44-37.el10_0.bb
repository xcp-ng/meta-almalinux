# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Lite"
PV = "2.44"
PR = "37.el10_0"
PACKAGES = " \
 perl-HTTP-Lite \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-Lite-2.44-37.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e99b81a5f34a8f0266e11230af382f08846ed76ee4282ec1b7a897a3495706e0"

URI_x86_64_v2_perl-HTTP-Lite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Lite-2.44-37.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Lite}"
SRC_URI[x86_64_v2_perl-HTTP-Lite.sha256sum] = "f01692fbd432d92d1b36bf661e5e0029b8f00a9568cf72e14debf91f1cdba496"

URI_aarch64_perl-HTTP-Lite = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Lite-2.44-37.el10_0.noarch.rpm;name=aarch64_perl-HTTP-Lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Lite}"
SRC_URI[aarch64_perl-HTTP-Lite.sha256sum] = "9e6a57ed88f2fe626309f80fd98161a0f56e3da78a8384ec69659aa54220e629"

RDEPENDS:perl-HTTP-Lite = " \
 perl-Errno \
 perl-Fcntl \
 perl-Socket \
 perl-libs \
 "
