# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-aws-v4"
PV = "3.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-aws-v4+default-devel \
 rust-reqsign-aws-v4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-aws-v4-3.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d4114645ffbc9a9dd69d7930d2bcf99e6e8781fdc2cfba67e3a5437a33998b37"

URI_x86_64_v2_rust-reqsign-aws-v4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aws-v4+default-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aws-v4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aws-v4+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aws-v4+default-devel.sha256sum] = "16ea6ab40707ee2b5a66eef4c1afa6328868ddb0c8e06ca7a6bc258ef81225e1"

URI_x86_64_v2_rust-reqsign-aws-v4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-aws-v4-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-aws-v4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-aws-v4-devel}"
SRC_URI[x86_64_v2_rust-reqsign-aws-v4-devel.sha256sum] = "0a98dde425668080ae67aae75e7a09165724e608a1980f714c6f380456624243"

URI_aarch64_rust-reqsign-aws-v4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aws-v4+default-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-aws-v4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aws-v4+default-devel}"
SRC_URI[aarch64_rust-reqsign-aws-v4+default-devel.sha256sum] = "7c5911b70408640f542eaf24947ae8e45a38441d521af7e44bef6d57ef2575f1"

URI_aarch64_rust-reqsign-aws-v4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-aws-v4-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-aws-v4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-aws-v4-devel}"
SRC_URI[aarch64_rust-reqsign-aws-v4-devel.sha256sum] = "c433151aa8b424a1a567149ffe61f64622b235785487e97bcb43b2d5f0cf3fe2"

RDEPENDS:rust-reqsign-aws-v4+default-devel = " \
 cargo \
 rust-reqsign-aws-v4-devel \
 "
RDEPENDS:rust-reqsign-aws-v4-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-hex+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-quick-xml+default-devel \
 rust-quick-xml+serialize-devel \
 rust-reqsign-core+default-devel \
 rust-rust-ini+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_urlencoded+default-devel \
 rust-sha1+default-devel \
 "
