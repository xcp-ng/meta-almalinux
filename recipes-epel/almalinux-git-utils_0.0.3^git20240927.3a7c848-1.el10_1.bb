# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "almalinux-git-utils"
PV = "0.0.3^git20240927.3a7c848"
PR = "1.el10_1"
PACKAGES = " \
 almalinux-git-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/almalinux-git-utils-0.0.3^git20240927.3a7c848-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "371b66fc18d4ff78776d19f951d85f7651b4a19da104f5358963ffc1419eb05e"

URI_x86_64_v2_almalinux-git-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/almalinux-git-utils-0.0.3^git20240927.3a7c848-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_almalinux-git-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-git-utils}"
SRC_URI[x86_64_v2_almalinux-git-utils.sha256sum] = "6f7ecafa7368da714e0cb5dc7bf98ae65566638385be0eb3fd8c1108daa0d8cb"

URI_aarch64_almalinux-git-utils = "${EPEL_MIRROR}/aarch64/Packages/a/almalinux-git-utils-0.0.3^git20240927.3a7c848-1.el10_1.noarch.rpm;name=aarch64_almalinux-git-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-git-utils}"
SRC_URI[aarch64_almalinux-git-utils.sha256sum] = "497f3f9891437893ddd8d7d83cedc530330e3f81af97ffeb6a4625f585f3ea0d"

RDEPENDS:almalinux-git-utils = " \
 python3 \
 python3-boto3 \
 python3-requests \
 "
