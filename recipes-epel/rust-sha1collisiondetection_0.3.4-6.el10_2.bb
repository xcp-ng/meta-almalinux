# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha1collisiondetection"
PV = "0.3.4"
PR = "6.el10_2"
PACKAGES = " \
 rust-sha1collisiondetection+clap-devel \
 rust-sha1collisiondetection+clap_mangen-devel \
 rust-sha1collisiondetection+const-oid-devel \
 rust-sha1collisiondetection+default-devel \
 rust-sha1collisiondetection+digest-devel \
 rust-sha1collisiondetection+digest-trait-devel \
 rust-sha1collisiondetection+oid-devel \
 rust-sha1collisiondetection+std-devel \
 rust-sha1collisiondetection-devel \
 sha1collisiondetection \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha1collisiondetection-0.3.4-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b627e04e249ed7383532bc753a9cc7268f7e5b13f74585aa3ef83c99073b4f9"

URI_x86_64_v2_rust-sha1collisiondetection+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1collisiondetection+clap-devel-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1collisiondetection+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1collisiondetection+clap-devel}"
SRC_URI[x86_64_v2_rust-sha1collisiondetection+clap-devel.sha256sum] = "6359a7c0c7bd6592eafae0c2c2422538077318812cf5d13afd9a18516eece31f"

URI_x86_64_v2_rust-sha1collisiondetection+clap_mangen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1collisiondetection+clap_mangen-devel-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1collisiondetection+clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1collisiondetection+clap_mangen-devel}"
SRC_URI[x86_64_v2_rust-sha1collisiondetection+clap_mangen-devel.sha256sum] = "fa015097bf09cd7b4293c1e91578ae8bde3ead32c36e29c4097d80a8ac8aa4ed"

URI_x86_64_v2_rust-sha1collisiondetection+const-oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1collisiondetection+const-oid-devel-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1collisiondetection+const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1collisiondetection+const-oid-devel}"
SRC_URI[x86_64_v2_rust-sha1collisiondetection+const-oid-devel.sha256sum] = "3cda7f8ae729c71a8b6acd6abf08e8feb11472491180e0b0a2a0b1d1bc0cfad1"

URI_x86_64_v2_rust-sha1collisiondetection+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1collisiondetection+default-devel-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1collisiondetection+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1collisiondetection+default-devel}"
SRC_URI[x86_64_v2_rust-sha1collisiondetection+default-devel.sha256sum] = "64bb267f7946f1df8f0be034ddcc98e1714eab16d70e827adb5772b6c514cc6a"

URI_x86_64_v2_rust-sha1collisiondetection+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1collisiondetection+digest-devel-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1collisiondetection+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1collisiondetection+digest-devel}"
SRC_URI[x86_64_v2_rust-sha1collisiondetection+digest-devel.sha256sum] = "5549f98eeca2ae768671e7564d8279665ba1f9ecd0d5545df31b85a8eed99cc4"

URI_x86_64_v2_rust-sha1collisiondetection+digest-trait-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1collisiondetection+digest-trait-devel-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1collisiondetection+digest-trait-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1collisiondetection+digest-trait-devel}"
SRC_URI[x86_64_v2_rust-sha1collisiondetection+digest-trait-devel.sha256sum] = "1497ddb88192cde541f73bc69ca61a3f780ceadf60244eacc4cdcbb88231cc81"

URI_x86_64_v2_rust-sha1collisiondetection+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1collisiondetection+oid-devel-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1collisiondetection+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1collisiondetection+oid-devel}"
SRC_URI[x86_64_v2_rust-sha1collisiondetection+oid-devel.sha256sum] = "313475980806c350e433f1828abb0a7e0f540cd693d508abddc7106713843a13"

URI_x86_64_v2_rust-sha1collisiondetection+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1collisiondetection+std-devel-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1collisiondetection+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1collisiondetection+std-devel}"
SRC_URI[x86_64_v2_rust-sha1collisiondetection+std-devel.sha256sum] = "2e92c083bdf2e9bc25548f7bb9ed13f1feb8540f5a319c6858e2f17377e05b38"

URI_x86_64_v2_rust-sha1collisiondetection-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1collisiondetection-devel-0.3.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1collisiondetection-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1collisiondetection-devel}"
SRC_URI[x86_64_v2_rust-sha1collisiondetection-devel.sha256sum] = "b869a273a6e83e3c34744443b2382e74d15b5402bc90908860e7ec16dfda52ff"

URI_x86_64_v2_sha1collisiondetection = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sha1collisiondetection-0.3.4-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sha1collisiondetection;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sha1collisiondetection}"
SRC_URI[x86_64_v2_sha1collisiondetection.sha256sum] = "893e36b19a12be1c59f092de942dd315663f48caab00e9d5e01a0dc7ea2c0fb2"

URI_aarch64_rust-sha1collisiondetection+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1collisiondetection+clap-devel-0.3.4-6.el10_2.noarch.rpm;name=aarch64_rust-sha1collisiondetection+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1collisiondetection+clap-devel}"
SRC_URI[aarch64_rust-sha1collisiondetection+clap-devel.sha256sum] = "50fcdfe7d5a6fceaf60c020306915af97855cd3fee99ef7b46623569398ce009"

URI_aarch64_rust-sha1collisiondetection+clap_mangen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1collisiondetection+clap_mangen-devel-0.3.4-6.el10_2.noarch.rpm;name=aarch64_rust-sha1collisiondetection+clap_mangen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1collisiondetection+clap_mangen-devel}"
SRC_URI[aarch64_rust-sha1collisiondetection+clap_mangen-devel.sha256sum] = "ef3c52421cfe656fbfce5128c22d6202f73dd685e18ae670e7afdd1cc0d65a65"

URI_aarch64_rust-sha1collisiondetection+const-oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1collisiondetection+const-oid-devel-0.3.4-6.el10_2.noarch.rpm;name=aarch64_rust-sha1collisiondetection+const-oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1collisiondetection+const-oid-devel}"
SRC_URI[aarch64_rust-sha1collisiondetection+const-oid-devel.sha256sum] = "79e74141bac224ac2469992c010595e479d22498b4a0577a9da65cb78d4c4673"

URI_aarch64_rust-sha1collisiondetection+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1collisiondetection+default-devel-0.3.4-6.el10_2.noarch.rpm;name=aarch64_rust-sha1collisiondetection+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1collisiondetection+default-devel}"
SRC_URI[aarch64_rust-sha1collisiondetection+default-devel.sha256sum] = "bdd4f13b70e437557722c9797c3567a0d18ba0e6db150a89fe91cdc133af4992"

URI_aarch64_rust-sha1collisiondetection+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1collisiondetection+digest-devel-0.3.4-6.el10_2.noarch.rpm;name=aarch64_rust-sha1collisiondetection+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1collisiondetection+digest-devel}"
SRC_URI[aarch64_rust-sha1collisiondetection+digest-devel.sha256sum] = "c9af61f0961562c256cc2127e55fa234816e7504a033581a92a7c7fcf2f6c568"

URI_aarch64_rust-sha1collisiondetection+digest-trait-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1collisiondetection+digest-trait-devel-0.3.4-6.el10_2.noarch.rpm;name=aarch64_rust-sha1collisiondetection+digest-trait-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1collisiondetection+digest-trait-devel}"
SRC_URI[aarch64_rust-sha1collisiondetection+digest-trait-devel.sha256sum] = "0b8b258622f90381991c3881564c5af91f3e1d99f32d951314af311bb397b442"

URI_aarch64_rust-sha1collisiondetection+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1collisiondetection+oid-devel-0.3.4-6.el10_2.noarch.rpm;name=aarch64_rust-sha1collisiondetection+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1collisiondetection+oid-devel}"
SRC_URI[aarch64_rust-sha1collisiondetection+oid-devel.sha256sum] = "f10642e6a33ea6729d9a087b6ea6b99af84ae8726a72f710c979d1fd478eee8c"

URI_aarch64_rust-sha1collisiondetection+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1collisiondetection+std-devel-0.3.4-6.el10_2.noarch.rpm;name=aarch64_rust-sha1collisiondetection+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1collisiondetection+std-devel}"
SRC_URI[aarch64_rust-sha1collisiondetection+std-devel.sha256sum] = "9db41bcca1998cb4936c044512fdb188d367510672847822a155527864b42594"

URI_aarch64_rust-sha1collisiondetection-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1collisiondetection-devel-0.3.4-6.el10_2.noarch.rpm;name=aarch64_rust-sha1collisiondetection-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1collisiondetection-devel}"
SRC_URI[aarch64_rust-sha1collisiondetection-devel.sha256sum] = "5a72ccb3752e4314dda00da0902707cb6dfcde3318da2cdb58d2f0d455c7a5dc"

URI_aarch64_sha1collisiondetection = "${EPEL_MIRROR}/aarch64/Packages/s/sha1collisiondetection-0.3.4-6.el10_2.aarch64.rpm;name=aarch64_sha1collisiondetection;unpack=0"
SRC_URI:append = " ${URI_aarch64_sha1collisiondetection}"
SRC_URI[aarch64_sha1collisiondetection.sha256sum] = "da7cd853cd4d97ddacc537bb8844d1aa656c3f5b729ca129a44d20bce7805dd6"

RDEPENDS:rust-sha1collisiondetection+clap-devel = " \
 cargo \
 rust-clap+derive-devel \
 rust-clap+help-devel \
 rust-clap+std-devel \
 rust-clap+wrap_help-devel \
 rust-clap-devel \
 rust-sha1collisiondetection-devel \
 "
RDEPENDS:rust-sha1collisiondetection+clap_mangen-devel = " \
 cargo \
 rust-clap_mangen-devel \
 rust-sha1collisiondetection-devel \
 "
RDEPENDS:rust-sha1collisiondetection+const-oid-devel = " \
 cargo \
 rust-const-oid-devel \
 rust-sha1collisiondetection-devel \
 "
RDEPENDS:rust-sha1collisiondetection+default-devel = " \
 cargo \
 rust-sha1collisiondetection+digest-trait-devel \
 rust-sha1collisiondetection+std-devel \
 rust-sha1collisiondetection-devel \
 "
RDEPENDS:rust-sha1collisiondetection+digest-devel = " \
 cargo \
 rust-digest+default-devel \
 rust-sha1collisiondetection-devel \
 "
RDEPENDS:rust-sha1collisiondetection+digest-trait-devel = " \
 cargo \
 rust-sha1collisiondetection+digest-devel \
 rust-sha1collisiondetection-devel \
 "
RDEPENDS:rust-sha1collisiondetection+oid-devel = " \
 cargo \
 rust-sha1collisiondetection+const-oid-devel \
 rust-sha1collisiondetection-devel \
 "
RDEPENDS:rust-sha1collisiondetection+std-devel = " \
 cargo \
 rust-digest+default-devel \
 rust-digest+std-devel \
 rust-sha1collisiondetection-devel \
 "
RDEPENDS:rust-sha1collisiondetection-devel = " \
 cargo \
 rust \
 rust-generic-array+default-devel \
 "
RDEPENDS:sha1collisiondetection = " \
 glibc \
 libgcc \
 "
