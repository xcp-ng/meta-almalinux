# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkexiv2"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 libkexiv2-qt6 \
 libkexiv2-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkexiv2-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "97d402dc9e55102a2116e82d2230e96293b429f69a1c10008eca5e9a58dd7ba3"

URI_x86_64_v2_libkexiv2-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkexiv2-qt6}"
SRC_URI[x86_64_v2_libkexiv2-qt6.sha256sum] = "aada9cc0e2bf15e4d309a2b4855e6e618566f687e54f825cfa89bf587573a85e"

URI_x86_64_v2_libkexiv2-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkexiv2-qt6-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkexiv2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkexiv2-qt6-devel}"
SRC_URI[x86_64_v2_libkexiv2-qt6-devel.sha256sum] = "936895f004ad2b3cd1940d058cae510ee75a7eee5462a913a82ef3fbfd2e29c4"

URI_aarch64_libkexiv2-qt6 = "${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkexiv2-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkexiv2-qt6}"
SRC_URI[aarch64_libkexiv2-qt6.sha256sum] = "726d6ea63829daf31e8dfb22f8e799b6df2a197a7186f0e64b272d3d1db40e07"

URI_aarch64_libkexiv2-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkexiv2-qt6-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_libkexiv2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkexiv2-qt6-devel}"
SRC_URI[aarch64_libkexiv2-qt6-devel.sha256sum] = "d29ff47d7e15f2a6f1456d7b4ebf7972f53834eb07e5c28c981c8e1d5d1d4788"

RDEPENDS:libkexiv2-qt6 = " \
 exiv2-libs \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkexiv2-qt6-devel = " \
 cmake-filesystem \
 libkexiv2-qt6 \
 qt6-qtbase-devel \
 "
