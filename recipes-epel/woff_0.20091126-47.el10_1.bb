# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "woff"
PV = "0.20091126"
PR = "47.el10_1"
PACKAGES = " \
 woff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/woff-0.20091126-47.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3d3ae94b39657183e27ce2896de2061614f67abb3d805c65cf29a53628dabfe"

URI_x86_64_v2_woff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/woff-0.20091126-47.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_woff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_woff}"
SRC_URI[x86_64_v2_woff.sha256sum] = "4d32e3ed36d35f082df550cd2afbfe578d555f167b2f1e39633168a6648305e4"

URI_aarch64_woff = "${EPEL_MIRROR}/aarch64/Packages/w/woff-0.20091126-47.el10_1.aarch64.rpm;name=aarch64_woff;unpack=0"
SRC_URI:append = " ${URI_aarch64_woff}"
SRC_URI[aarch64_woff.sha256sum] = "88ad1cee2793201bc2a5c046d74106cffa86cd3b00e6bb496f664d2d66fb0c60"

RDEPENDS:woff = " \
 glibc \
 zlib-ng-compat \
 "
