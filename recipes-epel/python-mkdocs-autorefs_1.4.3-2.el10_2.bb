# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mkdocs-autorefs"
PV = "1.4.3"
PR = "2.el10_2"
PACKAGES = " \
 python3-mkdocs-autorefs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-mkdocs-autorefs-1.4.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e9119041f197d61172cc1be0737fac08e7c9e286637c5fa5df5b0a67b8789e8"

URI_x86_64_v2_python3-mkdocs-autorefs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mkdocs-autorefs-1.4.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mkdocs-autorefs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mkdocs-autorefs}"
SRC_URI[x86_64_v2_python3-mkdocs-autorefs.sha256sum] = "9ade19b729a14b471e7c0816f03d71180cb643cce4f511cc74057c24bada585a"

URI_aarch64_python3-mkdocs-autorefs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mkdocs-autorefs-1.4.3-2.el10_2.noarch.rpm;name=aarch64_python3-mkdocs-autorefs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mkdocs-autorefs}"
SRC_URI[aarch64_python3-mkdocs-autorefs.sha256sum] = "7932fca59f59a99537cb9abdb33d8f7ca6d5161ec16ca3984e271fa3fa6f1621"

RDEPENDS:python3-mkdocs-autorefs = " \
 mkdocs \
 python3 \
 python3-markdown \
 python3-markupsafe \
 "
