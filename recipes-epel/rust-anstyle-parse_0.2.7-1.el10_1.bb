# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-parse"
PV = "0.2.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-anstyle-parse+core-devel \
 rust-anstyle-parse+default-devel \
 rust-anstyle-parse+utf8-devel \
 rust-anstyle-parse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-parse-0.2.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "adfafe1fcf317f42cf17137c60a86a3c31c84cb14ac3b3826d1daa247cb30a17"

URI_x86_64_v2_rust-anstyle-parse+core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse+core-devel-0.2.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse+core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse+core-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse+core-devel.sha256sum] = "c8f4bf48b384bd67ce50903e3a4488bf78d7bdfdc4eed05eceee442b0a519a13"

URI_x86_64_v2_rust-anstyle-parse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse+default-devel-0.2.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse+default-devel.sha256sum] = "b0dd6c4fdc859b39e5a1a1eb7245c4836ea572f071765c4d2a365063c6f864d7"

URI_x86_64_v2_rust-anstyle-parse+utf8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse+utf8-devel-0.2.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse+utf8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse+utf8-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse+utf8-devel.sha256sum] = "e7ca4b2bf87b3d1c73fceded23c279fa79a49b959eb980089c5a6dc33031052c"

URI_x86_64_v2_rust-anstyle-parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-parse-devel-0.2.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-parse-devel}"
SRC_URI[x86_64_v2_rust-anstyle-parse-devel.sha256sum] = "8c6478ea0e651d8ff435b559b16f9beccfbb0cc467478006b5ece9c3fffe0c60"

URI_aarch64_rust-anstyle-parse+core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse+core-devel-0.2.7-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-parse+core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse+core-devel}"
SRC_URI[aarch64_rust-anstyle-parse+core-devel.sha256sum] = "076cf75b4171cde3b98c13d75c777d9be2c32a01f1d6fc34cfbccd0dcb6f09da"

URI_aarch64_rust-anstyle-parse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse+default-devel-0.2.7-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-parse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse+default-devel}"
SRC_URI[aarch64_rust-anstyle-parse+default-devel.sha256sum] = "561a255d0df9f09ae67fa2f31f1c03bd0c07ca117adc11e67a9abea4e4bc301b"

URI_aarch64_rust-anstyle-parse+utf8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse+utf8-devel-0.2.7-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-parse+utf8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse+utf8-devel}"
SRC_URI[aarch64_rust-anstyle-parse+utf8-devel.sha256sum] = "87f3ec06a2cd4cda053ebaf689215a015d8c8685e21b202f35b6305f3b6e791c"

URI_aarch64_rust-anstyle-parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-parse-devel-0.2.7-1.el10_1.noarch.rpm;name=aarch64_rust-anstyle-parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-parse-devel}"
SRC_URI[aarch64_rust-anstyle-parse-devel.sha256sum] = "1ec8b36e4c915c37e67e158ace59428e576149481d452271db0f6adbf7c4c727"

RDEPENDS:rust-anstyle-parse+core-devel = " \
 cargo \
 rust-anstyle-parse-devel \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-anstyle-parse+default-devel = " \
 cargo \
 rust-anstyle-parse+utf8-devel \
 rust-anstyle-parse-devel \
 "
RDEPENDS:rust-anstyle-parse+utf8-devel = " \
 cargo \
 rust-anstyle-parse-devel \
 rust-utf8parse+default-devel \
 "
RDEPENDS:rust-anstyle-parse-devel = " \
 cargo \
 rust \
 "
