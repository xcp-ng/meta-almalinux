# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-iancoleman-strcase"
PV = "0.1.3"
PR = "12.el10_0"
PACKAGES = " \
 golang-github-iancoleman-strcase-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-iancoleman-strcase-0.1.3-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "016d54b2baf776cee25d594a16b47b1664020e2653ab0052e682fa029b5e7aa0"

URI_x86_64_v2_golang-github-iancoleman-strcase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-iancoleman-strcase-devel-0.1.3-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-iancoleman-strcase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-iancoleman-strcase-devel}"
SRC_URI[x86_64_v2_golang-github-iancoleman-strcase-devel.sha256sum] = "19ac728084ba4395d1abc571dfca9da5f0dd56c7747dbaadec61bdffea1982db"

URI_aarch64_golang-github-iancoleman-strcase-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-iancoleman-strcase-devel-0.1.3-12.el10_0.noarch.rpm;name=aarch64_golang-github-iancoleman-strcase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-iancoleman-strcase-devel}"
SRC_URI[aarch64_golang-github-iancoleman-strcase-devel.sha256sum] = "7a6fbaf87a3eaaf7b4459c00cbf9bf523a30eac13ebf8b95b768ba8111193b6c"

RDEPENDS:golang-github-iancoleman-strcase-devel = " \
 go-filesystem \
 "
