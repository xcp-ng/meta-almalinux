# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-kiosk"
PV = "49.0"
PR = "14.el10"
PACKAGES = " \
 gnome-kiosk \
 gnome-kiosk-script-session \
 gnome-kiosk-search-appliance \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-kiosk-49.0-14.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a306e627c63c9e54fcb87c24b8c843db873f6422da2f7442a923292aab5e854f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-49.0-14.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-kiosk;unpack=0"
SRC_URI[x86_64_v2_gnome-kiosk.sha256sum] = "c6db2b195b1efd4fc63243bd96b428752b0d55ce679a6707b2026227811e24c3"
RPROVIDES:gnome-kiosk:append:x86_64_v2 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-script-session-49.0-14.el10.noarch.rpm;name=x86_64_v2_gnome-kiosk-script-session;unpack=0"
SRC_URI[x86_64_v2_gnome-kiosk-script-session.sha256sum] = "ec29cfdda28143d24ccc28f140c89e6f21c3887e1b6b8fff6fa225819457c1f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-kiosk-search-appliance-49.0-14.el10.noarch.rpm;name=x86_64_v2_gnome-kiosk-search-appliance;unpack=0"
SRC_URI[x86_64_v2_gnome-kiosk-search-appliance.sha256sum] = "00b3cce5a11922ebea4000fd5c4594eac1a029021a4569dc41fea1fb02c0c9f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-49.0-14.el10.aarch64.rpm;name=aarch64_gnome-kiosk;unpack=0"
SRC_URI[aarch64_gnome-kiosk.sha256sum] = "8c96ec09fa4f2aebf3fd1972649530bdc0f538db3e456ddf5562d5988b924814"
RPROVIDES:gnome-kiosk:append:aarch64 = " virtual/weston_or_cage_or_kwin-wayland_or_mutter_or_gnome-kiosk"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-script-session-49.0-14.el10.noarch.rpm;name=aarch64_gnome-kiosk-script-session;unpack=0"
SRC_URI[aarch64_gnome-kiosk-script-session.sha256sum] = "ec29cfdda28143d24ccc28f140c89e6f21c3887e1b6b8fff6fa225819457c1f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-kiosk-search-appliance-49.0-14.el10.noarch.rpm;name=aarch64_gnome-kiosk-search-appliance;unpack=0"
SRC_URI[aarch64_gnome-kiosk-search-appliance.sha256sum] = "00b3cce5a11922ebea4000fd5c4594eac1a029021a4569dc41fea1fb02c0c9f8"

RDEPENDS:gnome-kiosk = " \
 cairo \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gnome-desktop4 \
 gnome-settings-daemon \
 graphene \
 gsettings-desktop-schemas \
 ibus-libs \
 libX11 \
 libgcc \
 libglvnd-gles \
 mutter \
 systemd-libs \
 "
RDEPENDS:gnome-kiosk-script-session = " \
 bash \
 gnome-kiosk \
 gnome-session \
 "
RDEPENDS:gnome-kiosk-search-appliance = " \
 flatpak \
 gnome-kiosk \
 gnome-session \
 "
