# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gorilla-sessions"
PV = "1.2.1"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-gorilla-sessions-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gorilla-sessions-1.2.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ecfe2cf6ee147bfba83e7b69fb2b9c4a43e2a4dcaa971aee882ac4bae8ea673"

URI_x86_64_v2_golang-github-gorilla-sessions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-gorilla-sessions-devel-1.2.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-gorilla-sessions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-gorilla-sessions-devel}"
SRC_URI[x86_64_v2_golang-github-gorilla-sessions-devel.sha256sum] = "6bbda8ca78e39f6e1237d140decc8bcf17bc2cd15ec848292bf67a60cee8246e"

URI_aarch64_golang-github-gorilla-sessions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gorilla-sessions-devel-1.2.1-13.el10_0.noarch.rpm;name=aarch64_golang-github-gorilla-sessions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gorilla-sessions-devel}"
SRC_URI[aarch64_golang-github-gorilla-sessions-devel.sha256sum] = "b30694e5f99bcf948b11dc5e0fb8996fef359db4c678581892752d48e8b919f7"

RDEPENDS:golang-github-gorilla-sessions-devel = " \
 go-filesystem \
 golang-github-gorilla-securecookie-devel \
 "
