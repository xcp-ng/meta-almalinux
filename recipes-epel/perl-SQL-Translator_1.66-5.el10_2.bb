# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SQL-Translator"
PV = "1.66"
PR = "5.el10_2"
PACKAGES = " \
 perl-SQL-Translator \
 perl-SQL-Translator-Producer-Diagram \
 perl-SQL-Translator-Producer-GraphViz \
 perl-SQL-Translator-tests \
 sqlt-graph \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-SQL-Translator-1.66-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3be1663ee72129d03257f23140a685980892c80202c094f90b87ecbc28e2c687"

URI_x86_64_v2_perl-SQL-Translator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Translator-1.66-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Translator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Translator}"
SRC_URI[x86_64_v2_perl-SQL-Translator.sha256sum] = "071827096d2e3b1d09549a7ffe63198d1466a66ae9b34c41b83a322fc06ce6f0"

URI_x86_64_v2_perl-SQL-Translator-Producer-Diagram = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Translator-Producer-Diagram-1.66-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Translator-Producer-Diagram;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Translator-Producer-Diagram}"
SRC_URI[x86_64_v2_perl-SQL-Translator-Producer-Diagram.sha256sum] = "5a0938e01c51c2557e94aa3508255e126d5563dee0c111bf8c7eff8e554c2ca2"

URI_x86_64_v2_perl-SQL-Translator-Producer-GraphViz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Translator-Producer-GraphViz-1.66-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Translator-Producer-GraphViz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Translator-Producer-GraphViz}"
SRC_URI[x86_64_v2_perl-SQL-Translator-Producer-GraphViz.sha256sum] = "15a30bae09dbe3f1eadbe8827a0378540393c74a02580814fc62e9727941d928"

URI_x86_64_v2_perl-SQL-Translator-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-SQL-Translator-tests-1.66-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-SQL-Translator-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SQL-Translator-tests}"
SRC_URI[x86_64_v2_perl-SQL-Translator-tests.sha256sum] = "21156656bad044dc3fd38d546c159cd04b3041a913ef2f1357ed08074ccd4cdd"

URI_x86_64_v2_sqlt-graph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sqlt-graph-1.66-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sqlt-graph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlt-graph}"
SRC_URI[x86_64_v2_sqlt-graph.sha256sum] = "ab5b9beaee495a83a7328210202d681666af9570b6fa3500f1d31454eaf14494"

URI_aarch64_perl-SQL-Translator = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Translator-1.66-5.el10_2.noarch.rpm;name=aarch64_perl-SQL-Translator;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Translator}"
SRC_URI[aarch64_perl-SQL-Translator.sha256sum] = "feddda15eb8389b221d8e7b55a754baf8c900f1c2591c7b7ad090afbc04f4089"

URI_aarch64_perl-SQL-Translator-Producer-Diagram = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Translator-Producer-Diagram-1.66-5.el10_2.noarch.rpm;name=aarch64_perl-SQL-Translator-Producer-Diagram;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Translator-Producer-Diagram}"
SRC_URI[aarch64_perl-SQL-Translator-Producer-Diagram.sha256sum] = "95ac2c61fcef37a1dc69ca61c0d71ecbbf0124d9892070d4fececd6bcd0d5b56"

URI_aarch64_perl-SQL-Translator-Producer-GraphViz = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Translator-Producer-GraphViz-1.66-5.el10_2.noarch.rpm;name=aarch64_perl-SQL-Translator-Producer-GraphViz;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Translator-Producer-GraphViz}"
SRC_URI[aarch64_perl-SQL-Translator-Producer-GraphViz.sha256sum] = "e6efaab64422e2782ae7cb5f6b3a4ae726bd3ffc1fd16fa2a156fdd39dca2fa1"

URI_aarch64_perl-SQL-Translator-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-SQL-Translator-tests-1.66-5.el10_2.noarch.rpm;name=aarch64_perl-SQL-Translator-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SQL-Translator-tests}"
SRC_URI[aarch64_perl-SQL-Translator-tests.sha256sum] = "cee9818c1300bb89fad9fe2fe95f3c5bf9a1b452fd23e3c593a2750a0149c83b"

URI_aarch64_sqlt-graph = "${EPEL_MIRROR}/aarch64/Packages/s/sqlt-graph-1.66-5.el10_2.noarch.rpm;name=aarch64_sqlt-graph;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlt-graph}"
SRC_URI[aarch64_sqlt-graph.sha256sum] = "1bb6ce33f11eba96a4cb3b1f4180b07687c635882bcaea0247e649da247b7988"

RDEPENDS:perl-SQL-Translator = " \
 perl-CGI \
 perl-Carp \
 perl-Carp-Clan \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-File-ShareDir \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-Graph \
 perl-IO \
 perl-JSON-MaybeXS \
 perl-Moo \
 perl-Package-Variant \
 perl-Parse-RecDescent \
 perl-PathTools \
 perl-Pod-Usage \
 perl-SQL-Translator \
 perl-Scalar-List-Utils \
 perl-Spreadsheet-ParseExcel \
 perl-Storable \
 perl-Sub-Quote \
 perl-Template-Toolkit \
 perl-Test-Simple \
 perl-Text-ParseWords \
 perl-Text-RecordParser \
 perl-Try-Tiny \
 perl-XML-LibXML \
 perl-XML-Writer \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:perl-SQL-Translator-Producer-Diagram = " \
 perl-Data-Dumper \
 perl-GD \
 perl-SQL-Translator \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-SQL-Translator-Producer-GraphViz = " \
 perl-GraphViz \
 perl-SQL-Translator \
 perl-Scalar-List-Utils \
 perl-libs \
 "
RDEPENDS:perl-SQL-Translator-tests = " \
 bash \
 perl-DBD-SQLite \
 perl-Data-Dumper \
 perl-File-Temp \
 perl-FindBin \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-SQL-Translator \
 perl-SQL-Translator-Producer-Diagram \
 perl-SQL-Translator-Producer-GraphViz \
 perl-Storable \
 perl-Symbol \
 perl-Test-Differences \
 perl-Test-Exception \
 perl-Test-Harness \
 perl-Test-PostgreSQL \
 perl-Text-ParseWords \
 perl-XML-Parser \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 sqlt-graph \
 "
RDEPENDS:sqlt-graph = " \
 perl-Data-Dumper \
 perl-Getopt-Long \
 perl-GraphViz \
 perl-Pod-Usage \
 perl-SQL-Translator \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
