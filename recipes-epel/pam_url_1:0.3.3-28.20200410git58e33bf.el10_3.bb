# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam_url"
PE = "1"
PV = "0.3.3"
PR = "28.20200410git58e33bf.el10_3"
PACKAGES = " \
 pam_url \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pam_url-0.3.3-28.20200410git58e33bf.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49afc627b22c151ee850207f20f41b14923e994a0375259dd209a77bbaf63d60"

URI_aarch64_pam_url = "${EPEL_MIRROR}/aarch64/Packages/p/pam_url-0.3.3-28.20200410git58e33bf.el10_3.aarch64.rpm;name=aarch64_pam_url;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_url}"
SRC_URI[aarch64_pam_url.sha256sum] = "ff16ada79253dd895ca14dd58d30544b915666ff033992508e5f8c1e39b6da27"

RDEPENDS:pam_url = " \
 glibc \
 libconfig \
 pam \
 pam-libs \
 virtual/libcurl.so.4___64bit_ \
 "
