# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-microlens"
PV = "0.4.13.1"
PR = "6.el10_0"
PACKAGES = " \
 ghc-microlens \
 ghc-microlens-devel \
 ghc-microlens-doc \
 ghc-microlens-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-microlens-0.4.13.1-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9195b749d7be37de06e1269ab7adb9897f73be430d74c0def4be7560c9485740"

URI_x86_64_v2_ghc-microlens = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-0.4.13.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens}"
SRC_URI[x86_64_v2_ghc-microlens.sha256sum] = "e00a5878f2ed66ca7dfd69aea2a2a390286cc607b5f819e96a5eedad07e09fbb"

URI_x86_64_v2_ghc-microlens-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-devel-0.4.13.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-devel}"
SRC_URI[x86_64_v2_ghc-microlens-devel.sha256sum] = "9b19635cb0effee13682cddf795722f5445a878c6eda4f70912d982ffe22b5f5"

URI_x86_64_v2_ghc-microlens-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-doc-0.4.13.1-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-microlens-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-doc}"
SRC_URI[x86_64_v2_ghc-microlens-doc.sha256sum] = "031c7ef5e1f81d02726d74c2f5f17ed5cde075c031f1459c605f51493f24aae8"

URI_x86_64_v2_ghc-microlens-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-microlens-prof-0.4.13.1-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-microlens-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-microlens-prof}"
SRC_URI[x86_64_v2_ghc-microlens-prof.sha256sum] = "4ebcd2c5d040c4d49ab5a8831268a2ee05a88e73f7aed6bb17444dc12b8450e9"

URI_aarch64_ghc-microlens = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-0.4.13.1-6.el10_0.aarch64.rpm;name=aarch64_ghc-microlens;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens}"
SRC_URI[aarch64_ghc-microlens.sha256sum] = "b5f8ab9c0cb4ff68700e022996411d93fa78eaae76ed996af4276e93e370e5bc"

URI_aarch64_ghc-microlens-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-devel-0.4.13.1-6.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-devel}"
SRC_URI[aarch64_ghc-microlens-devel.sha256sum] = "d08f59b5271c88f8b67d75b5b886625831ebcce015a16e886668a12200487ac8"

URI_aarch64_ghc-microlens-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-doc-0.4.13.1-6.el10_0.noarch.rpm;name=aarch64_ghc-microlens-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-doc}"
SRC_URI[aarch64_ghc-microlens-doc.sha256sum] = "20ef13eb955a27518e9a3b9eb62aff4151fb37c39694b3a0ad8b87e331acafbc"

URI_aarch64_ghc-microlens-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-microlens-prof-0.4.13.1-6.el10_0.aarch64.rpm;name=aarch64_ghc-microlens-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-microlens-prof}"
SRC_URI[aarch64_ghc-microlens-prof.sha256sum] = "52c6c1b7facf1f496c5bdf11563b341901b7879f90ef54834e8f716817ef5107"

RDEPENDS:ghc-microlens = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-microlens-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-microlens \
 "
RDEPENDS:ghc-microlens-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-microlens-prof = " \
 ghc-base-prof \
 ghc-microlens-devel \
 "
