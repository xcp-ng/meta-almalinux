# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ratatui"
PV = "0.29.0"
PR = "4.el10_1"
PACKAGES = " \
 rust-ratatui+all-widgets-devel \
 rust-ratatui+crossterm-devel \
 rust-ratatui+default-devel \
 rust-ratatui+document-features-devel \
 rust-ratatui+macros-devel \
 rust-ratatui+palette-devel \
 rust-ratatui+scrolling-regions-devel \
 rust-ratatui+serde-devel \
 rust-ratatui+termion-devel \
 rust-ratatui+underline-color-devel \
 rust-ratatui+unstable-backend-writer-devel \
 rust-ratatui+unstable-devel \
 rust-ratatui+unstable-rendered-line-info-devel \
 rust-ratatui+unstable-widget-ref-devel \
 rust-ratatui+widget-calendar-devel \
 rust-ratatui-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ratatui-0.29.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1b751c8a4434fe3b1dea007522a47547a92342e09dc24bec6004ba310a13674"

URI_x86_64_v2_rust-ratatui+all-widgets-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+all-widgets-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+all-widgets-devel}"
SRC_URI[x86_64_v2_rust-ratatui+all-widgets-devel.sha256sum] = "70e7818084ce91e29fcd5f792b2c239b6f6ab68bb4a8f8dbdf0d344a5d7229c8"

URI_x86_64_v2_rust-ratatui+crossterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+crossterm-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+crossterm-devel}"
SRC_URI[x86_64_v2_rust-ratatui+crossterm-devel.sha256sum] = "d025b84580842bcb171e36b86545a04a1c06e54056abec72e0a613f3f6fbdd7c"

URI_x86_64_v2_rust-ratatui+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+default-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+default-devel}"
SRC_URI[x86_64_v2_rust-ratatui+default-devel.sha256sum] = "a523374cf17ddf76eb01c41a0b7642d8db6e304f96711f385d3b321dde4d4147"

URI_x86_64_v2_rust-ratatui+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+document-features-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+document-features-devel}"
SRC_URI[x86_64_v2_rust-ratatui+document-features-devel.sha256sum] = "3f0315a23878a461bed3145e28765dee2c5ab9bd733bb24efb75355493d6606b"

URI_x86_64_v2_rust-ratatui+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+macros-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+macros-devel}"
SRC_URI[x86_64_v2_rust-ratatui+macros-devel.sha256sum] = "67163b2c126bf3aee6b5ac2e40df9a651e6a0b2f6e4ea8beb09ab1d05824cc88"

URI_x86_64_v2_rust-ratatui+palette-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+palette-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+palette-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+palette-devel}"
SRC_URI[x86_64_v2_rust-ratatui+palette-devel.sha256sum] = "334c6125fd7dee2558990427d42f212d14b5a66505cb4d2ce5719819aeec051d"

URI_x86_64_v2_rust-ratatui+scrolling-regions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+scrolling-regions-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+scrolling-regions-devel}"
SRC_URI[x86_64_v2_rust-ratatui+scrolling-regions-devel.sha256sum] = "054226a4803c015b2ebc4893a0bbd14a5c70efa540dade84df1e9a6b44440701"

URI_x86_64_v2_rust-ratatui+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+serde-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+serde-devel}"
SRC_URI[x86_64_v2_rust-ratatui+serde-devel.sha256sum] = "31860500e4080b05fa18fca3388b46e960244343637359c63f90af0b1c54696d"

URI_x86_64_v2_rust-ratatui+termion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+termion-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+termion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+termion-devel}"
SRC_URI[x86_64_v2_rust-ratatui+termion-devel.sha256sum] = "24cac09aa2adb81f2e82a1e89878850152569847d88859894670e2ea86cb6859"

URI_x86_64_v2_rust-ratatui+underline-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+underline-color-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+underline-color-devel}"
SRC_URI[x86_64_v2_rust-ratatui+underline-color-devel.sha256sum] = "ce5a76ec667b63951a95ff8b03ebf5ea563d3407d2594cf79346c94bdfde6471"

URI_x86_64_v2_rust-ratatui+unstable-backend-writer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+unstable-backend-writer-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+unstable-backend-writer-devel}"
SRC_URI[x86_64_v2_rust-ratatui+unstable-backend-writer-devel.sha256sum] = "85b421f5e8f7ffd1287611b1e0c02fc126de4084dcf9ed965af2b453accaa2a4"

URI_x86_64_v2_rust-ratatui+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+unstable-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+unstable-devel}"
SRC_URI[x86_64_v2_rust-ratatui+unstable-devel.sha256sum] = "c6f69c2f253f8fecb6a0c00bf9d03e1318341a4aa00c6c01441fadddfc031d3c"

URI_x86_64_v2_rust-ratatui+unstable-rendered-line-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+unstable-rendered-line-info-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+unstable-rendered-line-info-devel}"
SRC_URI[x86_64_v2_rust-ratatui+unstable-rendered-line-info-devel.sha256sum] = "885323b5255f594d085539cbf43ee15ae5626ea8de0b231ce33c201997f3d269"

URI_x86_64_v2_rust-ratatui+unstable-widget-ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+unstable-widget-ref-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+unstable-widget-ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+unstable-widget-ref-devel}"
SRC_URI[x86_64_v2_rust-ratatui+unstable-widget-ref-devel.sha256sum] = "a9de8122c4190e0f8a872f09de8d6476fea1d48a8c430c00dd8189ebcaebacd3"

URI_x86_64_v2_rust-ratatui+widget-calendar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui+widget-calendar-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui+widget-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui+widget-calendar-devel}"
SRC_URI[x86_64_v2_rust-ratatui+widget-calendar-devel.sha256sum] = "15639d1abbb8895a07a3ede2201661c814fdce3e6cb931b374d4f871d44e98b6"

URI_x86_64_v2_rust-ratatui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ratatui-devel-0.29.0-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ratatui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ratatui-devel}"
SRC_URI[x86_64_v2_rust-ratatui-devel.sha256sum] = "38e1a52ece140fd62d30b041ec1760ae29614d40ba01a3d31b2b3285ef09d911"

URI_aarch64_rust-ratatui+all-widgets-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+all-widgets-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+all-widgets-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+all-widgets-devel}"
SRC_URI[aarch64_rust-ratatui+all-widgets-devel.sha256sum] = "77c99a5f9b4d21604ab3edc27b6a967ee36b012e47a507d353f7a67895a7d26e"

URI_aarch64_rust-ratatui+crossterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+crossterm-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+crossterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+crossterm-devel}"
SRC_URI[aarch64_rust-ratatui+crossterm-devel.sha256sum] = "c0596e8d87cd7c21db538cd65b496c2a1019c2077868b136ee133596388f8bcf"

URI_aarch64_rust-ratatui+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+default-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+default-devel}"
SRC_URI[aarch64_rust-ratatui+default-devel.sha256sum] = "03f05459f6ddb29a5ce37fa2b1aaf507b7ca01b6324fb2ac875bbfb05793044a"

URI_aarch64_rust-ratatui+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+document-features-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+document-features-devel}"
SRC_URI[aarch64_rust-ratatui+document-features-devel.sha256sum] = "bb713c178adcadc3eac7c700061e853d2659b1ae0972aa49e8f5a14f458cb3ba"

URI_aarch64_rust-ratatui+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+macros-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+macros-devel}"
SRC_URI[aarch64_rust-ratatui+macros-devel.sha256sum] = "41632129e8884670936a4111dd84ecc3688c4a84105848532c681468542aad5a"

URI_aarch64_rust-ratatui+palette-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+palette-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+palette-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+palette-devel}"
SRC_URI[aarch64_rust-ratatui+palette-devel.sha256sum] = "acf2ec76891754c7bb660bc1f2817e99aa156fb517d07d31dc00a9309c7fdbf4"

URI_aarch64_rust-ratatui+scrolling-regions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+scrolling-regions-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+scrolling-regions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+scrolling-regions-devel}"
SRC_URI[aarch64_rust-ratatui+scrolling-regions-devel.sha256sum] = "1f9b3bc34ebfb26f8feeb8cd374a04736a5049a091edb1d43ae360284f935771"

URI_aarch64_rust-ratatui+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+serde-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+serde-devel}"
SRC_URI[aarch64_rust-ratatui+serde-devel.sha256sum] = "fa88eadab85fa6da0bb1c161b66e5cfd23b3612bd747e6a7f5204e9d36f8bfcc"

URI_aarch64_rust-ratatui+termion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+termion-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+termion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+termion-devel}"
SRC_URI[aarch64_rust-ratatui+termion-devel.sha256sum] = "80a0351ae498aa0a1a00412ed58030968b3e0fc2e614dee72ebd89053ec4306a"

URI_aarch64_rust-ratatui+underline-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+underline-color-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+underline-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+underline-color-devel}"
SRC_URI[aarch64_rust-ratatui+underline-color-devel.sha256sum] = "ed60294fee6b9fee1dd19282ed19bb741550c7b873adde6f266f93c47ecad649"

URI_aarch64_rust-ratatui+unstable-backend-writer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+unstable-backend-writer-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+unstable-backend-writer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+unstable-backend-writer-devel}"
SRC_URI[aarch64_rust-ratatui+unstable-backend-writer-devel.sha256sum] = "1e605a619e2f64140b238e8217ab0582da5d71af79b273efa2a226134ee863d7"

URI_aarch64_rust-ratatui+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+unstable-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+unstable-devel}"
SRC_URI[aarch64_rust-ratatui+unstable-devel.sha256sum] = "d7cce900df17de6f817b6e3aa33d5ef0c1ebd226d2562779d18abb350708470f"

URI_aarch64_rust-ratatui+unstable-rendered-line-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+unstable-rendered-line-info-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+unstable-rendered-line-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+unstable-rendered-line-info-devel}"
SRC_URI[aarch64_rust-ratatui+unstable-rendered-line-info-devel.sha256sum] = "56b75ca1cf6a376a416f1f23a0d416af7d14099d420837d0a9065ab7a4703a65"

URI_aarch64_rust-ratatui+unstable-widget-ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+unstable-widget-ref-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+unstable-widget-ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+unstable-widget-ref-devel}"
SRC_URI[aarch64_rust-ratatui+unstable-widget-ref-devel.sha256sum] = "4a7fef6ba95d72cc324106a519175a57f812e6dd0fb25c7ee062063ac519b295"

URI_aarch64_rust-ratatui+widget-calendar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui+widget-calendar-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui+widget-calendar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui+widget-calendar-devel}"
SRC_URI[aarch64_rust-ratatui+widget-calendar-devel.sha256sum] = "7e3f36b70d5dbbf57a4ccdad683cfb42035b0e5a71e9ed31591f390b60ae43f6"

URI_aarch64_rust-ratatui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ratatui-devel-0.29.0-4.el10_1.noarch.rpm;name=aarch64_rust-ratatui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ratatui-devel}"
SRC_URI[aarch64_rust-ratatui-devel.sha256sum] = "96c30f5742bac2f3f6951e92713bd627c359a0a93119d160e5ee2e95d1a62e9f"

RDEPENDS:rust-ratatui+all-widgets-devel = " \
 cargo \
 rust-ratatui+widget-calendar-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+crossterm-devel = " \
 cargo \
 rust-crossterm+default-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+default-devel = " \
 cargo \
 rust-ratatui+crossterm-devel \
 rust-ratatui+underline-color-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+macros-devel = " \
 cargo \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+palette-devel = " \
 cargo \
 rust-palette+default-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+scrolling-regions-devel = " \
 cargo \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+serde-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-compact_str+serde-devel \
 rust-ratatui-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-ratatui+termion-devel = " \
 cargo \
 rust-ratatui-devel \
 rust-termion+default-devel \
 "
RDEPENDS:rust-ratatui+underline-color-devel = " \
 cargo \
 rust-crossterm+default-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+unstable-backend-writer-devel = " \
 cargo \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+unstable-devel = " \
 cargo \
 rust-ratatui+unstable-backend-writer-devel \
 rust-ratatui+unstable-rendered-line-info-devel \
 rust-ratatui+unstable-widget-ref-devel \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+unstable-rendered-line-info-devel = " \
 cargo \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+unstable-widget-ref-devel = " \
 cargo \
 rust-ratatui-devel \
 "
RDEPENDS:rust-ratatui+widget-calendar-devel = " \
 cargo \
 rust-ratatui-devel \
 rust-time+default-devel \
 rust-time+local-offset-devel \
 "
RDEPENDS:rust-ratatui-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cassowary+default-devel \
 rust-compact_str+default-devel \
 rust-indoc+default-devel \
 rust-instability+default-devel \
 rust-itertools0.13+default-devel \
 rust-lru0.12+default-devel \
 rust-paste+default-devel \
 rust-strum0.26+default-devel \
 rust-strum0.26+derive-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-truncate1+default-devel \
 rust-unicode-width+default-devel \
 "
