# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerofrom"
PV = "0.1.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerofrom+alloc-devel \
 rust-zerofrom+default-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerofrom-0.1.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "825d4fef24cbd97eb588ae1fc0c5391a795afb35a69fe8651f60d1d70f49662d"

URI_x86_64_v2_rust-zerofrom+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+alloc-devel-0.1.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+alloc-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+alloc-devel.sha256sum] = "3e66ef5fdd1c40e713fd76ca72beb7c062b81ee9f1f98a90b92057ace407f1c2"

URI_x86_64_v2_rust-zerofrom+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+default-devel-0.1.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+default-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+default-devel.sha256sum] = "a6cc73919603a389f9ba4d761cff0e400f28e675e31816918a44b77441307b7a"

URI_x86_64_v2_rust-zerofrom+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom+derive-devel-0.1.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom+derive-devel}"
SRC_URI[x86_64_v2_rust-zerofrom+derive-devel.sha256sum] = "03d96bc5b5d83d5d8ceed2b4a2dd6202054bfcac6e7b7caf6ea01cd098d8f024"

URI_x86_64_v2_rust-zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerofrom-devel-0.1.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerofrom-devel}"
SRC_URI[x86_64_v2_rust-zerofrom-devel.sha256sum] = "58f06cbd024dc9ef815299cafb3f377e8aafcbe4118fd15d237e3709b16dbf2a"

URI_aarch64_rust-zerofrom+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+alloc-devel-0.1.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerofrom+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+alloc-devel}"
SRC_URI[aarch64_rust-zerofrom+alloc-devel.sha256sum] = "783deb1749788b1d4b117f4e8bfa922c6dbd93fa68f26538d48a25350c7269bb"

URI_aarch64_rust-zerofrom+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+default-devel-0.1.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerofrom+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+default-devel}"
SRC_URI[aarch64_rust-zerofrom+default-devel.sha256sum] = "a8e70a66add817fe69bde50c291c472d79a0c712c2e74bab22dd7752183280c9"

URI_aarch64_rust-zerofrom+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom+derive-devel-0.1.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerofrom+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom+derive-devel}"
SRC_URI[aarch64_rust-zerofrom+derive-devel.sha256sum] = "8834e45766959519f6f0afeb206210e9c539f90cb8da166df1208ea0398a371e"

URI_aarch64_rust-zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerofrom-devel-0.1.8-1.el10_3.noarch.rpm;name=aarch64_rust-zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerofrom-devel}"
SRC_URI[aarch64_rust-zerofrom-devel.sha256sum] = "d4be0f7611c27077259410a2cd51bd86401ce1dc02806832758f44f650432aa9"

RDEPENDS:rust-zerofrom+alloc-devel = " \
 cargo \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom+default-devel = " \
 cargo \
 rust-zerofrom+alloc-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom+derive-devel = " \
 cargo \
 rust-zerofrom-derive-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-zerofrom-devel = " \
 cargo \
 rust \
 "
