# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-openssl-probe"
PV = "0.2.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-openssl-probe+default-devel \
 rust-openssl-probe-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-openssl-probe-0.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3cf98b067e92a93c1922fce6ff401aa70f9afa3c593dff25b9dbc0c5c425471b"

URI_x86_64_v2_rust-openssl-probe+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-probe+default-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-probe+default-devel}"
SRC_URI[x86_64_v2_rust-openssl-probe+default-devel.sha256sum] = "09e65f86194b81ee786f6b4c5d7ee7671d0f41ec3fffcc48be40ce9369cc5972"

URI_x86_64_v2_rust-openssl-probe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-openssl-probe-devel-0.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-openssl-probe-devel}"
SRC_URI[x86_64_v2_rust-openssl-probe-devel.sha256sum] = "53a6f38fe2b0790aadba68a51b8bc2f9e3008ce3981147bc22aa2cb9e4419775"

URI_aarch64_rust-openssl-probe+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-probe+default-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-openssl-probe+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-probe+default-devel}"
SRC_URI[aarch64_rust-openssl-probe+default-devel.sha256sum] = "9f77a1ccf5bcb23e2bff2ced716e041ead7b2484656e2477032fad9be2fed7db"

URI_aarch64_rust-openssl-probe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-openssl-probe-devel-0.2.1-1.el10_3.noarch.rpm;name=aarch64_rust-openssl-probe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-openssl-probe-devel}"
SRC_URI[aarch64_rust-openssl-probe-devel.sha256sum] = "efa9fa52aa4a664cee1d7b4f72486d9767fa1ddbaae49650102a354687d1e4bd"

RDEPENDS:rust-openssl-probe+default-devel = " \
 cargo \
 rust-openssl-probe-devel \
 "
RDEPENDS:rust-openssl-probe-devel = " \
 cargo \
 rust \
 "
