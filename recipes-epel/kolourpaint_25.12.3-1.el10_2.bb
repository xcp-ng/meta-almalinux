# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolourpaint"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kolourpaint \
 kolourpaint-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kolourpaint-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5010bdac0e3cd2a7d1dae530eb1fcb0b4ac6b033a315c7a5d1191bec3b8ef70c"

URI_x86_64_v2_kolourpaint = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolourpaint}"
SRC_URI[x86_64_v2_kolourpaint.sha256sum] = "708682b617d1b5972f327bb61efdd8d0083c8d473d6edc853c7bcf2a1960e321"

URI_x86_64_v2_kolourpaint-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolourpaint-libs}"
SRC_URI[x86_64_v2_kolourpaint-libs.sha256sum] = "af6abe9d7a7bc35923b33adf23478bcdc64500fe411b56ccc6a907216c974dd1"

URI_aarch64_kolourpaint = "${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kolourpaint;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolourpaint}"
SRC_URI[aarch64_kolourpaint.sha256sum] = "7cdcf3143f1eb4374f57a7dceee06fd8c4069fbfc4dc534160e83de03d4f6e69"

URI_aarch64_kolourpaint-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kolourpaint-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolourpaint-libs}"
SRC_URI[aarch64_kolourpaint-libs.sha256sum] = "5fc19942c0b8de4f259e7e6c08408534f81ef5cc04c504381b841abc71bf24ca"

RDEPENDS:kolourpaint = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kolourpaint-libs \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kolourpaint-libs = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kolourpaint \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
