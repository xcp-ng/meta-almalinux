# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "markdownpart"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 markdownpart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/markdownpart-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30e93e4e22a25b0190aab61ea899e57e35bbf05030dc54728a0a73dbcb023d2e"

URI_x86_64_v2_markdownpart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/markdownpart-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_markdownpart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_markdownpart}"
SRC_URI[x86_64_v2_markdownpart.sha256sum] = "d4972577001f5d38697877ba45be61b8d29caf0b19a911ff5e0dfed45013d41f"

URI_aarch64_markdownpart = "${EPEL_MIRROR}/aarch64/Packages/m/markdownpart-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_markdownpart;unpack=0"
SRC_URI:append = " ${URI_aarch64_markdownpart}"
SRC_URI[aarch64_markdownpart.sha256sum] = "90648b3d24224de65c2a57abbb582363c8cc70c2ee2181559efa5b879e52449e"

RDEPENDS:markdownpart = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kparts \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
