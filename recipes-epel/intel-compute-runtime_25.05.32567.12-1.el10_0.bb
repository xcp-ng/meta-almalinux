# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-compute-runtime"
PV = "25.05.32567.12"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 intel-compute-runtime \
 intel-level-zero \
 intel-level-zero-devel \
 intel-ocloc \
 intel-ocloc-devel \
 intel-opencl \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-compute-runtime-25.05.32567.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c329fe4fdbbe4d6cbc73197061bbf165b8de1b28473c5545005af396fd6e4a5c"

URI_x86_64_v2_intel-compute-runtime = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-compute-runtime-25.05.32567.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-compute-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-compute-runtime}"
SRC_URI[x86_64_v2_intel-compute-runtime.sha256sum] = "369a4641e2c90ada910d19eac807eedb2faa9ed3002ab7c101faca421c7a9e3a"

URI_x86_64_v2_intel-level-zero = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-level-zero-25.05.32567.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-level-zero;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-level-zero}"
SRC_URI[x86_64_v2_intel-level-zero.sha256sum] = "a27a831fe81fbe6e7b8c585807f5da4b8ac80ebefae00e24f5cf6b72723dd772"

URI_x86_64_v2_intel-level-zero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-level-zero-devel-25.05.32567.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-level-zero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-level-zero-devel}"
SRC_URI[x86_64_v2_intel-level-zero-devel.sha256sum] = "758beddebc16371862b65237d7ead6da351b54c1f537d766379aeaa0fe639d01"

URI_x86_64_v2_intel-ocloc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-ocloc-25.05.32567.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-ocloc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-ocloc}"
SRC_URI[x86_64_v2_intel-ocloc.sha256sum] = "3b8f2daf96dac074fcb758a615498d2d3a990e2fcbfee75955b86473d4c44686"

URI_x86_64_v2_intel-ocloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-ocloc-devel-25.05.32567.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-ocloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-ocloc-devel}"
SRC_URI[x86_64_v2_intel-ocloc-devel.sha256sum] = "1bd2f3c1d8d367a91a1404748b085523d310d2f56f766c585b51941ce19a2213"

URI_x86_64_v2_intel-opencl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-opencl-25.05.32567.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-opencl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-opencl}"
SRC_URI[x86_64_v2_intel-opencl.sha256sum] = "52a9f90a4f935ddfe71ffcaff0c25fb01ef74f96043a5f610c74cfae033bfecf"

RDEPENDS:intel-compute-runtime = " \
 intel-igc \
 intel-level-zero \
 intel-ocloc \
 intel-opencl \
 "
RDEPENDS:intel-level-zero = " \
 glibc \
 intel-gmmlib \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-level-zero-devel = " \
 intel-level-zero \
 "
RDEPENDS:intel-ocloc = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-ocloc-devel = " \
 intel-ocloc \
 "
RDEPENDS:intel-opencl = " \
 glibc \
 intel-gmmlib \
 intel-igc-libs \
 libgcc \
 libstdc++ \
 "
