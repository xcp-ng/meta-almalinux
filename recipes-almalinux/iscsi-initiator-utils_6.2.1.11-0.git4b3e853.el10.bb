# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iscsi-initiator-utils"
PV = "6.2.1.11"
PR = "0.git4b3e853.el10"
PACKAGES = " \
 iscsi-initiator-utils \
 iscsi-initiator-utils-iscsiuio \
 python3-iscsi-initiator-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iscsi-initiator-utils-6.2.1.11-0.git4b3e853.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e65501037d8ba78b760af1076caf865d42c806feaa0f179ad148fb4f0bb8631a"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - iscsi-initiator-utils: (fedora-release-common >= 38-0.23 if fedora-release-common)

URI_x86_64_v2_iscsi-initiator-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-6.2.1.11-0.git4b3e853.el10.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iscsi-initiator-utils}"
SRC_URI[x86_64_v2_iscsi-initiator-utils.sha256sum] = "62a4d84ecd4220947681031b6ab782598b53a68e4dc786a4dc78e9deabf34325"

URI_x86_64_v2_iscsi-initiator-utils-iscsiuio = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.11-0.git4b3e853.el10.x86_64_v2.rpm;name=x86_64_v2_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iscsi-initiator-utils-iscsiuio}"
SRC_URI[x86_64_v2_iscsi-initiator-utils-iscsiuio.sha256sum] = "d3917f06c558dcc03e1f03712abc69f6c0fd3896d39fae086fc872da7bcce08e"

URI_x86_64_v2_python3-iscsi-initiator-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-iscsi-initiator-utils-6.2.1.11-0.git4b3e853.el10.x86_64_v2.rpm;name=x86_64_v2_python3-iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-iscsi-initiator-utils}"
SRC_URI[x86_64_v2_python3-iscsi-initiator-utils.sha256sum] = "dd51f0cc1a9423284fec4cf53854ae36cd19ae88d92292952e003e021330251c"

URI_aarch64_iscsi-initiator-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-6.2.1.11-0.git4b3e853.el10.aarch64.rpm;name=aarch64_iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iscsi-initiator-utils}"
SRC_URI[aarch64_iscsi-initiator-utils.sha256sum] = "1bf6fad2ca3b7da862a5163e797d18e56a20332726ebc97ab1dbdff4243b1ef2"

URI_aarch64_iscsi-initiator-utils-iscsiuio = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iscsi-initiator-utils-iscsiuio-6.2.1.11-0.git4b3e853.el10.aarch64.rpm;name=aarch64_iscsi-initiator-utils-iscsiuio;unpack=0"
SRC_URI:append = " ${URI_aarch64_iscsi-initiator-utils-iscsiuio}"
SRC_URI[aarch64_iscsi-initiator-utils-iscsiuio.sha256sum] = "df73253a3b561fd526835469eaa4243fc44ebf10041572d0ef584883a4b0c6e9"

URI_aarch64_python3-iscsi-initiator-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-iscsi-initiator-utils-6.2.1.11-0.git4b3e853.el10.aarch64.rpm;name=aarch64_python3-iscsi-initiator-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-iscsi-initiator-utils}"
SRC_URI[aarch64_python3-iscsi-initiator-utils.sha256sum] = "3967e1860d20763b2cf1f6678ef6d914659207ada46a866e5c2a9d1933c9e9b1"

RDEPENDS:iscsi-initiator-utils = " \
 bash \
 glibc \
 iscsi-initiator-utils-iscsiuio \
 isns-utils-libs \
 kmod-libs \
 libmount \
 openssl-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:iscsi-initiator-utils-iscsiuio = " \
 bash \
 glibc \
 iscsi-initiator-utils \
 libgcc \
 systemd-libs \
 "
RDEPENDS:python3-iscsi-initiator-utils = " \
 glibc \
 iscsi-initiator-utils \
 python3 \
 "
