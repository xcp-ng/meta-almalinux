# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rlwrap"
PV = "0.46.2"
PR = "2.el10_1"
PACKAGES = " \
 rlwrap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rlwrap-0.46.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9744834d4d7b1129d5c160554de7ef3d3987f1fde980f9e5fbfbce14dd713467"

URI_x86_64_v2_rlwrap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rlwrap-0.46.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rlwrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rlwrap}"
SRC_URI[x86_64_v2_rlwrap.sha256sum] = "f6290ab90f380feead03ea1b89a386f9ba19cc928afb3b4ecafff9ab8fb4fe86"

URI_aarch64_rlwrap = "${EPEL_MIRROR}/aarch64/Packages/r/rlwrap-0.46.2-2.el10_1.aarch64.rpm;name=aarch64_rlwrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_rlwrap}"
SRC_URI[aarch64_rlwrap.sha256sum] = "ba8d5d143ab75adbbeab49c262f185a0ba376c5abec60c76e4a41d457dda567f"

RDEPENDS:rlwrap = " \
 glibc \
 ncurses-libs \
 perl-AutoLoader \
 perl-Carp \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Slurp \
 perl-Getopt-Std \
 perl-POSIX \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 python3 \
 readline \
 rlwrap \
 "
