# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-msgpack"
PV = "3.0.0"
PR = "1.el10_0"
PACKAGES = " \
 php-pecl-msgpack \
 php-pecl-msgpack-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-msgpack-3.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "73da0e6a09fcd6c5c7c507056235102b04de7065ff0fb08d135e57f2eef470f2"

URI_x86_64_v2_php-pecl-msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-msgpack-3.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-msgpack}"
SRC_URI[x86_64_v2_php-pecl-msgpack.sha256sum] = "e96aae6ab00ae311bacd51cb50fc473471e2e2070358510a16522ea1e9b3e7ab"

URI_x86_64_v2_php-pecl-msgpack-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-msgpack-devel-3.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-msgpack-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-msgpack-devel}"
SRC_URI[x86_64_v2_php-pecl-msgpack-devel.sha256sum] = "4e915d003ab972ed94517ea79df5698191e75138d8b9859bfba070a5b677c110"

URI_aarch64_php-pecl-msgpack = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-msgpack-3.0.0-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-msgpack}"
SRC_URI[aarch64_php-pecl-msgpack.sha256sum] = "a186fa94ff52ca7209fde9fb444969d78fdfb4fd02714e77c92c541aed2f2514"

URI_aarch64_php-pecl-msgpack-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-msgpack-devel-3.0.0-1.el10_0.aarch64.rpm;name=aarch64_php-pecl-msgpack-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-msgpack-devel}"
SRC_URI[aarch64_php-pecl-msgpack-devel.sha256sum] = "87036690496ffe9e20ce08c80d2d3b772c4a75ae240bc6c39fe1b53b4c087a96"

RDEPENDS:php-pecl-msgpack = " \
 glibc \
 php-common \
 "
RDEPENDS:php-pecl-msgpack-devel = " \
 php-devel \
 php-pecl-msgpack \
 "
