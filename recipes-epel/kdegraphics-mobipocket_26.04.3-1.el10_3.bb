# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdegraphics-mobipocket"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kdegraphics-mobipocket \
 kdegraphics-mobipocket-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdegraphics-mobipocket-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a524ca5003044e1b67f1d655b15707795b7925065617809da1f4831969d706d4"

URI_x86_64_v2_kdegraphics-mobipocket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-mobipocket}"
SRC_URI[x86_64_v2_kdegraphics-mobipocket.sha256sum] = "8cba3fb5c8fd005b2e6ae7f2920a71d3953e56d529d6a164859a661e13e80616"

URI_x86_64_v2_kdegraphics-mobipocket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdegraphics-mobipocket-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdegraphics-mobipocket-devel}"
SRC_URI[x86_64_v2_kdegraphics-mobipocket-devel.sha256sum] = "14c863282d71b621ba0fa4dc9e37cfaa02cc0bba8aac6ca4acc7e810f44b7dd3"

URI_aarch64_kdegraphics-mobipocket = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdegraphics-mobipocket;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-mobipocket}"
SRC_URI[aarch64_kdegraphics-mobipocket.sha256sum] = "ef91906d43fb75264192c1f03470a6e17093859452e366b6d827d730b4f92a51"

URI_aarch64_kdegraphics-mobipocket-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdegraphics-mobipocket-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kdegraphics-mobipocket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdegraphics-mobipocket-devel}"
SRC_URI[aarch64_kdegraphics-mobipocket-devel.sha256sum] = "184d70c622dd35ad954fba0f997b8dc01135cc8aa2d6e53af3ac84ddd7f5b0bf"

RDEPENDS:kdegraphics-mobipocket = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdegraphics-mobipocket-devel = " \
 cmake-filesystem \
 kdegraphics-mobipocket \
 "
