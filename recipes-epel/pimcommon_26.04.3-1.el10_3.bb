# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pimcommon"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 pimcommon \
 pimcommon-devel \
 pimcommon-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pimcommon-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04fa401d0edc7e9a0390c83f8cca29bada8a62788bcab9634610f17759ca13bb"

URI_x86_64_v2_pimcommon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon}"
SRC_URI[x86_64_v2_pimcommon.sha256sum] = "6b08ca50d52e650c9fc123af06dbf8682845e449be1f2df04f1d22c5d28da72e"

URI_x86_64_v2_pimcommon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon-devel}"
SRC_URI[x86_64_v2_pimcommon-devel.sha256sum] = "4af714ec65e0b9b7958b9eedb44c8c00bf02c9ee1946e1323d237c0879f81f34"

URI_x86_64_v2_pimcommon-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pimcommon-doc-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pimcommon-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pimcommon-doc}"
SRC_URI[x86_64_v2_pimcommon-doc.sha256sum] = "90fd5ececea8e166946483f0a63e9a5619301654845fd522cde09f14ab285524"

URI_aarch64_pimcommon = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_pimcommon;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon}"
SRC_URI[aarch64_pimcommon.sha256sum] = "3993eb26ef020adcdfe93c6293b3ba42ba7489465b0c9b017e8d1268bc6b2214"

URI_aarch64_pimcommon-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_pimcommon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon-devel}"
SRC_URI[aarch64_pimcommon-devel.sha256sum] = "5ad078d2a1af4901077cf37c47009478a8573f9f4c94d0b4b504d6912f3b41ef"

URI_aarch64_pimcommon-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pimcommon-doc-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_pimcommon-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pimcommon-doc}"
SRC_URI[aarch64_pimcommon-doc.sha256sum] = "9692ffc20e33477b14efcd8bd1d9abf53212d84adb517c7cdd2333856df46c11"

RDEPENDS:pimcommon = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-purpose \
 kimap \
 kldap \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-devel = " \
 akonadi-contacts-devel \
 akonadi-server-devel \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kcontacts-devel \
 kimap-devel \
 ktextaddons-qt6-devel \
 libgcc \
 libstdc++ \
 pimcommon \
 plasma-activities-devel \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:pimcommon-doc = " \
 "
