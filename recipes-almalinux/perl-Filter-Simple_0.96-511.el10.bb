# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Filter-Simple"
PV = "0.96"
PR = "511.el10"
PACKAGES = " \
 perl-Filter-Simple \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Filter-Simple-0.96-511.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2f815806bb23de8361266ac1efda04a7b9530c9421b2b33f6d67fb82e37277e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Filter-Simple-0.96-511.el10.noarch.rpm;name=x86_64_v2_perl-Filter-Simple;unpack=0"
SRC_URI[x86_64_v2_perl-Filter-Simple.sha256sum] = "bfdca3dad67fb50197b5952b5658c0e786efb5430d9cee78e69c2c9bd6bc4bd7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Filter-Simple-0.96-511.el10.noarch.rpm;name=aarch64_perl-Filter-Simple;unpack=0"
SRC_URI[aarch64_perl-Filter-Simple.sha256sum] = "bfdca3dad67fb50197b5952b5658c0e786efb5430d9cee78e69c2c9bd6bc4bd7"

RDEPENDS:perl-Filter-Simple = " \
 perl-Carp \
 perl-Filter \
 perl-Text-Balanced \
 perl-libs \
 "
