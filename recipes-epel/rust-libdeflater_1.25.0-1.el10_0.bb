# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libdeflater"
PV = "1.25.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-libdeflater+default-devel \
 rust-libdeflater+dynamic-devel \
 rust-libdeflater+freestanding-devel \
 rust-libdeflater+use_rust_alloc-devel \
 rust-libdeflater-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libdeflater-1.25.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d8bb670c319b77e59b8360d2fd3f2e3db4fa9a6fc973b0bc132c479f19763e2b"

URI_x86_64_v2_rust-libdeflater+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+default-devel-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+default-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+default-devel.sha256sum] = "f8d05e28184069b7d9f6116d7f55910c28da77db8b7fa5b17c93c9462e8f0ef8"

URI_x86_64_v2_rust-libdeflater+dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+dynamic-devel-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+dynamic-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+dynamic-devel.sha256sum] = "2e6970fe06baa29eb1f5d49d2bdea3a764ae71f014f7d3d97815c7e8ced1a981"

URI_x86_64_v2_rust-libdeflater+freestanding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+freestanding-devel-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+freestanding-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+freestanding-devel.sha256sum] = "84a8ec93033aba8aad301ac2571cb0cca359896bb83b125b1110d936b183f361"

URI_x86_64_v2_rust-libdeflater+use_rust_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater+use_rust_alloc-devel-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater+use_rust_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater+use_rust_alloc-devel}"
SRC_URI[x86_64_v2_rust-libdeflater+use_rust_alloc-devel.sha256sum] = "b50f7addba06cab0e05701205b5a7e28d384250910d01d8831c49c17fff68a68"

URI_x86_64_v2_rust-libdeflater-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflater-devel-1.25.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflater-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflater-devel}"
SRC_URI[x86_64_v2_rust-libdeflater-devel.sha256sum] = "6d252e1df2014ce84e129662b5bc909d66f86cf64a25c8c8b45e99fc21699bd5"

URI_aarch64_rust-libdeflater+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+default-devel-1.25.0-1.el10_0.noarch.rpm;name=aarch64_rust-libdeflater+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+default-devel}"
SRC_URI[aarch64_rust-libdeflater+default-devel.sha256sum] = "6927990aa4d93440f6cec902b52f9a10cba4c7e6227f7331aa72e6dd2e0a1777"

URI_aarch64_rust-libdeflater+dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+dynamic-devel-1.25.0-1.el10_0.noarch.rpm;name=aarch64_rust-libdeflater+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+dynamic-devel}"
SRC_URI[aarch64_rust-libdeflater+dynamic-devel.sha256sum] = "dd5452a5d2e19e72c38bfcff7d4d748a2697934968e1323e452a5b37c6732f38"

URI_aarch64_rust-libdeflater+freestanding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+freestanding-devel-1.25.0-1.el10_0.noarch.rpm;name=aarch64_rust-libdeflater+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+freestanding-devel}"
SRC_URI[aarch64_rust-libdeflater+freestanding-devel.sha256sum] = "0ae745a6c08693403773907cfbd6c6d841214dd85d8be729c22118bc0d83a818"

URI_aarch64_rust-libdeflater+use_rust_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater+use_rust_alloc-devel-1.25.0-1.el10_0.noarch.rpm;name=aarch64_rust-libdeflater+use_rust_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater+use_rust_alloc-devel}"
SRC_URI[aarch64_rust-libdeflater+use_rust_alloc-devel.sha256sum] = "cf2f4760fbb202ec7826f7595f42bbd833a286f9447f5263dd24f13a42c9a357"

URI_aarch64_rust-libdeflater-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflater-devel-1.25.0-1.el10_0.noarch.rpm;name=aarch64_rust-libdeflater-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflater-devel}"
SRC_URI[aarch64_rust-libdeflater-devel.sha256sum] = "d0d2a0294e5033c183fd8f349d1e5ba3bcba5a35a4ae0563e3f3d725fefc6926"

RDEPENDS:rust-libdeflater+default-devel = " \
 cargo \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+dynamic-devel = " \
 cargo \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+freestanding-devel = " \
 cargo \
 rust-libdeflate-sys+freestanding-devel \
 rust-libdeflater+use_rust_alloc-devel \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater+use_rust_alloc-devel = " \
 cargo \
 rust-libdeflater-devel \
 "
RDEPENDS:rust-libdeflater-devel = " \
 cargo \
 rust-libdeflate-sys+default-devel \
 "
