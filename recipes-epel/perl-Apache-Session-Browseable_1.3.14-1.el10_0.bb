# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Apache-Session-Browseable"
PV = "1.3.14"
PR = "1.el10_0"
PACKAGES = " \
 perl-Apache-Session-Browseable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Apache-Session-Browseable-1.3.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc90c296ac0f1d33a634f4ea7d1dd8feec83ca48a6e62ae0ae78540fbae2b33c"

URI_x86_64_v2_perl-Apache-Session-Browseable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Apache-Session-Browseable-1.3.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Apache-Session-Browseable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Apache-Session-Browseable}"
SRC_URI[x86_64_v2_perl-Apache-Session-Browseable.sha256sum] = "305bedb5f021547b36c204e098960926c1c1c3bb55cfe677b427938b64357462"

URI_aarch64_perl-Apache-Session-Browseable = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Apache-Session-Browseable-1.3.14-1.el10_0.noarch.rpm;name=aarch64_perl-Apache-Session-Browseable;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Apache-Session-Browseable}"
SRC_URI[aarch64_perl-Apache-Session-Browseable.sha256sum] = "e1b2c50e6e09b40ea21246bf058b5c7fc4d1472c19851a30d3c47bd10d9df4e6"

RDEPENDS:perl-Apache-Session-Browseable = " \
 perl-Apache-Session \
 perl-Apache-Session-Browseable \
 perl-AutoLoader \
 perl-DBI \
 perl-Digest-SHA \
 perl-JSON \
 perl-LDAP \
 perl-MIME-Base64 \
 perl-Redis \
 perl-Storable \
 perl-constant \
 perl-libs \
 perl-vars \
 "
