# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lsb_release"
PV = "3.3"
PR = "5.el10_0"
PACKAGES = " \
 lsb_release \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lsb_release-3.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b406e093b479f3e6b5724677685c207998c1f7a27273025c4fc90f4b577f7845"

URI_x86_64_v2_lsb_release = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsb_release-3.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_lsb_release;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsb_release}"
SRC_URI[x86_64_v2_lsb_release.sha256sum] = "e7bd79f3b924317a4277a3e82be2a4066d2db842796b8310803b5023c6aaa9e0"

URI_aarch64_lsb_release = "${EPEL_MIRROR}/aarch64/Packages/l/lsb_release-3.3-5.el10_0.noarch.rpm;name=aarch64_lsb_release;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsb_release}"
SRC_URI[aarch64_lsb_release.sha256sum] = "6fde184fa3e1dfc0ebad0462ed48ec05332681103ecadce4d51c59cf7dd58d6b"

RDEPENDS:lsb_release = " \
 bash \
 sed \
 util-linux \
 virtual//usr/bin/tr \
 "
