# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-jpeg"
PV = "0.5.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-zune-jpeg+default-devel \
 rust-zune-jpeg+log-devel \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+portable_simd-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-jpeg-0.5.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ae5b2329c539aa9be21ba92ba73f94914df1774a485a8eb122a224371d92427"

URI_x86_64_v2_rust-zune-jpeg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+default-devel-0.5.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+default-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+default-devel.sha256sum] = "0c74af162652f04f7f75809b833ec83bec1d100b6edd2e9e4fe90897b85c2a3f"

URI_x86_64_v2_rust-zune-jpeg+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+log-devel-0.5.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+log-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+log-devel.sha256sum] = "7a8f2226736cd3c454533fac0b16a4ba157e4a8a4a62969529eecaea26ade684"

URI_x86_64_v2_rust-zune-jpeg+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+neon-devel-0.5.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+neon-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+neon-devel.sha256sum] = "75c9b34ab49560bc0ec1be58946747862fabc370efb477b61b657ea22251d086"

URI_x86_64_v2_rust-zune-jpeg+portable_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+portable_simd-devel-0.5.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+portable_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+portable_simd-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+portable_simd-devel.sha256sum] = "eba235f3d5d61621ea305c0bed21b5e3b9d60eeb2fb69c505de3bc0c16215ee5"

URI_x86_64_v2_rust-zune-jpeg+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+std-devel-0.5.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+std-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+std-devel.sha256sum] = "bfe70003d9846926d1f2f348ce817e2b364ce0d306dab5979cb6be534959af31"

URI_x86_64_v2_rust-zune-jpeg+x86-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg+x86-devel-0.5.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg+x86-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg+x86-devel.sha256sum] = "0570ef57deaef09096c8b7558e6f4e771581cc5903ae83d7e2a8448a95312df9"

URI_x86_64_v2_rust-zune-jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-jpeg-devel-0.5.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-jpeg-devel}"
SRC_URI[x86_64_v2_rust-zune-jpeg-devel.sha256sum] = "e0da7e45ced364540a36d01c4427e8f0c2d88c041dd680c7263a203cfe1e1797"

URI_aarch64_rust-zune-jpeg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+default-devel-0.5.13-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+default-devel}"
SRC_URI[aarch64_rust-zune-jpeg+default-devel.sha256sum] = "ef33ac735702ca1cffe057fdc334bec027f770201e444329cb565a439c087f46"

URI_aarch64_rust-zune-jpeg+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+log-devel-0.5.13-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+log-devel}"
SRC_URI[aarch64_rust-zune-jpeg+log-devel.sha256sum] = "49c6fe9742b6393c84d1e6afd94b4aa64554067d9d56f191baba7c0a961b4e68"

URI_aarch64_rust-zune-jpeg+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+neon-devel-0.5.13-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+neon-devel}"
SRC_URI[aarch64_rust-zune-jpeg+neon-devel.sha256sum] = "310a119ab1fe5117c25dff36e18be0772e56ed9e936f588ede52175c92d373c0"

URI_aarch64_rust-zune-jpeg+portable_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+portable_simd-devel-0.5.13-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+portable_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+portable_simd-devel}"
SRC_URI[aarch64_rust-zune-jpeg+portable_simd-devel.sha256sum] = "9f1c32513f1f402d1137492d98033e0820b15d62b098c9ff241499e15899e50b"

URI_aarch64_rust-zune-jpeg+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+std-devel-0.5.13-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+std-devel}"
SRC_URI[aarch64_rust-zune-jpeg+std-devel.sha256sum] = "5b2e789fa1e9d2a2c84b57282cdd2479fff3af4c44fbdaac135e43887b46fb3a"

URI_aarch64_rust-zune-jpeg+x86-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg+x86-devel-0.5.13-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg+x86-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg+x86-devel}"
SRC_URI[aarch64_rust-zune-jpeg+x86-devel.sha256sum] = "9d49426e8bd06deee7c769132e926c97865c0e7fbeb92b53481baa855508a132"

URI_aarch64_rust-zune-jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-jpeg-devel-0.5.13-1.el10_2.noarch.rpm;name=aarch64_rust-zune-jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-jpeg-devel}"
SRC_URI[aarch64_rust-zune-jpeg-devel.sha256sum] = "be79e90887fb74d2faff4009c303db476fef420f38a43674b46558b6cdb6941b"

RDEPENDS:rust-zune-jpeg+default-devel = " \
 cargo \
 rust-zune-jpeg+neon-devel \
 rust-zune-jpeg+std-devel \
 rust-zune-jpeg+x86-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+log-devel = " \
 cargo \
 rust-zune-core+log-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+neon-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+portable_simd-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+std-devel = " \
 cargo \
 rust-zune-core+std-devel \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg+x86-devel = " \
 cargo \
 rust-zune-jpeg-devel \
 "
RDEPENDS:rust-zune-jpeg-devel = " \
 cargo \
 rust \
 rust-zune-core+default-devel \
 "
