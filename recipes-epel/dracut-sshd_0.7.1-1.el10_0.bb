# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dracut-sshd"
PV = "0.7.1"
PR = "1.el10_0"
PACKAGES = " \
 dracut-sshd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dracut-sshd-0.7.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8aba7f967c698a9f1aded72a4b31a21466742df8c850c1cb6e8a621a9efabeed"

URI_x86_64_v2_dracut-sshd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dracut-sshd-0.7.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dracut-sshd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dracut-sshd}"
SRC_URI[x86_64_v2_dracut-sshd.sha256sum] = "6a30fcc93f8153c495ee6b1a47395464a35325bb51f30382df6c5336407b5919"

URI_aarch64_dracut-sshd = "${EPEL_MIRROR}/aarch64/Packages/d/dracut-sshd-0.7.1-1.el10_0.noarch.rpm;name=aarch64_dracut-sshd;unpack=0"
SRC_URI:append = " ${URI_aarch64_dracut-sshd}"
SRC_URI[aarch64_dracut-sshd.sha256sum] = "79e847f00442cf7233d63d5d8d14374836feaade448fe36eacc17d0114105b12"

RDEPENDS:dracut-sshd = " \
 bash \
 dracut \
 openssh-server \
 "
