# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-twofish"
PV = "0.7.1"
PR = "4.el10_2"
PACKAGES = " \
 rust-twofish+default-devel \
 rust-twofish+zeroize-devel \
 rust-twofish-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-twofish-0.7.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f89125c6b5c15e79f0d3568b5be43f44866d85173f556755ec9e4f92a5cfde25"

URI_x86_64_v2_rust-twofish+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twofish+default-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twofish+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twofish+default-devel}"
SRC_URI[x86_64_v2_rust-twofish+default-devel.sha256sum] = "a9cc98a4d6f6a92dcaf86ae526d0d7567bbc41215d3b4d3c4ce27ea886049a07"

URI_x86_64_v2_rust-twofish+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twofish+zeroize-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twofish+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twofish+zeroize-devel}"
SRC_URI[x86_64_v2_rust-twofish+zeroize-devel.sha256sum] = "b7b4e3b0e11d9018e6bcdb9dc98dc374d4e860aa42510bf9d275e2db5341d792"

URI_x86_64_v2_rust-twofish-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-twofish-devel-0.7.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-twofish-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-twofish-devel}"
SRC_URI[x86_64_v2_rust-twofish-devel.sha256sum] = "324e7e11f29a4e801f3a85b944e7b1a1e8393afc384eff6c64dbff675980ac3b"

URI_aarch64_rust-twofish+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twofish+default-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-twofish+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twofish+default-devel}"
SRC_URI[aarch64_rust-twofish+default-devel.sha256sum] = "e46a45477c190e052098138e275e45ba6cc209187f29fa1a119c2768a4a341bb"

URI_aarch64_rust-twofish+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twofish+zeroize-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-twofish+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twofish+zeroize-devel}"
SRC_URI[aarch64_rust-twofish+zeroize-devel.sha256sum] = "f8d82574b03205f73fc0f03f5a0dcc15f5d416e94e2a84982b80cd5dca4eb843"

URI_aarch64_rust-twofish-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-twofish-devel-0.7.1-4.el10_2.noarch.rpm;name=aarch64_rust-twofish-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-twofish-devel}"
SRC_URI[aarch64_rust-twofish-devel.sha256sum] = "a4b6cd35fa26e4be641144206a4e6c7b61e5f8b41dd9b20029b9f66dd303e382"

RDEPENDS:rust-twofish+default-devel = " \
 cargo \
 rust-twofish-devel \
 "
RDEPENDS:rust-twofish+zeroize-devel = " \
 cargo \
 rust-cipher0.4+zeroize-devel \
 rust-twofish-devel \
 "
RDEPENDS:rust-twofish-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
