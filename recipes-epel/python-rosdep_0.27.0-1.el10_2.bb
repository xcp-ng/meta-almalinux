# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rosdep"
PV = "0.27.0"
PR = "1.el10_2"
PACKAGES = " \
 python-rosdep-doc \
 python3-rosdep \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-rosdep-0.27.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2fa00d728ae19b9a8b66cfe7aff985f9854b0ad57b37f6c49c8187987807a7c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-rosdep-doc-0.27.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-rosdep-doc;unpack=0"
SRC_URI[x86_64_v2_python-rosdep-doc.sha256sum] = "b0acc9727d86a88136625fc87dc399357b74bcda03016d9c481fb5925a3a0a92"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rosdep-0.27.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rosdep;unpack=0"
SRC_URI[x86_64_v2_python3-rosdep.sha256sum] = "5deadbe66ffd021c8534635e7adcb5a6e62d4f865a4fa0e77b5cb28a133ebb21"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-rosdep-doc-0.27.0-1.el10_2.noarch.rpm;name=aarch64_python-rosdep-doc;unpack=0"
SRC_URI[aarch64_python-rosdep-doc.sha256sum] = "6844314f7d52dfaf96194c5becb04176b53d5ffd359a11fc29692ad79dcc37ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-rosdep-0.27.0-1.el10_2.noarch.rpm;name=aarch64_python3-rosdep;unpack=0"
SRC_URI[aarch64_python3-rosdep.sha256sum] = "bf4277a062eae08e18e3b94413ce5af79875e10636ea80e503c8da2fd825cd71"

RDEPENDS:python-rosdep-doc = " \
 "
RDEPENDS:python3-rosdep = " \
 python-srpm-macros \
 python3 \
 python3-catkin_pkg \
 python3-pyyaml \
 python3-rosdistro \
 python3-rospkg \
 "
