# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oracledb"
PV = "2.5.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-oracledb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oracledb-2.5.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2672f60f1994af97cf4c314eed43876f58f6e9dff6ebc828d29b5efd6f0a6125"

URI_x86_64_v2_python3-oracledb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oracledb-2.5.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-oracledb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oracledb}"
SRC_URI[x86_64_v2_python3-oracledb.sha256sum] = "bad00385ec35799e294e26f29eb806a16ae55c100cdd9005266cdeebc3c1d20e"

URI_aarch64_python3-oracledb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oracledb-2.5.1-1.el10_0.aarch64.rpm;name=aarch64_python3-oracledb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oracledb}"
SRC_URI[aarch64_python3-oracledb.sha256sum] = "9c89f4af2725073a7e1b55508660160a9b167603aa5b00ab6aca168905b2ebbe"

RDEPENDS:python3-oracledb = " \
 glibc \
 python3 \
 python3-cryptography \
 "
