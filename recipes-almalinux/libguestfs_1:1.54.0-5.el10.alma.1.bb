# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libguestfs"
PE = "1"
PV = "1.54.0"
PR = "5.el10.alma.1"
PACKAGES = " \
 libguestfs \
 libguestfs-appliance \
 libguestfs-bash-completion \
 libguestfs-devel \
 libguestfs-inspect-icons \
 libguestfs-man-pages-ja \
 libguestfs-man-pages-uk \
 libguestfs-rescue \
 libguestfs-rsync \
 libguestfs-xfs \
 ocaml-libguestfs \
 ocaml-libguestfs-devel \
 perl-Sys-Guestfs \
 python3-libguestfs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libguestfs-1.54.0-5.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71818de14e471cf0a8f6b7dbaafabef2169dc772787a5556c79a23a979cb61aa"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ocaml-libguestfs-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs-devel: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libguestfs-devel: ocamlx(CamlinternalOO) = 3bb5173e1a86ae74d96d5b3bc80f14a3
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libguestfs: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - ocaml-libguestfs-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs-devel: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libguestfs-devel: ocamlx(CamlinternalOO) = 3bb5173e1a86ae74d96d5b3bc80f14a3
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Array) = b3215f99afe054938b4b66df456093cb
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libguestfs-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libguestfs: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libguestfs: ocaml(CamlinternalOO) = bf3206c1e533a97ee4e00a76bfe1dae6
# - ocaml-libguestfs: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libguestfs: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libguestfs: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libguestfs: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libguestfs: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libguestfs: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827

URI_x86_64_v2_libguestfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs}"
SRC_URI[x86_64_v2_libguestfs.sha256sum] = "ade694e3c4c7f28295080bf55c6fb90522c3b372346fe8b5323e9ee5aaede7ba"

URI_x86_64_v2_libguestfs-appliance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-appliance-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-appliance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-appliance}"
SRC_URI[x86_64_v2_libguestfs-appliance.sha256sum] = "d1a0f612557f7f1860f57b0b965e8ffdfe503164bab75abecade2069e941e547"

URI_x86_64_v2_libguestfs-bash-completion = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-bash-completion-1.54.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-bash-completion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-bash-completion}"
SRC_URI[x86_64_v2_libguestfs-bash-completion.sha256sum] = "dc2b79c1bb0c1e6e58f9c4d2cacfc3a403bf0d00a39a2c6f37bcff160d4652bb"

URI_x86_64_v2_libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-devel-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-devel}"
SRC_URI[x86_64_v2_libguestfs-devel.sha256sum] = "b66553ac2e5fccef93537a431a41751bc62040898119c0a06d79bcac154c00f8"

URI_x86_64_v2_libguestfs-inspect-icons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-inspect-icons-1.54.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-inspect-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-inspect-icons}"
SRC_URI[x86_64_v2_libguestfs-inspect-icons.sha256sum] = "40dad531d6c74229422705d1f972756555cb77fc42e698925b32768acb192b3e"

URI_x86_64_v2_libguestfs-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-ja-1.54.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-man-pages-ja}"
SRC_URI[x86_64_v2_libguestfs-man-pages-ja.sha256sum] = "8bb280f47b9465c6e44a1eb58e5a694b5038ef5932d05f7af6f75a68fc324dc7"

URI_x86_64_v2_libguestfs-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libguestfs-man-pages-uk-1.54.0-5.el10.alma.1.noarch.rpm;name=x86_64_v2_libguestfs-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-man-pages-uk}"
SRC_URI[x86_64_v2_libguestfs-man-pages-uk.sha256sum] = "75bdb5d7df406792ec5e5d7cec2cad944e880a73ceec6f6db8d14710a38cf74d"

URI_x86_64_v2_libguestfs-rescue = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-rescue-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-rescue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-rescue}"
SRC_URI[x86_64_v2_libguestfs-rescue.sha256sum] = "d3df3074e7ba38e37380e9768533aa0e058e0b89852cb814ef6e4404c6815f18"

URI_x86_64_v2_libguestfs-rsync = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-rsync-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-rsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-rsync}"
SRC_URI[x86_64_v2_libguestfs-rsync.sha256sum] = "ceb78208a649ebbc9e7d10d9b0f27d47647d8b0741bc161b58172a0c02378a7b"

URI_x86_64_v2_libguestfs-xfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libguestfs-xfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libguestfs-xfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libguestfs-xfs}"
SRC_URI[x86_64_v2_libguestfs-xfs.sha256sum] = "0def00f238655dd27e78d6e872285fc3f2465922adafd434ae375a46a11fc578"

URI_x86_64_v2_ocaml-libguestfs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libguestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libguestfs}"
SRC_URI[x86_64_v2_ocaml-libguestfs.sha256sum] = "be6d66847b20f16aa149d2adf5ca67585537516dc67dc4ca3154788fed5321cd"

URI_x86_64_v2_ocaml-libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libguestfs-devel-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_ocaml-libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ocaml-libguestfs-devel}"
SRC_URI[x86_64_v2_ocaml-libguestfs-devel.sha256sum] = "59a4b5d282a8dc7b8544fd7c9f8b3cc24d18ad1766968f8a467acecde34cb8ce"

URI_x86_64_v2_perl-Sys-Guestfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sys-Guestfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Guestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Guestfs}"
SRC_URI[x86_64_v2_perl-Sys-Guestfs.sha256sum] = "6bf136b3547f937c9432324caabc0713ccfa69be450cb8c24323c8a8a4a2f1cc"

URI_x86_64_v2_python3-libguestfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libguestfs-1.54.0-5.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-libguestfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libguestfs}"
SRC_URI[x86_64_v2_python3-libguestfs.sha256sum] = "ff69c7c66790df20f0a6c0a43168aab3c7ccf48c256c92e879e183c9849afb17"

URI_aarch64_libguestfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs}"
SRC_URI[aarch64_libguestfs.sha256sum] = "309180e7df35eb8a515fd765191b57becf573945d6a3471806ecd24d86541da8"

URI_aarch64_libguestfs-appliance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-appliance-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-appliance;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-appliance}"
SRC_URI[aarch64_libguestfs-appliance.sha256sum] = "3305997c6844d77c5c6cd8468daa45b920445ef2fde04424cbadb0255b35515b"

URI_aarch64_libguestfs-bash-completion = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-bash-completion-1.54.0-5.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-bash-completion;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-bash-completion}"
SRC_URI[aarch64_libguestfs-bash-completion.sha256sum] = "dc2b79c1bb0c1e6e58f9c4d2cacfc3a403bf0d00a39a2c6f37bcff160d4652bb"

URI_aarch64_libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-devel-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-devel}"
SRC_URI[aarch64_libguestfs-devel.sha256sum] = "d6acc0f7f19a25499697cfb6a00810070b2cea9ef48dbaf40150dca83ce14d3a"

URI_aarch64_libguestfs-inspect-icons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-inspect-icons-1.54.0-5.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-inspect-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-inspect-icons}"
SRC_URI[aarch64_libguestfs-inspect-icons.sha256sum] = "40dad531d6c74229422705d1f972756555cb77fc42e698925b32768acb192b3e"

URI_aarch64_libguestfs-man-pages-ja = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-man-pages-ja-1.54.0-5.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-man-pages-ja;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-man-pages-ja}"
SRC_URI[aarch64_libguestfs-man-pages-ja.sha256sum] = "8bb280f47b9465c6e44a1eb58e5a694b5038ef5932d05f7af6f75a68fc324dc7"

URI_aarch64_libguestfs-man-pages-uk = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libguestfs-man-pages-uk-1.54.0-5.el10.alma.1.noarch.rpm;name=aarch64_libguestfs-man-pages-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-man-pages-uk}"
SRC_URI[aarch64_libguestfs-man-pages-uk.sha256sum] = "75bdb5d7df406792ec5e5d7cec2cad944e880a73ceec6f6db8d14710a38cf74d"

URI_aarch64_libguestfs-rescue = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-rescue-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-rescue;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-rescue}"
SRC_URI[aarch64_libguestfs-rescue.sha256sum] = "67807a398f1b6ac334d378b542d2a6ecafbd3f7278317feb5406bc481a7e1cd0"

URI_aarch64_libguestfs-rsync = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-rsync-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-rsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-rsync}"
SRC_URI[aarch64_libguestfs-rsync.sha256sum] = "8e8eadd6fa9c1e8a3aeae701e3663c1d35c649d49ab60307e491d512b29d4148"

URI_aarch64_libguestfs-xfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libguestfs-xfs-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_libguestfs-xfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libguestfs-xfs}"
SRC_URI[aarch64_libguestfs-xfs.sha256sum] = "3592ba3860566c0e7aa5faac92fe55cf6f3f7acf1e105cf96738f8b4bf516913"

URI_aarch64_ocaml-libguestfs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libguestfs-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_ocaml-libguestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libguestfs}"
SRC_URI[aarch64_ocaml-libguestfs.sha256sum] = "7e88104ae06ef83e447147ebd999f2b963500b91ab09d64622e284d940c22ef0"

URI_aarch64_ocaml-libguestfs-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libguestfs-devel-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_ocaml-libguestfs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ocaml-libguestfs-devel}"
SRC_URI[aarch64_ocaml-libguestfs-devel.sha256sum] = "982080455ac3cdb8e77f23f1c6ec5ce8e4e55bbbb64cf1b2ac3915de9ed55508"

URI_aarch64_perl-Sys-Guestfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sys-Guestfs-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_perl-Sys-Guestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Guestfs}"
SRC_URI[aarch64_perl-Sys-Guestfs.sha256sum] = "3230ee6e6fc95f429fd38f80e4f1f8628444a59467a37d50df1e9ec396e85d16"

URI_aarch64_python3-libguestfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libguestfs-1.54.0-5.el10.alma.1.aarch64.rpm;name=aarch64_python3-libguestfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libguestfs}"
SRC_URI[aarch64_python3-libguestfs.sha256sum] = "f1db8b2bfd7187bfe3db3e5d15911e7e7cf3540f9351ab652edb9e7443ae3476"

RDEPENDS:libguestfs:x86_64_v2 = " \
 augeas-libs \
 bash \
 fuse \
 fuse-libs \
 glibc \
 grep \
 hexedit \
 hivex-libs \
 json-c \
 less \
 libacl \
 libcap \
 libconfig \
 libgcc \
 libguestfs-appliance \
 libselinux \
 libtirpc \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 libxml2 \
 man-db \
 ncurses-libs \
 pcre2 \
 qemu-img \
 qemu-kvm-core \
 readline \
 rpm-libs \
 selinux-policy \
 systemd-libs \
 tar \
 vim-minimal \
 virtual/coreutils \
 xz \
"
RDEPENDS:libguestfs:aarch64 = " \
 augeas-libs \
 bash \
 edk2-aarch64 \
 fuse \
 fuse-libs \
 glibc \
 grep \
 hexedit \
 hivex-libs \
 json-c \
 less \
 libacl \
 libcap \
 libconfig \
 libgcc \
 libguestfs-appliance \
 libselinux \
 libtirpc \
 libvirt-daemon-driver-qemu \
 libvirt-daemon-driver-secret \
 libvirt-daemon-driver-storage-core \
 libvirt-libs \
 libxml2 \
 man-db \
 ncurses-libs \
 pcre2 \
 qemu-img \
 qemu-kvm-core \
 readline \
 rpm-libs \
 selinux-policy \
 systemd-libs \
 tar \
 vim-minimal \
 virtual/coreutils \
 xz \
"
RDEPENDS:libguestfs-appliance = " \
 acl \
 attr \
 augeas-libs \
 bash \
 binutils \
 bzip2 \
 clevis-luks \
 cpio \
 cryptsetup \
 dhcpcd \
 diffutils \
 dosfstools \
 e2fsprogs \
 file \
 findutils \
 gawk \
 glibc \
 glibc-gconv-extra \
 grep \
 gzip \
 hivex-libs \
 iproute \
 json-c \
 kmod \
 less \
 libacl \
 libcap \
 libgcc \
 libselinux \
 libtirpc \
 libxml2 \
 lsscsi \
 lvm2 \
 lzop \
 mdadm \
 parted \
 pcre2 \
 policycoreutils \
 procps-ng \
 psmisc \
 rpm-libs \
 scrub \
 sed \
 supermin \
 systemd \
 systemd-libs \
 systemd-udev \
 tar \
 util-linux \
 virtual/coreutils \
 virtual/kernel \
 xz \
 zstd \
 "
RDEPENDS:libguestfs-bash-completion = " \
 bash-completion \
 "
RDEPENDS:libguestfs-devel = " \
 libguestfs \
 pkgconf-pkg-config \
 "
RDEPENDS:libguestfs-inspect-icons = " \
 icoutils \
 libguestfs \
 netpbm-progs \
 "
RDEPENDS:libguestfs-man-pages-ja = " \
 libguestfs \
 "
RDEPENDS:libguestfs-man-pages-uk = " \
 libguestfs \
 "
RDEPENDS:libguestfs-rescue = " \
 glibc \
 iputils \
 libconfig \
 libgcc \
 libguestfs \
 libxml2 \
 lsof \
 openssh-clients \
 pciutils \
 strace \
 vim-minimal \
 "
RDEPENDS:libguestfs-rsync = " \
 libguestfs \
 rsync \
 "
RDEPENDS:libguestfs-xfs = " \
 libguestfs \
 xfsprogs \
 "
RDEPENDS:ocaml-libguestfs = " \
 glibc \
 libguestfs \
 "
RDEPENDS:ocaml-libguestfs-devel = " \
 ocaml-libguestfs \
 "
RDEPENDS:perl-Sys-Guestfs = " \
 glibc \
 libguestfs \
 perl-libs \
 perl-vars \
 "
RDEPENDS:python3-libguestfs = " \
 glibc \
 libguestfs \
 python3 \
 "
