# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-ignore"
PV = "0.13.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-ignore+default-devel \
 rust-gix-ignore+document-features-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-ignore-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-ignore-0.13.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dd060675517db664e7170c1cede11d0c5187e73c0b4b1654095b7676061ec8c"

URI_x86_64_v2_rust-gix-ignore+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+default-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore+default-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore+default-devel.sha256sum] = "49922f66ec194272e4f6f2f5a6c4a2ea61eda1dd8e118b73cc00a632b54171d1"

URI_x86_64_v2_rust-gix-ignore+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+document-features-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore+document-features-devel.sha256sum] = "1bf35adc3edf15fcfe82ee9602fb8e3e71708e0ea2c55cbb8a45e67132d70bd4"

URI_x86_64_v2_rust-gix-ignore+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore+serde-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore+serde-devel.sha256sum] = "af7ff1293d544a740106feaa19a07d00ce5d7643c3a26dd22438be181fd504bc"

URI_x86_64_v2_rust-gix-ignore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-ignore-devel-0.13.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-ignore-devel}"
SRC_URI[x86_64_v2_rust-gix-ignore-devel.sha256sum] = "2226f8aff6083006cff8c4bde9f707b25865696ad26035cd7bcae0dc09c141c3"

URI_aarch64_rust-gix-ignore+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+default-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-ignore+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore+default-devel}"
SRC_URI[aarch64_rust-gix-ignore+default-devel.sha256sum] = "7a235b82d33b655a9de01c484552bacdb72ab49672617facb4d5b4072ccbc48a"

URI_aarch64_rust-gix-ignore+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+document-features-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-ignore+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore+document-features-devel}"
SRC_URI[aarch64_rust-gix-ignore+document-features-devel.sha256sum] = "ccc8705d5fe79f3af707cd6d931dee4ca8abf61f30533359decd42fe9fb4cd0b"

URI_aarch64_rust-gix-ignore+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore+serde-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-ignore+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore+serde-devel}"
SRC_URI[aarch64_rust-gix-ignore+serde-devel.sha256sum] = "11655d51be00e4cfcf6c9a3335251e6b87b1fd7f29b0bc58cae2a46537bec7c1"

URI_aarch64_rust-gix-ignore-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-ignore-devel-0.13.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-ignore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-ignore-devel}"
SRC_URI[aarch64_rust-gix-ignore-devel.sha256sum] = "6380c72accd7b3d9d0b6e6af9884ad418fb3baa4665454ddeef2788b9b88db12"

RDEPENDS:rust-gix-ignore+default-devel = " \
 cargo \
 rust-gix-ignore-devel \
 "
RDEPENDS:rust-gix-ignore+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-ignore-devel \
 "
RDEPENDS:rust-gix-ignore+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-glob+serde-devel \
 rust-gix-ignore-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-ignore-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr+unicode-devel \
 rust-bstr-devel \
 rust-gix-glob+default-devel \
 rust-gix-path+default-devel \
 rust-gix-trace+default-devel \
 rust-unicode-bom+default-devel \
 "
