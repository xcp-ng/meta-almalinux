# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "containers-common"
PE = "5"
PV = "0.64.0"
PR = "5.el10_1"
PACKAGES = " \
 containers-common \
 containers-common-extra \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/containers-common-0.64.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "425b56a3c878ec1134ae8b0adaca296de63bfd78a25d24241bd7c49c2597d600"

URI_x86_64_v2_containers-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-0.64.0-5.el10_1.noarch.rpm;name=x86_64_v2_containers-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_containers-common}"
SRC_URI[x86_64_v2_containers-common.sha256sum] = "27d5c7bd281f20eee40779e25bfe45f6bb5dfbfb401794a34c477d4b07383890"

URI_x86_64_v2_containers-common-extra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/containers-common-extra-0.64.0-5.el10_1.noarch.rpm;name=x86_64_v2_containers-common-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_containers-common-extra}"
SRC_URI[x86_64_v2_containers-common-extra.sha256sum] = "bffd8263f890165c034e6a3ed0870b070f7b4eb22d60ecce78694365e6c46a11"

URI_aarch64_containers-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-0.64.0-5.el10_1.noarch.rpm;name=aarch64_containers-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_containers-common}"
SRC_URI[aarch64_containers-common.sha256sum] = "27d5c7bd281f20eee40779e25bfe45f6bb5dfbfb401794a34c477d4b07383890"

URI_aarch64_containers-common-extra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/containers-common-extra-0.64.0-5.el10_1.noarch.rpm;name=aarch64_containers-common-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_containers-common-extra}"
SRC_URI[aarch64_containers-common-extra.sha256sum] = "bffd8263f890165c034e6a3ed0870b070f7b4eb22d60ecce78694365e6c46a11"

RDEPENDS:containers-common = " \
 container-selinux \
 netavark \
 "
RDEPENDS:containers-common-extra = " \
 containers-common \
 crun \
 netavark \
 nftables \
 passt \
 "
