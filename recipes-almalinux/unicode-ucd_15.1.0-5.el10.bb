# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "unicode-ucd"
PV = "15.1.0"
PR = "5.el10"
PACKAGES = " \
 unicode-ucd \
 unicode-ucd-unihan \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/unicode-ucd-15.1.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e8711fde850e051ffc7b42eb2af5f7b294b9f01851ad7ecbb4304ee59644dd55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/unicode-ucd-15.1.0-5.el10.noarch.rpm;name=x86_64_v2_unicode-ucd;unpack=0"
SRC_URI[x86_64_v2_unicode-ucd.sha256sum] = "f61d56dab01b276dd9153cdf3d36f337002cfa3231b4d7e66ef99e63171f0dcd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/unicode-ucd-unihan-15.1.0-5.el10.noarch.rpm;name=x86_64_v2_unicode-ucd-unihan;unpack=0"
SRC_URI[x86_64_v2_unicode-ucd-unihan.sha256sum] = "a1fb64526ab0a20cb1002670b1f07da87601bdeaa9f736771a66a4ec371f206e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/unicode-ucd-15.1.0-5.el10.noarch.rpm;name=aarch64_unicode-ucd;unpack=0"
SRC_URI[aarch64_unicode-ucd.sha256sum] = "f61d56dab01b276dd9153cdf3d36f337002cfa3231b4d7e66ef99e63171f0dcd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/unicode-ucd-unihan-15.1.0-5.el10.noarch.rpm;name=aarch64_unicode-ucd-unihan;unpack=0"
SRC_URI[aarch64_unicode-ucd-unihan.sha256sum] = "a1fb64526ab0a20cb1002670b1f07da87601bdeaa9f736771a66a4ec371f206e"

RDEPENDS:unicode-ucd = " \
 "
RDEPENDS:unicode-ucd-unihan = " \
 unicode-ucd \
 "
