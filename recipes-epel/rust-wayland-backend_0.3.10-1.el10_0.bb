# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-backend"
PV = "0.3.10"
PR = "1.el10_0"
PACKAGES = " \
 rust-wayland-backend+client_system-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-backend+dlopen-devel \
 rust-wayland-backend+log-devel \
 rust-wayland-backend+raw-window-handle-devel \
 rust-wayland-backend+rwh_06-devel \
 rust-wayland-backend+server_system-devel \
 rust-wayland-backend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-backend-0.3.10-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "118c0092c0b9a725ac2ebcd139f4033a5222f459cdd5f4fac0d0ec62cec2a134"

URI_x86_64_v2_rust-wayland-backend+client_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+client_system-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+client_system-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+client_system-devel.sha256sum] = "3013f2024941406740d52d89ea295bff61f36a8dca8a2685276443c70f15a29d"

URI_x86_64_v2_rust-wayland-backend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+default-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+default-devel.sha256sum] = "5e18e27e7cffcebb2f3e339fb6bd3b391fdc0605a0e401572481a52af3815f54"

URI_x86_64_v2_rust-wayland-backend+dlopen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+dlopen-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+dlopen-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+dlopen-devel.sha256sum] = "8ef89ac5ecd3fb5da89c4a015d1b6f44b145d6f68f00c412f4e43901873577d8"

URI_x86_64_v2_rust-wayland-backend+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+log-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+log-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+log-devel.sha256sum] = "144e25a9b8b399a9ebdf1f95d380bbcf966076baf8b94446505719456fb65e80"

URI_x86_64_v2_rust-wayland-backend+raw-window-handle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+raw-window-handle-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+raw-window-handle-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "18faf27adf5b1209caedfd3c7ccc93926a4076042d1aaea1fc8cfaeb0123de38"

URI_x86_64_v2_rust-wayland-backend+rwh_06-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+rwh_06-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+rwh_06-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+rwh_06-devel.sha256sum] = "47162b65f20121ce15197289b6f64172d457c9c5417da0218d2f957eaa5bd1bf"

URI_x86_64_v2_rust-wayland-backend+server_system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend+server_system-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend+server_system-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend+server_system-devel.sha256sum] = "181512f6f0953d813cad8694929c6c34e3da771671d903a62641d54f5f6afcaa"

URI_x86_64_v2_rust-wayland-backend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-backend-devel-0.3.10-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-backend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-backend-devel}"
SRC_URI[x86_64_v2_rust-wayland-backend-devel.sha256sum] = "a268e14df89dfec4cd4292fa4b8c4c636a228f1c12945764c2489fa4720009ca"

URI_aarch64_rust-wayland-backend+client_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+client_system-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-backend+client_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+client_system-devel}"
SRC_URI[aarch64_rust-wayland-backend+client_system-devel.sha256sum] = "9b9cc9ff1924e52eed282080fc0263e6ed1a8fcf8dc541650891bb23ad9821ee"

URI_aarch64_rust-wayland-backend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+default-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-backend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+default-devel}"
SRC_URI[aarch64_rust-wayland-backend+default-devel.sha256sum] = "4fcd6c511a3a1850e2e134b3f9cfab9c1dbef5a3d83644ecb317625cd4e8f523"

URI_aarch64_rust-wayland-backend+dlopen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+dlopen-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-backend+dlopen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+dlopen-devel}"
SRC_URI[aarch64_rust-wayland-backend+dlopen-devel.sha256sum] = "7b82c896928e091d4060f0cd3106cee600149aa8a13802600a65a053396137f4"

URI_aarch64_rust-wayland-backend+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+log-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-backend+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+log-devel}"
SRC_URI[aarch64_rust-wayland-backend+log-devel.sha256sum] = "0d78bb78a68c8c2bffe038046ad255932f17848a8859e0aea4914148ccfc59d4"

URI_aarch64_rust-wayland-backend+raw-window-handle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+raw-window-handle-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-backend+raw-window-handle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+raw-window-handle-devel}"
SRC_URI[aarch64_rust-wayland-backend+raw-window-handle-devel.sha256sum] = "ab8bcf9d898c188d86c0bb586644c171881cb2a491748da46eadd5e9aebabdeb"

URI_aarch64_rust-wayland-backend+rwh_06-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+rwh_06-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-backend+rwh_06-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+rwh_06-devel}"
SRC_URI[aarch64_rust-wayland-backend+rwh_06-devel.sha256sum] = "11c4e77b6f3a1a96a2bb05d4d2abe6b2481245bcb1c92dc783caba97dbdec755"

URI_aarch64_rust-wayland-backend+server_system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend+server_system-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-backend+server_system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend+server_system-devel}"
SRC_URI[aarch64_rust-wayland-backend+server_system-devel.sha256sum] = "d7b2734f20d67820e1222a4626104d213ec174f68dc9aaea34765780a86edc65"

URI_aarch64_rust-wayland-backend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-backend-devel-0.3.10-1.el10_0.noarch.rpm;name=aarch64_rust-wayland-backend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-backend-devel}"
SRC_URI[aarch64_rust-wayland-backend-devel.sha256sum] = "938fc47774186363913fbd733a2ae0c689c41a2aace80e90d92c817d9f90f489"

RDEPENDS:rust-wayland-backend+client_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+client-devel \
 "
RDEPENDS:rust-wayland-backend+default-devel = " \
 cargo \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+dlopen-devel = " \
 cargo \
 rust-wayland-backend-devel \
 rust-wayland-sys+dlopen-devel \
 "
RDEPENDS:rust-wayland-backend+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+raw-window-handle-devel = " \
 cargo \
 rust-raw-window-handle0.5+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+rwh_06-devel = " \
 cargo \
 rust-raw-window-handle+default-devel \
 rust-wayland-backend-devel \
 "
RDEPENDS:rust-wayland-backend+server_system-devel = " \
 cargo \
 rust-scoped-tls+default-devel \
 rust-wayland-backend-devel \
 rust-wayland-sys+server-devel \
 "
RDEPENDS:rust-wayland-backend-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-downcast-rs+default-devel \
 rust-rustix+default-devel \
 rust-rustix+event-devel \
 rust-rustix+fs-devel \
 rust-rustix+net-devel \
 rust-rustix+process-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-smallvec+union-devel \
 rust-wayland-sys+default-devel \
 "
