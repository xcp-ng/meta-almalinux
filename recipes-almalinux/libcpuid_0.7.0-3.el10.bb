# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcpuid"
PV = "0.7.0"
PR = "3.el10"
PACKAGES = " \
 libcpuid \
 libcpuid-devel \
 python3-libcpuid \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libcpuid-0.7.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4641cc248c40bf54bf708a6c545aaf379fb7713028e45eba492eced39b53d5c1"

URI_x86_64_v2_libcpuid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcpuid-0.7.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libcpuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcpuid}"
SRC_URI[x86_64_v2_libcpuid.sha256sum] = "2c85406e5e4f67ca119b50347ed6b833e3516d088bcd036f70243777a6a318ac"

URI_x86_64_v2_libcpuid-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libcpuid-devel-0.7.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_libcpuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcpuid-devel}"
SRC_URI[x86_64_v2_libcpuid-devel.sha256sum] = "998852602cfd95e92d2678a195a7fdc32f2cb22e65db9d6af4b9b1fa382bd128"

URI_x86_64_v2_python3-libcpuid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-libcpuid-0.7.0-3.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libcpuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libcpuid}"
SRC_URI[x86_64_v2_python3-libcpuid.sha256sum] = "fb89ffd9e5f06195b6c051c391cd49906e4e8c32ffebb9f87f0727e18a6bb49e"

URI_aarch64_libcpuid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcpuid-0.7.0-3.el10.aarch64.rpm;name=aarch64_libcpuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcpuid}"
SRC_URI[aarch64_libcpuid.sha256sum] = "ca39c14402077f7a5ad56d82c8c3d8883de4dff59afc7c59e3e8e76e3f694861"

URI_aarch64_libcpuid-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libcpuid-devel-0.7.0-3.el10.aarch64.rpm;name=aarch64_libcpuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcpuid-devel}"
SRC_URI[aarch64_libcpuid-devel.sha256sum] = "774a7dc5c586e9b2a8c8444b34b002b1b14b55a1b1f811d79053a3c26214458b"

URI_aarch64_python3-libcpuid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-libcpuid-0.7.0-3.el10.aarch64.rpm;name=aarch64_python3-libcpuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libcpuid}"
SRC_URI[aarch64_python3-libcpuid.sha256sum] = "b59cfc370cc9a49eaed5be41959d4f4f50549780a9a0f5060fa79e7bc633e9be"

RDEPENDS:libcpuid = " \
 glibc \
 "
RDEPENDS:libcpuid-devel = " \
 glibc \
 libcpuid \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libcpuid = " \
 glibc \
 libcpuid \
 python3 \
 python3-cffi \
 "
