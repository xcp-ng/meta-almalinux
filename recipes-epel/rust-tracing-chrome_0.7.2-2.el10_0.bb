# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-chrome"
PV = "0.7.2"
PR = "2.el10_0"
PACKAGES = " \
 rust-tracing-chrome+default-devel \
 rust-tracing-chrome-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-chrome-0.7.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45c3083c53c297a00675f5d073762d83bbfbbedd2721dba7ab9217879226efc3"

URI_x86_64_v2_rust-tracing-chrome+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-chrome+default-devel-0.7.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-chrome+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-chrome+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-chrome+default-devel.sha256sum] = "6b55197c8980d55df9541cd263f2a5e9662f634159ed728c8380e5facebadcd6"

URI_x86_64_v2_rust-tracing-chrome-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-chrome-devel-0.7.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-chrome-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-chrome-devel}"
SRC_URI[x86_64_v2_rust-tracing-chrome-devel.sha256sum] = "2c15239387f44c403d9217f10d74098ebc24fcb4c660d87a2f74114a34cf818a"

URI_aarch64_rust-tracing-chrome+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-chrome+default-devel-0.7.2-2.el10_0.noarch.rpm;name=aarch64_rust-tracing-chrome+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-chrome+default-devel}"
SRC_URI[aarch64_rust-tracing-chrome+default-devel.sha256sum] = "a094d5385082057a9bba9a485ba153f55cbf00a68657a963dce78ec3dfb119cf"

URI_aarch64_rust-tracing-chrome-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-chrome-devel-0.7.2-2.el10_0.noarch.rpm;name=aarch64_rust-tracing-chrome-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-chrome-devel}"
SRC_URI[aarch64_rust-tracing-chrome-devel.sha256sum] = "966e8110f9a06c6f7d3bdccef4b1974d6f4e33de611b88db446d181b8eb69130"

RDEPENDS:rust-tracing-chrome+default-devel = " \
 cargo \
 rust-tracing-chrome-devel \
 "
RDEPENDS:rust-tracing-chrome-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-tracing-core+default-devel \
 rust-tracing-subscriber+default-devel \
 "
