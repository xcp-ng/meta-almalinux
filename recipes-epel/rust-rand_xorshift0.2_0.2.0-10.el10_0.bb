# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xorshift0.2"
PV = "0.2.0"
PR = "10.el10_0"
PACKAGES = " \
 rust-rand_xorshift0.2+default-devel \
 rust-rand_xorshift0.2+serde-devel \
 rust-rand_xorshift0.2+serde1-devel \
 rust-rand_xorshift0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xorshift0.2-0.2.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "469e19442d89889a1884306bde475972b7e11bf932a8206c62cb7c80e0ca1d9f"

URI_x86_64_v2_rust-rand_xorshift0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.2+default-devel-0.2.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.2+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.2+default-devel.sha256sum] = "02d07ed6e9e968e8fd3169086797538ac47728d0f8d2330e7796c6511a7f96bd"

URI_x86_64_v2_rust-rand_xorshift0.2+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.2+serde-devel-0.2.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.2+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.2+serde-devel.sha256sum] = "ae938513a083c8ba6ac75fbfcea1bc8a1935563e40515f42c96b73b599aaac61"

URI_x86_64_v2_rust-rand_xorshift0.2+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.2+serde1-devel-0.2.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.2+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.2+serde1-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.2+serde1-devel.sha256sum] = "9a30af368408ef5fb865ebe77139dd425e781b2add23e1fec1315610f3ca6cfe"

URI_x86_64_v2_rust-rand_xorshift0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift0.2-devel-0.2.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift0.2-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift0.2-devel.sha256sum] = "07207c6a6e35db34ed82437eec6b9011e09d26901526b4323ca432df11cf5c8d"

URI_aarch64_rust-rand_xorshift0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.2+default-devel-0.2.0-10.el10_0.noarch.rpm;name=aarch64_rust-rand_xorshift0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.2+default-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.2+default-devel.sha256sum] = "98bc9bed8bf5f54ce4a5ef985a2efb82732e92be58aa7b653beacf24d9b529f8"

URI_aarch64_rust-rand_xorshift0.2+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.2+serde-devel-0.2.0-10.el10_0.noarch.rpm;name=aarch64_rust-rand_xorshift0.2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.2+serde-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.2+serde-devel.sha256sum] = "b23d4e6969644cde95313c4851e7a0a7a1e2ffbec2588e3feada8c17dc6a9d5a"

URI_aarch64_rust-rand_xorshift0.2+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.2+serde1-devel-0.2.0-10.el10_0.noarch.rpm;name=aarch64_rust-rand_xorshift0.2+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.2+serde1-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.2+serde1-devel.sha256sum] = "bc9fb00dc30145c1315b40b7cd533f20fd2189f8565ea9ed1d9ddb54eb92940f"

URI_aarch64_rust-rand_xorshift0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift0.2-devel-0.2.0-10.el10_0.noarch.rpm;name=aarch64_rust-rand_xorshift0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift0.2-devel}"
SRC_URI[aarch64_rust-rand_xorshift0.2-devel.sha256sum] = "3892b62956562776403369b9570edf6a425ce337f51a6847b759923cee49fc61"

RDEPENDS:rust-rand_xorshift0.2+default-devel = " \
 cargo \
 rust-rand_xorshift0.2-devel \
 "
RDEPENDS:rust-rand_xorshift0.2+serde-devel = " \
 cargo \
 rust-rand_xorshift0.2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_xorshift0.2+serde1-devel = " \
 cargo \
 rust-rand_xorshift0.2+serde-devel \
 rust-rand_xorshift0.2-devel \
 "
RDEPENDS:rust-rand_xorshift0.2-devel = " \
 cargo \
 rust-rand_core0.5+default-devel \
 "
