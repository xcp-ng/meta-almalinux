# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkeduvocdocument"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 libkeduvocdocument \
 libkeduvocdocument-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkeduvocdocument-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "089a99acd5a12e15bf81f66e1dff02bb0f5e0a14686d4e121475ac34c7b1e7ae"

URI_x86_64_v2_libkeduvocdocument = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkeduvocdocument}"
SRC_URI[x86_64_v2_libkeduvocdocument.sha256sum] = "0e2f86d79f7020a3b9049d47d24b10479b7bfc7e84c73491e56217beeedbf4c7"

URI_x86_64_v2_libkeduvocdocument-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkeduvocdocument-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkeduvocdocument-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkeduvocdocument-devel}"
SRC_URI[x86_64_v2_libkeduvocdocument-devel.sha256sum] = "1bc3420f6a419e82ff1e5c516e0adfb6a58f4b6eca2db04d92ae4d6f97239598"

URI_aarch64_libkeduvocdocument = "${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkeduvocdocument;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkeduvocdocument}"
SRC_URI[aarch64_libkeduvocdocument.sha256sum] = "d75ced3bd100a084d9f0923151ff97db588f15c9697a6b02fdedf39fdfd84701"

URI_aarch64_libkeduvocdocument-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkeduvocdocument-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_libkeduvocdocument-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkeduvocdocument-devel}"
SRC_URI[aarch64_libkeduvocdocument-devel.sha256sum] = "de6c72b7e97fa416409a3f2b3314c34c6d9ffdeefab08dda34ea8237ab0a4e27"

RDEPENDS:libkeduvocdocument = " \
 glibc \
 kdeedu-data \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libkeduvocdocument-devel = " \
 cmake-filesystem \
 libkeduvocdocument \
 "
