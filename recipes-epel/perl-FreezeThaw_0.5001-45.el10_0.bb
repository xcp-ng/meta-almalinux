# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-FreezeThaw"
PV = "0.5001"
PR = "45.el10_0"
PACKAGES = " \
 perl-FreezeThaw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-FreezeThaw-0.5001-45.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "562f8de58dfe85f58196e3980ea7d476e6f80c6649f9375b653a4327d7bdf8e9"

URI_x86_64_v2_perl-FreezeThaw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-FreezeThaw-0.5001-45.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-FreezeThaw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-FreezeThaw}"
SRC_URI[x86_64_v2_perl-FreezeThaw.sha256sum] = "4ee2089dc0045aeefcffc472b048c3304b87dbb32fe01c0c93717deb0befdfcb"

URI_aarch64_perl-FreezeThaw = "${EPEL_MIRROR}/aarch64/Packages/p/perl-FreezeThaw-0.5001-45.el10_0.noarch.rpm;name=aarch64_perl-FreezeThaw;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-FreezeThaw}"
SRC_URI[aarch64_perl-FreezeThaw.sha256sum] = "27c14cab68afd7ec8046999b56651bfdaa33e795c52b59345a0c28c61ee74538"

RDEPENDS:perl-FreezeThaw = " \
 perl-Carp \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
