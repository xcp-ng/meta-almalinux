# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dav1d"
PV = "1.5.2"
PR = "1.el10_0"
PACKAGES = " \
 dav1d \
 libdav1d \
 libdav1d-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/dav1d-1.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bcfcbbb0ce442f25708518d7bdb98c1672570984dfd560f52edb43082d5b380c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dav1d-1.5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dav1d;unpack=0"
SRC_URI[x86_64_v2_dav1d.sha256sum] = "adb30285ae4eb4188199c9af6e521bb3d5536d2d661bb5914330b8fc2a31aaae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-1.5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d;unpack=0"
SRC_URI[x86_64_v2_libdav1d.sha256sum] = "a2e6a9d4e04342db888fbfcf6692e7dc59a94595463b9e4d739e301341023d52"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdav1d-devel-1.5.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdav1d-devel;unpack=0"
SRC_URI[x86_64_v2_libdav1d-devel.sha256sum] = "fb16aa2a4d07331841ab120c968e8bef9f682d7e754e8ad0bcb5f970555b5dcb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/dav1d-1.5.2-1.el10_0.aarch64.rpm;name=aarch64_dav1d;unpack=0"
SRC_URI[aarch64_dav1d.sha256sum] = "4ecca14c3c8a47372f1344556f872280b52362093f5ff463fcb92667701b52c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-1.5.2-1.el10_0.aarch64.rpm;name=aarch64_libdav1d;unpack=0"
SRC_URI[aarch64_libdav1d.sha256sum] = "9bca88cbcb30d8c6b7045f845c3d1d9a0d6c7cd0ef1c7f1999b20fd1091598b7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdav1d-devel-1.5.2-1.el10_0.aarch64.rpm;name=aarch64_libdav1d-devel;unpack=0"
SRC_URI[aarch64_libdav1d-devel.sha256sum] = "e86ff6f6393fce873bf11e93e4f2f65d8c9e6a9e58add6b6a6ea54b48580dd7b"

RDEPENDS:dav1d = " \
 glibc \
 libdav1d \
 "
RDEPENDS:libdav1d = " \
 glibc \
 "
RDEPENDS:libdav1d-devel = " \
 libdav1d \
 pkgconf-pkg-config \
 "
