# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Image-PNG-Libpng"
PV = "0.60"
PR = "1.el10_2"
PACKAGES = " \
 perl-Image-PNG-Libpng \
 perl-Image-PNG-Libpng-tests \
 perl-Image-PNG-Libpng-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Image-PNG-Libpng-0.60-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e37bce8699190883970b5773a8c59933823b1f63c3096b2ee896ebcc3af19db9"

URI_x86_64_v2_perl-Image-PNG-Libpng = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-PNG-Libpng-0.60-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Image-PNG-Libpng;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-PNG-Libpng}"
SRC_URI[x86_64_v2_perl-Image-PNG-Libpng.sha256sum] = "b4c4b05363be89985e65a128dde588eef5eee2c27132e33e4112718c37f362aa"

URI_x86_64_v2_perl-Image-PNG-Libpng-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-PNG-Libpng-tests-0.60-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-PNG-Libpng-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-PNG-Libpng-tests}"
SRC_URI[x86_64_v2_perl-Image-PNG-Libpng-tests.sha256sum] = "2ef998b0cdc10858377430e5697e20b055960c3ee4a7e7fdb73a4ad5cb661afe"

URI_x86_64_v2_perl-Image-PNG-Libpng-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Image-PNG-Libpng-tools-0.60-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Image-PNG-Libpng-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Image-PNG-Libpng-tools}"
SRC_URI[x86_64_v2_perl-Image-PNG-Libpng-tools.sha256sum] = "f83160fca3d4fed418fc87203efabc490ca1ba41445a38c1337a044c0b1508ab"

URI_aarch64_perl-Image-PNG-Libpng = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-PNG-Libpng-0.60-1.el10_2.aarch64.rpm;name=aarch64_perl-Image-PNG-Libpng;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-PNG-Libpng}"
SRC_URI[aarch64_perl-Image-PNG-Libpng.sha256sum] = "870066e686d64e0f66b1bd07cf497da0edad846b2f37514bf6a6051ea870ce96"

URI_aarch64_perl-Image-PNG-Libpng-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-PNG-Libpng-tests-0.60-1.el10_2.noarch.rpm;name=aarch64_perl-Image-PNG-Libpng-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-PNG-Libpng-tests}"
SRC_URI[aarch64_perl-Image-PNG-Libpng-tests.sha256sum] = "49ffeaf4de6489255a491d94c884e39002b70817a11423c0acbee17506c349eb"

URI_aarch64_perl-Image-PNG-Libpng-tools = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Image-PNG-Libpng-tools-0.60-1.el10_2.noarch.rpm;name=aarch64_perl-Image-PNG-Libpng-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Image-PNG-Libpng-tools}"
SRC_URI[aarch64_perl-Image-PNG-Libpng-tools.sha256sum] = "7d62d634b4235826756be61fcbf4190c24a32036cc0867213281dd49954890ae"

RDEPENDS:perl-Image-PNG-Libpng = " \
 glibc \
 libpng \
 perl-Carp \
 perl-Exporter \
 perl-Image-PNG-Libpng \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Image-PNG-Libpng-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Compare \
 perl-FindBin \
 perl-Image-PNG-Libpng \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-lib \
 perl-libs \
 virtual/coreutils \
 "
RDEPENDS:perl-Image-PNG-Libpng-tools = " \
 perl-Data-Dumper \
 perl-Getopt-Long \
 perl-Image-PNG-Libpng \
 perl-interpreter \
 perl-libs \
 "
