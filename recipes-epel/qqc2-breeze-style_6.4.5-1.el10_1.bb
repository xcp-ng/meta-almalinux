# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qqc2-breeze-style"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 qqc2-breeze-style \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qqc2-breeze-style-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aff4141f34daafd4929d559fa6ce92f44a0016289cd373f94a29cfa357d18f65"

URI_x86_64_v2_qqc2-breeze-style = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qqc2-breeze-style-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qqc2-breeze-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qqc2-breeze-style}"
SRC_URI[x86_64_v2_qqc2-breeze-style.sha256sum] = "84cba933ef31ca4c0cc410c05c9902c97245eb9ad8a2712a49aa626f3afa43c9"

URI_aarch64_qqc2-breeze-style = "${EPEL_MIRROR}/aarch64/Packages/q/qqc2-breeze-style-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_qqc2-breeze-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_qqc2-breeze-style}"
SRC_URI[aarch64_qqc2-breeze-style.sha256sum] = "c4c8de48fed31f8035e122a062742d003c0d8669b4a5dac9c0470212f30539e3"

RDEPENDS:qqc2-breeze-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kquickcharts \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
