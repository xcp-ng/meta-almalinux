# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pxfm"
PV = "0.1.23"
PR = "1.el10_2"
PACKAGES = " \
 rust-pxfm+default-devel \
 rust-pxfm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pxfm-0.1.23-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d6d4287f7de3c98f9f4d9fa9e4992927267a58e123678adf7300ac624aaf8a3"

URI_x86_64_v2_rust-pxfm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pxfm+default-devel-0.1.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pxfm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pxfm+default-devel}"
SRC_URI[x86_64_v2_rust-pxfm+default-devel.sha256sum] = "f63073f5dbec5544413b970704ab151d351b6fd0efa6c162e01391c0bdbf4ccd"

URI_x86_64_v2_rust-pxfm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pxfm-devel-0.1.23-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pxfm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pxfm-devel}"
SRC_URI[x86_64_v2_rust-pxfm-devel.sha256sum] = "8072b7a44f537f03be7a536ca14e04fc68c70667c6030c5cec6124d49664ee1e"

URI_aarch64_rust-pxfm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pxfm+default-devel-0.1.23-1.el10_2.noarch.rpm;name=aarch64_rust-pxfm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pxfm+default-devel}"
SRC_URI[aarch64_rust-pxfm+default-devel.sha256sum] = "fa920de7ff85b1384ce0095dbc3c06b78da4ace6940102da6c0f54eef618c416"

URI_aarch64_rust-pxfm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pxfm-devel-0.1.23-1.el10_2.noarch.rpm;name=aarch64_rust-pxfm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pxfm-devel}"
SRC_URI[aarch64_rust-pxfm-devel.sha256sum] = "657d54993c987cabfab7a6450ac57088f9851a9029316a0f1f2d0a9b136b3f92"

RDEPENDS:rust-pxfm+default-devel = " \
 cargo \
 rust-pxfm-devel \
 "
RDEPENDS:rust-pxfm-devel = " \
 cargo \
 rust \
 rust-num-traits+default-devel \
 "
