# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-block-buffer"
PV = "0.12.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-block-buffer+default-devel \
 rust-block-buffer+zeroize-devel \
 rust-block-buffer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-block-buffer-0.12.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb63a47a53c86fbf8f571c3c1016f33ccc6d23294caca8b36ba22d0a0ca98178"

URI_x86_64_v2_rust-block-buffer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer+default-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer+default-devel}"
SRC_URI[x86_64_v2_rust-block-buffer+default-devel.sha256sum] = "fed04a0c7b56683a2695cd38cfe1478ecdbcd52fd92ed51bb233c2c1d142eae6"

URI_x86_64_v2_rust-block-buffer+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer+zeroize-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer+zeroize-devel}"
SRC_URI[x86_64_v2_rust-block-buffer+zeroize-devel.sha256sum] = "7fa0b89626a286006075777a0f37845b9ee67a713d5ec2798da19252654af1d6"

URI_x86_64_v2_rust-block-buffer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-block-buffer-devel-0.12.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-block-buffer-devel}"
SRC_URI[x86_64_v2_rust-block-buffer-devel.sha256sum] = "a809c17272a4043e3d1c2efb0360c1541361b89e3d8281701f1ddec572c3459b"

URI_aarch64_rust-block-buffer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer+default-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-block-buffer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer+default-devel}"
SRC_URI[aarch64_rust-block-buffer+default-devel.sha256sum] = "8e0fa88d16c9c5ea413559facffe6ce4882a6c616ec3c66a39ba4de63fde4835"

URI_aarch64_rust-block-buffer+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer+zeroize-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-block-buffer+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer+zeroize-devel}"
SRC_URI[aarch64_rust-block-buffer+zeroize-devel.sha256sum] = "913e0bc06f09e451b49391c177eb53eae948d3f76a547225522fb777b6232cad"

URI_aarch64_rust-block-buffer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-block-buffer-devel-0.12.1-1.el10_3.noarch.rpm;name=aarch64_rust-block-buffer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-block-buffer-devel}"
SRC_URI[aarch64_rust-block-buffer-devel.sha256sum] = "145f40eb6a3f33e10a34c9771fcc47362548fdac8bfe5c7d9c2ecb733ab2d5e8"

RDEPENDS:rust-block-buffer+default-devel = " \
 cargo \
 rust-block-buffer-devel \
 "
RDEPENDS:rust-block-buffer+zeroize-devel = " \
 cargo \
 rust-block-buffer-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-block-buffer-devel = " \
 cargo \
 rust \
 rust-hybrid-array+default-devel \
 "
