# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Linux-Pid"
PV = "0.04"
PR = "57.el10_0"
PACKAGES = " \
 perl-Linux-Pid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Linux-Pid-0.04-57.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "012ac811e94381768db85a5ae1b68ea0cc53eaeacbe51f5adf63f39b0071cc07"

URI_x86_64_v2_perl-Linux-Pid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Linux-Pid-0.04-57.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Linux-Pid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Linux-Pid}"
SRC_URI[x86_64_v2_perl-Linux-Pid.sha256sum] = "b16db2bbb73f063e1156c10f4ee5d041f526902e9c2d1d85f6cc23918f1771a5"

URI_aarch64_perl-Linux-Pid = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Linux-Pid-0.04-57.el10_0.aarch64.rpm;name=aarch64_perl-Linux-Pid;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Linux-Pid}"
SRC_URI[aarch64_perl-Linux-Pid.sha256sum] = "17fc16541f3df4df791664e9b1debe7785b0973cbcf9a6b8055293ae54cb5d9c"

RDEPENDS:perl-Linux-Pid = " \
 glibc \
 perl-Carp \
 perl-libs \
 "
