# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glog"
PV = "0.3.5"
PR = "22.el10_0"
PACKAGES = " \
 glog \
 glog-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glog-0.3.5-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e189346a00bb0b88322da320062bba9bce617b98d4fd7caf18e967cdedc51180"

URI_x86_64_v2_glog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glog-0.3.5-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glog}"
SRC_URI[x86_64_v2_glog.sha256sum] = "d4e4c166882b3e6884cd925f990145b7e37579e17101d6e952b4367765f5df78"

URI_x86_64_v2_glog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glog-devel-0.3.5-22.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glog-devel}"
SRC_URI[x86_64_v2_glog-devel.sha256sum] = "d37827db4873907bc9faf3464c12f6046784ce0b5f0cc670560f8a34c3c57da6"

URI_aarch64_glog = "${EPEL_MIRROR}/aarch64/Packages/g/glog-0.3.5-22.el10_0.aarch64.rpm;name=aarch64_glog;unpack=0"
SRC_URI:append = " ${URI_aarch64_glog}"
SRC_URI[aarch64_glog.sha256sum] = "30a13e94c0eda5dcffd035e697ed85bae4c701d4a5ea36b0b43772f0971de4d4"

URI_aarch64_glog-devel = "${EPEL_MIRROR}/aarch64/Packages/g/glog-devel-0.3.5-22.el10_0.aarch64.rpm;name=aarch64_glog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glog-devel}"
SRC_URI[aarch64_glog-devel.sha256sum] = "b939704b9e4c1fd9930b2a0f0dde6fee88ff5e6e8d12346b7a5c4d967abafe80"

RDEPENDS:glog = " \
 gflags \
 gflags-devel \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:glog-devel = " \
 glog \
 pkgconf-pkg-config \
 "
