# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_with"
PV = "3.16.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_with+alloc-devel \
 rust-serde_with+base64-devel \
 rust-serde_with+chrono-devel \
 rust-serde_with+chrono_0_4-devel \
 rust-serde_with+default-devel \
 rust-serde_with+guide-devel \
 rust-serde_with+hashbrown_0_14-devel \
 rust-serde_with+hex-devel \
 rust-serde_with+indexmap-devel \
 rust-serde_with+indexmap_1-devel \
 rust-serde_with+indexmap_2-devel \
 rust-serde_with+json-devel \
 rust-serde_with+macros-devel \
 rust-serde_with+schemars_0_8-devel \
 rust-serde_with+std-devel \
 rust-serde_with+time_0_3-devel \
 rust-serde_with-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_with-3.16.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6658b5a1344402e1381508889e9a1a42706682896d319135e54398c04abc2dfb"

URI_x86_64_v2_rust-serde_with+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+alloc-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_with+alloc-devel.sha256sum] = "2165157733997d0f9aacbffebaadac2259ccbec93c3317a49ab255b2271bca05"

URI_x86_64_v2_rust-serde_with+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+base64-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+base64-devel}"
SRC_URI[x86_64_v2_rust-serde_with+base64-devel.sha256sum] = "85e8df2eca8294989c0c526f45f5abb72017c4f222f0380b7ed86a49eb953361"

URI_x86_64_v2_rust-serde_with+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+chrono-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+chrono-devel}"
SRC_URI[x86_64_v2_rust-serde_with+chrono-devel.sha256sum] = "08f90be4ae5906542922b75171eb6c30d92a5f55d87466d935a92db44876f17b"

URI_x86_64_v2_rust-serde_with+chrono_0_4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+chrono_0_4-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+chrono_0_4-devel}"
SRC_URI[x86_64_v2_rust-serde_with+chrono_0_4-devel.sha256sum] = "04c5e5e3beea762b0a43feb2d35ef66b30923d0db6391ac1ef29a3a753e1418c"

URI_x86_64_v2_rust-serde_with+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+default-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+default-devel}"
SRC_URI[x86_64_v2_rust-serde_with+default-devel.sha256sum] = "6ecba5beec7a5c4050e39362613f310826772f7f973bdb74fa1f21a9694546dd"

URI_x86_64_v2_rust-serde_with+guide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+guide-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+guide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+guide-devel}"
SRC_URI[x86_64_v2_rust-serde_with+guide-devel.sha256sum] = "6e11abe961ad7d9c8fb357eaef109ae7605438704386a8bf3b8c463a53b34093"

URI_x86_64_v2_rust-serde_with+hashbrown_0_14-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+hashbrown_0_14-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+hashbrown_0_14-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+hashbrown_0_14-devel}"
SRC_URI[x86_64_v2_rust-serde_with+hashbrown_0_14-devel.sha256sum] = "ab12f2919f1aedffc9a4214e500237ea19c031098871b8218a13f225296210b9"

URI_x86_64_v2_rust-serde_with+hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+hex-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+hex-devel}"
SRC_URI[x86_64_v2_rust-serde_with+hex-devel.sha256sum] = "4f694620e3c6a6d1a2d063ae60e07ede93e8c1c102d8cd71e02266f8970c8e73"

URI_x86_64_v2_rust-serde_with+indexmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+indexmap-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+indexmap-devel}"
SRC_URI[x86_64_v2_rust-serde_with+indexmap-devel.sha256sum] = "e0196ceb07188f494f8c1fbf6a143f19d81473a496c586c3ac43f1f678257569"

URI_x86_64_v2_rust-serde_with+indexmap_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+indexmap_1-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+indexmap_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+indexmap_1-devel}"
SRC_URI[x86_64_v2_rust-serde_with+indexmap_1-devel.sha256sum] = "3e56ab34b0fb88bfaa892ff1f6b2662917dae677a97fbf929f76fb4834b49569"

URI_x86_64_v2_rust-serde_with+indexmap_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+indexmap_2-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+indexmap_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+indexmap_2-devel}"
SRC_URI[x86_64_v2_rust-serde_with+indexmap_2-devel.sha256sum] = "18535af310bf0d9242250bd6951075f23aab4c49184946add9978e9360febe5b"

URI_x86_64_v2_rust-serde_with+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+json-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+json-devel}"
SRC_URI[x86_64_v2_rust-serde_with+json-devel.sha256sum] = "a49e8b123ef5179276a29d5d64332c4f793d313d7b5522643264e88af394f0b1"

URI_x86_64_v2_rust-serde_with+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+macros-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+macros-devel}"
SRC_URI[x86_64_v2_rust-serde_with+macros-devel.sha256sum] = "f4a5e4d5fb916b3413c99e41eec6b8e8f9591705d5f4423bd522a94f667280f2"

URI_x86_64_v2_rust-serde_with+schemars_0_8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+schemars_0_8-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+schemars_0_8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+schemars_0_8-devel}"
SRC_URI[x86_64_v2_rust-serde_with+schemars_0_8-devel.sha256sum] = "e0ec48469ff261d202ffca1dd5e33699bfe1fe63ff23c734ead5513dba872d44"

URI_x86_64_v2_rust-serde_with+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+std-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+std-devel}"
SRC_URI[x86_64_v2_rust-serde_with+std-devel.sha256sum] = "090fa9d898018824eb2964be1495e7d0e90cc7b98a4d4e0757f2dad69f0cc52f"

URI_x86_64_v2_rust-serde_with+time_0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with+time_0_3-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with+time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with+time_0_3-devel}"
SRC_URI[x86_64_v2_rust-serde_with+time_0_3-devel.sha256sum] = "feb8fcacf8551acaa0c8b7fa96ceffb4f315fd9051e64ed24a51bb0a8fc039ad"

URI_x86_64_v2_rust-serde_with-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_with-devel-3.16.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_with-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_with-devel}"
SRC_URI[x86_64_v2_rust-serde_with-devel.sha256sum] = "90e68bc13536712f425bab8a0bee7083d12daec18afb47483bf662e0d9a2d3c7"

URI_aarch64_rust-serde_with+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+alloc-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+alloc-devel}"
SRC_URI[aarch64_rust-serde_with+alloc-devel.sha256sum] = "d3670a04bfa2c59d5935617de3cca2c2ece2d0ee6f2d45793f7983cd1e4174ec"

URI_aarch64_rust-serde_with+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+base64-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+base64-devel}"
SRC_URI[aarch64_rust-serde_with+base64-devel.sha256sum] = "041cf473c8980276ecedc0fd2c947dfc3aabb7854988c5a81e6464e9f970b803"

URI_aarch64_rust-serde_with+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+chrono-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+chrono-devel}"
SRC_URI[aarch64_rust-serde_with+chrono-devel.sha256sum] = "fd883654a2848646cf10e1e31b4e5421d0b2adc63fb9d0fe1d2f6030a47b06a8"

URI_aarch64_rust-serde_with+chrono_0_4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+chrono_0_4-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+chrono_0_4-devel}"
SRC_URI[aarch64_rust-serde_with+chrono_0_4-devel.sha256sum] = "e088eb7e52a711d3100ec057b02c128ec5e9cfe0d0f63ca5b25f60bfa6fa2297"

URI_aarch64_rust-serde_with+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+default-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+default-devel}"
SRC_URI[aarch64_rust-serde_with+default-devel.sha256sum] = "67f00b82cf6d42bef86b9a444e12c802818adc2786f463161f92107340e4af30"

URI_aarch64_rust-serde_with+guide-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+guide-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+guide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+guide-devel}"
SRC_URI[aarch64_rust-serde_with+guide-devel.sha256sum] = "e9008550d1d36e09504ed73a9132c5c644437292b18a33e6cbfbc9f7240ced8f"

URI_aarch64_rust-serde_with+hashbrown_0_14-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+hashbrown_0_14-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+hashbrown_0_14-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+hashbrown_0_14-devel}"
SRC_URI[aarch64_rust-serde_with+hashbrown_0_14-devel.sha256sum] = "7fb47bd57e2d7ff26a8cb39608f6a5530527dab9232ce4f74ae8bb07041e547e"

URI_aarch64_rust-serde_with+hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+hex-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+hex-devel}"
SRC_URI[aarch64_rust-serde_with+hex-devel.sha256sum] = "b2a41a419c6acf08cdf4c9795fb57a6454b2d495c0c2ac29a2af9219cdc04351"

URI_aarch64_rust-serde_with+indexmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+indexmap-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+indexmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+indexmap-devel}"
SRC_URI[aarch64_rust-serde_with+indexmap-devel.sha256sum] = "eb0c9908879198a3d281cf319ee5ab740da13ae9c33b1215db3f576f2dbec3b4"

URI_aarch64_rust-serde_with+indexmap_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+indexmap_1-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+indexmap_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+indexmap_1-devel}"
SRC_URI[aarch64_rust-serde_with+indexmap_1-devel.sha256sum] = "2b812fbe3842e6d01b3c7ad9340865e4558147db27a9de8a13b3a9d3c0e07560"

URI_aarch64_rust-serde_with+indexmap_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+indexmap_2-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+indexmap_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+indexmap_2-devel}"
SRC_URI[aarch64_rust-serde_with+indexmap_2-devel.sha256sum] = "1ad2b1e8e457443d61e2c96140d1cad7e620f616d739a1cad8bab97be58d0bb0"

URI_aarch64_rust-serde_with+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+json-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+json-devel}"
SRC_URI[aarch64_rust-serde_with+json-devel.sha256sum] = "0108e1313a534f07c5290d463515ccdba26d88ccab4b1a411548d029ff234685"

URI_aarch64_rust-serde_with+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+macros-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+macros-devel}"
SRC_URI[aarch64_rust-serde_with+macros-devel.sha256sum] = "ef717a115a608813a307ac1da8a6172f4da248d2edb2414340ee8c69bf69a419"

URI_aarch64_rust-serde_with+schemars_0_8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+schemars_0_8-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+schemars_0_8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+schemars_0_8-devel}"
SRC_URI[aarch64_rust-serde_with+schemars_0_8-devel.sha256sum] = "c9122fef5b9d79eb2747bbc1feb9bf0dad205e081fbe649b161032b58ec137fc"

URI_aarch64_rust-serde_with+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+std-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+std-devel}"
SRC_URI[aarch64_rust-serde_with+std-devel.sha256sum] = "9d5768053e7b25cd045b893bb8968522bb31c89d87719c9f51a46f48f8436de4"

URI_aarch64_rust-serde_with+time_0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with+time_0_3-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with+time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with+time_0_3-devel}"
SRC_URI[aarch64_rust-serde_with+time_0_3-devel.sha256sum] = "ef77bbf51128c851ae3ded87f8a8ea6575882563e4fc373df79e515dcf7ff179"

URI_aarch64_rust-serde_with-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_with-devel-3.16.1-1.el10_2.noarch.rpm;name=aarch64_rust-serde_with-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_with-devel}"
SRC_URI[aarch64_rust-serde_with-devel.sha256sum] = "e9bcf5d1ddb6d9cd585d6d7d5f73d832738b231bdb860c57fc9b5752d8fe3e38"

RDEPENDS:rust-serde_with+alloc-devel = " \
 cargo \
 rust-base64_0.22+alloc-devel \
 rust-base64_0.22-devel \
 rust-chrono+alloc-devel \
 rust-chrono+serde-devel \
 rust-chrono-devel \
 rust-hex+alloc-devel \
 rust-hex-devel \
 rust-serde_core+alloc-devel \
 rust-serde_json+alloc-devel \
 rust-serde_json-devel \
 rust-serde_with-devel \
 rust-time+alloc-devel \
 rust-time-devel \
 "
RDEPENDS:rust-serde_with+base64-devel = " \
 cargo \
 rust-base64_0.22-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+chrono-devel = " \
 cargo \
 rust-serde_with+chrono_0_4-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+chrono_0_4-devel = " \
 cargo \
 rust-chrono+serde-devel \
 rust-chrono-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+default-devel = " \
 cargo \
 rust-serde_with+macros-devel \
 rust-serde_with+std-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+guide-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-serde_with+macros-devel \
 rust-serde_with+std-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+hashbrown_0_14-devel = " \
 cargo \
 rust-hashbrown0.14+serde-devel \
 rust-hashbrown0.14-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+hex-devel = " \
 cargo \
 rust-hex-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+indexmap-devel = " \
 cargo \
 rust-serde_with+indexmap_1-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+indexmap_1-devel = " \
 cargo \
 rust-indexmap1+serde-1-devel \
 rust-indexmap1-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+indexmap_2-devel = " \
 cargo \
 rust-indexmap+serde-devel \
 rust-indexmap-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+json-devel = " \
 cargo \
 rust-serde_json-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 "
RDEPENDS:rust-serde_with+macros-devel = " \
 cargo \
 rust-serde_with-devel \
 rust-serde_with_macros+default-devel \
 "
RDEPENDS:rust-serde_with+schemars_0_8-devel = " \
 cargo \
 rust-schemars0.8-devel \
 rust-serde_with+std-devel \
 rust-serde_with-devel \
 rust-serde_with_macros+default-devel \
 rust-serde_with_macros+schemars_0_8-devel \
 "
RDEPENDS:rust-serde_with+std-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+serde-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-indexmap+serde-devel \
 rust-indexmap+std-devel \
 rust-indexmap-devel \
 rust-indexmap1+serde-1-devel \
 rust-indexmap1+std-devel \
 rust-indexmap1-devel \
 rust-serde_core+std-devel \
 rust-serde_with+alloc-devel \
 rust-serde_with-devel \
 rust-time+serde-well-known-devel \
 rust-time+std-devel \
 rust-time-devel \
 "
RDEPENDS:rust-serde_with+time_0_3-devel = " \
 cargo \
 rust-serde_with-devel \
 rust-time-devel \
 "
RDEPENDS:rust-serde_with-devel = " \
 cargo \
 rust \
 rust-serde_core+result-devel \
 rust-serde_core-devel \
 "
