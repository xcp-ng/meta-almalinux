# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kasts"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kasts \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kasts-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "154f9e916b6e3c97ddc707f56d01ee97dcfc9d9d7ada52dd83c1e9cbe1125fb1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kasts-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kasts;unpack=0"
SRC_URI[x86_64_v2_kasts.sha256sum] = "e8d5f91d09c52d90def1cc05425baa3c022b9852477b90ae28ef712b4d339213"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kasts-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kasts;unpack=0"
SRC_URI[aarch64_kasts.sha256sum] = "860e525c02556e64c826646d45e1da2647f348e32fd5f2db3d67c5422b86bb9f"

RDEPENDS:kasts = " \
 glibc \
 kf6-breeze-icons \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kwindowsystem \
 kf6-syndication \
 kf6-threadweaver \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qtkeychain-qt6 \
 taglib \
 vlc-libs \
 "
