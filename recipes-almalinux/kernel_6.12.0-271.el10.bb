# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernel"
PV = "6.12.0"
PR = "271.el10"
PACKAGES:x86_64_v2 = " \
 kernel \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-debug-uki-virt \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"
PACKAGES:aarch64 = " \
 kernel \
 kernel-64k \
 kernel-64k-core \
 kernel-64k-debug \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 kernel-64k-debug-devel-matched \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 kernel-64k-devel \
 kernel-64k-devel-matched \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 kernel-abi-stablelists \
 kernel-core \
 kernel-cross-headers \
 kernel-debug \
 kernel-debug-core \
 kernel-debug-devel \
 kernel-debug-devel-matched \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 kernel-devel \
 kernel-devel-matched \
 kernel-doc \
 kernel-headers \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 kernel-modules-extra-matched \
 kernel-tools \
 kernel-tools-libs \
 kernel-tools-libs-devel \
 kernel-uki-virt \
 kernel-uki-virt-addons \
 libperf \
 perf \
 python3-perf \
 rtla \
 rv \
"

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kernel-6.12.0-271.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4d3a6e9337fd97baaf8ad7a312f041ebe26d74d27c5ef3bed8c0ca37ff9f3e50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel;unpack=0"
SRC_URI[x86_64_v2_kernel.sha256sum] = "da5e6260ad6f85cabb87f2c039782789b619f86d40ef653d58768f918add7963"
RPROVIDES:kernel:append:x86_64_v2 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-abi-stablelists-6.12.0-271.el10.noarch.rpm;name=x86_64_v2_kernel-abi-stablelists;unpack=0"
SRC_URI[x86_64_v2_kernel-abi-stablelists.sha256sum] = "c851329df1cc1d9d0b84dddbc242d735f932d244c325d050e6c8551dfc9c21a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-core-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-core;unpack=0"
SRC_URI[x86_64_v2_kernel-core.sha256sum] = "b6125f221eb0007a13a51e924cef763ad3dda8a94b0152d0eeeb500f78d98459"
RPROVIDES:kernel-core:append:x86_64_v2 = " virtual/kernel virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-cross-headers-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-cross-headers;unpack=0"
SRC_URI[x86_64_v2_kernel-cross-headers.sha256sum] = "711e48d47ee0f3397ca47235a09f333c3662fb2518edc707c7eba00e4d24603f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug;unpack=0"
SRC_URI[x86_64_v2_kernel-debug.sha256sum] = "50ce1be0340f11b6239fec9a87cd90ade1fb5af911c3b794346c37d1c767da21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-core-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-core;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-core.sha256sum] = "e985f994eeccae94ec313d893004f01fde0393332a1248d45cd0f2a66d20c0d5"
RPROVIDES:kernel-debug-core:append:x86_64_v2 = " virtual/kernel virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2+debug"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-devel.sha256sum] = "1575a9a6cbac02acf3faa969b7cbbb6734792263bdc1a27c221e12bedd6301a8"
RPROVIDES:kernel-debug-devel:append:x86_64_v2 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-debug-devel-matched-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-devel-matched;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-devel-matched.sha256sum] = "1060428f3d4dad4cb53c6c511fe6a922da91c0e33fcfa4c038ccbebca1ef27ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-modules.sha256sum] = "fffdcf2819378c126e188eff2463ce71514763c8e21c7d7a7997ee7184cd081b"
RPROVIDES:kernel-debug-modules:append:x86_64_v2 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-core-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-core;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-modules-core.sha256sum] = "0293a18df70821de77eb61c3df5de5f32210a2a7738b84981d29202b99da5f3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-modules-extra-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-modules-extra;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-modules-extra.sha256sum] = "19da796611098b4d352aca4daf71e63faf3de3dca83fd167557b48d677a17e61"
RPROVIDES:kernel-debug-modules-extra:append:x86_64_v2 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-debug-uki-virt-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-debug-uki-virt;unpack=0"
SRC_URI[x86_64_v2_kernel-debug-uki-virt.sha256sum] = "8967154c21e787733bdecd8b9e35aa1993ebf8b90cee9528ad7a03d2285a5bf9"
RPROVIDES:kernel-debug-uki-virt:append:x86_64_v2 = " virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2+debug"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-devel;unpack=0"
SRC_URI[x86_64_v2_kernel-devel.sha256sum] = "0a04f4e1912b1904be95c6ea0630de5633fd1b56856a95fee95fd317ffc7e947"
RPROVIDES:kernel-devel:append:x86_64_v2 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-devel-matched-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-devel-matched;unpack=0"
SRC_URI[x86_64_v2_kernel-devel-matched.sha256sum] = "99d9a791f29886793d50cbe603d1e070c68b3f0bc7bc2f19c711d12db06106ba"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-doc-6.12.0-271.el10.noarch.rpm;name=x86_64_v2_kernel-doc;unpack=0"
SRC_URI[x86_64_v2_kernel-doc.sha256sum] = "6cdfe9f7ede27208600e285f827080b717a6ad58855d9518b6c61e642c2d46e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernel-headers-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-headers;unpack=0"
SRC_URI[x86_64_v2_kernel-headers.sha256sum] = "f0d2736dc03272a2948d4ff0129ee205966a88810a914d9dc3db582247a83341"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-modules;unpack=0"
SRC_URI[x86_64_v2_kernel-modules.sha256sum] = "dfd329e6f6c92349ff2cdf67e341b7ec121a275b96a09e43fe006a1308e1b221"
RPROVIDES:kernel-modules:append:x86_64_v2 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-core-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-core;unpack=0"
SRC_URI[x86_64_v2_kernel-modules-core.sha256sum] = "16369515e1019a4541485d751d3b1092e3fcb7ad3c79e4532a941459cffc4048"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra;unpack=0"
SRC_URI[x86_64_v2_kernel-modules-extra.sha256sum] = "8c0702452cd6bfc5958b20f339f10fc707dba2832b17d47d99b71928d25e5d73"
RPROVIDES:kernel-modules-extra:append:x86_64_v2 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-modules-extra-matched-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-modules-extra-matched;unpack=0"
SRC_URI[x86_64_v2_kernel-modules-extra-matched.sha256sum] = "9266a5d32d68bcb28d48ba86ffd3ddb1fa8bc935a896e2914210cf4786101dbc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-tools;unpack=0"
SRC_URI[x86_64_v2_kernel-tools.sha256sum] = "c066fed046cc179b84d14f01ba9f39fe1781e84ad8e12ae8a9935b159f56da0f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-tools-libs-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs;unpack=0"
SRC_URI[x86_64_v2_kernel-tools-libs.sha256sum] = "63bbf6aa74ce7e3eb05d258854b498cc16816ec92cc6357685fd3d69f76d5b31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kernel-tools-libs-devel-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-tools-libs-devel;unpack=0"
SRC_URI[x86_64_v2_kernel-tools-libs-devel.sha256sum] = "9d1fa5ead69ae3e9badf71f05b3d476c2bdcc7e831581ce795cd410bf5df59df"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt;unpack=0"
SRC_URI[x86_64_v2_kernel-uki-virt.sha256sum] = "a53bdf1bec0a0962160b03e16a1864ee8a464a5504e9f209a32c9417daaa69e6"
RPROVIDES:kernel-uki-virt:append:x86_64_v2 = " virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kernel-uki-virt-addons-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_kernel-uki-virt-addons;unpack=0"
SRC_URI[x86_64_v2_kernel-uki-virt-addons.sha256sum] = "d735c9a492898a096265707e3060d3185ba6804b49beeaac98cd1645649848ab"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libperf-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_libperf;unpack=0"
SRC_URI[x86_64_v2_libperf.sha256sum] = "68db9c7716c7272b24d176c5fc7e997fb887266337f3e7f4b7f83c6a56c5cb98"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perf-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_perf;unpack=0"
SRC_URI[x86_64_v2_perf.sha256sum] = "4106ba5f458fb4cfbeeca42842a0e6c1390c4803bf482504228b8577205479e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-perf-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_python3-perf;unpack=0"
SRC_URI[x86_64_v2_python3-perf.sha256sum] = "9a4a575d443842fd4877ae6eb2347c09adcda5e2c6e910567a53119499a6e316"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rtla-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_rtla;unpack=0"
SRC_URI[x86_64_v2_rtla.sha256sum] = "58ef3d40a30fab5f8576e8d16565b80ccbee5876afefe13a6809d40d386e9158"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rv-6.12.0-271.el10.x86_64_v2.rpm;name=x86_64_v2_rv;unpack=0"
SRC_URI[x86_64_v2_rv.sha256sum] = "9c786486042fd4250c00d3104a3ee80f223ed96637546e3b9e412de5a6457c1a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel;unpack=0"
SRC_URI[aarch64_kernel.sha256sum] = "69fbc69a8e435ec03bc5735739c3e20180ec22e4d8e0835be07969b9ff17bebc"
RPROVIDES:kernel:append:aarch64 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k;unpack=0"
SRC_URI[aarch64_kernel-64k.sha256sum] = "1d47c7ed04ed413855adbb553e5cb42d98e25cbbf7367f88dccd26e624efd53b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-core-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-core;unpack=0"
SRC_URI[aarch64_kernel-64k-core.sha256sum] = "a08a79b4453434024514113fab158ebeaeb095b768f673d3657a03f41b4829b6"
RPROVIDES:kernel-64k-core:append:aarch64 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-debug;unpack=0"
SRC_URI[aarch64_kernel-64k-debug.sha256sum] = "789006a909e0c5060fe9ed8d6055d2e0882833aa3c685cac50278d15abca36da"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-core-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-core;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-core.sha256sum] = "56a3da6e00a29d2410f1cc205b6d7ebe6057cbe1f6c800e84e2f5bc24b547385"
RPROVIDES:kernel-64k-debug-core:append:aarch64 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-devel;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-devel.sha256sum] = "30c710fb30e01f6913107df718ab8c1661e1b00efd33efa648d4aa3deb472a9a"
RPROVIDES:kernel-64k-debug-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-debug-devel-matched-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-devel-matched;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-devel-matched.sha256sum] = "7375a4b4c962c672948e7c85d1a6433e94da3a0e15dc9e26389d4faabeadd5ac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-modules;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-modules.sha256sum] = "12256b6f73497aaf6d6afd141bf4dbfd5289d25e8c73b33f03a27388b3573b73"
RPROVIDES:kernel-64k-debug-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-core-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-core;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-modules-core.sha256sum] = "40be28ce4fa350106ca9d5dda1b2c3a07a7a9ad4cdb9eb3547f782dab1d02361"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-debug-modules-extra-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-debug-modules-extra;unpack=0"
SRC_URI[aarch64_kernel-64k-debug-modules-extra.sha256sum] = "1f89c20b5b9266561fdc4c56c26e1d7d236f75a56094aaa17ef25780c48a3d35"
RPROVIDES:kernel-64k-debug-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-devel;unpack=0"
SRC_URI[aarch64_kernel-64k-devel.sha256sum] = "ae614eca6361ccc7ff56aa43ef8f112031b07e804fe8e6d7d2e75d3c82325a79"
RPROVIDES:kernel-64k-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-64k-devel-matched-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-devel-matched;unpack=0"
SRC_URI[aarch64_kernel-64k-devel-matched.sha256sum] = "78b7ae9b85554f5fd87fc1b09dd7cf168a434016e64238719cb6ea04dbdd498c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-modules;unpack=0"
SRC_URI[aarch64_kernel-64k-modules.sha256sum] = "0ffe71cfc3875853057f40d8b5b8c86b4ad92176b35f7d225ac955368299b315"
RPROVIDES:kernel-64k-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-core-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-modules-core;unpack=0"
SRC_URI[aarch64_kernel-64k-modules-core.sha256sum] = "2f2d16c7398654dbf37c89e4085e91da380dcaabbfc42ab86d19feb3e86c2f19"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-64k-modules-extra-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-64k-modules-extra;unpack=0"
SRC_URI[aarch64_kernel-64k-modules-extra.sha256sum] = "f739b5239c141f24558144c1ac20cdf980af1f35ad1eb491139ed8945ec71982"
RPROVIDES:kernel-64k-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-abi-stablelists-6.12.0-271.el10.noarch.rpm;name=aarch64_kernel-abi-stablelists;unpack=0"
SRC_URI[aarch64_kernel-abi-stablelists.sha256sum] = "c851329df1cc1d9d0b84dddbc242d735f932d244c325d050e6c8551dfc9c21a1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-core-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-core;unpack=0"
SRC_URI[aarch64_kernel-core.sha256sum] = "8e34f374bebd32f96744a42eed07247a417b7dd8eb9d5501813b829c6cc203d0"
RPROVIDES:kernel-core:append:aarch64 = " virtual/kernel virtual/kernel-uname-r_eq_6.12.0-271.el10.aarch64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-cross-headers-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-cross-headers;unpack=0"
SRC_URI[aarch64_kernel-cross-headers.sha256sum] = "bffa3e5620d7c171308ae443381167b8d90b665a3cfebc3cbb5081c12cd399a9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-debug;unpack=0"
SRC_URI[aarch64_kernel-debug.sha256sum] = "06d71133b5af5a639c51aa51e8daa7b84ff28e2df78ef0b69de4c69802f45cc7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-core-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-debug-core;unpack=0"
SRC_URI[aarch64_kernel-debug-core.sha256sum] = "1ba9bf5c4ad1b1903d49f54329e6cf472a648cad86d9e10ce47f4c18a423297d"
RPROVIDES:kernel-debug-core:append:aarch64 = " virtual/kernel"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-debug-devel;unpack=0"
SRC_URI[aarch64_kernel-debug-devel.sha256sum] = "28b5aa22aebd93fc0bd75f92ff2bb917676ddf02ef17c551d5287c0027755914"
RPROVIDES:kernel-debug-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-debug-devel-matched-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-debug-devel-matched;unpack=0"
SRC_URI[aarch64_kernel-debug-devel-matched.sha256sum] = "090547f24c44f1051363607b2f9ff4bf0f4a6e1e99e2b454cda547de329bf39e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-debug-modules;unpack=0"
SRC_URI[aarch64_kernel-debug-modules.sha256sum] = "33936556a7f62efe59e0b4741492f01b8abcdd9350b2593adb7a3187e585f2b6"
RPROVIDES:kernel-debug-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-core-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-debug-modules-core;unpack=0"
SRC_URI[aarch64_kernel-debug-modules-core.sha256sum] = "5f1df5f0b7c14963f88ebf333db559edbbafebf96d070bff04ec32b41e64d287"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-debug-modules-extra-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-debug-modules-extra;unpack=0"
SRC_URI[aarch64_kernel-debug-modules-extra.sha256sum] = "63ad39441e718ced350373cadc2304509f3e5d12f545cdb045778528fdd8fdb5"
RPROVIDES:kernel-debug-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-devel;unpack=0"
SRC_URI[aarch64_kernel-devel.sha256sum] = "cedaf4ac3872dc18c509ca82fbc7dba29c3b332509a2ab6d2e48bfb51a8ef224"
RPROVIDES:kernel-devel:append:aarch64 = " virtual/kernel-devel-uname-r"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-devel-matched-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-devel-matched;unpack=0"
SRC_URI[aarch64_kernel-devel-matched.sha256sum] = "bb3efb766df1ef42d4a10357eb3b5e44c678dd89dde24dcf282562b2c4031897"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-doc-6.12.0-271.el10.noarch.rpm;name=aarch64_kernel-doc;unpack=0"
SRC_URI[aarch64_kernel-doc.sha256sum] = "6cdfe9f7ede27208600e285f827080b717a6ad58855d9518b6c61e642c2d46e7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernel-headers-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-headers;unpack=0"
SRC_URI[aarch64_kernel-headers.sha256sum] = "f23007f5e5ce5f15a47ca9ded2abbb6d4db79459bde04ec7f2205439e2698597"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-modules;unpack=0"
SRC_URI[aarch64_kernel-modules.sha256sum] = "57a6ee359862155f3afdc8622e920bfd8a7c46889bcdb57f6e0cf289d5b585d7"
RPROVIDES:kernel-modules:append:aarch64 = " virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-core-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-modules-core;unpack=0"
SRC_URI[aarch64_kernel-modules-core.sha256sum] = "0f419982720e0bf0f067f74dd2282a00069195887762165dc5c894a587a852d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-modules-extra;unpack=0"
SRC_URI[aarch64_kernel-modules-extra.sha256sum] = "b2bac587ace685489ceff1dea1667e081c77173f8f8048a32f2731e7e91d3794"
RPROVIDES:kernel-modules-extra:append:aarch64 = " virtual/kmod_cuse.ko_ virtual/kmod_l2tp_ppp.ko_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-modules-extra-matched-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-modules-extra-matched;unpack=0"
SRC_URI[aarch64_kernel-modules-extra-matched.sha256sum] = "5dcd9f0308499e252faec3ea38740d75ccd7eed7a46b0f4e479a6268bfb109eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-tools;unpack=0"
SRC_URI[aarch64_kernel-tools.sha256sum] = "9c9a31af676740cb143f088f78046a6836d67f026c87c9b861ff2c208e65d3b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-tools-libs-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-tools-libs;unpack=0"
SRC_URI[aarch64_kernel-tools-libs.sha256sum] = "bf22f7aa75d1f50da7e9b2f818cb50106ded709330c17002e0f890e1bfce0d95"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kernel-tools-libs-devel-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-tools-libs-devel;unpack=0"
SRC_URI[aarch64_kernel-tools-libs-devel.sha256sum] = "16fcf003502fa69130a8531a001c0dbc3a66c9251e7cb3325dd0a88aea0d3d86"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-uki-virt;unpack=0"
SRC_URI[aarch64_kernel-uki-virt.sha256sum] = "d4293cc197107c8bcc3238913d1102cbe832b8a56e83d031ecff1cb977b4b2c9"
RPROVIDES:kernel-uki-virt:append:aarch64 = " virtual/kernel-uname-r_eq_6.12.0-271.el10.aarch64"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kernel-uki-virt-addons-6.12.0-271.el10.aarch64.rpm;name=aarch64_kernel-uki-virt-addons;unpack=0"
SRC_URI[aarch64_kernel-uki-virt-addons.sha256sum] = "d7bd11c11f21e12f73581880105fb7f03d12ba0117cfb540ad500de52324c445"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libperf-6.12.0-271.el10.aarch64.rpm;name=aarch64_libperf;unpack=0"
SRC_URI[aarch64_libperf.sha256sum] = "9ab168b13f12790df82d5a49e97bfefa84effbf925f031429ff0e9bce5854b9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perf-6.12.0-271.el10.aarch64.rpm;name=aarch64_perf;unpack=0"
SRC_URI[aarch64_perf.sha256sum] = "08c7fad6351c72d9b48775fbd2738cd54bbc408532a7b89ec3923ad07bb79b14"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-perf-6.12.0-271.el10.aarch64.rpm;name=aarch64_python3-perf;unpack=0"
SRC_URI[aarch64_python3-perf.sha256sum] = "201c7f6c662ebc6579efff0efedca0ea5043c3fe57fa8fa13702b7b2b19a090d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rtla-6.12.0-271.el10.aarch64.rpm;name=aarch64_rtla;unpack=0"
SRC_URI[aarch64_rtla.sha256sum] = "ec4be119e44d65f8d234179d543a3767ed9016bbcde4c0789c1c8351436d10b4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rv-6.12.0-271.el10.aarch64.rpm;name=aarch64_rv;unpack=0"
SRC_URI[aarch64_rv.sha256sum] = "6895e6bc8fb96d18e39013fd7da573005a17873bec6cf21d2be493d35ba34b8c"

RDEPENDS:kernel = " \
 kernel-core \
 kernel-modules \
 kernel-modules-core \
 kernel-modules-extra \
 "
RDEPENDS:kernel-abi-stablelists = " \
 "
RDEPENDS:kernel-core = " \
 bash \
 dracut \
 kernel-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-cross-headers = " \
 "
RDEPENDS:kernel-debug = " \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
 kernel-debug-modules-extra \
 "
RDEPENDS:kernel-debug-core = " \
 bash \
 dracut \
 kernel-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-debug-devel-matched = " \
 kernel-debug-core \
 kernel-debug-devel \
 "
RDEPENDS:kernel-debug-modules:x86_64_v2 = " \
 bash \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-core:aarch64 = " \
 bash \
 kernel-debug-core \
"
RDEPENDS:kernel-debug-modules-extra:x86_64_v2 = " \
 bash \
 kernel-debug-modules \
 kernel-debug-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2+debug \
"
RDEPENDS:kernel-debug-modules-extra:aarch64 = " \
 bash \
 kernel-debug-core \
 kernel-debug-modules \
 kernel-debug-modules-core \
"
RDEPENDS:kernel-debug-uki-virt = " \
 bash \
 kernel-debug-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-devel-matched = " \
 kernel-core \
 kernel-devel \
 "
RDEPENDS:kernel-doc = " \
 "
RDEPENDS:kernel-headers = " \
 "
RDEPENDS:kernel-modules:x86_64_v2 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2 \
"
RDEPENDS:kernel-modules:aarch64 = " \
 bash \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-271.el10.aarch64 \
"
RDEPENDS:kernel-modules-core:x86_64_v2 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2 \
"
RDEPENDS:kernel-modules-core:aarch64 = " \
 bash \
 virtual/kernel-uname-r_eq_6.12.0-271.el10.aarch64 \
"
RDEPENDS:kernel-modules-extra:x86_64_v2 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-271.el10.x86_64_v2 \
"
RDEPENDS:kernel-modules-extra:aarch64 = " \
 bash \
 kernel-modules \
 kernel-modules-core \
 virtual/kernel-uname-r_eq_6.12.0-271.el10.aarch64 \
"
RDEPENDS:kernel-modules-extra-matched = " \
 "
RDEPENDS:kernel-tools:x86_64_v2 = " \
 glibc \
 kernel-tools-libs \
 libcap \
 libnl3 \
 ncurses-libs \
 pciutils-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools:aarch64 = " \
 glibc \
 kernel-tools-libs \
 ncurses-libs \
 python3 \
 python3-jsonschema \
 python3-pyyaml \
"
RDEPENDS:kernel-tools-libs = " \
 bash \
 glibc \
 "
RDEPENDS:kernel-tools-libs-devel = " \
 glibc \
 kernel-tools \
 kernel-tools-libs \
 python3 \
 "
RDEPENDS:kernel-uki-virt = " \
 bash \
 kernel-modules-core \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-uki-virt-addons = " \
 kernel-uki-virt \
 systemd \
 "
RDEPENDS:libperf = " \
 glibc \
 "
RDEPENDS:perf:x86_64_v2 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:perf:aarch64 = " \
 bash \
 bzip2 \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 perf \
 perl-Exporter \
 perl-POSIX \
 perl-interpreter \
 perl-lib \
 perl-libs \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:x86_64_v2 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:python3-perf:aarch64 = " \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 libbabeltrace \
 libstdc++ \
 libtraceevent \
 libzstd \
 llvm-libs \
 numactl-libs \
 opencsd \
 perl-libs \
 python3 \
 python3-libs \
 slang \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:rtla = " \
 glibc \
 kernel-tools-libs \
 libbpf \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:rv = " \
 glibc \
 libtraceevent \
 libtracefs \
 "
RDEPENDS:kernel-64k = " \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 kernel-64k-modules-extra \
 "
RDEPENDS:kernel-64k-core = " \
 bash \
 dracut \
 kernel-64k-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug = " \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 kernel-64k-debug-modules-extra \
 "
RDEPENDS:kernel-64k-debug-core = " \
 bash \
 dracut \
 kernel-64k-debug-modules-core \
 linux-firmware \
 systemd \
 systemd-udev \
 virtual/coreutils \
 "
RDEPENDS:kernel-64k-debug-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-debug-devel-matched = " \
 kernel-64k-debug-core \
 kernel-64k-debug-devel \
 "
RDEPENDS:kernel-64k-debug-modules = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-debug-modules-core = " \
 bash \
 kernel-64k-debug-core \
 "
RDEPENDS:kernel-64k-debug-modules-extra = " \
 bash \
 kernel-64k-debug-core \
 kernel-64k-debug-modules \
 kernel-64k-debug-modules-core \
 "
RDEPENDS:kernel-64k-devel = " \
 bash \
 bison \
 elfutils-libelf-devel \
 findutils \
 flex \
 gcc \
 make \
 openssl-devel \
 perl-interpreter \
 "
RDEPENDS:kernel-64k-devel-matched = " \
 kernel-64k-core \
 kernel-64k-devel \
 "
RDEPENDS:kernel-64k-modules = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules-core \
 "
RDEPENDS:kernel-64k-modules-core = " \
 bash \
 kernel-64k-core \
 "
RDEPENDS:kernel-64k-modules-extra = " \
 bash \
 kernel-64k-core \
 kernel-64k-modules \
 kernel-64k-modules-core \
 "
