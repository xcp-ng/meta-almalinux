# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwallet"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kwallet \
 kf6-kwallet-devel \
 kf6-kwallet-doc \
 kf6-kwallet-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwallet-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1eebd703e1fab45c784a47666651f65ac8b6d7add8453d839d3a609cd9d1ae4b"

URI_x86_64_v2_kf6-kwallet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet}"
SRC_URI[x86_64_v2_kf6-kwallet.sha256sum] = "76e9d8165ae299af882ce08691be73566b554379b77478cb302b6cc3107356c7"

URI_x86_64_v2_kf6-kwallet-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-devel}"
SRC_URI[x86_64_v2_kf6-kwallet-devel.sha256sum] = "14cb8446e0dffec081148155677026c340ce077a9b946574b4bd3d90525fbdda"

URI_x86_64_v2_kf6-kwallet-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwallet-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-doc}"
SRC_URI[x86_64_v2_kf6-kwallet-doc.sha256sum] = "dede6e31627ff46fa70da839b5b8c8f3911469f50b6bafaadc01b8096fd2b3cf"

URI_x86_64_v2_kf6-kwallet-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwallet-libs-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwallet-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwallet-libs}"
SRC_URI[x86_64_v2_kf6-kwallet-libs.sha256sum] = "59a7e8d81b43f203b47daea8237fdb64477af5c083e08737330742446374fecd"

URI_aarch64_kf6-kwallet = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kwallet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet}"
SRC_URI[aarch64_kf6-kwallet.sha256sum] = "aa894f90705a390582b3ee5a5ffe2cd865e6598df42ed8c3ae9b9c18d3a1aca2"

URI_aarch64_kf6-kwallet-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kwallet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-devel}"
SRC_URI[aarch64_kf6-kwallet-devel.sha256sum] = "44e4c209d0195142eeeccf481b1b67b6120d1eed09ec521b77ea4ceaca3e6b97"

URI_aarch64_kf6-kwallet-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kwallet-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-doc}"
SRC_URI[aarch64_kf6-kwallet-doc.sha256sum] = "744cd3203abde02d7ea5d08fd562c6c8df80e2a8b2108ea1032bda33f6798879"

URI_aarch64_kf6-kwallet-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwallet-libs-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kwallet-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwallet-libs}"
SRC_URI[aarch64_kf6-kwallet-libs.sha256sum] = "11987e08ab0ebf3a7d50b93d7026baec7b1b969a34534ccd9955bc8cfaa0920f"

RDEPENDS:kf6-kwallet = " \
 glibc \
 gpgmepp \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libgcc \
 libstdc++ \
 pinentry-gnome3 \
 qca-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kwallet-devel = " \
 cmake-filesystem \
 kf6-kwallet-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwallet-doc = " \
 "
RDEPENDS:kf6-kwallet-libs = " \
 glibc \
 gpgmepp \
 kf6-kconfig \
 kf6-ki18n \
 kf6-knotifications \
 kf6-kwallet \
 kf6-kwidgetsaddons \
 libgcrypt \
 libstdc++ \
 qt6-qtbase \
 "
