# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "open-vmdk"
PV = "0.3.12"
PR = "1.el10_2"
PACKAGES = " \
 open-vmdk \
 ovfenv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/open-vmdk-0.3.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2827b31d49e92acc603b3bd959581695caa05ba03ff074d0c05f404e377a6b29"

URI_x86_64_v2_open-vmdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/open-vmdk-0.3.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_open-vmdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_open-vmdk}"
SRC_URI[x86_64_v2_open-vmdk.sha256sum] = "b4e346074bc003fad78bda6e3d64c36c66e70cc1aa14e1a5841deae605c535c1"

URI_x86_64_v2_ovfenv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ovfenv-0.3.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ovfenv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ovfenv}"
SRC_URI[x86_64_v2_ovfenv.sha256sum] = "6183c4ddffc16a5b1266d175f281a9dc83d0553ab09f629f23e8f6053f535d52"

URI_aarch64_open-vmdk = "${EPEL_MIRROR}/aarch64/Packages/o/open-vmdk-0.3.12-1.el10_2.aarch64.rpm;name=aarch64_open-vmdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_open-vmdk}"
SRC_URI[aarch64_open-vmdk.sha256sum] = "f18e330ba5c34720e2930b374073835e83f1844f9e2bcd093c24fa4fb71ce0e0"

URI_aarch64_ovfenv = "${EPEL_MIRROR}/aarch64/Packages/o/ovfenv-0.3.12-1.el10_2.noarch.rpm;name=aarch64_ovfenv;unpack=0"
SRC_URI:append = " ${URI_aarch64_ovfenv}"
SRC_URI[aarch64_ovfenv.sha256sum] = "020e9fa1f3a01c341f4851219edf66c7cf89f4101745500699b04663211d2d08"

RDEPENDS:open-vmdk = " \
 bash \
 glibc \
 grep \
 python3 \
 python3-lxml \
 python3-pyyaml \
 sed \
 tar \
 util-linux \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:ovfenv = " \
 open-vm-tools \
 python3 \
 python3-libxml2 \
 "
