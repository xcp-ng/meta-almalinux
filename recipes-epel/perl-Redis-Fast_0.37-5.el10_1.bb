# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Redis-Fast"
PV = "0.37"
PR = "5.el10_1"
PACKAGES = " \
 perl-Redis-Fast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Redis-Fast-0.37-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c5c49dc5075ab24303738d7066696ca1010fb10db7aff847b3445612c6f88b42"

URI_x86_64_v2_perl-Redis-Fast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Redis-Fast-0.37-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Redis-Fast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Redis-Fast}"
SRC_URI[x86_64_v2_perl-Redis-Fast.sha256sum] = "d991bd90a99e9304889c30b485e010e4ab0ab28f293abd0767b1f56f0972bf04"

URI_aarch64_perl-Redis-Fast = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Redis-Fast-0.37-5.el10_1.aarch64.rpm;name=aarch64_perl-Redis-Fast;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Redis-Fast}"
SRC_URI[aarch64_perl-Redis-Fast.sha256sum] = "c2fe2c87ea5dc70810a76915e1044795859b6d6b6d27fe5989053cf3ae4d1dd2"

RDEPENDS:perl-Redis-Fast = " \
 glibc \
 hiredis \
 perl-Carp \
 perl-Encode \
 perl-Redis-Fast \
 perl-Scalar-List-Utils \
 perl-Tie \
 perl-Try-Tiny \
 perl-base \
 perl-constant \
 perl-libs \
 "
