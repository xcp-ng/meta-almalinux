# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-boxcar"
PV = "0.2.14"
PR = "1.el10_0"
PACKAGES = " \
 rust-boxcar+default-devel \
 rust-boxcar-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-boxcar-0.2.14-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f884cd3b65eede6f61b3b39578525b90674833bd6ffa46c6a53b1426caa83e38"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-boxcar+default-devel-0.2.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-boxcar+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-boxcar+default-devel.sha256sum] = "42a6889ac5acfe6629271c5f1c09ece2cab57123d0d262c447477cb73c830bab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-boxcar-devel-0.2.14-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-boxcar-devel;unpack=0"
SRC_URI[x86_64_v2_rust-boxcar-devel.sha256sum] = "464b183d5628a2f4c3db398c3f9be36274f7feadc15d29b1649be1febfb67739"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-boxcar+default-devel-0.2.14-1.el10_0.noarch.rpm;name=aarch64_rust-boxcar+default-devel;unpack=0"
SRC_URI[aarch64_rust-boxcar+default-devel.sha256sum] = "82dd98f6da83631c30e65133847389e233bed255ebd7db1adf2c3d46a9fb173a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-boxcar-devel-0.2.14-1.el10_0.noarch.rpm;name=aarch64_rust-boxcar-devel;unpack=0"
SRC_URI[aarch64_rust-boxcar-devel.sha256sum] = "2315fc8e87467bd504dc43f7bcdcfb248d192f066b6ab3c553040cd19be983f6"

RDEPENDS:rust-boxcar+default-devel = " \
 cargo \
 rust-boxcar-devel \
 "
RDEPENDS:rust-boxcar-devel = " \
 cargo \
 rust \
 "
