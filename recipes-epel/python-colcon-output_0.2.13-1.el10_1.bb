# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-output"
PV = "0.2.13"
PR = "1.el10_1"
PACKAGES = " \
 python3-colcon-output \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-output-0.2.13-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c0a112298f74a2201c0998de6e8b0c9556fcfbe357e6ad88a50679bd3ca752d"

URI_x86_64_v2_python3-colcon-output = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-output-0.2.13-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-output;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-output}"
SRC_URI[x86_64_v2_python3-colcon-output.sha256sum] = "fa318ba01035983ff712ba06a30ed61540895b7aaee36281bd446638d5248057"

URI_aarch64_python3-colcon-output = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-output-0.2.13-1.el10_1.noarch.rpm;name=aarch64_python3-colcon-output;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-output}"
SRC_URI[aarch64_python3-colcon-output.sha256sum] = "b035eeadeaf663bec29daa3b15fc12d5fe8ab57be01f371b340cf390dcaa23e9"

RDEPENDS:python3-colcon-output = " \
 python3 \
 python3-colcon-core \
 "
