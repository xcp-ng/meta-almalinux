# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdivide"
PV = "5.3.0"
PR = "1.el10_2"
PACKAGES = " \
 libdivide-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdivide-5.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6abe4bea3c9b284d6d4f695ef701ea2649d2903f37273820aff95875d9b0e9bf"

URI_x86_64_v2_libdivide-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdivide-devel-5.3.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdivide-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdivide-devel}"
SRC_URI[x86_64_v2_libdivide-devel.sha256sum] = "fa94226916b58a6a899306a20c43121d21209aedb9f0220ad51fd034ccca6c88"

URI_aarch64_libdivide-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libdivide-devel-5.3.0-1.el10_2.aarch64.rpm;name=aarch64_libdivide-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdivide-devel}"
SRC_URI[aarch64_libdivide-devel.sha256sum] = "7fee506cecfc27cc76e6406b41c0435d2fb604bef32d6a42eb39e0f307a8b8c2"

RDEPENDS:libdivide-devel = " \
 cmake-filesystem \
 "
