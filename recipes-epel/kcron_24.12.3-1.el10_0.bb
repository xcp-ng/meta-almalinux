# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcron"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kcron \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcron-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d8341a8ada176937e6d8ffca5f20cd428a8df3ffd69eeb2870380994cc1b9d8"

URI_x86_64_v2_kcron = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcron-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcron;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcron}"
SRC_URI[x86_64_v2_kcron.sha256sum] = "ba553cdfa54aeac3aae6bf3aafad19b709c2ace744b0a0b95fbfbc8409aa7d47"

URI_aarch64_kcron = "${EPEL_MIRROR}/aarch64/Packages/k/kcron-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kcron;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcron}"
SRC_URI[aarch64_kcron.sha256sum] = "b56e27c0e6bcacb7f0f06d69902fb7457f7e0c960fef81898bcacf9a91e982cd"

RDEPENDS:kcron = " \
 glibc \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
