# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dary_heap"
PV = "0.3.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-dary_heap+default-devel \
 rust-dary_heap+extra-devel \
 rust-dary_heap+serde-devel \
 rust-dary_heap-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dary_heap-0.3.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2819ea5f3d6dbdc28c79d583fc59f7083e76fde69a45010d8f23550528bfb01d"

URI_x86_64_v2_rust-dary_heap+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap+default-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap+default-devel}"
SRC_URI[x86_64_v2_rust-dary_heap+default-devel.sha256sum] = "8fb32a020c6e14dd037284ab4383d665349a5032d26c1bd78f448fdc48bc2318"

URI_x86_64_v2_rust-dary_heap+extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap+extra-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap+extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap+extra-devel}"
SRC_URI[x86_64_v2_rust-dary_heap+extra-devel.sha256sum] = "787b418187d9a92786fbffaf363b2da6fdf39979ace7c3d82c7a2757d15ec81a"

URI_x86_64_v2_rust-dary_heap+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap+serde-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap+serde-devel}"
SRC_URI[x86_64_v2_rust-dary_heap+serde-devel.sha256sum] = "29058017e91892bafcf6ef978a2fb15320d22401b74d9e8681b71fc369aa2633"

URI_x86_64_v2_rust-dary_heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dary_heap-devel-0.3.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dary_heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dary_heap-devel}"
SRC_URI[x86_64_v2_rust-dary_heap-devel.sha256sum] = "9e4bd81fa9512cc988f7ed17d5b556665d22a45dc8cb8eff4368e59e05edbc79"

URI_aarch64_rust-dary_heap+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap+default-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-dary_heap+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap+default-devel}"
SRC_URI[aarch64_rust-dary_heap+default-devel.sha256sum] = "dba7295b15f7b3cc4c6742ad052730e0e5c06785d63c8457cd0c3007bb14a177"

URI_aarch64_rust-dary_heap+extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap+extra-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-dary_heap+extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap+extra-devel}"
SRC_URI[aarch64_rust-dary_heap+extra-devel.sha256sum] = "58982b8baed1100a79a64eaa41a7cff092839b762d49c0742d1a0730cf040088"

URI_aarch64_rust-dary_heap+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap+serde-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-dary_heap+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap+serde-devel}"
SRC_URI[aarch64_rust-dary_heap+serde-devel.sha256sum] = "109c548cfb403d72ef48bd11cf9074c829d0e87066106981db0bb2d2923864ed"

URI_aarch64_rust-dary_heap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dary_heap-devel-0.3.8-1.el10_2.noarch.rpm;name=aarch64_rust-dary_heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dary_heap-devel}"
SRC_URI[aarch64_rust-dary_heap-devel.sha256sum] = "3f5b052ebfb7c5462588da18723114377d00218cfd841d76668a509aecc67002"

RDEPENDS:rust-dary_heap+default-devel = " \
 cargo \
 rust-dary_heap-devel \
 "
RDEPENDS:rust-dary_heap+extra-devel = " \
 cargo \
 rust-dary_heap-devel \
 "
RDEPENDS:rust-dary_heap+serde-devel = " \
 cargo \
 rust-dary_heap-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-dary_heap-devel = " \
 cargo \
 "
