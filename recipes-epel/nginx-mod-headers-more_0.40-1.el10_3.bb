# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-headers-more"
PV = "0.40"
PR = "1.el10_3"
PACKAGES = " \
 nginx-mod-headers-more \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-headers-more-0.40-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fad8f3df4ee68e594e9758c05004995741b46dfbf9c4d6f9e204c8184b343fc3"

URI_x86_64_v2_nginx-mod-headers-more = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-headers-more-0.40-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-headers-more;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-headers-more}"
SRC_URI[x86_64_v2_nginx-mod-headers-more.sha256sum] = "ac9c250fea832cc32fab137d4d7e020ae600e2c2e5c072698e6fdaf95b17b514"

URI_aarch64_nginx-mod-headers-more = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-headers-more-0.40-1.el10_3.aarch64.rpm;name=aarch64_nginx-mod-headers-more;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-headers-more}"
SRC_URI[aarch64_nginx-mod-headers-more.sha256sum] = "652c09e55bb46620fe1cb04bf01a2243f200f57fd7a7895f404bff8b17d28f14"

RDEPENDS:nginx-mod-headers-more = " \
 glibc \
 nginx \
 "
