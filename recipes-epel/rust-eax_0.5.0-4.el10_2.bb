# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-eax"
PV = "0.5.0"
PR = "4.el10_2"
PACKAGES = " \
 rust-eax+alloc-devel \
 rust-eax+default-devel \
 rust-eax+getrandom-devel \
 rust-eax+heapless-devel \
 rust-eax+std-devel \
 rust-eax+stream-devel \
 rust-eax-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-eax-0.5.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2701459fedd648b80339b5c8b41c788ecd139131362330c7327f098d4a387399"

URI_x86_64_v2_rust-eax+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eax+alloc-devel-0.5.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eax+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eax+alloc-devel}"
SRC_URI[x86_64_v2_rust-eax+alloc-devel.sha256sum] = "fc2393a28837a310ebf284f189b134b98b617b4b6eb4b50e4ef522e555c2e917"

URI_x86_64_v2_rust-eax+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eax+default-devel-0.5.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eax+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eax+default-devel}"
SRC_URI[x86_64_v2_rust-eax+default-devel.sha256sum] = "f25aa9161ea2f2cfb3cf53ac168cfb09f874406328bb9773f314452cf67f9c11"

URI_x86_64_v2_rust-eax+getrandom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eax+getrandom-devel-0.5.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eax+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eax+getrandom-devel}"
SRC_URI[x86_64_v2_rust-eax+getrandom-devel.sha256sum] = "c561fbc6deec28ec2aaae008747aaf63ea0554f8a3f8fad0f149b5fcc33d10d5"

URI_x86_64_v2_rust-eax+heapless-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eax+heapless-devel-0.5.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eax+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eax+heapless-devel}"
SRC_URI[x86_64_v2_rust-eax+heapless-devel.sha256sum] = "a162d120b92b885e28dcfa1327d8d81a405fadce4a4886d0adc263fd67ad405b"

URI_x86_64_v2_rust-eax+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eax+std-devel-0.5.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eax+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eax+std-devel}"
SRC_URI[x86_64_v2_rust-eax+std-devel.sha256sum] = "39dcf7668cf9dab65d68641e2afd47b4380c0e5e8bdb7910dcb0e736d2de7c3d"

URI_x86_64_v2_rust-eax+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eax+stream-devel-0.5.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eax+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eax+stream-devel}"
SRC_URI[x86_64_v2_rust-eax+stream-devel.sha256sum] = "7b4b8bec475b7116b24050432236c622858eb49e516f3ae9e94f4e8962d6fbcf"

URI_x86_64_v2_rust-eax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eax-devel-0.5.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-eax-devel}"
SRC_URI[x86_64_v2_rust-eax-devel.sha256sum] = "af04c967a17549c021b8387bdbf06351c043803e634dae4cf3a5cba595a9ae83"

URI_aarch64_rust-eax+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eax+alloc-devel-0.5.0-4.el10_2.noarch.rpm;name=aarch64_rust-eax+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eax+alloc-devel}"
SRC_URI[aarch64_rust-eax+alloc-devel.sha256sum] = "ab3495e923c88ff4f45400e90a0a28744da736c8f47c9e5968e8b94667ee1c45"

URI_aarch64_rust-eax+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eax+default-devel-0.5.0-4.el10_2.noarch.rpm;name=aarch64_rust-eax+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eax+default-devel}"
SRC_URI[aarch64_rust-eax+default-devel.sha256sum] = "b6b2c0f2df08e485a2a9f38b3a64839e76cbbe414a553f773ab392349ac12099"

URI_aarch64_rust-eax+getrandom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eax+getrandom-devel-0.5.0-4.el10_2.noarch.rpm;name=aarch64_rust-eax+getrandom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eax+getrandom-devel}"
SRC_URI[aarch64_rust-eax+getrandom-devel.sha256sum] = "926264b3c60c018e7c0e618f4da71912e6d2146d9ef1896ce94b443c381b522c"

URI_aarch64_rust-eax+heapless-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eax+heapless-devel-0.5.0-4.el10_2.noarch.rpm;name=aarch64_rust-eax+heapless-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eax+heapless-devel}"
SRC_URI[aarch64_rust-eax+heapless-devel.sha256sum] = "1654d9a40e28106dd50ad8bff503b4a383693b3016d5dcd2d519288d7137077a"

URI_aarch64_rust-eax+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eax+std-devel-0.5.0-4.el10_2.noarch.rpm;name=aarch64_rust-eax+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eax+std-devel}"
SRC_URI[aarch64_rust-eax+std-devel.sha256sum] = "618efaf594270019a5f4f26597342cc7ee0f0b46e2570be4e0d3be1ade216cf0"

URI_aarch64_rust-eax+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eax+stream-devel-0.5.0-4.el10_2.noarch.rpm;name=aarch64_rust-eax+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eax+stream-devel}"
SRC_URI[aarch64_rust-eax+stream-devel.sha256sum] = "e0ae9f120a339df2d109ef9cd10bb56de234ffca58ec178220fd84a360d62edf"

URI_aarch64_rust-eax-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-eax-devel-0.5.0-4.el10_2.noarch.rpm;name=aarch64_rust-eax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-eax-devel}"
SRC_URI[aarch64_rust-eax-devel.sha256sum] = "7601f4d462f415475f6fd0a5efabae0bcc46beecf591cbb2f02319853a8a3fa7"

RDEPENDS:rust-eax+alloc-devel = " \
 cargo \
 rust-aead+alloc-devel \
 rust-eax-devel \
 "
RDEPENDS:rust-eax+default-devel = " \
 cargo \
 rust-eax+alloc-devel \
 rust-eax+getrandom-devel \
 rust-eax-devel \
 "
RDEPENDS:rust-eax+getrandom-devel = " \
 cargo \
 rust-aead+getrandom-devel \
 rust-eax-devel \
 "
RDEPENDS:rust-eax+heapless-devel = " \
 cargo \
 rust-aead+heapless-devel \
 rust-eax-devel \
 "
RDEPENDS:rust-eax+std-devel = " \
 cargo \
 rust-aead+std-devel \
 rust-eax+alloc-devel \
 rust-eax-devel \
 "
RDEPENDS:rust-eax+stream-devel = " \
 cargo \
 rust-aead+stream-devel \
 rust-eax-devel \
 "
RDEPENDS:rust-eax-devel = " \
 cargo \
 rust \
 rust-aead-devel \
 rust-cipher0.4+default-devel \
 rust-cmac+default-devel \
 rust-ctr+default-devel \
 rust-subtle-devel \
 "
