# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-backtrace-ext"
PV = "0.2.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-backtrace-ext+default-devel \
 rust-backtrace-ext-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-backtrace-ext-0.2.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e65e50b2597977d2f750e5a56e5bddc4901b3e6cb44db245ff7dfd5bdf3c528"

URI_x86_64_v2_rust-backtrace-ext+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace-ext+default-devel-0.2.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace-ext+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace-ext+default-devel}"
SRC_URI[x86_64_v2_rust-backtrace-ext+default-devel.sha256sum] = "ff2d1e8afc675e9c033e01bddfca5918b2b85c7a93bfa6b6e5c60bf7dcb8b8d2"

URI_x86_64_v2_rust-backtrace-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-backtrace-ext-devel-0.2.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-backtrace-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-backtrace-ext-devel}"
SRC_URI[x86_64_v2_rust-backtrace-ext-devel.sha256sum] = "5cd5b89a3b9ab8949c35ae0d1bb8ba60cb17bfcc22c286b6eb58afd559f4fe25"

URI_aarch64_rust-backtrace-ext+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace-ext+default-devel-0.2.1-3.el10_0.noarch.rpm;name=aarch64_rust-backtrace-ext+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace-ext+default-devel}"
SRC_URI[aarch64_rust-backtrace-ext+default-devel.sha256sum] = "4f6350de0803e0f7491814136e6f9e04ad31cb9b68c7e1026dd28291d19310e1"

URI_aarch64_rust-backtrace-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-backtrace-ext-devel-0.2.1-3.el10_0.noarch.rpm;name=aarch64_rust-backtrace-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-backtrace-ext-devel}"
SRC_URI[aarch64_rust-backtrace-ext-devel.sha256sum] = "2fc3802696d5446ecca754318ae25513e725a2bf3f804fcf923be9e0911f6729"

RDEPENDS:rust-backtrace-ext+default-devel = " \
 cargo \
 rust-backtrace-ext-devel \
 "
RDEPENDS:rust-backtrace-ext-devel = " \
 cargo \
 rust \
 rust-backtrace+default-devel \
 "
