# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cryptography"
PV = "43.0.0"
PR = "4.el10_2.5"
PACKAGES = " \
 python3-cryptography \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-cryptography-43.0.0-4.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "40cdf7d265a7ce8308ffdb1c3a1c0cd355b28ae3e82b949958709e1ed8f86c33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-cryptography-43.0.0-4.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_python3-cryptography;unpack=0"
SRC_URI[x86_64_v2_python3-cryptography.sha256sum] = "2f4661b7715fa4a5738a17613b8e27239699882b7aaab2699c16bab8874d1c55"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-cryptography-43.0.0-4.el10_2.5.aarch64.rpm;name=aarch64_python3-cryptography;unpack=0"
SRC_URI[aarch64_python3-cryptography.sha256sum] = "f55078782360cf708ea863a1b1e981d392656faac2666b1318d287be68313735"

RDEPENDS:python3-cryptography = " \
 glibc \
 libgcc \
 openssl-libs \
 python3 \
 python3-cffi \
 "
