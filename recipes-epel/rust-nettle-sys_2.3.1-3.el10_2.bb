# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nettle-sys"
PV = "2.3.1"
PR = "3.el10_2"
PACKAGES = " \
 rust-nettle-sys+default-devel \
 rust-nettle-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nettle-sys-2.3.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e1b82fc38e89f47cf4ef32311a6ad7b2b2b888d96266b538652bc658247dcbdd"

URI_x86_64_v2_rust-nettle-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nettle-sys+default-devel-2.3.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nettle-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nettle-sys+default-devel}"
SRC_URI[x86_64_v2_rust-nettle-sys+default-devel.sha256sum] = "45ef5bb8edb113f42884455c6ece3c4c449915d558a4bed4dc49434f5f3e28c3"

URI_x86_64_v2_rust-nettle-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nettle-sys-devel-2.3.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nettle-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nettle-sys-devel}"
SRC_URI[x86_64_v2_rust-nettle-sys-devel.sha256sum] = "c5b81036362893e18960bb1141726031aead7295b9924e02795b267706ec2d11"

URI_aarch64_rust-nettle-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nettle-sys+default-devel-2.3.1-3.el10_2.noarch.rpm;name=aarch64_rust-nettle-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nettle-sys+default-devel}"
SRC_URI[aarch64_rust-nettle-sys+default-devel.sha256sum] = "3906ee128816c638b65202f5519a6de3fd7ac62f0314d386566a910e3076353b"

URI_aarch64_rust-nettle-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nettle-sys-devel-2.3.1-3.el10_2.noarch.rpm;name=aarch64_rust-nettle-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nettle-sys-devel}"
SRC_URI[aarch64_rust-nettle-sys-devel.sha256sum] = "6698c700bc5e4e1a4cc2cc9a5ade6968b30206e95b79bc56091c1b8e6930e238"

RDEPENDS:rust-nettle-sys+default-devel = " \
 cargo \
 rust-nettle-sys-devel \
 "
RDEPENDS:rust-nettle-sys-devel = " \
 cargo \
 nettle-devel \
 rust-bindgen+runtime-devel \
 rust-bindgen-devel \
 rust-cc+default-devel \
 rust-libc+default-devel \
 rust-pkg-config+default-devel \
 rust-tempfile+default-devel \
 "
