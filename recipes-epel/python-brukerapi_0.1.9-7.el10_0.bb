# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-brukerapi"
PV = "0.1.9"
PR = "7.el10_0"
PACKAGES = " \
 python-brukerapi-doc \
 python3-brukerapi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-brukerapi-0.1.9-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf69a0c1b190e885d05d894b837155268fd6990e4474180d3507410c5baaca1c"

URI_x86_64_v2_python-brukerapi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-brukerapi-doc-0.1.9-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-brukerapi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-brukerapi-doc}"
SRC_URI[x86_64_v2_python-brukerapi-doc.sha256sum] = "f6d1df21010fb54872dda4f42d3606d103f764b6c327269add27fa0942108479"

URI_x86_64_v2_python3-brukerapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-brukerapi-0.1.9-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-brukerapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-brukerapi}"
SRC_URI[x86_64_v2_python3-brukerapi.sha256sum] = "ec2d83a9a75e0f5cd40adf1e4915ee36939ae43ef2a3e3c94eb2cd5f5bf07548"

URI_aarch64_python-brukerapi-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-brukerapi-doc-0.1.9-7.el10_0.noarch.rpm;name=aarch64_python-brukerapi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-brukerapi-doc}"
SRC_URI[aarch64_python-brukerapi-doc.sha256sum] = "3d540d68d8aac306d741e9f8a87f5a66d6083509de5a4cffb6af53045a290ce3"

URI_aarch64_python3-brukerapi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-brukerapi-0.1.9-7.el10_0.noarch.rpm;name=aarch64_python3-brukerapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-brukerapi}"
SRC_URI[aarch64_python3-brukerapi.sha256sum] = "fd9f301d00962a1f78c0b464a2cac3ad493eb0bf677f90839851ccf0a68ddc49"

RDEPENDS:python-brukerapi-doc = " \
 "
RDEPENDS:python3-brukerapi = " \
 python3 \
 python3-numpy \
 python3-pyyaml \
 "
