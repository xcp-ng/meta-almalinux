# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "esc"
PV = "1.1.2"
PR = "20.el10_0"
PACKAGES = " \
 esc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/esc-1.1.2-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e7371630bf01fcd182f16474a7cf3e2852c278057ca13da0fc94b633cd651a4"

URI_x86_64_v2_esc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/esc-1.1.2-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_esc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_esc}"
SRC_URI[x86_64_v2_esc.sha256sum] = "d57abcbcbdf006bce61fc4eda6a3135a94fc70343847ba34e25849a6b2c7be96"

URI_aarch64_esc = "${EPEL_MIRROR}/aarch64/Packages/e/esc-1.1.2-20.el10_0.aarch64.rpm;name=aarch64_esc;unpack=0"
SRC_URI:append = " ${URI_aarch64_esc}"
SRC_URI[aarch64_esc.sha256sum] = "d6dff43e9bc63356bf9e52e2eae28750571d1bf7eb0cf0e91d08f9e7de17ee75"

RDEPENDS:esc = " \
 dbus \
 gjs \
 glib2 \
 gobject-introspection \
 gtk3 \
 nspr \
 nss \
 opensc \
 pcsc-lite \
 "
