# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pcp"
PV = "6.3.7"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-infiniband \
 pcp-pmda-json \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mssql \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-resctrl \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"
PACKAGES:aarch64 = " \
 pcp \
 pcp-conf \
 pcp-devel \
 pcp-doc \
 pcp-export-pcp2elasticsearch \
 pcp-export-pcp2graphite \
 pcp-export-pcp2influxdb \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-export-zabbix-agent \
 pcp-geolocate \
 pcp-gui \
 pcp-import-collectl2pcp \
 pcp-import-ganglia2pcp \
 pcp-import-iostat2pcp \
 pcp-import-mrtg2pcp \
 pcp-import-sar2pcp \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cifs \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-infiniband \
 pcp-pmda-json \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-perfevent \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-redis \
 pcp-pmda-roomtemp \
 pcp-pmda-rsyslog \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-systemd \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-selinux \
 pcp-system-tools \
 pcp-testsuite \
 pcp-zeroconf \
 perl-PCP-LogImport \
 perl-PCP-LogSummary \
 perl-PCP-MMV \
 perl-PCP-PMDA \
 python3-pcp \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pcp-6.3.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "52ad60e79a10a9faf3460aeb9eb721bf4a095c8f6635642acff0c092118a6964"

URI_x86_64_v2_pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp}"
SRC_URI[x86_64_v2_pcp.sha256sum] = "b3ba2adf9f8deb51466c3db73bd99363e69d5df8d006edacd276fd8bca9c0ef3"

URI_x86_64_v2_pcp-conf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-conf-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-conf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-conf}"
SRC_URI[x86_64_v2_pcp-conf.sha256sum] = "128b1bc70b5205bb0bc536dff09d501f97244d74c6ac03088997c1e3c8026a35"

URI_x86_64_v2_pcp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-devel-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-devel}"
SRC_URI[x86_64_v2_pcp-devel.sha256sum] = "2e20fbb2c269d85642d1ca611329a22f53ba0eeee7571440d76fb3685bce5ed6"

URI_x86_64_v2_pcp-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-doc-6.3.7-1.el10_0.noarch.rpm;name=x86_64_v2_pcp-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-doc}"
SRC_URI[x86_64_v2_pcp-doc.sha256sum] = "12cdce38c917eee9ec6e11afb47e99e99786c0232ffa327a8c23e5cb94448b36"

URI_x86_64_v2_pcp-export-pcp2elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2elasticsearch-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2elasticsearch}"
SRC_URI[x86_64_v2_pcp-export-pcp2elasticsearch.sha256sum] = "311150273f4f883db072d98f11bb7d9d51da3a6d87ca9222463debeeb22720b1"

URI_x86_64_v2_pcp-export-pcp2graphite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2graphite-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2graphite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2graphite}"
SRC_URI[x86_64_v2_pcp-export-pcp2graphite.sha256sum] = "af4d3aa98d7e8d2c392832c634d5e457806e4495883588e79a2fa1a0da027dc4"

URI_x86_64_v2_pcp-export-pcp2influxdb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2influxdb-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2influxdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2influxdb}"
SRC_URI[x86_64_v2_pcp-export-pcp2influxdb.sha256sum] = "6ebc6a06e3431cf7e11d5b796d8e7c3b98e71011520bd1d62dd01687385ba3ce"

URI_x86_64_v2_pcp-export-pcp2json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2json-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2json}"
SRC_URI[x86_64_v2_pcp-export-pcp2json.sha256sum] = "a6cd6ea726016c9e92187ce46fc1b5af0aa4bdc7dda674c4cc042e8d8cdb28aa"

URI_x86_64_v2_pcp-export-pcp2openmetrics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2openmetrics-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2openmetrics}"
SRC_URI[x86_64_v2_pcp-export-pcp2openmetrics.sha256sum] = "d9ede1a54ed7ce124fa822dbbac25b87549fbdfb702ed9e03d69089ddfe91420"

URI_x86_64_v2_pcp-export-pcp2spark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2spark-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2spark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2spark}"
SRC_URI[x86_64_v2_pcp-export-pcp2spark.sha256sum] = "f3f776847bfd8f2fbfaf88927eb9d1dce64059ccbe88b8839291cd78e215897a"

URI_x86_64_v2_pcp-export-pcp2xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2xml-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2xml}"
SRC_URI[x86_64_v2_pcp-export-pcp2xml.sha256sum] = "0c77d1cec5b53dc7b90cd633b5e06ca81deb1d74102013825442d02d8f5afb55"

URI_x86_64_v2_pcp-export-pcp2zabbix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-pcp2zabbix-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-export-pcp2zabbix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-pcp2zabbix}"
SRC_URI[x86_64_v2_pcp-export-pcp2zabbix.sha256sum] = "134ae5cf7c6b919156cc646a02f35b3a4a085993611e55638637d04b5354d086"

URI_x86_64_v2_pcp-export-zabbix-agent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-export-zabbix-agent-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-export-zabbix-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-export-zabbix-agent}"
SRC_URI[x86_64_v2_pcp-export-zabbix-agent.sha256sum] = "e3f8f1f70f980cf973abe00a0c2be44e16fba348e23a5d290557ab276cbb458b"

URI_x86_64_v2_pcp-geolocate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-geolocate-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-geolocate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-geolocate}"
SRC_URI[x86_64_v2_pcp-geolocate.sha256sum] = "0365d9fb2e47dbb99ba113a8003cddd4a323ad41dbe51334cad4933ea904d035"

URI_x86_64_v2_pcp-gui = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-gui-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-gui}"
SRC_URI[x86_64_v2_pcp-gui.sha256sum] = "145062f55fa758b703d70839e2ec3eda272071d54e60e1dfdf61657cf36e0680"

URI_x86_64_v2_pcp-import-collectl2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-collectl2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-import-collectl2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-collectl2pcp}"
SRC_URI[x86_64_v2_pcp-import-collectl2pcp.sha256sum] = "2a6a72b98a8827980b636f53f17f82638137b51f7c02e4639fd4c62f1f95211e"

URI_x86_64_v2_pcp-import-ganglia2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-ganglia2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-import-ganglia2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-ganglia2pcp}"
SRC_URI[x86_64_v2_pcp-import-ganglia2pcp.sha256sum] = "e0b6127d29d4a52a1cfb9deaa8a2041abec31a4fb9fbac4972f17b8f02d1cea5"

URI_x86_64_v2_pcp-import-iostat2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-iostat2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-import-iostat2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-iostat2pcp}"
SRC_URI[x86_64_v2_pcp-import-iostat2pcp.sha256sum] = "c9490598ac1027f737d25e7aa1f2dfcf7c75694164aacfe0a1e52320b2b92484"

URI_x86_64_v2_pcp-import-mrtg2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-mrtg2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-import-mrtg2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-mrtg2pcp}"
SRC_URI[x86_64_v2_pcp-import-mrtg2pcp.sha256sum] = "1060975159b851da8d01300895c8231d46739a0cf1382506d5f5b034e3e9755f"

URI_x86_64_v2_pcp-import-sar2pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-import-sar2pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-import-sar2pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-import-sar2pcp}"
SRC_URI[x86_64_v2_pcp-import-sar2pcp.sha256sum] = "293bc3384fb5d9ea18b7ebd8a98725a887c12e17c3f0f04a7a5a3275851545f8"

URI_x86_64_v2_pcp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-libs}"
SRC_URI[x86_64_v2_pcp-libs.sha256sum] = "65a52186703c3cc079fa92f191aa9773d8c5cb06ef3e77669fa3f34a6b7832a9"

URI_x86_64_v2_pcp-libs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-libs-devel-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-libs-devel}"
SRC_URI[x86_64_v2_pcp-libs-devel.sha256sum] = "dad15422fc5b399bf659efc09221ffc774da5d0ecd103a3c68a5479b21e5978c"

URI_x86_64_v2_pcp-pmda-activemq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-activemq-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-activemq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-activemq}"
SRC_URI[x86_64_v2_pcp-pmda-activemq.sha256sum] = "6436ac694f3844411c4876d9e73a2ad4ff4be44f5cd61b3fbc7d28ba86484c92"

URI_x86_64_v2_pcp-pmda-amdgpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-amdgpu-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-amdgpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-amdgpu}"
SRC_URI[x86_64_v2_pcp-pmda-amdgpu.sha256sum] = "bd3832cf49eec92a4371a270c5e36f56081005255a57ed5fd7bb998e6e33db0c"

URI_x86_64_v2_pcp-pmda-apache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-apache-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-apache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-apache}"
SRC_URI[x86_64_v2_pcp-pmda-apache.sha256sum] = "6b332ca6b8f9608833cdac5d3fc5c4a95b28dac7f7ccd1af1df4c0be2c6565ca"

URI_x86_64_v2_pcp-pmda-bash = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bash-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bash}"
SRC_URI[x86_64_v2_pcp-pmda-bash.sha256sum] = "f2b6bbbb1681821004c3f1e54af02e51833050eff202233373c869a17d709620"

URI_x86_64_v2_pcp-pmda-bcc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bcc-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bcc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bcc}"
SRC_URI[x86_64_v2_pcp-pmda-bcc.sha256sum] = "9b1ef0e3b0a40dc29ce0809532d5163fe6d50704422a49da5ad8cf890195e50a"

URI_x86_64_v2_pcp-pmda-bind2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bind2-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bind2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bind2}"
SRC_URI[x86_64_v2_pcp-pmda-bind2.sha256sum] = "ee19d06a93fa9d92dad5284af715007fd8c29b7904b54563d36b26cadbbbb4da"

URI_x86_64_v2_pcp-pmda-bonding = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bonding-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bonding;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bonding}"
SRC_URI[x86_64_v2_pcp-pmda-bonding.sha256sum] = "065a748f69cdb789beb5f1c327ac5a9ada710098a3f7278390afd015041f25c6"

URI_x86_64_v2_pcp-pmda-bpf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpf-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bpf}"
SRC_URI[x86_64_v2_pcp-pmda-bpf.sha256sum] = "a4df985bb6f09353c7e9f08733d831b0e8a3e16aec7c2f64f18466adf3baf6f1"

URI_x86_64_v2_pcp-pmda-bpftrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-bpftrace-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-bpftrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-bpftrace}"
SRC_URI[x86_64_v2_pcp-pmda-bpftrace.sha256sum] = "ab1d8023995a5214b60c4286ded66539cd54cd7525a2cbb8e2021fffadbfe7b3"

URI_x86_64_v2_pcp-pmda-cifs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cifs-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cifs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-cifs}"
SRC_URI[x86_64_v2_pcp-pmda-cifs.sha256sum] = "1da5af02cc52cbd2cd686ee2174154a0ede1e042668eafc3dbc04817e925b7fb"

URI_x86_64_v2_pcp-pmda-cisco = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-cisco-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-cisco;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-cisco}"
SRC_URI[x86_64_v2_pcp-pmda-cisco.sha256sum] = "8c1fc39926985f26c671af3c013ec92abb8f6c9150755e6ee02b08de25ab5a6b"

URI_x86_64_v2_pcp-pmda-dbping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dbping-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dbping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-dbping}"
SRC_URI[x86_64_v2_pcp-pmda-dbping.sha256sum] = "b0d92f19b5790c849236d0e6414b48ed07616430740d952b22213ff9a0e94d4f"

URI_x86_64_v2_pcp-pmda-denki = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-denki-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-denki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-denki}"
SRC_URI[x86_64_v2_pcp-pmda-denki.sha256sum] = "52e54253b0cd9ad003757cebeb564d649511ffca5d3712cba3193128679af8b7"

URI_x86_64_v2_pcp-pmda-dm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-dm-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-dm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-dm}"
SRC_URI[x86_64_v2_pcp-pmda-dm.sha256sum] = "2ec2ef966d6e8a67799224574e75d13b407f621c22595c89cc7e3894bd96bd41"

URI_x86_64_v2_pcp-pmda-docker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-docker-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-docker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-docker}"
SRC_URI[x86_64_v2_pcp-pmda-docker.sha256sum] = "3b22e43d6715812a87813bcecfaf50c53d524d77a7bce1e65737b8428a7ef12c"

URI_x86_64_v2_pcp-pmda-ds389 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-ds389}"
SRC_URI[x86_64_v2_pcp-pmda-ds389.sha256sum] = "676b3f872c0755a11056afdbad11ed17cc3ab2d7994bec7b245eb929b4ae9ddb"

URI_x86_64_v2_pcp-pmda-ds389log = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-ds389log-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-ds389log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-ds389log}"
SRC_URI[x86_64_v2_pcp-pmda-ds389log.sha256sum] = "bae43a7193c52f4478375d90d370e22544abed9bf64f8ef6111d601c46e7b95d"

URI_x86_64_v2_pcp-pmda-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-elasticsearch-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-elasticsearch}"
SRC_URI[x86_64_v2_pcp-pmda-elasticsearch.sha256sum] = "d5202495f026490472e4899b041734fcb5c7af09ddc60f2d0b79e5062cf8d4c7"

URI_x86_64_v2_pcp-pmda-farm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-farm-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-farm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-farm}"
SRC_URI[x86_64_v2_pcp-pmda-farm.sha256sum] = "a8bb5c401aa156bd5d59267c2151ee442e6e2dbe5856288a9ae48c718d0a1566"

URI_x86_64_v2_pcp-pmda-gluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gluster-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gluster}"
SRC_URI[x86_64_v2_pcp-pmda-gluster.sha256sum] = "edd15d42518c0b273cee1ac59407f9374b9cf3a130204c2e61d6b6c7b798c240"

URI_x86_64_v2_pcp-pmda-gpfs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpfs-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpfs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gpfs}"
SRC_URI[x86_64_v2_pcp-pmda-gpfs.sha256sum] = "6e6c82c2379c3743f65e74c626eca37c1e6f917b0112e7d00a2d76447799191e"

URI_x86_64_v2_pcp-pmda-gpsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-gpsd-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-gpsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-gpsd}"
SRC_URI[x86_64_v2_pcp-pmda-gpsd.sha256sum] = "2eb64135a11eda27fb339f298a922d0164bf66e5849e251b0ac5b93410f67310"

URI_x86_64_v2_pcp-pmda-hacluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-hacluster-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-hacluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-hacluster}"
SRC_URI[x86_64_v2_pcp-pmda-hacluster.sha256sum] = "d288d8b7d2abaa2430d7f92a888d19319bc8a526259d7b66201972759121ee77"

URI_x86_64_v2_pcp-pmda-haproxy = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-haproxy-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-haproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-haproxy}"
SRC_URI[x86_64_v2_pcp-pmda-haproxy.sha256sum] = "641c4d24fe37f6d25a3982c4f2b08fc277eb28d561054c6c6226b4eb752532ab"

URI_x86_64_v2_pcp-pmda-infiniband = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-infiniband-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-infiniband;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-infiniband}"
SRC_URI[x86_64_v2_pcp-pmda-infiniband.sha256sum] = "51d3900eb535bee89666f28130449e07430883c9ad48b79d26faa6f5c94aff00"

URI_x86_64_v2_pcp-pmda-json = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-json-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-json;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-json}"
SRC_URI[x86_64_v2_pcp-pmda-json.sha256sum] = "80a31f1e88248b47c56fc3ed205ddde147b9a8e9a43fd54592716c41f53efe9a"

URI_x86_64_v2_pcp-pmda-libvirt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-libvirt-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-libvirt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-libvirt}"
SRC_URI[x86_64_v2_pcp-pmda-libvirt.sha256sum] = "ef3f090b22e13892b27f7781e19c3044cc874d09ce0b7676c53abdf40260ad13"

URI_x86_64_v2_pcp-pmda-lio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lio-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lio}"
SRC_URI[x86_64_v2_pcp-pmda-lio.sha256sum] = "5e1a5e7019a9c17c6bdc56b7ca44e443e7c8408745f03168dd90b3f46d96528b"

URI_x86_64_v2_pcp-pmda-lmsensors = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lmsensors-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lmsensors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lmsensors}"
SRC_URI[x86_64_v2_pcp-pmda-lmsensors.sha256sum] = "da415937118575f92d312f7d7cd7691a0a65abac5e210a72f8b8e9afb973db50"

URI_x86_64_v2_pcp-pmda-logger = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-logger-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-logger;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-logger}"
SRC_URI[x86_64_v2_pcp-pmda-logger.sha256sum] = "57e5875be3c70a8f5b219a633ba12a7bf9fd2ab2f77b3a28b3c0bfbf9bc46c23"

URI_x86_64_v2_pcp-pmda-lustre = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustre-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustre;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lustre}"
SRC_URI[x86_64_v2_pcp-pmda-lustre.sha256sum] = "97c8939b62dd70be51f67da02d9fc6ab251fd908ea2cdfe9adfdac901b948b80"

URI_x86_64_v2_pcp-pmda-lustrecomm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-lustrecomm-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-lustrecomm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-lustrecomm}"
SRC_URI[x86_64_v2_pcp-pmda-lustrecomm.sha256sum] = "82aedbeb8edc4803e092bec9684131d7af6ce0bf08da14a15ea53b5783e808fb"

URI_x86_64_v2_pcp-pmda-mailq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mailq-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mailq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mailq}"
SRC_URI[x86_64_v2_pcp-pmda-mailq.sha256sum] = "49a254d95e4c30d8cd0b685c64b596fe2a4d15b4872e1caba72aa43c2883ec85"

URI_x86_64_v2_pcp-pmda-memcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-memcache-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-memcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-memcache}"
SRC_URI[x86_64_v2_pcp-pmda-memcache.sha256sum] = "276aa1797973a718e821bdaf9cc52432a2af0d0b23d158692b98606e630f0da7"

URI_x86_64_v2_pcp-pmda-mic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mic-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mic}"
SRC_URI[x86_64_v2_pcp-pmda-mic.sha256sum] = "3d72dba9dae12676633d77eed4f385e5725dd15419ceed843ae4a04670a8c178"

URI_x86_64_v2_pcp-pmda-mongodb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mongodb-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mongodb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mongodb}"
SRC_URI[x86_64_v2_pcp-pmda-mongodb.sha256sum] = "d5f89c3300869313ee09895c5e42886c1b1d3acc2f59b17826b26c46631f3449"

URI_x86_64_v2_pcp-pmda-mounts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mounts-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mounts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mounts}"
SRC_URI[x86_64_v2_pcp-pmda-mounts.sha256sum] = "1d6fcc7e0f58d4c88abc21c068c21a6836f9c04ee47095bd5ed273d6ad665114"

URI_x86_64_v2_pcp-pmda-mssql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mssql-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mssql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mssql}"
SRC_URI[x86_64_v2_pcp-pmda-mssql.sha256sum] = "2fa1a74c0e2f31ec3956e1ab787ac01d681f4351c64fd04f5db26bb588b38551"

URI_x86_64_v2_pcp-pmda-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-mysql-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-mysql}"
SRC_URI[x86_64_v2_pcp-pmda-mysql.sha256sum] = "d035cb9d359ed9f08d1e57e7ab35806aabde7218d7310018caac4742966b4072"

URI_x86_64_v2_pcp-pmda-named = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-named-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-named;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-named}"
SRC_URI[x86_64_v2_pcp-pmda-named.sha256sum] = "4db7ad3a8da6b284a9be8c4217a469d538bf733fcfc9eb7720c33c442c24c60c"

URI_x86_64_v2_pcp-pmda-netcheck = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netcheck-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-netcheck}"
SRC_URI[x86_64_v2_pcp-pmda-netcheck.sha256sum] = "4d870f3ce587017432f95e90a16957548c098f108bcdd7de6a038244c47d5c98"

URI_x86_64_v2_pcp-pmda-netfilter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-netfilter-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-netfilter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-netfilter}"
SRC_URI[x86_64_v2_pcp-pmda-netfilter.sha256sum] = "5bd7a385fa96b27792f3014a1c2cc04b0190ca8690749a2cede7a40296838120"

URI_x86_64_v2_pcp-pmda-news = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-news-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-news;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-news}"
SRC_URI[x86_64_v2_pcp-pmda-news.sha256sum] = "3a7f0d7a765329ff8512dc2d11831d8d9f1f0c49c6ef5bfe72fd8c13ec865c2f"

URI_x86_64_v2_pcp-pmda-nfsclient = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nfsclient-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nfsclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nfsclient}"
SRC_URI[x86_64_v2_pcp-pmda-nfsclient.sha256sum] = "095d861800b846d36f36b6d70c539571fb8d7d8ff5bb1ff970b5c433d3614e69"

URI_x86_64_v2_pcp-pmda-nginx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nginx-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nginx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nginx}"
SRC_URI[x86_64_v2_pcp-pmda-nginx.sha256sum] = "2f72362a20e8c75735e449a7e05707e0b9401707e4e13a46dd9c48eda0d89e95"

URI_x86_64_v2_pcp-pmda-nvidia-gpu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-nvidia-gpu-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-nvidia-gpu}"
SRC_URI[x86_64_v2_pcp-pmda-nvidia-gpu.sha256sum] = "9a9df5273411fc7c18bccc9acb2e47a7e6d5d8b892363d2ccf1b935f8ee623c9"

URI_x86_64_v2_pcp-pmda-openmetrics = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openmetrics-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openmetrics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-openmetrics}"
SRC_URI[x86_64_v2_pcp-pmda-openmetrics.sha256sum] = "d46a110f2972d1c05b5d4903680734ad96a73073048ee430c88754c585b52301"

URI_x86_64_v2_pcp-pmda-openvswitch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-openvswitch-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-openvswitch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-openvswitch}"
SRC_URI[x86_64_v2_pcp-pmda-openvswitch.sha256sum] = "1cffa3d23ff24024c18c61fd798b3db897e29325d94ab35ff2882f9ebf234d46"

URI_x86_64_v2_pcp-pmda-oracle = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-oracle-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-oracle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-oracle}"
SRC_URI[x86_64_v2_pcp-pmda-oracle.sha256sum] = "09e8cc41b7fb086f69e467dcd1af3ccb90416ffe8d22fe1388f872954a9c1169"

URI_x86_64_v2_pcp-pmda-pdns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-pdns-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-pdns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-pdns}"
SRC_URI[x86_64_v2_pcp-pmda-pdns.sha256sum] = "e8f033106638950b14b031c847b924676113716d5476c4c2c8cc0b5c306433c9"

URI_x86_64_v2_pcp-pmda-perfevent = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-perfevent-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-perfevent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-perfevent}"
SRC_URI[x86_64_v2_pcp-pmda-perfevent.sha256sum] = "1688cb0e48228d2c089c850216c1a7b55a902fee8c1158f4ee0b6ac89433277c"

URI_x86_64_v2_pcp-pmda-podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-podman-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-podman}"
SRC_URI[x86_64_v2_pcp-pmda-podman.sha256sum] = "06d5cbda8794a99092d16b2b511d2431f67dd345a7df21ab6078144e17a1a6c3"

URI_x86_64_v2_pcp-pmda-postfix = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postfix-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postfix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-postfix}"
SRC_URI[x86_64_v2_pcp-pmda-postfix.sha256sum] = "e1642e40588d0aa533389d710225f175e8423304e3722330fa7de4d5c26649ad"

URI_x86_64_v2_pcp-pmda-postgresql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-postgresql-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-postgresql}"
SRC_URI[x86_64_v2_pcp-pmda-postgresql.sha256sum] = "77a167b29939bcf59338e3cf366a64c4d257c21636a8a4551d1b5e0486ee1a4a"

URI_x86_64_v2_pcp-pmda-rabbitmq = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rabbitmq-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rabbitmq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rabbitmq}"
SRC_URI[x86_64_v2_pcp-pmda-rabbitmq.sha256sum] = "27d94418e237ce8f64ff0b8264f3c3b80663520bd1fc6699f4d4b959ffdaa123"

URI_x86_64_v2_pcp-pmda-redis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-redis-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-redis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-redis}"
SRC_URI[x86_64_v2_pcp-pmda-redis.sha256sum] = "e87f6fbeda46d937d60f05fe6f19b4e9a560e6a8ee1143b05a274f71f0d9e2ac"

URI_x86_64_v2_pcp-pmda-resctrl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-resctrl-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-resctrl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-resctrl}"
SRC_URI[x86_64_v2_pcp-pmda-resctrl.sha256sum] = "921480039dba5e1b7fd87d5592329471dab2e040892622e0473f5e2ed35ddda6"

URI_x86_64_v2_pcp-pmda-roomtemp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-roomtemp-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-roomtemp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-roomtemp}"
SRC_URI[x86_64_v2_pcp-pmda-roomtemp.sha256sum] = "f9b8e29584289aa3e84fcb91d27c1482e6d041ce8946d9f962335f33d9d0fa94"

URI_x86_64_v2_pcp-pmda-rsyslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-rsyslog-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-rsyslog}"
SRC_URI[x86_64_v2_pcp-pmda-rsyslog.sha256sum] = "0e7607601b055f3f56449a18214e27e1f86e94fe5c9b5ad2a4f522a619473c75"

URI_x86_64_v2_pcp-pmda-samba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-samba-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-samba}"
SRC_URI[x86_64_v2_pcp-pmda-samba.sha256sum] = "13716b9e98a25415d5c4e1aa5ff3faefa9d972c24729882ad14df43e63f877e8"

URI_x86_64_v2_pcp-pmda-sendmail = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sendmail-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sendmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-sendmail}"
SRC_URI[x86_64_v2_pcp-pmda-sendmail.sha256sum] = "7c09c9cd9b273c8c0813a4acf69585f48bf910fdb40b9755b28e00afdcaf3f67"

URI_x86_64_v2_pcp-pmda-shping = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-shping-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-shping;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-shping}"
SRC_URI[x86_64_v2_pcp-pmda-shping.sha256sum] = "c85a11ddd95bfb3218a5de5b99d0cf662a43cd1df2e6a7a64c05af0bd1b06640"

URI_x86_64_v2_pcp-pmda-slurm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-slurm-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-slurm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-slurm}"
SRC_URI[x86_64_v2_pcp-pmda-slurm.sha256sum] = "b5e36f7b15acdd8bd160db27ee98c2b9728249f9e8f2414a5964dd1b4f89ab3b"

URI_x86_64_v2_pcp-pmda-smart = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-smart-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-smart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-smart}"
SRC_URI[x86_64_v2_pcp-pmda-smart.sha256sum] = "62b71ddc5e69d1e290c74683816394d1812d2adc41c51992515685a2f0818ce6"

URI_x86_64_v2_pcp-pmda-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-snmp-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-snmp}"
SRC_URI[x86_64_v2_pcp-pmda-snmp.sha256sum] = "b2ad4d690fbe2fa382920b17078181846ed97a488daebdc872da42940d5be7f1"

URI_x86_64_v2_pcp-pmda-sockets = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-sockets-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-sockets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-sockets}"
SRC_URI[x86_64_v2_pcp-pmda-sockets.sha256sum] = "b51df22ceaebe1a3a39ebdc7a53e6efb8cd1113244829026ec01d084753cdd69"

URI_x86_64_v2_pcp-pmda-statsd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-statsd-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-statsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-statsd}"
SRC_URI[x86_64_v2_pcp-pmda-statsd.sha256sum] = "afb16946851a079dcf5f111a1047d06b42b14fb8806abc2c6519a1d5f92bb9e4"

URI_x86_64_v2_pcp-pmda-summary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-summary-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-summary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-summary}"
SRC_URI[x86_64_v2_pcp-pmda-summary.sha256sum] = "90e3c6d29e113a6b97dbbef070054078418cb98290b353daa9aeeae812133122"

URI_x86_64_v2_pcp-pmda-systemd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-systemd-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-systemd}"
SRC_URI[x86_64_v2_pcp-pmda-systemd.sha256sum] = "2781d8fff6650b22a875ba2912533dd44d739f315973cdce205bfd3182117cf2"

URI_x86_64_v2_pcp-pmda-trace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-trace-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-trace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-trace}"
SRC_URI[x86_64_v2_pcp-pmda-trace.sha256sum] = "d92f445fa376c4417f085f1239e79e5d7427b7fc498dd8f8455e5d8577f21e27"

URI_x86_64_v2_pcp-pmda-unbound = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-unbound-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-unbound;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-unbound}"
SRC_URI[x86_64_v2_pcp-pmda-unbound.sha256sum] = "148537e49897b5f48ef1dc42edbc1101b7feea5aaba4c257645237bb99aad433"

URI_x86_64_v2_pcp-pmda-uwsgi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-uwsgi-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-uwsgi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-uwsgi}"
SRC_URI[x86_64_v2_pcp-pmda-uwsgi.sha256sum] = "d8169302092610006677a0a710e2fb98d8903f3b52b496425b31811c1406ce50"

URI_x86_64_v2_pcp-pmda-weblog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-weblog-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-weblog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-weblog}"
SRC_URI[x86_64_v2_pcp-pmda-weblog.sha256sum] = "72618b55e68c75b4bac9f1e56a9e92aa56cb6b557d0d147f0351b646d327b797"

URI_x86_64_v2_pcp-pmda-zimbra = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zimbra-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zimbra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-zimbra}"
SRC_URI[x86_64_v2_pcp-pmda-zimbra.sha256sum] = "a0bfee914e2d9922d0982a6526cfc455a3cd4de27d2c4748652b547d5c691e61"

URI_x86_64_v2_pcp-pmda-zswap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-pmda-zswap-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-pmda-zswap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-pmda-zswap}"
SRC_URI[x86_64_v2_pcp-pmda-zswap.sha256sum] = "8dff4e26d0823e6d629e47bbb44ae6ca2eca0b4e7e15c885a9285fabc55d8004"

URI_x86_64_v2_pcp-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-selinux-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-selinux}"
SRC_URI[x86_64_v2_pcp-selinux.sha256sum] = "ecbb272b7356e47616e34adef4889020d979b9000fc7601f1327f4434bb197f2"

URI_x86_64_v2_pcp-system-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-system-tools-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-system-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-system-tools}"
SRC_URI[x86_64_v2_pcp-system-tools.sha256sum] = "0b83d3b71d67ce64e30806cfe4970d4b8ca5cb6536b9182c985c20124818c190"

URI_x86_64_v2_pcp-testsuite = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/pcp-testsuite-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-testsuite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-testsuite}"
SRC_URI[x86_64_v2_pcp-testsuite.sha256sum] = "23ae5deac6d22e873fd67700293017e36888d886f0ba36adc471a70a54d9c670"

URI_x86_64_v2_pcp-zeroconf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pcp-zeroconf-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_pcp-zeroconf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pcp-zeroconf}"
SRC_URI[x86_64_v2_pcp-zeroconf.sha256sum] = "4e1daa841168ee471b5c2ebb15646ba75211bf5a496729d440523f55fdf59c13"

URI_x86_64_v2_perl-PCP-LogImport = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogImport-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogImport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-LogImport}"
SRC_URI[x86_64_v2_perl-PCP-LogImport.sha256sum] = "298acdde9c22da03e7f9dc6599c6cb82f17887ac790254edd28f93bde7509d62"

URI_x86_64_v2_perl-PCP-LogSummary = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-LogSummary-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-LogSummary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-LogSummary}"
SRC_URI[x86_64_v2_perl-PCP-LogSummary.sha256sum] = "6fbc36c4dc735facbe590aa97f24a61b962787a9cf4798c0c415635065fe3600"

URI_x86_64_v2_perl-PCP-MMV = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-MMV-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-MMV;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-MMV}"
SRC_URI[x86_64_v2_perl-PCP-MMV.sha256sum] = "33b14248c323eb1987a87bc6d9159fb76cd4ae6f8af6fcdbd2dd5f8fb9a739a8"

URI_x86_64_v2_perl-PCP-PMDA = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-PCP-PMDA-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_perl-PCP-PMDA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-PCP-PMDA}"
SRC_URI[x86_64_v2_perl-PCP-PMDA.sha256sum] = "c4c82b716f4f1bc204b3c860788174855069f2949b52ec6ecfbf8fa73b416b20"

URI_x86_64_v2_python3-pcp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pcp-6.3.7-1.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-pcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pcp}"
SRC_URI[x86_64_v2_python3-pcp.sha256sum] = "9e65beffa6805ef67c0fb9ff2bafaa4d21f23bd34efddda2f96f9563bc7adec6"

URI_aarch64_pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp}"
SRC_URI[aarch64_pcp.sha256sum] = "30a2639e4ad0f5366af2aab87eb9a623cdedf2c06e9c887787504b89022bded1"

URI_aarch64_pcp-conf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-conf-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-conf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-conf}"
SRC_URI[aarch64_pcp-conf.sha256sum] = "9d1e7719430de4b966498330f52a2934b27ecd9c36d75c637a8b9f62a7fb0213"

URI_aarch64_pcp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-devel-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-devel}"
SRC_URI[aarch64_pcp-devel.sha256sum] = "ea88eccf2164c84a7acc0febcc39a7342e664471cfde8525232d72e0986adab9"

URI_aarch64_pcp-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-doc-6.3.7-1.el10_0.noarch.rpm;name=aarch64_pcp-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-doc}"
SRC_URI[aarch64_pcp-doc.sha256sum] = "12cdce38c917eee9ec6e11afb47e99e99786c0232ffa327a8c23e5cb94448b36"

URI_aarch64_pcp-export-pcp2elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2elasticsearch-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-export-pcp2elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2elasticsearch}"
SRC_URI[aarch64_pcp-export-pcp2elasticsearch.sha256sum] = "eb2933f4779bfdb198bf646365b1c2c174d5b09351f4a7951a6f0a238c866907"

URI_aarch64_pcp-export-pcp2graphite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2graphite-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-export-pcp2graphite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2graphite}"
SRC_URI[aarch64_pcp-export-pcp2graphite.sha256sum] = "7523ec7f4106e6580e052ea358c1b1abe2854668595ade2d206fd251245e62a7"

URI_aarch64_pcp-export-pcp2influxdb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2influxdb-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-export-pcp2influxdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2influxdb}"
SRC_URI[aarch64_pcp-export-pcp2influxdb.sha256sum] = "7ec9240d29cdb7cf999ac687302b0ab2998affe81a473bfe5e699cd29ec81d7b"

URI_aarch64_pcp-export-pcp2json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2json-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-export-pcp2json;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2json}"
SRC_URI[aarch64_pcp-export-pcp2json.sha256sum] = "bfb40bd5589f80fbe5aef5ba758796676cb0e057ac63532342c94173fd903751"

URI_aarch64_pcp-export-pcp2openmetrics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2openmetrics-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-export-pcp2openmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2openmetrics}"
SRC_URI[aarch64_pcp-export-pcp2openmetrics.sha256sum] = "a1022d870a802c37d88c01e0823788b9728b8d8111bb4c167e26453311c05c1a"

URI_aarch64_pcp-export-pcp2spark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2spark-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-export-pcp2spark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2spark}"
SRC_URI[aarch64_pcp-export-pcp2spark.sha256sum] = "d384af2c8845edd497673fb66fa6770e202476b66f4646c1d08ef23962e4322e"

URI_aarch64_pcp-export-pcp2xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2xml-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-export-pcp2xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2xml}"
SRC_URI[aarch64_pcp-export-pcp2xml.sha256sum] = "88ca257e1758b0a934a0bb32f0f8b012093407ce159722fd27d26f3e22b9e2be"

URI_aarch64_pcp-export-pcp2zabbix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-pcp2zabbix-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-export-pcp2zabbix;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-pcp2zabbix}"
SRC_URI[aarch64_pcp-export-pcp2zabbix.sha256sum] = "50017f25bba45795ca6e9e00fd10e24632c31563a4d0334d4f31ca92f3bf7a85"

URI_aarch64_pcp-export-zabbix-agent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-export-zabbix-agent-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-export-zabbix-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-export-zabbix-agent}"
SRC_URI[aarch64_pcp-export-zabbix-agent.sha256sum] = "bf7940e1db252552c7d2c4918a8b266bef5d280b0e0bc21a2ca5d8d530630a08"

URI_aarch64_pcp-geolocate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-geolocate-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-geolocate;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-geolocate}"
SRC_URI[aarch64_pcp-geolocate.sha256sum] = "6fe97c897b180f8cd6853f9898c2b1970adee1886c34327bcb4acab8c9078609"

URI_aarch64_pcp-gui = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-gui-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-gui}"
SRC_URI[aarch64_pcp-gui.sha256sum] = "d3ab4db91e364ccc6ba3a45ae13f250cdbe39c5445f29b7c647b82bd92c7acf3"

URI_aarch64_pcp-import-collectl2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-collectl2pcp-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-import-collectl2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-collectl2pcp}"
SRC_URI[aarch64_pcp-import-collectl2pcp.sha256sum] = "5175d37007c7d1bff2c632f8f3d910940498c5ea49605f3dc21e4db31cd6954e"

URI_aarch64_pcp-import-ganglia2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-ganglia2pcp-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-import-ganglia2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-ganglia2pcp}"
SRC_URI[aarch64_pcp-import-ganglia2pcp.sha256sum] = "b303c9ac82c456bef63399ea81c27048ecc1705482d1d6584c3d97d18c3c3082"

URI_aarch64_pcp-import-iostat2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-iostat2pcp-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-import-iostat2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-iostat2pcp}"
SRC_URI[aarch64_pcp-import-iostat2pcp.sha256sum] = "5adf3284bd6c762f136850b09cf0044f7e3306b3087f79b208086971333aa9ad"

URI_aarch64_pcp-import-mrtg2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-mrtg2pcp-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-import-mrtg2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-mrtg2pcp}"
SRC_URI[aarch64_pcp-import-mrtg2pcp.sha256sum] = "66407b44d70aa0675b45b5c052d6ada44b61f96c63e3b37dc8e5daa9647e97e4"

URI_aarch64_pcp-import-sar2pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-import-sar2pcp-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-import-sar2pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-import-sar2pcp}"
SRC_URI[aarch64_pcp-import-sar2pcp.sha256sum] = "f3931c479eea0fe64d15705532e43125808dd3de1faa9196a84b1b5da82ef6ce"

URI_aarch64_pcp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-libs}"
SRC_URI[aarch64_pcp-libs.sha256sum] = "7b77e2249ca99d684f2d077da46d9ff1158453bdf5ab0765112e16245c91ee43"

URI_aarch64_pcp-libs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-libs-devel-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-libs-devel}"
SRC_URI[aarch64_pcp-libs-devel.sha256sum] = "f8dd0161fed7e65eddc1b8337cf374972b45682cf913b84b3960acd2f35449cd"

URI_aarch64_pcp-pmda-activemq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-activemq-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-activemq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-activemq}"
SRC_URI[aarch64_pcp-pmda-activemq.sha256sum] = "4e03d84a707fe8f85868373df6ed0842f045320e02eb6a091a08166a94185108"

URI_aarch64_pcp-pmda-amdgpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-amdgpu-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-amdgpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-amdgpu}"
SRC_URI[aarch64_pcp-pmda-amdgpu.sha256sum] = "b3739e5f2ece0f8314b315a3570b20a2a5ee98c006f1e88006d981ed85618d12"

URI_aarch64_pcp-pmda-apache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-apache-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-apache;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-apache}"
SRC_URI[aarch64_pcp-pmda-apache.sha256sum] = "925f5d6d137db1424e3b766aa74d0a844410e89f5c0e419df0d40901c58d8170"

URI_aarch64_pcp-pmda-bash = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bash-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-bash;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bash}"
SRC_URI[aarch64_pcp-pmda-bash.sha256sum] = "400a36cd178b2e9e22a08839eb2a5f621b4c5cf048bd22c27380d4c193889843"

URI_aarch64_pcp-pmda-bcc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bcc-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-bcc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bcc}"
SRC_URI[aarch64_pcp-pmda-bcc.sha256sum] = "9b533250b9f4c6dee1ac7146ecb0085ec33d27b9fc9d075ada6b07e7971dd0d5"

URI_aarch64_pcp-pmda-bind2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bind2-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-bind2;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bind2}"
SRC_URI[aarch64_pcp-pmda-bind2.sha256sum] = "3a0600177f82a5d8f5db911a4e101ab3742efaad1c1c452ac725a3cca11baab9"

URI_aarch64_pcp-pmda-bonding = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bonding-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-bonding;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bonding}"
SRC_URI[aarch64_pcp-pmda-bonding.sha256sum] = "8330ad5592f5eb4f0b5e014b58037f6808c3f6f9bb84663f4c43acbd7fde409d"

URI_aarch64_pcp-pmda-bpf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpf-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-bpf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bpf}"
SRC_URI[aarch64_pcp-pmda-bpf.sha256sum] = "6bcdeea27cb6bc475d94a69bdaf84379712308ddf650096eeea04f024499daa2"

URI_aarch64_pcp-pmda-bpftrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-bpftrace-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-bpftrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-bpftrace}"
SRC_URI[aarch64_pcp-pmda-bpftrace.sha256sum] = "e361c7f140b3f4cbd8ceba442e50512a9179bc64a1ffbb5c7bb0d48258299a65"

URI_aarch64_pcp-pmda-cifs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cifs-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-cifs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-cifs}"
SRC_URI[aarch64_pcp-pmda-cifs.sha256sum] = "96f5f4597ccbdba178e331792e69018c3320004fe8e3e958caa750ad82397ebc"

URI_aarch64_pcp-pmda-cisco = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-cisco-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-cisco;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-cisco}"
SRC_URI[aarch64_pcp-pmda-cisco.sha256sum] = "2415e6b741d397d8473cb1f17a9b2d66fb2c8cd206cd9564daf7e93221a7fb58"

URI_aarch64_pcp-pmda-dbping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dbping-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-dbping;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-dbping}"
SRC_URI[aarch64_pcp-pmda-dbping.sha256sum] = "a31d61c1f46592697b4a9b47861030b07271eb836ac6e75fdc08b2035727b806"

URI_aarch64_pcp-pmda-denki = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-denki-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-denki;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-denki}"
SRC_URI[aarch64_pcp-pmda-denki.sha256sum] = "fe191617cf1bf8438c52b1a974bbd1a32366743cfbd4d2942f121388b45702c1"

URI_aarch64_pcp-pmda-dm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-dm-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-dm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-dm}"
SRC_URI[aarch64_pcp-pmda-dm.sha256sum] = "8635ec473fc1f9de4f739ae3719f5ba987b76ecd85584d6389590027cfee8744"

URI_aarch64_pcp-pmda-docker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-docker-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-docker;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-docker}"
SRC_URI[aarch64_pcp-pmda-docker.sha256sum] = "db15001eec5119564a3459a410567598a9875c3b5710288e631ac03e5a4420e5"

URI_aarch64_pcp-pmda-ds389 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-ds389;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-ds389}"
SRC_URI[aarch64_pcp-pmda-ds389.sha256sum] = "4dfb1ce9ec4228083743beb37b5f0d26dc4f7b35e2593fa007632ac4bf1e6b55"

URI_aarch64_pcp-pmda-ds389log = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-ds389log-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-ds389log;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-ds389log}"
SRC_URI[aarch64_pcp-pmda-ds389log.sha256sum] = "3052b7d492794e0656ce66633c02f2647acfebc36b43741f5fa49083fc75193a"

URI_aarch64_pcp-pmda-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-elasticsearch-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-elasticsearch}"
SRC_URI[aarch64_pcp-pmda-elasticsearch.sha256sum] = "784a3dc87be8fa7d2a0b564bb38167ed7257cc0f2b8ec687b33c962e17640b8f"

URI_aarch64_pcp-pmda-farm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-farm-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-farm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-farm}"
SRC_URI[aarch64_pcp-pmda-farm.sha256sum] = "50cfea5936fc827eb7b9852bcd0870e65f07bfa5dc58046df69bc5c6b6514900"

URI_aarch64_pcp-pmda-gluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gluster-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-gluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gluster}"
SRC_URI[aarch64_pcp-pmda-gluster.sha256sum] = "969218a3781cfac65619f3ea9a27d820c46d8f132a92ace2ce60a523b29d8166"

URI_aarch64_pcp-pmda-gpfs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpfs-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-gpfs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gpfs}"
SRC_URI[aarch64_pcp-pmda-gpfs.sha256sum] = "7d725228170b6add506438d818830da163c1a9e46ca67831cb46ea2637b5046e"

URI_aarch64_pcp-pmda-gpsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-gpsd-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-gpsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-gpsd}"
SRC_URI[aarch64_pcp-pmda-gpsd.sha256sum] = "adb7ce17d65dae082c153f1a0f26672a16e19ac3ab14b41dd0e35df0c8075717"

URI_aarch64_pcp-pmda-hacluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-hacluster-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-hacluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-hacluster}"
SRC_URI[aarch64_pcp-pmda-hacluster.sha256sum] = "c086262a1ca9167065d8047b52479177eebea44a929b56a697731106ed183459"

URI_aarch64_pcp-pmda-haproxy = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-haproxy-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-haproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-haproxy}"
SRC_URI[aarch64_pcp-pmda-haproxy.sha256sum] = "eb62fe20f64db916f534ed6530a96a3f86c96d284a69aacb5ad620fa1439b67a"

URI_aarch64_pcp-pmda-infiniband = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-infiniband-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-infiniband;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-infiniband}"
SRC_URI[aarch64_pcp-pmda-infiniband.sha256sum] = "067f6bbc3a4432d4fe839e5db6d7c94a1cea197c995467406f0a73c0f790f111"

URI_aarch64_pcp-pmda-json = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-json-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-json;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-json}"
SRC_URI[aarch64_pcp-pmda-json.sha256sum] = "b255b3fa1207e4531ffc6806d324e335f37bb02702afe4079eb62c8c30a5ff77"

URI_aarch64_pcp-pmda-libvirt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-libvirt-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-libvirt;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-libvirt}"
SRC_URI[aarch64_pcp-pmda-libvirt.sha256sum] = "15f97886f0f648f76c495c3876168ef2786f0074083a5f8fc313ed45da4d4ef4"

URI_aarch64_pcp-pmda-lio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lio-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-lio;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lio}"
SRC_URI[aarch64_pcp-pmda-lio.sha256sum] = "188e99288bd30acdde1653a0ab4482432ee6288cb8fdc62a3db75dbc69b5c794"

URI_aarch64_pcp-pmda-lmsensors = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lmsensors-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-lmsensors;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lmsensors}"
SRC_URI[aarch64_pcp-pmda-lmsensors.sha256sum] = "cf40f24172d759963ea913277f1943bbd93bed362b2a2d2c72b78983846e3859"

URI_aarch64_pcp-pmda-logger = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-logger-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-logger;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-logger}"
SRC_URI[aarch64_pcp-pmda-logger.sha256sum] = "71826d5ae0bacea32ec58e0915b6ae28dd8174125400ac6e63d418b405aaad16"

URI_aarch64_pcp-pmda-lustre = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustre-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-lustre;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lustre}"
SRC_URI[aarch64_pcp-pmda-lustre.sha256sum] = "ea3b504b7cf24da744c1c99c2839ec4590591a99da92e7cd3c51b9d5bdbde2a6"

URI_aarch64_pcp-pmda-lustrecomm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-lustrecomm-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-lustrecomm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-lustrecomm}"
SRC_URI[aarch64_pcp-pmda-lustrecomm.sha256sum] = "064f36e7ee46e1da2e18502dfb259b4938b1bfa1c2f8597bc83b835aa994a947"

URI_aarch64_pcp-pmda-mailq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mailq-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-mailq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mailq}"
SRC_URI[aarch64_pcp-pmda-mailq.sha256sum] = "1ac839a3987ddc730900610e6c42c830268d97257723b13e5e606df06560c876"

URI_aarch64_pcp-pmda-memcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-memcache-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-memcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-memcache}"
SRC_URI[aarch64_pcp-pmda-memcache.sha256sum] = "a79f66e414c96209e930d1de214a7262c0d13873ec3bea40dc9e6b823fb123e6"

URI_aarch64_pcp-pmda-mic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mic-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-mic;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mic}"
SRC_URI[aarch64_pcp-pmda-mic.sha256sum] = "76383e69b64dda4bd7f3b7a131b039a5996497ce72a159a8637fd17334abe565"

URI_aarch64_pcp-pmda-mongodb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mongodb-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-mongodb;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mongodb}"
SRC_URI[aarch64_pcp-pmda-mongodb.sha256sum] = "6c842649f2f48444bfe52099254de9588847dbe974a514af9dd07bee5f26a79f"

URI_aarch64_pcp-pmda-mounts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mounts-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-mounts;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mounts}"
SRC_URI[aarch64_pcp-pmda-mounts.sha256sum] = "f320dc7f49247ca62db771d3b5e548fc82b81cba1fa37d436d4cc08003b331ca"

URI_aarch64_pcp-pmda-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-mysql-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-mysql}"
SRC_URI[aarch64_pcp-pmda-mysql.sha256sum] = "86636e04f02265f72540241496d26e29dd6edf1b70f682a11a24e78ccbff179a"

URI_aarch64_pcp-pmda-named = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-named-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-named;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-named}"
SRC_URI[aarch64_pcp-pmda-named.sha256sum] = "227d7e90867058e0f4aca5fe9f51aa78d6d95fdcb2cfa65988233bccabee51d8"

URI_aarch64_pcp-pmda-netcheck = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netcheck-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-netcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-netcheck}"
SRC_URI[aarch64_pcp-pmda-netcheck.sha256sum] = "da2fde6cf71926d5f1a063ff86ec597784d9025bf11a2f9b8eb45887db08e9d6"

URI_aarch64_pcp-pmda-netfilter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-netfilter-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-netfilter;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-netfilter}"
SRC_URI[aarch64_pcp-pmda-netfilter.sha256sum] = "63a39968424cc58fde601cee1f2d5d7b29d7e8dab43592cb3f1c4e8604cd4a9d"

URI_aarch64_pcp-pmda-news = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-news-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-news;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-news}"
SRC_URI[aarch64_pcp-pmda-news.sha256sum] = "e581e1bf1eaab5ebb034f7a25705bb743cccb75ef4c5f1d7c646dbbc8a6268d8"

URI_aarch64_pcp-pmda-nfsclient = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nfsclient-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-nfsclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nfsclient}"
SRC_URI[aarch64_pcp-pmda-nfsclient.sha256sum] = "c804101b0eaad0c6f63ab05eea3016d1f824a5e16fab268cf89a1ea3419c0c0e"

URI_aarch64_pcp-pmda-nginx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nginx-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-nginx;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nginx}"
SRC_URI[aarch64_pcp-pmda-nginx.sha256sum] = "378bcbfe1d0a2f38b733b2b067cea97d3b274f53171eb2056a10856eee5a10c7"

URI_aarch64_pcp-pmda-nvidia-gpu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-nvidia-gpu-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-nvidia-gpu;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-nvidia-gpu}"
SRC_URI[aarch64_pcp-pmda-nvidia-gpu.sha256sum] = "6ac26cff1ca786134a8285c35384356b20da45a5bbd4ccdb4bbe1c4f8e81467a"

URI_aarch64_pcp-pmda-openmetrics = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openmetrics-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-openmetrics;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-openmetrics}"
SRC_URI[aarch64_pcp-pmda-openmetrics.sha256sum] = "d445abe6322ebe547a262e442eec1beee5e787b1a622d44722b624a8c2ec2759"

URI_aarch64_pcp-pmda-openvswitch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-openvswitch-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-openvswitch;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-openvswitch}"
SRC_URI[aarch64_pcp-pmda-openvswitch.sha256sum] = "1111d71b801453f6ac97c03fb11f4360e1f352fd073c884dd2127677baa4a127"

URI_aarch64_pcp-pmda-oracle = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-oracle-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-oracle;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-oracle}"
SRC_URI[aarch64_pcp-pmda-oracle.sha256sum] = "e88c747a4227f42f03c3d41058d130047bb9e4a8c85ba2fc26311606a0e3aa14"

URI_aarch64_pcp-pmda-pdns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-pdns-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-pdns;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-pdns}"
SRC_URI[aarch64_pcp-pmda-pdns.sha256sum] = "53711e5ff8ccbaf8a09e2487affcc34019a5746812429be509362b0f668d0fa5"

URI_aarch64_pcp-pmda-perfevent = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-perfevent-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-perfevent;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-perfevent}"
SRC_URI[aarch64_pcp-pmda-perfevent.sha256sum] = "a25ea5408304436d9d1164cdefad877452cf6e37562ba93f000f8520284314d7"

URI_aarch64_pcp-pmda-podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-podman-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-podman}"
SRC_URI[aarch64_pcp-pmda-podman.sha256sum] = "b18d230e5d3d838f4d63534e2cab4d14ac387e55601b6a647ae021c66101313e"

URI_aarch64_pcp-pmda-postfix = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postfix-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-postfix;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-postfix}"
SRC_URI[aarch64_pcp-pmda-postfix.sha256sum] = "d6488c226afca0cb61c87d6728ccfe4e5affe391ede853e8354dd821b969cc72"

URI_aarch64_pcp-pmda-postgresql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-postgresql-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-postgresql}"
SRC_URI[aarch64_pcp-pmda-postgresql.sha256sum] = "00105c90ef521cd4c7c95464137acc39e8cd43f906c9e388e58b8bde89ddb72f"

URI_aarch64_pcp-pmda-rabbitmq = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rabbitmq-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-rabbitmq;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rabbitmq}"
SRC_URI[aarch64_pcp-pmda-rabbitmq.sha256sum] = "7182883c1c5fc70dc1b8c85e099e0b1bb9b0ba1eea196797d2dd761ea797667d"

URI_aarch64_pcp-pmda-redis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-redis-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-redis;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-redis}"
SRC_URI[aarch64_pcp-pmda-redis.sha256sum] = "44b1cc873fc523df6f6d242268140a85bdd63ba74389f99f887de27a1eedc352"

URI_aarch64_pcp-pmda-roomtemp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-roomtemp-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-roomtemp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-roomtemp}"
SRC_URI[aarch64_pcp-pmda-roomtemp.sha256sum] = "314de83063a439f1aac1ffed1f6c25e85b01978c16daa140a9c0b3a78cf64e4e"

URI_aarch64_pcp-pmda-rsyslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-rsyslog-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-rsyslog}"
SRC_URI[aarch64_pcp-pmda-rsyslog.sha256sum] = "bb69a7206e8296c1e9af255f3159ed8e8f31bacc15a2d576d98c316fdd97992d"

URI_aarch64_pcp-pmda-samba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-samba-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-samba}"
SRC_URI[aarch64_pcp-pmda-samba.sha256sum] = "2779c06adb41a4ffa8552a287dcfe25cc406ef87ba5d1c11d474be0ee37a7504"

URI_aarch64_pcp-pmda-sendmail = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sendmail-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-sendmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-sendmail}"
SRC_URI[aarch64_pcp-pmda-sendmail.sha256sum] = "44df62f154b694e47b21a81a4ef1f26c0e86dc2d9795d77627b40e4f786795e9"

URI_aarch64_pcp-pmda-shping = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-shping-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-shping;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-shping}"
SRC_URI[aarch64_pcp-pmda-shping.sha256sum] = "13bca88f64fefa5b53b1944e18eea65bb67a61a628a5e3a799b3ef801d679f49"

URI_aarch64_pcp-pmda-slurm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-slurm-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-slurm;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-slurm}"
SRC_URI[aarch64_pcp-pmda-slurm.sha256sum] = "1d8c043673f5d6f4188f1b7811d70a45d0e28be73c1a3d8b69d6cfc754af73b8"

URI_aarch64_pcp-pmda-smart = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-smart-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-smart;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-smart}"
SRC_URI[aarch64_pcp-pmda-smart.sha256sum] = "d1b3f182c91f2cf081fc11389ea0236c2f5986c7b305d2adc71e38b53dfc02ee"

URI_aarch64_pcp-pmda-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-snmp-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-snmp}"
SRC_URI[aarch64_pcp-pmda-snmp.sha256sum] = "d0e5d997f32bdfd11a5e494d87347aed78e8b100ae08f2e735d84def3366fc15"

URI_aarch64_pcp-pmda-sockets = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-sockets-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-sockets;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-sockets}"
SRC_URI[aarch64_pcp-pmda-sockets.sha256sum] = "51b8d05e011128f0d05c040f50bb17042ee85d130c0787043b2d8c81ff11211f"

URI_aarch64_pcp-pmda-statsd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-statsd-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-statsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-statsd}"
SRC_URI[aarch64_pcp-pmda-statsd.sha256sum] = "df75317e25db98ca2236c0d1fbaeb64a4de11c2c45db2ed9dbd519533154ff3f"

URI_aarch64_pcp-pmda-summary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-summary-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-summary;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-summary}"
SRC_URI[aarch64_pcp-pmda-summary.sha256sum] = "8865cab9f641819b56f4182ec4a9b0d43bcb919e6afaf0d2d41cacff5dac666d"

URI_aarch64_pcp-pmda-systemd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-systemd-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-systemd}"
SRC_URI[aarch64_pcp-pmda-systemd.sha256sum] = "81510c3251358ee27505415846a03a5637b36865ec256bd132ff33f78b404ada"

URI_aarch64_pcp-pmda-trace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-trace-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-trace;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-trace}"
SRC_URI[aarch64_pcp-pmda-trace.sha256sum] = "9d69b5762d32ee55c48d5bd780601f4a676f5edd01518ce22a6e27edaed5a85e"

URI_aarch64_pcp-pmda-unbound = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-unbound-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-unbound;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-unbound}"
SRC_URI[aarch64_pcp-pmda-unbound.sha256sum] = "3cd1c64d16783b4879754c6920cd4e6c2df9b992c0c7f062748cdaff37141346"

URI_aarch64_pcp-pmda-uwsgi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-uwsgi-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-uwsgi;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-uwsgi}"
SRC_URI[aarch64_pcp-pmda-uwsgi.sha256sum] = "18908a77763b0b7027db3973e8f10b649e79424f0e580ae9d8fa0c9eb3adda30"

URI_aarch64_pcp-pmda-weblog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-weblog-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-weblog;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-weblog}"
SRC_URI[aarch64_pcp-pmda-weblog.sha256sum] = "3004154f9d8d4fb66c2bf4f5f200fe092142692cd44bedd43b7ce229ee93ad64"

URI_aarch64_pcp-pmda-zimbra = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zimbra-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-zimbra;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-zimbra}"
SRC_URI[aarch64_pcp-pmda-zimbra.sha256sum] = "23362e01c3613416b505c2df797a1310c55f1fa3afbc5b8916710799a38f3bf9"

URI_aarch64_pcp-pmda-zswap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-pmda-zswap-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-pmda-zswap;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-pmda-zswap}"
SRC_URI[aarch64_pcp-pmda-zswap.sha256sum] = "54f2374d8c48c52775bbcccc2da3a2f59ea3596403ab22b10c2e37ee7651dff1"

URI_aarch64_pcp-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-selinux-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-selinux}"
SRC_URI[aarch64_pcp-selinux.sha256sum] = "e3df51486406394798b7d78f1057cdea222d36e1422a11024550cb878c973ade"

URI_aarch64_pcp-system-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-system-tools-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-system-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-system-tools}"
SRC_URI[aarch64_pcp-system-tools.sha256sum] = "cc36f1ba2e42c06a834d0788b82d630558a7dfc80e19336eef88049ba75ca6ba"

URI_aarch64_pcp-testsuite = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/pcp-testsuite-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-testsuite;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-testsuite}"
SRC_URI[aarch64_pcp-testsuite.sha256sum] = "7698206091ea1eb83280b1d0029992d720ffad57af6999a2ab188c00aeba9887"

URI_aarch64_pcp-zeroconf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pcp-zeroconf-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_pcp-zeroconf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pcp-zeroconf}"
SRC_URI[aarch64_pcp-zeroconf.sha256sum] = "5b93be7f83ff86de7f96d1f9990a5e246cf4fe73c96fea416305bcdccbed4d23"

URI_aarch64_perl-PCP-LogImport = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogImport-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_perl-PCP-LogImport;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-LogImport}"
SRC_URI[aarch64_perl-PCP-LogImport.sha256sum] = "493a6e356c534a2e092d979527739818c506814a71be81f4802e89dce2b2bc61"

URI_aarch64_perl-PCP-LogSummary = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-LogSummary-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_perl-PCP-LogSummary;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-LogSummary}"
SRC_URI[aarch64_perl-PCP-LogSummary.sha256sum] = "7c3f91733888da50a1996f7dd6ece18a2b8714dbb3a610a04cea01d5d37962a1"

URI_aarch64_perl-PCP-MMV = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-MMV-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_perl-PCP-MMV;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-MMV}"
SRC_URI[aarch64_perl-PCP-MMV.sha256sum] = "10b5d3a9cba3a95117af77dea6ca9b0fd4d6a2e4cdc9d51023774a59809934ab"

URI_aarch64_perl-PCP-PMDA = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-PCP-PMDA-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_perl-PCP-PMDA;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-PCP-PMDA}"
SRC_URI[aarch64_perl-PCP-PMDA.sha256sum] = "c30dd63c9c513cfac70b17f55907d3cd5574f4f58df469dd0ac21ca1ddcb394c"

URI_aarch64_python3-pcp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pcp-6.3.7-1.el10_0.aarch64.rpm;name=aarch64_python3-pcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pcp}"
SRC_URI[aarch64_python3-pcp.sha256sum] = "b5485fc8427f0470233701a7e4324e7ae1b290a27040be6d549124c034474cc8"

RDEPENDS:pcp = " \
 bash \
 diffutils \
 findutils \
 gawk \
 glibc \
 grep \
 hostname \
 libuv \
 openssl-libs \
 pcp-libs \
 pcp-selinux \
 pkgconf-pkg-config \
 procps-ng \
 readline \
 sed \
 virtual/coreutils \
 which \
 xz \
 zlib-ng-compat \
 "
RDEPENDS:pcp-conf = " \
 "
RDEPENDS:pcp-devel = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 pcp-libs-devel \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:pcp-doc = " \
 "
RDEPENDS:pcp-export-pcp2elasticsearch = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2graphite = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2influxdb = " \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-export-pcp2json = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2openmetrics = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2spark = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2xml = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-pcp2zabbix = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-export-zabbix-agent = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-geolocate = " \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-gui = " \
 bash \
 glibc \
 liberation-sans-fonts \
 libgcc \
 libstdc++ \
 pcp \
 pcp-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:pcp-import-collectl2pcp = " \
 glibc \
 pcp-libs \
 "
RDEPENDS:pcp-import-ganglia2pcp = " \
 pcp-libs \
 perl-File-Basename \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-POSIX \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 perl-vars \
 rrdtool-perl \
 "
RDEPENDS:pcp-import-iostat2pcp = " \
 pcp-libs \
 perl-Getopt-Std \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-mrtg2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-import-sar2pcp = " \
 pcp-libs \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-XML-TokeParser \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-libs = " \
 avahi-libs \
 cyrus-sasl-lib \
 glibc \
 libuv \
 openssl-libs \
 pcp-conf \
 systemd-libs \
 xz-libs \
 "
RDEPENDS:pcp-libs-devel = " \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-activemq = " \
 bash \
 pcp \
 pcp-libs \
 perl-Digest-MD5 \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-libs \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-amdgpu = " \
 bash \
 glibc \
 libdrm \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-apache = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bash = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-bcc = " \
 bash \
 pcp \
 pcp-libs \
 python3-bcc \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-bind2 = " \
 bash \
 pcp \
 pcp-libs \
 perl-File-Slurp \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-XML-LibXML \
 perl-autodie \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-bonding = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-bpf = " \
 bash \
 elfutils-libelf \
 glibc \
 libbpf \
 pcp \
 pcp-libs \
 zlib-ng-compat \
 "
RDEPENDS:pcp-pmda-bpftrace = " \
 bash \
 bpftrace \
 pcp \
 pcp-libs \
 python3 \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-cifs = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-cisco = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dbping = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-denki = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-dm = " \
 bash \
 device-mapper-libs \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-docker = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-ds389 = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-ds389log = " \
 bash \
 pcp \
 pcp-libs \
 perl-Date-Manip \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-elasticsearch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-farm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-gluster = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-gpfs = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-gpsd = " \
 bash \
 pcp \
 pcp-libs \
 perl-JSON \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-hacluster = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-haproxy = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-infiniband = " \
 bash \
 glibc \
 infiniband-diags \
 libibumad \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-json = " \
 bash \
 pcp \
 pcp-libs \
 python3-jsonpointer \
 python3-pcp \
 python3-six \
 "
RDEPENDS:pcp-pmda-libvirt = " \
 bash \
 pcp \
 pcp-libs \
 python3-libvirt \
 python3-lxml \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-lio = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-rtslib \
 "
RDEPENDS:pcp-pmda-lmsensors = " \
 bash \
 lm_sensors \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-logger = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-lustre = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-lustrecomm = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mailq = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-memcache = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-mic = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mongodb = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-mounts = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-mssql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-pyodbc \
 "
RDEPENDS:pcp-pmda-mysql = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBD-MySQL \
 perl-DBI \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-named = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-netcheck = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-netfilter = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-news = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-nfsclient = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-nginx = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-libwww-perl \
 "
RDEPENDS:pcp-pmda-nvidia-gpu = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-openmetrics = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-requests \
 "
RDEPENDS:pcp-pmda-openvswitch = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-oracle = " \
 bash \
 pcp \
 pcp-libs \
 perl-DBI \
 perl-PCP-PMDA \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-pdns = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 "
RDEPENDS:pcp-pmda-perfevent = " \
 bash \
 glibc \
 libpfm \
 pcp \
 pcp-libs \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:pcp-pmda-podman = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-postfix = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 postfix-perl-scripts \
 "
RDEPENDS:pcp-pmda-postgresql = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 python3-psycopg2 \
 "
RDEPENDS:pcp-pmda-rabbitmq = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-redis = " \
 bash \
 pcp \
 pcp-libs \
 perl-Data-Dumper \
 perl-PCP-PMDA \
 perl-Time-HiRes \
 perl-autodie \
 "
RDEPENDS:pcp-pmda-resctrl = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-roomtemp = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-rsyslog = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-samba = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sendmail = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-shping = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-slurm = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-smart = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 smartmontools \
 "
RDEPENDS:pcp-pmda-snmp = " \
 bash \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-sockets = " \
 bash \
 glibc \
 iproute \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-statsd = " \
 HdrHistogram_c \
 bash \
 chan \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-summary = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-systemd = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 systemd-libs \
 "
RDEPENDS:pcp-pmda-trace = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-unbound = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-uwsgi = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-pmda-weblog = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 "
RDEPENDS:pcp-pmda-zimbra = " \
 bash \
 glibc \
 pcp \
 pcp-libs \
 perl-PCP-PMDA \
 "
RDEPENDS:pcp-pmda-zswap = " \
 bash \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-selinux = " \
 bash \
 policycoreutils \
 selinux-policy-targeted \
 "
RDEPENDS:pcp-system-tools = " \
 bash \
 glibc \
 ncurses-libs \
 pcp \
 pcp-libs \
 python3-pcp \
 "
RDEPENDS:pcp-testsuite:x86_64_v2 = " \
 avahi-libs \
 bash \
 bc \
 bzip2 \
 cyrus-sasl-lib \
 gcc \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcp \
 pcp-devel \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-geolocate \
 pcp-gui \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-json \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mssql \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-resctrl \
 pcp-pmda-roomtemp \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-system-tools \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 redhat-rpm-config \
 selinux-policy-devel \
 selinux-policy-targeted \
 setools-console \
 systemd-libs \
 xz-libs \
"
RDEPENDS:pcp-testsuite:aarch64 = " \
 avahi-libs \
 bash \
 bc \
 bzip2 \
 cyrus-sasl-lib \
 gcc \
 glibc \
 gzip \
 libgcc \
 libstdc++ \
 openssl-libs \
 pcp \
 pcp-devel \
 pcp-export-pcp2json \
 pcp-export-pcp2openmetrics \
 pcp-export-pcp2spark \
 pcp-export-pcp2xml \
 pcp-export-pcp2zabbix \
 pcp-geolocate \
 pcp-gui \
 pcp-libs \
 pcp-libs-devel \
 pcp-pmda-activemq \
 pcp-pmda-amdgpu \
 pcp-pmda-apache \
 pcp-pmda-bash \
 pcp-pmda-bcc \
 pcp-pmda-bind2 \
 pcp-pmda-bonding \
 pcp-pmda-bpf \
 pcp-pmda-bpftrace \
 pcp-pmda-cisco \
 pcp-pmda-dbping \
 pcp-pmda-denki \
 pcp-pmda-dm \
 pcp-pmda-docker \
 pcp-pmda-ds389 \
 pcp-pmda-ds389log \
 pcp-pmda-elasticsearch \
 pcp-pmda-farm \
 pcp-pmda-gluster \
 pcp-pmda-gpfs \
 pcp-pmda-gpsd \
 pcp-pmda-hacluster \
 pcp-pmda-haproxy \
 pcp-pmda-json \
 pcp-pmda-libvirt \
 pcp-pmda-lio \
 pcp-pmda-lmsensors \
 pcp-pmda-logger \
 pcp-pmda-lustre \
 pcp-pmda-lustrecomm \
 pcp-pmda-mailq \
 pcp-pmda-memcache \
 pcp-pmda-mic \
 pcp-pmda-mongodb \
 pcp-pmda-mounts \
 pcp-pmda-mysql \
 pcp-pmda-named \
 pcp-pmda-netcheck \
 pcp-pmda-netfilter \
 pcp-pmda-news \
 pcp-pmda-nfsclient \
 pcp-pmda-nginx \
 pcp-pmda-nvidia-gpu \
 pcp-pmda-openmetrics \
 pcp-pmda-openvswitch \
 pcp-pmda-oracle \
 pcp-pmda-pdns \
 pcp-pmda-podman \
 pcp-pmda-postfix \
 pcp-pmda-postgresql \
 pcp-pmda-rabbitmq \
 pcp-pmda-roomtemp \
 pcp-pmda-samba \
 pcp-pmda-sendmail \
 pcp-pmda-shping \
 pcp-pmda-slurm \
 pcp-pmda-smart \
 pcp-pmda-snmp \
 pcp-pmda-sockets \
 pcp-pmda-statsd \
 pcp-pmda-summary \
 pcp-pmda-trace \
 pcp-pmda-unbound \
 pcp-pmda-uwsgi \
 pcp-pmda-weblog \
 pcp-pmda-zimbra \
 pcp-pmda-zswap \
 pcp-system-tools \
 perl-Exporter \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-PCP-LogImport \
 perl-TimeDate \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 redhat-rpm-config \
 selinux-policy-devel \
 selinux-policy-targeted \
 setools-console \
 systemd-libs \
 xz-libs \
"
RDEPENDS:pcp-zeroconf = " \
 bash \
 pcp \
 pcp-doc \
 pcp-libs \
 pcp-pmda-dm \
 pcp-pmda-nfsclient \
 pcp-pmda-openmetrics \
 pcp-system-tools \
 "
RDEPENDS:perl-PCP-LogImport = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:perl-PCP-LogSummary = " \
 pcp-libs \
 perl-Exporter \
 perl-PCP-LogSummary \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-MMV = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-PCP-MMV \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-PCP-PMDA = " \
 glibc \
 pcp-libs \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:python3-pcp = " \
 glibc \
 pcp \
 pcp-libs \
 python3 \
 "
