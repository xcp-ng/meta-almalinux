# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-pelletier-toml-2"
PV = "2.2.2"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-pelletier-toml-2 \
 golang-github-pelletier-toml-2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-pelletier-toml-2-2.2.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac55bed053256a0ca35a7f8bd1805612f11c7e32777c2fbbdc071b5b065da519"

URI_x86_64_v2_golang-github-pelletier-toml-2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pelletier-toml-2-2.2.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-pelletier-toml-2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pelletier-toml-2}"
SRC_URI[x86_64_v2_golang-github-pelletier-toml-2.sha256sum] = "86f77c8ed69dcc50ee92f949c223bd3bc1167fea4658fe87b2257e85aff3b263"

URI_x86_64_v2_golang-github-pelletier-toml-2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-pelletier-toml-2-devel-2.2.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-pelletier-toml-2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-pelletier-toml-2-devel}"
SRC_URI[x86_64_v2_golang-github-pelletier-toml-2-devel.sha256sum] = "1578be947b3a03583abde8d2c7e44df24e8095643f9f4c2c018c68c81930dbc0"

URI_aarch64_golang-github-pelletier-toml-2 = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pelletier-toml-2-2.2.2-2.el10_0.aarch64.rpm;name=aarch64_golang-github-pelletier-toml-2;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pelletier-toml-2}"
SRC_URI[aarch64_golang-github-pelletier-toml-2.sha256sum] = "d646fbd1bb3aaaa014967e4bcbc3840f228052bc2c77ff0a76351ceee94daaf1"

URI_aarch64_golang-github-pelletier-toml-2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-pelletier-toml-2-devel-2.2.2-2.el10_0.noarch.rpm;name=aarch64_golang-github-pelletier-toml-2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-pelletier-toml-2-devel}"
SRC_URI[aarch64_golang-github-pelletier-toml-2-devel.sha256sum] = "54cb23e7abbcd119a551a5ec39eb70dde3d3990f709a97689160bc5dd4f93097"

RDEPENDS:golang-github-pelletier-toml-2 = " \
 glibc \
 "
RDEPENDS:golang-github-pelletier-toml-2-devel = " \
 go-filesystem \
 "
