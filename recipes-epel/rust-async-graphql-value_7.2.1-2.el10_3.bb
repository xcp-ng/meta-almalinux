# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-graphql-value"
PV = "7.2.1"
PR = "2.el10_3"
PACKAGES = " \
 rust-async-graphql-value+default-devel \
 rust-async-graphql-value+raw_value-devel \
 rust-async-graphql-value-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-async-graphql-value-7.2.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "24f57c2889fbc5e4bfa7af45002ac118e37e4a85a15f6f15931693f1c194dc81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-graphql-value+default-devel-7.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-graphql-value+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-async-graphql-value+default-devel.sha256sum] = "8631904d7e41aa89916de0cadded46fa07d91ae590257eec5f15d1d49173cc3d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-graphql-value+raw_value-devel-7.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-graphql-value+raw_value-devel;unpack=0"
SRC_URI[x86_64_v2_rust-async-graphql-value+raw_value-devel.sha256sum] = "61a9d7a03da6da75356aca69ee4c9160fb293645e2eb243a0e5e8de0f528bb60"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-graphql-value-devel-7.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-graphql-value-devel;unpack=0"
SRC_URI[x86_64_v2_rust-async-graphql-value-devel.sha256sum] = "7bc2532f31f0494d70f554eab8572e7ba41db7e5bb41a5701599af48f32f4e9f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-async-graphql-value+default-devel-7.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-async-graphql-value+default-devel;unpack=0"
SRC_URI[aarch64_rust-async-graphql-value+default-devel.sha256sum] = "ea8e7f83fd40e241473d8af8f0ea7eab2e91c4802c66757c500b5423b03121b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-async-graphql-value+raw_value-devel-7.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-async-graphql-value+raw_value-devel;unpack=0"
SRC_URI[aarch64_rust-async-graphql-value+raw_value-devel.sha256sum] = "cf2692695908b7ac4a7731170fc22d3cb577c0ab6d70c0fa4ffebed47bec3e6a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-async-graphql-value-devel-7.2.1-2.el10_3.noarch.rpm;name=aarch64_rust-async-graphql-value-devel;unpack=0"
SRC_URI[aarch64_rust-async-graphql-value-devel.sha256sum] = "e1d13dd78098887c05d9708b98362a4728b5af8838b12afaad21c03f26b307a6"

RDEPENDS:rust-async-graphql-value+default-devel = " \
 cargo \
 rust-async-graphql-value-devel \
 "
RDEPENDS:rust-async-graphql-value+raw_value-devel = " \
 cargo \
 rust-async-graphql-value-devel \
 rust-serde_json+raw_value-devel \
 "
RDEPENDS:rust-async-graphql-value-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-bytes+serde-devel \
 rust-indexmap+default-devel \
 rust-indexmap+serde-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
