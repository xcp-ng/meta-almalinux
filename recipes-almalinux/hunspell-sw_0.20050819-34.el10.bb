# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-sw"
PV = "0.20050819"
PR = "34.el10"
PACKAGES = " \
 hunspell-sw \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-sw-0.20050819-34.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "71f84b5a20a29a378a3387a8c22edbc0783c71f316edd44ea3f84ff680f711b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-sw-0.20050819-34.el10.noarch.rpm;name=x86_64_v2_hunspell-sw;unpack=0"
SRC_URI[x86_64_v2_hunspell-sw.sha256sum] = "383bb24c47f1bebfa11b5ab93c452320a4edc9466ff5c11ca5f06782e49cd982"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-sw-0.20050819-34.el10.noarch.rpm;name=aarch64_hunspell-sw;unpack=0"
SRC_URI[aarch64_hunspell-sw.sha256sum] = "383bb24c47f1bebfa11b5ab93c452320a4edc9466ff5c11ca5f06782e49cd982"

RDEPENDS:hunspell-sw = " \
 hunspell-filesystem \
 "
