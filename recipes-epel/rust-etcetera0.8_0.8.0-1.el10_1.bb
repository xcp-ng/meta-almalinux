# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-etcetera0.8"
PV = "0.8.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-etcetera0.8+default-devel \
 rust-etcetera0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-etcetera0.8-0.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5aa5cdb177d1e9facda83687ebfc3e603bc82dceb3c1943959c4707292ed2b1f"

URI_x86_64_v2_rust-etcetera0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-etcetera0.8+default-devel-0.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-etcetera0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-etcetera0.8+default-devel}"
SRC_URI[x86_64_v2_rust-etcetera0.8+default-devel.sha256sum] = "2e3e14b5111249247d874d417ce72bf6ac1650b95d74437dcb75dc07e5bcf8fd"

URI_x86_64_v2_rust-etcetera0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-etcetera0.8-devel-0.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-etcetera0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-etcetera0.8-devel}"
SRC_URI[x86_64_v2_rust-etcetera0.8-devel.sha256sum] = "297481cb3c52139f7bfefdac0880f1a41009ed0e47d160cde870cb4e6465a52d"

URI_aarch64_rust-etcetera0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-etcetera0.8+default-devel-0.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-etcetera0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-etcetera0.8+default-devel}"
SRC_URI[aarch64_rust-etcetera0.8+default-devel.sha256sum] = "c7bd457d85af5d4bfca130d5be10fb399a2c5a9aa80bf6b2d73c8a62be493235"

URI_aarch64_rust-etcetera0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-etcetera0.8-devel-0.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-etcetera0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-etcetera0.8-devel}"
SRC_URI[aarch64_rust-etcetera0.8-devel.sha256sum] = "586103d7d80b1a353d00b1d3872775c7a82aa2a95846f33477b4d623e8f17d67"

RDEPENDS:rust-etcetera0.8+default-devel = " \
 cargo \
 rust-etcetera0.8-devel \
 "
RDEPENDS:rust-etcetera0.8-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-home+default-devel \
 "
