# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uthash"
PV = "2.3.0"
PR = "8.el10_0"
PACKAGES = " \
 uthash-devel \
 uthash-doc \
 uthash-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/u/uthash-2.3.0-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cab590ac80228b25ec4591a797f128f961eadb102375ad01cdd31ada011bb98a"

URI_x86_64_v2_uthash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uthash-devel-2.3.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_uthash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uthash-devel}"
SRC_URI[x86_64_v2_uthash-devel.sha256sum] = "2f497253f75c3ba02ac3c2d8e0ed3250d680b3959bdd423a8fbac7773cb737eb"

URI_x86_64_v2_uthash-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uthash-doc-2.3.0-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_uthash-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uthash-doc}"
SRC_URI[x86_64_v2_uthash-doc.sha256sum] = "cf00774cc620a4b0ab88db5d5d5380c17f35a0f60fe25ce99006bad55717a48a"

URI_x86_64_v2_uthash-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/uthash-tools-2.3.0-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_uthash-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uthash-tools}"
SRC_URI[x86_64_v2_uthash-tools.sha256sum] = "1533bb15a3299911c4a75e9961de3a28cb69316a64990fad518cae4106f09d8f"

URI_aarch64_uthash-devel = "${EPEL_MIRROR}/aarch64/Packages/u/uthash-devel-2.3.0-8.el10_0.noarch.rpm;name=aarch64_uthash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_uthash-devel}"
SRC_URI[aarch64_uthash-devel.sha256sum] = "64440d20799a957a31d3fd65aae59e8671f33271877dbd25ed29b8df0d460149"

URI_aarch64_uthash-doc = "${EPEL_MIRROR}/aarch64/Packages/u/uthash-doc-2.3.0-8.el10_0.noarch.rpm;name=aarch64_uthash-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_uthash-doc}"
SRC_URI[aarch64_uthash-doc.sha256sum] = "88461c9e1bc682b0fac5ae3faad41b1f07451b89e3c7b2a77ce29aa093adccde"

URI_aarch64_uthash-tools = "${EPEL_MIRROR}/aarch64/Packages/u/uthash-tools-2.3.0-8.el10_0.aarch64.rpm;name=aarch64_uthash-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_uthash-tools}"
SRC_URI[aarch64_uthash-tools.sha256sum] = "b63e9704d9db7b08e0c24a637585ace3e26f275631380664ec61a7a275c8d206"

RDEPENDS:uthash-devel = " \
 "
RDEPENDS:uthash-doc = " \
 uthash-devel \
 "
RDEPENDS:uthash-tools = " \
 glibc \
 perl-interpreter \
 uthash-devel \
 "
