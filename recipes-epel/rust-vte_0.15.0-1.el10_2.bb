# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-vte"
PV = "0.15.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-vte+ansi-devel \
 rust-vte+bitflags-devel \
 rust-vte+cursor-icon-devel \
 rust-vte+default-devel \
 rust-vte+log-devel \
 rust-vte+serde-devel \
 rust-vte+std-devel \
 rust-vte-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-vte-0.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "527a764777a4d4437c576d235bd394fbe7c6cf43ced26b3c0d64daabcf27e3fd"

URI_x86_64_v2_rust-vte+ansi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+ansi-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+ansi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+ansi-devel}"
SRC_URI[x86_64_v2_rust-vte+ansi-devel.sha256sum] = "f8ca62360e2d3c1893b3785d4e69b7ab4bb2eabd1fefb595fd8bfaf261f4e0fb"

URI_x86_64_v2_rust-vte+bitflags-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+bitflags-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+bitflags-devel}"
SRC_URI[x86_64_v2_rust-vte+bitflags-devel.sha256sum] = "6c0616b11ba512fcef33cc9cd5e69557bc5ea96f5d1a72bf92b7425e5ec20210"

URI_x86_64_v2_rust-vte+cursor-icon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+cursor-icon-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+cursor-icon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+cursor-icon-devel}"
SRC_URI[x86_64_v2_rust-vte+cursor-icon-devel.sha256sum] = "d060bb418ac9d0f5179d1661b6cf6578938b670ebc7b3c3937d03b702b48c0ff"

URI_x86_64_v2_rust-vte+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+default-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+default-devel}"
SRC_URI[x86_64_v2_rust-vte+default-devel.sha256sum] = "673aace5cd3819e22737a3dbf39620249a136107dfc2fef81e7baf67ffff4b94"

URI_x86_64_v2_rust-vte+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+log-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+log-devel}"
SRC_URI[x86_64_v2_rust-vte+log-devel.sha256sum] = "b7cf30916f48c69635f945e5980e9c3590e61d63d67243d0de792b7d43423a35"

URI_x86_64_v2_rust-vte+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+serde-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+serde-devel}"
SRC_URI[x86_64_v2_rust-vte+serde-devel.sha256sum] = "c109d105534a8ac8dd58fe0650a06147871501cecf8001e02345246c4852be5c"

URI_x86_64_v2_rust-vte+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte+std-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte+std-devel}"
SRC_URI[x86_64_v2_rust-vte+std-devel.sha256sum] = "d847b19cf2fd787bd0cea8b725ad8f1bb9a008afdfbec89b4baa182054e37505"

URI_x86_64_v2_rust-vte-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-vte-devel-0.15.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-vte-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-vte-devel}"
SRC_URI[x86_64_v2_rust-vte-devel.sha256sum] = "c2a9f8ba25b10d89f751cb8320f22002b1ff8a90ebddcc5c7e389be74b77b917"

URI_aarch64_rust-vte+ansi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+ansi-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-vte+ansi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+ansi-devel}"
SRC_URI[aarch64_rust-vte+ansi-devel.sha256sum] = "af9f9374066f9eee378e1da0951570a2b9ab63f9dadae0c2d5368ead57986247"

URI_aarch64_rust-vte+bitflags-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+bitflags-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-vte+bitflags-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+bitflags-devel}"
SRC_URI[aarch64_rust-vte+bitflags-devel.sha256sum] = "8e327e9869855a028b4e13cac06cdb5f4fc8f1b7f7784e81df0eced90c0070ee"

URI_aarch64_rust-vte+cursor-icon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+cursor-icon-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-vte+cursor-icon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+cursor-icon-devel}"
SRC_URI[aarch64_rust-vte+cursor-icon-devel.sha256sum] = "e205e2c84429756f6cd5f07badcc9115bf28535571a99f54c20f2c500f900460"

URI_aarch64_rust-vte+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+default-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-vte+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+default-devel}"
SRC_URI[aarch64_rust-vte+default-devel.sha256sum] = "4552ef9f2daebb1bfff01bb8f58e79acf2dac2c0868b02c29ff7a9e4e593a89d"

URI_aarch64_rust-vte+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+log-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-vte+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+log-devel}"
SRC_URI[aarch64_rust-vte+log-devel.sha256sum] = "116b08501a8a1f49ddcf5a5670ac473d5d9830b26d30d805cb6ee64468019832"

URI_aarch64_rust-vte+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+serde-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-vte+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+serde-devel}"
SRC_URI[aarch64_rust-vte+serde-devel.sha256sum] = "f1f6011cda61959de7da5e2831ee6f950c2439bb398e63824460f80aa997ec34"

URI_aarch64_rust-vte+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte+std-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-vte+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte+std-devel}"
SRC_URI[aarch64_rust-vte+std-devel.sha256sum] = "2d78084537c4648b69e38c5b1393583f8db6a5bf0cf3a4ace8a6d1e6d0377716"

URI_aarch64_rust-vte-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-vte-devel-0.15.0-1.el10_2.noarch.rpm;name=aarch64_rust-vte-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-vte-devel}"
SRC_URI[aarch64_rust-vte-devel.sha256sum] = "f747caf43b7ee14a8c5834249236675fcae18ec0ac686d8dcc22eff81f5498a6"

RDEPENDS:rust-vte+ansi-devel = " \
 cargo \
 rust-vte+bitflags-devel \
 rust-vte+cursor-icon-devel \
 rust-vte+log-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+bitflags-devel = " \
 cargo \
 rust-bitflags-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+cursor-icon-devel = " \
 cargo \
 rust-cursor-icon-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+default-devel = " \
 cargo \
 rust-vte+std-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte+std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-vte-devel \
 "
RDEPENDS:rust-vte-devel = " \
 cargo \
 rust \
 rust-arrayvec-devel \
 rust-memchr-devel \
 "
