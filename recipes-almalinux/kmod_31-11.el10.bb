# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmod"
PV = "31"
PR = "11.el10"
PACKAGES = " \
 kmod \
 kmod-devel \
 kmod-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kmod-31-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc4376fb5de9c88f4f6e61853b5fb34520e4461c69c4e829335d6cef96926604"

URI_x86_64_v2_kmod = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kmod-31-11.el10.x86_64_v2.rpm;name=x86_64_v2_kmod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmod}"
SRC_URI[x86_64_v2_kmod.sha256sum] = "c03e5a76d7e3d24210924f6b8483e3800a8d8e4e103056fc036725933c6810dc"

URI_x86_64_v2_kmod-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/kmod-devel-31-11.el10.x86_64_v2.rpm;name=x86_64_v2_kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmod-devel}"
SRC_URI[x86_64_v2_kmod-devel.sha256sum] = "b7d8d901410f26125ab4414f03a17cb8d69397e838047e143901cbe4c77a4d98"

URI_x86_64_v2_kmod-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kmod-libs-31-11.el10.x86_64_v2.rpm;name=x86_64_v2_kmod-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmod-libs}"
SRC_URI[x86_64_v2_kmod-libs.sha256sum] = "4bf145ec0165f1b88dd73f032d5d8fbaa1ac89160a500684b229b410412c9699"

URI_aarch64_kmod = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kmod-31-11.el10.aarch64.rpm;name=aarch64_kmod;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmod}"
SRC_URI[aarch64_kmod.sha256sum] = "255a92687c8f512331c72863411ace2e4a435b3223af12f37920e4a34963c65b"

URI_aarch64_kmod-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/kmod-devel-31-11.el10.aarch64.rpm;name=aarch64_kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmod-devel}"
SRC_URI[aarch64_kmod-devel.sha256sum] = "314f6e06d344ff5c99324554bede1d5f0bb4036acbfa21a2f6b25671470c48f7"

URI_aarch64_kmod-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kmod-libs-31-11.el10.aarch64.rpm;name=aarch64_kmod-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmod-libs}"
SRC_URI[aarch64_kmod-libs.sha256sum] = "e6d874e4682989976c8418da3cae6df47808ef750d10b350cfeb6fc24b79c490"

RDEPENDS:kmod = " \
 bash \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:kmod-devel = " \
 kmod-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:kmod-libs = " \
 glibc \
 libgcc \
 libzstd \
 openssl-libs \
 xz-libs \
 zlib-ng-compat \
 "
