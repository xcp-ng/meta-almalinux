# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmms"
PV = "0.6.4"
PR = "27.el10_0"
PACKAGES = " \
 libmms \
 libmms-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmms-0.6.4-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f01c284c7a943a481bf49385777040dea8d65f4e42eabf842d27a23cc4eda3f6"

URI_x86_64_v2_libmms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmms-0.6.4-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmms}"
SRC_URI[x86_64_v2_libmms.sha256sum] = "99f37a8b245fe7384d64453c379e151b3d838b179df2f52c3a812256b0d62f58"

URI_x86_64_v2_libmms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmms-devel-0.6.4-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmms-devel}"
SRC_URI[x86_64_v2_libmms-devel.sha256sum] = "4d14c52aca56b700e3e135b81817326e07b7b2bb0ce8f441197396b3408f6bcf"

URI_aarch64_libmms = "${EPEL_MIRROR}/aarch64/Packages/l/libmms-0.6.4-27.el10_0.aarch64.rpm;name=aarch64_libmms;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmms}"
SRC_URI[aarch64_libmms.sha256sum] = "a11a64d3b0f737da983ea833a0edbd46206cc7ad84f89d9e7b75c140d72c1668"

URI_aarch64_libmms-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmms-devel-0.6.4-27.el10_0.aarch64.rpm;name=aarch64_libmms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmms-devel}"
SRC_URI[aarch64_libmms-devel.sha256sum] = "ff978dd9ed087892c5a7f427ce549925ad658cf34676c52f349ec697b8d6b263"

RDEPENDS:libmms = " \
 glibc \
 "
RDEPENDS:libmms-devel = " \
 libmms \
 pkgconf-pkg-config \
 "
