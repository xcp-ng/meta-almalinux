# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "uid_wrapper"
PV = "1.3.0"
PR = "8.el10"
PACKAGES = " \
 uid_wrapper \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/uid_wrapper-1.3.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "897847381ae9748d809916cd87efe239139ae7ffbb05ed29e47cfa689c6e7405"

URI_x86_64_v2_uid_wrapper = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/uid_wrapper-1.3.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_uid_wrapper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uid_wrapper}"
SRC_URI[x86_64_v2_uid_wrapper.sha256sum] = "aff5a314259d71a14b42cb9d2806697cbfd6ca6913289e58ae34c71e36ae8e9c"

URI_aarch64_uid_wrapper = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/uid_wrapper-1.3.0-8.el10.aarch64.rpm;name=aarch64_uid_wrapper;unpack=0"
SRC_URI:append = " ${URI_aarch64_uid_wrapper}"
SRC_URI[aarch64_uid_wrapper.sha256sum] = "b6eb88bd23a199f7a1949104c1106301a842bd6faa31288ff631047daa1401d9"

RDEPENDS:uid_wrapper = " \
 cmake-filesystem \
 glibc \
 pkgconf-pkg-config \
 "
