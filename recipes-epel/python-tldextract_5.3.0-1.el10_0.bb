# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tldextract"
PV = "5.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-tldextract \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-tldextract-5.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d394957eeb214faf6df61031264c6cad702c7c0f4a5feb64513a3b60ec67f00f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tldextract-5.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-tldextract;unpack=0"
SRC_URI[x86_64_v2_python3-tldextract.sha256sum] = "cac7b948bb64892b00f2f9322a17366b57ffef86959430446c5f635c6103f128"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-tldextract-5.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-tldextract;unpack=0"
SRC_URI[aarch64_python3-tldextract.sha256sum] = "90ee85467772bfd80fa95dd852290d5e85f8dd5aea580198c0d7931ffcb2f82a"

RDEPENDS:python3-tldextract = " \
 python3 \
 python3-filelock \
 python3-idna \
 python3-requests \
 python3-requests-file \
 "
