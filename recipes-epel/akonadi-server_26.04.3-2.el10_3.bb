# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-server"
PV = "26.04.3"
PR = "2.el10_3"
PACKAGES = " \
 akonadi-server \
 akonadi-server-devel \
 akonadi-server-doc \
 akonadi-server-mysql \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-server-26.04.3-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "534a58fd8d3102761b3d5de670167e765b030e58136715c5811f527de5148b25"

URI_x86_64_v2_akonadi-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-26.04.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server}"
SRC_URI[x86_64_v2_akonadi-server.sha256sum] = "bded96fbf4dce3bec7bcff8811c5139875f937b40e6a41fdfccb24047068a0f8"

URI_x86_64_v2_akonadi-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-devel-26.04.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-devel}"
SRC_URI[x86_64_v2_akonadi-server-devel.sha256sum] = "d48a0ed2ae8ea33b36833f75ddf10b8ce3c9a5dd15a194cc19c4c953699d64cf"

URI_x86_64_v2_akonadi-server-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-doc-26.04.3-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_akonadi-server-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-doc}"
SRC_URI[x86_64_v2_akonadi-server-doc.sha256sum] = "05bfa448d59dc941f9c004a4f77eb4c853c3edc3b999743527a4f9a1cd8fac8c"

URI_x86_64_v2_akonadi-server-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-server-mysql-26.04.3-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-server-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-server-mysql}"
SRC_URI[x86_64_v2_akonadi-server-mysql.sha256sum] = "bede0a3789d02d258346995b0c8addb1e5b1cb7e65a4188f55fe3986406b3240"

URI_aarch64_akonadi-server = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-26.04.3-2.el10_3.aarch64.rpm;name=aarch64_akonadi-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server}"
SRC_URI[aarch64_akonadi-server.sha256sum] = "e72c47cf8d47d1b22c6717acb91d8cfd6b1e0834592d489c9bb903fb04b37048"

URI_aarch64_akonadi-server-devel = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-devel-26.04.3-2.el10_3.aarch64.rpm;name=aarch64_akonadi-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-devel}"
SRC_URI[aarch64_akonadi-server-devel.sha256sum] = "ad23a56b7dfb556eb3e1147ddd4fd8a50680aad85b8329fd296076b5da814679"

URI_aarch64_akonadi-server-doc = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-doc-26.04.3-2.el10_3.noarch.rpm;name=aarch64_akonadi-server-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-doc}"
SRC_URI[aarch64_akonadi-server-doc.sha256sum] = "1b5c2de4e73050d94663c43a47d109706bac89f5153ab04bdeae0f188835c346"

URI_aarch64_akonadi-server-mysql = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-server-mysql-26.04.3-2.el10_3.aarch64.rpm;name=aarch64_akonadi-server-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-server-mysql}"
SRC_URI[aarch64_akonadi-server-mysql.sha256sum] = "9ae04bd97a6d66efc4d5bae16eb8955a8e89a3d0df352f33dd9e2f6211b08e87"

RDEPENDS:akonadi-server = " \
 alternatives \
 bash \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 libxml2 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 xz-libs \
 "
RDEPENDS:akonadi-server-devel = " \
 akonadi-server \
 cmake-filesystem \
 glibc \
 kf6-kconfig \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kcoreaddons-devel \
 kf6-ki18n \
 kf6-kio-devel \
 kf6-kitemmodels-devel \
 kf6-kxmlgui-devel \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:akonadi-server-doc = " \
 "
RDEPENDS:akonadi-server-mysql = " \
 akonadi-server \
 alternatives \
 bash \
 qt6-qtbase-mysql \
 virtual/mariadb-server-any \
 "
