# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hyper"
PV = "1.7.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-hyper+capi-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+ffi-devel \
 rust-hyper+full-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper+tracing-devel \
 rust-hyper-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hyper-1.7.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c68d00556334d0b9cc81befc56fc04cf7f5ae684a4311eee6a2e40598e5bdefa"

URI_x86_64_v2_rust-hyper+capi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+capi-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+capi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+capi-devel}"
SRC_URI[x86_64_v2_rust-hyper+capi-devel.sha256sum] = "2e899668723ce0a14b5fc3726069b9f66e80863ee914ac21c4a8586e72894e6f"

URI_x86_64_v2_rust-hyper+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+client-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+client-devel}"
SRC_URI[x86_64_v2_rust-hyper+client-devel.sha256sum] = "51eed7f9ca35de40e089b191125a29e5df2f8c54df8f071a5faf29e086fad83a"

URI_x86_64_v2_rust-hyper+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+default-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+default-devel}"
SRC_URI[x86_64_v2_rust-hyper+default-devel.sha256sum] = "72b777a820c4ce3e2f9d4c3a9578b0d5ef1da79f376b1e1c650b571b1086b37d"

URI_x86_64_v2_rust-hyper+ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+ffi-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+ffi-devel}"
SRC_URI[x86_64_v2_rust-hyper+ffi-devel.sha256sum] = "0e0ab685b36d48e2f1615ff57c6631f0a63935996ee8fd7842d68ba5fc1e58e2"

URI_x86_64_v2_rust-hyper+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+full-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+full-devel}"
SRC_URI[x86_64_v2_rust-hyper+full-devel.sha256sum] = "31594eaabd6b45ccfd6b76cee4e9609af609482e602f1522a083d638f43d5133"

URI_x86_64_v2_rust-hyper+http1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http1-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+http1-devel}"
SRC_URI[x86_64_v2_rust-hyper+http1-devel.sha256sum] = "5c2182e48482c2b34c87e47693fef914d71cb88f0952cf5c4bea15f7ac87ff0d"

URI_x86_64_v2_rust-hyper+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+http2-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+http2-devel}"
SRC_URI[x86_64_v2_rust-hyper+http2-devel.sha256sum] = "41f0dd41fbd0d89ba6876b63654abe57041f68e9f03733732a9dc7adf97c807b"

URI_x86_64_v2_rust-hyper+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+server-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+server-devel}"
SRC_URI[x86_64_v2_rust-hyper+server-devel.sha256sum] = "a6d3d11dcda79ecb1397236d74394bffcbde6bfcb91356f80afa9bac93c1a1cc"

URI_x86_64_v2_rust-hyper+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper+tracing-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper+tracing-devel}"
SRC_URI[x86_64_v2_rust-hyper+tracing-devel.sha256sum] = "1390a487d093915b205a20145360b276a7bfc6438e0704ff82f5844c605fce7e"

URI_x86_64_v2_rust-hyper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hyper-devel-1.7.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hyper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hyper-devel}"
SRC_URI[x86_64_v2_rust-hyper-devel.sha256sum] = "4db3856dbe0deb1da4dc1abd8e9ee74a8e6b849c4455bade4f70641649197592"

URI_aarch64_rust-hyper+capi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+capi-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper+capi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+capi-devel}"
SRC_URI[aarch64_rust-hyper+capi-devel.sha256sum] = "2ceaca743cd2e0961c2758644e515bb387ce338fcd09f38941ccfa230dba7f7c"

URI_aarch64_rust-hyper+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+client-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+client-devel}"
SRC_URI[aarch64_rust-hyper+client-devel.sha256sum] = "af721f1a21a2983856180161d172b01c010415777ea2bb8219d9ba8dd12e5d2f"

URI_aarch64_rust-hyper+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+default-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+default-devel}"
SRC_URI[aarch64_rust-hyper+default-devel.sha256sum] = "f0a920aac85ec888e5d17101004c52b28cd524f8add807436b5063f4901fa930"

URI_aarch64_rust-hyper+ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+ffi-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+ffi-devel}"
SRC_URI[aarch64_rust-hyper+ffi-devel.sha256sum] = "2fb6f65e4efe0cf92f4e8c6298c4dbb19ada31324aab5aaaaafe73cdc0941f8c"

URI_aarch64_rust-hyper+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+full-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+full-devel}"
SRC_URI[aarch64_rust-hyper+full-devel.sha256sum] = "6d4e0d93accef79fadb3e6020a21d8c2cf534d21cc36d3e5ce3086d400506ddd"

URI_aarch64_rust-hyper+http1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http1-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper+http1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+http1-devel}"
SRC_URI[aarch64_rust-hyper+http1-devel.sha256sum] = "a0fea3f988cd55fa799a13c4bdc2c77973d2b90304033ea6eb67fb287a415143"

URI_aarch64_rust-hyper+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+http2-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+http2-devel}"
SRC_URI[aarch64_rust-hyper+http2-devel.sha256sum] = "1034b994ff6914993e0a4b2446f0bea8b54921f5cdcdb2b8bd7e3ffd10fbcde6"

URI_aarch64_rust-hyper+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+server-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+server-devel}"
SRC_URI[aarch64_rust-hyper+server-devel.sha256sum] = "40def83b9154621caa03f86a6e59db555113a530997fb3a4b3b00046911e2290"

URI_aarch64_rust-hyper+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper+tracing-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper+tracing-devel}"
SRC_URI[aarch64_rust-hyper+tracing-devel.sha256sum] = "4e609c8a62a30f77c0bfe90123acd26921d9c14e0b825f4ac2665f05a197ad2e"

URI_aarch64_rust-hyper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hyper-devel-1.7.0-1.el10_0.noarch.rpm;name=aarch64_rust-hyper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hyper-devel}"
SRC_URI[aarch64_rust-hyper-devel.sha256sum] = "b6d801893202d19f792db017c82520f2b9a4b4c4e1138e589eda34e65165dcc5"

RDEPENDS:rust-hyper+capi-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+client-devel = " \
 cargo \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 rust-want+default-devel \
 "
RDEPENDS:rust-hyper+default-devel = " \
 cargo \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+ffi-devel = " \
 cargo \
 rust-futures-util+alloc-devel \
 rust-futures-util-devel \
 rust-http-body-util+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+full-devel = " \
 cargo \
 rust-hyper+client-devel \
 rust-hyper+http1-devel \
 rust-hyper+http2-devel \
 rust-hyper+server-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+http1-devel = " \
 cargo \
 rust-atomic-waker+default-devel \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-httparse+default-devel \
 rust-hyper-devel \
 rust-itoa+default-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-hyper+http2-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-futures-core+default-devel \
 rust-h2+default-devel \
 rust-hyper-devel \
 "
RDEPENDS:rust-hyper+server-devel = " \
 cargo \
 rust-httpdate+default-devel \
 rust-hyper-devel \
 rust-pin-project-lite+default-devel \
 rust-smallvec+const_generics-devel \
 rust-smallvec+const_new-devel \
 rust-smallvec+default-devel \
 "
RDEPENDS:rust-hyper+tracing-devel = " \
 cargo \
 rust-hyper-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-hyper-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
