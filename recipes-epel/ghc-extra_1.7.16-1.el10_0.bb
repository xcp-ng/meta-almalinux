# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-extra"
PV = "1.7.16"
PR = "1.el10_0"
PACKAGES = " \
 ghc-extra \
 ghc-extra-devel \
 ghc-extra-doc \
 ghc-extra-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-extra-1.7.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0a13de33454016ef7d363f4f639332974333d0a97707e81a9c8b46b7caf6aa10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-extra-1.7.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-extra;unpack=0"
SRC_URI[x86_64_v2_ghc-extra.sha256sum] = "a7065faa0978053e296d3dd2d4c5c3f34ee75a3f440862ad23bdd5a0fa250db0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-extra-devel-1.7.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-extra-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-extra-devel.sha256sum] = "31842fae77e0a80e6b8be164b8f47f7d9edf9946066d55695e8a05a943f9bad0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-extra-doc-1.7.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-extra-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-extra-doc.sha256sum] = "612e8dcb0d59ff62b7deffc0a2a91712627c1746decc0e1a6146a7225599a830"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-extra-prof-1.7.16-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-extra-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-extra-prof.sha256sum] = "8d5bc1a98d4ffb8db5b6746f394a4a9cd09bec4255156f8f73e45deb25cff5cf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-extra-1.7.16-1.el10_0.aarch64.rpm;name=aarch64_ghc-extra;unpack=0"
SRC_URI[aarch64_ghc-extra.sha256sum] = "b97fbfc2078eecfb6265f7de2b2c5049a69fc87ccc304939988c493bd57da4a7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-extra-devel-1.7.16-1.el10_0.aarch64.rpm;name=aarch64_ghc-extra-devel;unpack=0"
SRC_URI[aarch64_ghc-extra-devel.sha256sum] = "3e71df40d6e0ba7bd51bbc01a171597dc1106d09dba951f5e22559e5572316bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-extra-doc-1.7.16-1.el10_0.noarch.rpm;name=aarch64_ghc-extra-doc;unpack=0"
SRC_URI[aarch64_ghc-extra-doc.sha256sum] = "8bbb4f0d349a605c4faf846e0e33bdc8fd36a582e4e8faa2cbd3bb99d46bafed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-extra-prof-1.7.16-1.el10_0.aarch64.rpm;name=aarch64_ghc-extra-prof;unpack=0"
SRC_URI[aarch64_ghc-extra-prof.sha256sum] = "27468cd598ae6e6009ad7dd3d4994e3cb11c0d009f7e03fb4283657e4cc25f8f"

RDEPENDS:ghc-extra = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-clock \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-extra-devel = " \
 ghc-base-devel \
 ghc-clock-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-extra \
 ghc-filepath-devel \
 ghc-process-devel \
 ghc-time-devel \
 ghc-unix-devel \
 "
RDEPENDS:ghc-extra-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-extra-prof = " \
 ghc-base-prof \
 ghc-clock-prof \
 ghc-directory-prof \
 ghc-extra-devel \
 ghc-filepath-prof \
 ghc-process-prof \
 ghc-time-prof \
 ghc-unix-prof \
 "
