# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-desktop"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plasma-desktop \
 plasma-desktop-doc \
 sddm-breeze \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-desktop-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ac12d97de76633b642aa8e17c3cf56248682cafef4b8fd3d11041851942261c"

URI_x86_64_v2_plasma-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-desktop}"
SRC_URI[x86_64_v2_plasma-desktop.sha256sum] = "76001c811db2e75f52a0877261aeea3403e092fe49a004d672fc6dabefb5bedd"

URI_x86_64_v2_plasma-desktop-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-desktop-doc-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-desktop-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-desktop-doc}"
SRC_URI[x86_64_v2_plasma-desktop-doc.sha256sum] = "7000ff909a22a669acd1598d7250fb2f13f18f0836516c3e99dc63a2717419e2"

URI_x86_64_v2_sddm-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-breeze-6.3.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-breeze}"
SRC_URI[x86_64_v2_sddm-breeze.sha256sum] = "33fce67b2c52cf0b7040148ff796f29dfaf5ef5a021dc67f7a71fc932bee92fc"

URI_aarch64_plasma-desktop = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plasma-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-desktop}"
SRC_URI[aarch64_plasma-desktop.sha256sum] = "87b6c637fc000b484dbf1e6ee3152afeecb6bbda39b0d0434dac6106618f7f45"

URI_aarch64_plasma-desktop-doc = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-desktop-doc-6.3.6-1.el10_0.noarch.rpm;name=aarch64_plasma-desktop-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-desktop-doc}"
SRC_URI[aarch64_plasma-desktop-doc.sha256sum] = "b9781154b6e11c9b165ca9aae797658c4a876993d246ffdc12eb03ca1d5cf981"

URI_aarch64_sddm-breeze = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-breeze-6.3.6-1.el10_0.noarch.rpm;name=aarch64_sddm-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-breeze}"
SRC_URI[aarch64_sddm-breeze.sha256sum] = "a7822a8f548d2467d941684b3e389b3ec25166489ee552c6c80dbe51440b290f"

RDEPENDS:plasma-desktop = " \
 PackageKit-Qt6 \
 accountsservice \
 glib2 \
 glibc \
 ibus-libs \
 kaccounts-integration-qt6 \
 kde-cli-tools \
 kf6-attica \
 kf6-baloo-libs \
 kf6-kauth \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kpackage \
 kf6-krunner \
 kf6-kservice \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-qqc2-desktop-style \
 kf6-solid \
 kf6-sonnet \
 kio-extras \
 kmenuedit \
 kpipewire \
 kwin \
 kwrited \
 libX11 \
 libXi \
 libaccounts-qt6 \
 libcanberra \
 libicu \
 libksysguard \
 libkworkspace6 \
 libplasma \
 libstdc++ \
 libwacom \
 libwayland-client \
 libxcb \
 libxkbcommon \
 libxkbfile \
 plasma-activities \
 plasma-activities-stats \
 plasma-integration \
 plasma-systemsettings \
 plasma-workspace \
 plasma-workspace-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 signon-plugin-oauth2 \
 virtual/libSDL2-2.0.so.0___64bit_ \
 xcb-util-keysyms \
 xdg-utils \
 "
RDEPENDS:plasma-desktop-doc = " \
 "
RDEPENDS:sddm-breeze = " \
 desktop-backgrounds-compat \
 kde-settings-sddm \
 kf6-kimageformats \
 libplasma \
 plasma-workspace \
 qt6-qtvirtualkeyboard \
 "
