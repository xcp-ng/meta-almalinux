# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wdiff"
PV = "1.2.2"
PR = "51.el10_0"
PACKAGES = " \
 wdiff \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wdiff-1.2.2-51.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "96103fb75180638c813ad2611759497b6a8399130ac31b43a3f4eb9169b271fe"

URI_x86_64_v2_wdiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wdiff-1.2.2-51.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wdiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wdiff}"
SRC_URI[x86_64_v2_wdiff.sha256sum] = "649e30b942a426bc3add1d0bc4e3f7c7628209eaa9dcb4cd880c2d13681d73f0"

URI_aarch64_wdiff = "${EPEL_MIRROR}/aarch64/Packages/w/wdiff-1.2.2-51.el10_0.aarch64.rpm;name=aarch64_wdiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_wdiff}"
SRC_URI[aarch64_wdiff.sha256sum] = "fb9515d8538580258de917c190aebd5641f64be9637a0d4da8a788d6d2edb33c"

RDEPENDS:wdiff = " \
 glibc \
 ncurses-libs \
 "
