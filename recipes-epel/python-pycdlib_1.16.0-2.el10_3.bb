# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pycdlib"
PV = "1.16.0"
PR = "2.el10_3"
PACKAGES = " \
 pycdlib-tools \
 python3-pycdlib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pycdlib-1.16.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc9176cdb9194616e1192a9474195e3a3b12fda92afbf88eb2009927e82e2676"

URI_x86_64_v2_pycdlib-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pycdlib-tools-1.16.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pycdlib-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pycdlib-tools}"
SRC_URI[x86_64_v2_pycdlib-tools.sha256sum] = "cca197feb126378516260a5cbf6d1e328bdd6f291a867808bf62ec1be906b892"

URI_x86_64_v2_python3-pycdlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pycdlib-1.16.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pycdlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pycdlib}"
SRC_URI[x86_64_v2_python3-pycdlib.sha256sum] = "2322267433460a3ad586c644d1fa2acfbd15b6c55a93bb7185168b540bb96296"

URI_aarch64_pycdlib-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pycdlib-tools-1.16.0-2.el10_3.noarch.rpm;name=aarch64_pycdlib-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pycdlib-tools}"
SRC_URI[aarch64_pycdlib-tools.sha256sum] = "583be471fa108e1fd73d431cabc2198c394f5a8cde6696b6d257bf534c721005"

URI_aarch64_python3-pycdlib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pycdlib-1.16.0-2.el10_3.noarch.rpm;name=aarch64_python3-pycdlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pycdlib}"
SRC_URI[aarch64_python3-pycdlib.sha256sum] = "132384275bc79b7947fddba72a2df562acb366a1d250824d6b5beceec05e5f50"

RDEPENDS:pycdlib-tools = " \
 python3 \
 python3-pycdlib \
 "
RDEPENDS:python3-pycdlib = " \
 python3 \
 "
