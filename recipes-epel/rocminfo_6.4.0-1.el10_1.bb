# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rocminfo"
PV = "6.4.0"
PR = "1.el10_1"
PACKAGES:x86_64_v2 = " \
 rocminfo \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rocminfo-6.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fdf09604f49a8d0e648616708280fd54c61d1280bde3e35ad53de621eb84d033"

URI_x86_64_v2_rocminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rocminfo-6.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rocminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rocminfo}"
SRC_URI[x86_64_v2_rocminfo.sha256sum] = "24511942a5de30671afd5c2e20d32cb66fbe976cc07cb0bdcc8f2f3edff82076"

RDEPENDS:rocminfo = " \
 glibc \
 kmod \
 libgcc \
 libstdc++ \
 python3 \
 rocm-runtime \
 "
