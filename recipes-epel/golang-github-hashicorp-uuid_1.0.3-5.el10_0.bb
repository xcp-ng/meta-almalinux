# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hashicorp-uuid"
PV = "1.0.3"
PR = "5.el10_0"
PACKAGES = " \
 golang-github-hashicorp-uuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hashicorp-uuid-1.0.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0abbaab947bf3040f957d48a9e75ac3eb3b37bdb71bb67202acaf6930d2874c8"

URI_x86_64_v2_golang-github-hashicorp-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hashicorp-uuid-devel-1.0.3-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hashicorp-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hashicorp-uuid-devel}"
SRC_URI[x86_64_v2_golang-github-hashicorp-uuid-devel.sha256sum] = "2f4f7cffa1a9d4bce4f44d73692613b76f57ebada2f149e59245f490b177e2af"

URI_aarch64_golang-github-hashicorp-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hashicorp-uuid-devel-1.0.3-5.el10_0.noarch.rpm;name=aarch64_golang-github-hashicorp-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hashicorp-uuid-devel}"
SRC_URI[aarch64_golang-github-hashicorp-uuid-devel.sha256sum] = "0d560e9dfad6fa9207ea0c0cf847d6a838729f29eb99b67725c78be22a84b054"

RDEPENDS:golang-github-hashicorp-uuid-devel = " \
 go-filesystem \
 "
