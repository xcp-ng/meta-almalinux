# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ramalama"
PV = "0.14.0"
PR = "1.el10_1"
PACKAGES = " \
 ramalama \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/ramalama-0.14.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f4eb8c84aef3984f24cd6a9a9d9cba890dc7209da0e4ebff384cf8df5dc2580"

URI_x86_64_v2_ramalama = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ramalama-0.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_ramalama;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ramalama}"
SRC_URI[x86_64_v2_ramalama.sha256sum] = "5c456b709e704db473a37e0fd085e2706cce478bcf18dc7748ec6338eaaa2414"

URI_aarch64_ramalama = "${EPEL_MIRROR}/aarch64/Packages/r/ramalama-0.14.0-1.el10_1.noarch.rpm;name=aarch64_ramalama;unpack=0"
SRC_URI:append = " ${URI_aarch64_ramalama}"
SRC_URI[aarch64_ramalama.sha256sum] = "362d7a2d058867e79e11f73d7f0c35b2a4a85587f322a3ee75058c3f9967c46d"

RDEPENDS:ramalama = " \
 podman \
 python3 \
 python3-argcomplete \
 python3-jinja2 \
 python3-jsonschema \
 python3-pyyaml \
 "
