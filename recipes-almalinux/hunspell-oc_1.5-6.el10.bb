# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-oc"
PV = "1.5"
PR = "6.el10"
PACKAGES = " \
 hunspell-oc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-oc-1.5-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebd3c2d0d9c6684bdf130839d9bb3f26e535cfd929e4b9ecc1bacefbed0ed15e"

URI_x86_64_v2_hunspell-oc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-oc-1.5-6.el10.noarch.rpm;name=x86_64_v2_hunspell-oc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-oc}"
SRC_URI[x86_64_v2_hunspell-oc.sha256sum] = "80a45f6ef40a7a2a30691b7c1cbf4216efc5790b6dc87b1a405b8a4ea84a9f9b"

URI_aarch64_hunspell-oc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-oc-1.5-6.el10.noarch.rpm;name=aarch64_hunspell-oc;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-oc}"
SRC_URI[aarch64_hunspell-oc.sha256sum] = "80a45f6ef40a7a2a30691b7c1cbf4216efc5790b6dc87b1a405b8a4ea84a9f9b"

RDEPENDS:hunspell-oc = " \
 hunspell \
 "
