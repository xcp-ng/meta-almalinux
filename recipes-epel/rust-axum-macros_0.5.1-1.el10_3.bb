# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-axum-macros"
PV = "0.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-axum-macros+__private-devel \
 rust-axum-macros+default-devel \
 rust-axum-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-axum-macros-0.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8138ce7d4f85b5df7e9f7c889eda4eed515b2e2bc12c1048da25aa10cd0e8364"

URI_x86_64_v2_rust-axum-macros+__private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros+__private-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros+__private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros+__private-devel}"
SRC_URI[x86_64_v2_rust-axum-macros+__private-devel.sha256sum] = "c674716cf3bf82b2cd27712b2e16bb3b95f281e5b11ed29ce1e10ea227d7c97e"

URI_x86_64_v2_rust-axum-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros+default-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros+default-devel}"
SRC_URI[x86_64_v2_rust-axum-macros+default-devel.sha256sum] = "78f820caf31d10abde82ee74ead04c8610ea3c5473ee0d4999cb3a1fac5d53fc"

URI_x86_64_v2_rust-axum-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-axum-macros-devel-0.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-axum-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-axum-macros-devel}"
SRC_URI[x86_64_v2_rust-axum-macros-devel.sha256sum] = "687a9ea6b64357fc4facc723b3279fcbacf9401ef8464836129d6f20cb0ae1fc"

URI_aarch64_rust-axum-macros+__private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros+__private-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-axum-macros+__private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros+__private-devel}"
SRC_URI[aarch64_rust-axum-macros+__private-devel.sha256sum] = "75e0603c67be3b3a2ec8b2f92b86432c09ed824bb14a7146aefaffd1f74b6ddf"

URI_aarch64_rust-axum-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros+default-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-axum-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros+default-devel}"
SRC_URI[aarch64_rust-axum-macros+default-devel.sha256sum] = "91aa4f9977db07c15e539a73ffe71ab0cc363a8fbc3fda88d671a61281226835"

URI_aarch64_rust-axum-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-axum-macros-devel-0.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-axum-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-axum-macros-devel}"
SRC_URI[aarch64_rust-axum-macros-devel.sha256sum] = "e11d77e314a234ee0362d310f7cb3f0c111619ddbf5b78a7179fff49ba62c0a4"

RDEPENDS:rust-axum-macros+__private-devel = " \
 cargo \
 rust-axum-macros-devel \
 rust-syn2+visit-mut-devel \
 "
RDEPENDS:rust-axum-macros+default-devel = " \
 cargo \
 rust-axum-macros-devel \
 "
RDEPENDS:rust-axum-macros-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 "
