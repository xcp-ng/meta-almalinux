# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kapman"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kapman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kapman-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "422d98db9027bc80ea276066be03f56460ef7566426260b7db900aa8038a8979"

URI_x86_64_v2_kapman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kapman-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kapman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kapman}"
SRC_URI[x86_64_v2_kapman.sha256sum] = "667730f29b77766db09334bfcce8fcfc5c6b55b055472cc3cb4e4783810ad13e"

URI_aarch64_kapman = "${EPEL_MIRROR}/aarch64/Packages/k/kapman-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kapman;unpack=0"
SRC_URI:append = " ${URI_aarch64_kapman}"
SRC_URI[aarch64_kapman.sha256sum] = "342eef0610d4891f5fd60fff19e96806c9e15d689fa455d217e3e0e42760e627"

RDEPENDS:kapman = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
