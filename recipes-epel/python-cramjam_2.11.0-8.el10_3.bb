# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cramjam"
PV = "2.11.0"
PR = "8.el10_3"
PACKAGES = " \
 python3-cramjam \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cramjam-2.11.0-8.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6d9e76a1040be7b78a81eba19b243a9797a46216d21b9f39e5dfd5cb8fc18d40"

URI_x86_64_v2_python3-cramjam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cramjam-2.11.0-8.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-cramjam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cramjam}"
SRC_URI[x86_64_v2_python3-cramjam.sha256sum] = "50db58122f76b91897c7257f9e0ed5f6c7f55103d4bb8de1abbe6291ef765b79"

URI_aarch64_python3-cramjam = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cramjam-2.11.0-8.el10_3.aarch64.rpm;name=aarch64_python3-cramjam;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cramjam}"
SRC_URI[aarch64_python3-cramjam.sha256sum] = "0323120a7df6e76b71ed8dc5d87e968f77dadb2c1a01c3c790156a7e26a3543b"

RDEPENDS:python3-cramjam = " \
 glibc \
 libgcc \
 libzstd \
 lz4-libs \
 python3 \
 xz-libs \
 "
