# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sddm-kcm"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 sddm-kcm \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sddm-kcm-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dc3346f174b1ad141d4d413b4624c58f6a54928eafc78f6e6c221c34f15ebd75"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-kcm-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sddm-kcm;unpack=0"
SRC_URI[x86_64_v2_sddm-kcm.sha256sum] = "85592052cab3717bc044e5b2c62402f559f64c7cb258feb083dd9fdcfbbf0e26"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sddm-kcm-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_sddm-kcm;unpack=0"
SRC_URI[aarch64_sddm-kcm.sha256sum] = "c45005961d03554b88be782db98e7ed1e55d0cf987ed9440dbfc1d396abc80a3"

RDEPENDS:sddm-kcm = " \
 glibc \
 kf6-karchive \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 sddm \
 "
