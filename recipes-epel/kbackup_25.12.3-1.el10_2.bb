# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbackup"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbackup-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2768b746288250b0766924dde0216e6ed3a38691781fae0305f29f5108c659b6"

URI_x86_64_v2_kbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbackup-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbackup}"
SRC_URI[x86_64_v2_kbackup.sha256sum] = "42e9ff40fed09c8b2e59e3c80147ba555ca628a56e0c285274a946440a8b8674"

URI_aarch64_kbackup = "${EPEL_MIRROR}/aarch64/Packages/k/kbackup-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbackup}"
SRC_URI[aarch64_kbackup.sha256sum] = "27b9cdda445e8165b5202b795ffddd2ee05ccc77f4017c2e4ba837630fa2749d"

RDEPENDS:kbackup = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
