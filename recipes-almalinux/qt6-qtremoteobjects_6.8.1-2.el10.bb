# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtremoteobjects"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtremoteobjects \
 qt6-qtremoteobjects-devel \
 qt6-qtremoteobjects-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtremoteobjects-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2276e0dc390fd211efe96e73bfbc3779fd06e17d1d5b4bd2bc9c70735f9a2b8d"

URI_x86_64_v2_qt6-qtremoteobjects = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtremoteobjects-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtremoteobjects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtremoteobjects}"
SRC_URI[x86_64_v2_qt6-qtremoteobjects.sha256sum] = "5b61afacb4fd4d95b4ce655e35a0dd3b2110c021df707a0fdd25faf1f8f6abe6"

URI_x86_64_v2_qt6-qtremoteobjects-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtremoteobjects-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtremoteobjects-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtremoteobjects-devel}"
SRC_URI[x86_64_v2_qt6-qtremoteobjects-devel.sha256sum] = "f524498d3b7119d367f1c30b6f6c9a53a0a5029ad67bf35e04b5d43ad48ae5c8"

URI_x86_64_v2_qt6-qtremoteobjects-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtremoteobjects-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtremoteobjects-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtremoteobjects-examples}"
SRC_URI[x86_64_v2_qt6-qtremoteobjects-examples.sha256sum] = "53ebd7eb3a1017181e7928e8513fd6d02f35e7d0f23af73071de8dcfc7b5876a"

URI_aarch64_qt6-qtremoteobjects = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtremoteobjects-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtremoteobjects;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtremoteobjects}"
SRC_URI[aarch64_qt6-qtremoteobjects.sha256sum] = "983bccbb9deb98e9ef8d61b0ef0701342005ca62456d490d46ec4d2d48517da1"

URI_aarch64_qt6-qtremoteobjects-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtremoteobjects-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtremoteobjects-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtremoteobjects-devel}"
SRC_URI[aarch64_qt6-qtremoteobjects-devel.sha256sum] = "a7a4bc0cd210982cf3755b18f61bfa3c725d4eff4803e289c5726654d6f7f0f4"

URI_aarch64_qt6-qtremoteobjects-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtremoteobjects-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtremoteobjects-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtremoteobjects-examples}"
SRC_URI[aarch64_qt6-qtremoteobjects-examples.sha256sum] = "eb3afb4a80bb885f83e98e4a030b93bd2540b0561a88ba552b14379b4139a1a2"

RDEPENDS:qt6-qtremoteobjects = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtremoteobjects-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtremoteobjects \
 qt6-qtremoteobjects-devel \
 "
RDEPENDS:qt6-qtremoteobjects-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtremoteobjects \
 "
