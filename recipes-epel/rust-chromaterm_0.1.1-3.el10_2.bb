# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chromaterm"
PV = "0.1.1"
PR = "3.el10_2"
PACKAGES = " \
 rust-chromaterm+default-devel \
 rust-chromaterm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chromaterm-0.1.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "452d3e707407ddc3ae1409b308650fbb02170ab20118d4439d4b293aa1568d74"

URI_x86_64_v2_rust-chromaterm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chromaterm+default-devel-0.1.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chromaterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chromaterm+default-devel}"
SRC_URI[x86_64_v2_rust-chromaterm+default-devel.sha256sum] = "4a2211a25c953932605811f3f13e0eac755dd1f88a8ae2384502d587836b3145"

URI_x86_64_v2_rust-chromaterm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chromaterm-devel-0.1.1-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chromaterm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chromaterm-devel}"
SRC_URI[x86_64_v2_rust-chromaterm-devel.sha256sum] = "5681acf9f3d62bedffdf78f09f59b3b724cba30029eb51c1697e6edd792c2e70"

URI_aarch64_rust-chromaterm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chromaterm+default-devel-0.1.1-3.el10_2.noarch.rpm;name=aarch64_rust-chromaterm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chromaterm+default-devel}"
SRC_URI[aarch64_rust-chromaterm+default-devel.sha256sum] = "eaae7deee4213032fd3134da5a04c70afd7b70ebd09777547a585128b714a7ac"

URI_aarch64_rust-chromaterm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chromaterm-devel-0.1.1-3.el10_2.noarch.rpm;name=aarch64_rust-chromaterm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chromaterm-devel}"
SRC_URI[aarch64_rust-chromaterm-devel.sha256sum] = "f2b74fa8bb573a1dc7bd37f46999bfa803e9fb2b2ca6ac115161b1d8e6d85b0e"

RDEPENDS:rust-chromaterm+default-devel = " \
 cargo \
 rust-chromaterm-devel \
 "
RDEPENDS:rust-chromaterm-devel = " \
 cargo \
 rust \
 "
