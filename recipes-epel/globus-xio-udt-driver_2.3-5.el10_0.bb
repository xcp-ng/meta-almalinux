# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xio-udt-driver"
PV = "2.3"
PR = "5.el10_0"
PACKAGES = " \
 globus-xio-udt-driver \
 globus-xio-udt-driver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-xio-udt-driver-2.3-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "042c68915c9a33c43aaeff415702ece220d3b55a3e6d4366f58693d92034cbcd"

URI_x86_64_v2_globus-xio-udt-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-udt-driver-2.3-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-udt-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-udt-driver}"
SRC_URI[x86_64_v2_globus-xio-udt-driver.sha256sum] = "9980c7df911854af1423c2904056be1edadaec50e40f68d47d6f9ea0ad2d44ef"

URI_x86_64_v2_globus-xio-udt-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-udt-driver-devel-2.3-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-udt-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-udt-driver-devel}"
SRC_URI[x86_64_v2_globus-xio-udt-driver-devel.sha256sum] = "23118efe953c5188739754200f97405438b2c22c3b09f94febc4117199817a65"

URI_aarch64_globus-xio-udt-driver = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-udt-driver-2.3-5.el10_0.aarch64.rpm;name=aarch64_globus-xio-udt-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-udt-driver}"
SRC_URI[aarch64_globus-xio-udt-driver.sha256sum] = "0530b8473bc7b89da4822cae83ac3f1f41b2a194fffbe80fdd88c25164b30821"

URI_aarch64_globus-xio-udt-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-udt-driver-devel-2.3-5.el10_0.aarch64.rpm;name=aarch64_globus-xio-udt-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-udt-driver-devel}"
SRC_URI[aarch64_globus-xio-udt-driver-devel.sha256sum] = "98dce4a325d8cef78f3e2555d529b7332c4a1c70799641d687b186951be1d336"

RDEPENDS:globus-xio-udt-driver = " \
 glib2 \
 glibc \
 globus-common \
 globus-xio \
 libgcc \
 libnice \
 libstdc++ \
 udt \
 "
RDEPENDS:globus-xio-udt-driver-devel = " \
 globus-common-devel \
 globus-xio-devel \
 globus-xio-udt-driver \
 pkgconf-pkg-config \
 "
