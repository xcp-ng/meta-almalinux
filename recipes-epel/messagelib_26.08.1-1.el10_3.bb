# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "messagelib"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 messagelib \
 messagelib-devel \
 messagelib-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/m/messagelib-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "90d72680a133e3ecf903306a8d08f1b23fcabb93719dd0c792794da0b2f6d84a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib;unpack=0"
SRC_URI[x86_64_v2_messagelib.sha256sum] = "0ad53fa6e91f93df88652e0ff3ee9bd61ada7262e2b266a9413fc683d6d357b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_messagelib-devel;unpack=0"
SRC_URI[x86_64_v2_messagelib-devel.sha256sum] = "bf3c536751a401ce14cb81859933f29f4168db2d4af82d09bb07cc567c9ade19"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/messagelib-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_messagelib-doc;unpack=0"
SRC_URI[x86_64_v2_messagelib-doc.sha256sum] = "3bd365228d73685ea48efb1e9085ca204404cef73f928551f81ba5ee20f5ded5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/messagelib-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_messagelib;unpack=0"
SRC_URI[aarch64_messagelib.sha256sum] = "9e4e3a630c9f7b33e1b6c326ae6021ecef949b154c693307cf356a4703c19034"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/messagelib-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_messagelib-devel;unpack=0"
SRC_URI[aarch64_messagelib-devel.sha256sum] = "fcd0d8e6b88d1a72319636e0d4d6363b1dcbc233cd420454918b1047a38046f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/messagelib-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_messagelib-doc;unpack=0"
SRC_URI[aarch64_messagelib-doc.sha256sum] = "20220b1b3bcc9cf4b07e36b912b17b801bd3b0720defd60ee611f9a7ed5c57a6"

RDEPENDS:messagelib = " \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgme2pp \
 grantleetheme \
 kf6-karchive \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kmime \
 kf6-kservice \
 kf6-ktexttemplate \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 kidentitymanagement \
 kmailtransport \
 kmbox \
 kpimtextedit \
 ktextaddons-qt6 \
 libgcc \
 libgravatar \
 libkdepim \
 libkleo \
 libstdc++ \
 openssl-libs \
 pimcommon \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:messagelib-devel = " \
 akonadi-mime-devel \
 akonadi-server-devel \
 cmake-filesystem \
 kf6-kcontacts-devel \
 kf6-kmime-devel \
 kidentitymanagement-devel \
 libkleo-devel \
 messagelib \
 pimcommon-devel \
 qt6-qtwebengine-devel \
 "
RDEPENDS:messagelib-doc = " \
 "
