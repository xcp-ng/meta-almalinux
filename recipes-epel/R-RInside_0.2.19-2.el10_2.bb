# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-RInside"
PV = "0.2.19"
PR = "2.el10_2"
PACKAGES = " \
 R-RInside \
 R-RInside-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-RInside-0.2.19-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7100b307beb661635a6cfd8896cd38fabbc5fbe7a393658d6ad1a3251334513a"

URI_x86_64_v2_R-RInside = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-RInside-0.2.19-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-RInside;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-RInside}"
SRC_URI[x86_64_v2_R-RInside.sha256sum] = "8f3d4e31cc0a553510c3fd0c3db41bef5aca3141245c35dc873a57d4c175983d"

URI_x86_64_v2_R-RInside-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-RInside-examples-0.2.19-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-RInside-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-RInside-examples}"
SRC_URI[x86_64_v2_R-RInside-examples.sha256sum] = "557372580efe8a9968c78370122e87f6827a4b2feb20a0120a48d0c9d1668985"

URI_aarch64_R-RInside = "${EPEL_MIRROR}/aarch64/Packages/r/R-RInside-0.2.19-2.el10_2.aarch64.rpm;name=aarch64_R-RInside;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-RInside}"
SRC_URI[aarch64_R-RInside.sha256sum] = "fec32c647ea8a6ddac6fe577ab2d01d3c3f21b807b68e9cd913ad790ad1f48f0"

URI_aarch64_R-RInside-examples = "${EPEL_MIRROR}/aarch64/Packages/r/R-RInside-examples-0.2.19-2.el10_2.aarch64.rpm;name=aarch64_R-RInside-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-RInside-examples}"
SRC_URI[aarch64_R-RInside-examples.sha256sum] = "45642ceb0719d4a44fb3275bc62b08b5620fbb7dccfffd97465b59ebc8e8a78b"

RDEPENDS:R-RInside = " \
 R-Rcpp \
 R-core \
 R-core-devel \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:R-RInside-examples = " \
 R-RInside \
 "
