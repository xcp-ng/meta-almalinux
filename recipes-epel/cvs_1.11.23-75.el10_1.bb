# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cvs"
PV = "1.11.23"
PR = "75.el10_1"
PACKAGES = " \
 cvs \
 cvs-contrib \
 cvs-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cvs-1.11.23-75.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3fb64355f7a419793f2a2fe2c82247f13baa8b256115650c4957397c9820cb8a"

URI_x86_64_v2_cvs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cvs-1.11.23-75.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cvs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cvs}"
SRC_URI[x86_64_v2_cvs.sha256sum] = "e54c8f566f2591eaa3377831293ba43a13ec5690e23d56ea03c9880fe5ee49d2"

URI_x86_64_v2_cvs-contrib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cvs-contrib-1.11.23-75.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_cvs-contrib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cvs-contrib}"
SRC_URI[x86_64_v2_cvs-contrib.sha256sum] = "a49febe74edf1e642966a548c02afb40741ca32e286849f555b27f77094a98a1"

URI_x86_64_v2_cvs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cvs-doc-1.11.23-75.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cvs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cvs-doc}"
SRC_URI[x86_64_v2_cvs-doc.sha256sum] = "408f5c6b6fad731d729ca6b523b14eb539e0cca8f59ba7251a441ab5e57c9fbb"

URI_aarch64_cvs = "${EPEL_MIRROR}/aarch64/Packages/c/cvs-1.11.23-75.el10_1.aarch64.rpm;name=aarch64_cvs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cvs}"
SRC_URI[aarch64_cvs.sha256sum] = "c48315d21ecd67393dd76eeda3c4a4100e5476b489bc4b2a71c3858af528661e"

URI_aarch64_cvs-contrib = "${EPEL_MIRROR}/aarch64/Packages/c/cvs-contrib-1.11.23-75.el10_1.noarch.rpm;name=aarch64_cvs-contrib;unpack=0"
SRC_URI:append = " ${URI_aarch64_cvs-contrib}"
SRC_URI[aarch64_cvs-contrib.sha256sum] = "e4453ddc1212211faba7938041dda76c1877f19d2a9976f3ecd96ae3fb713f2a"

URI_aarch64_cvs-doc = "${EPEL_MIRROR}/aarch64/Packages/c/cvs-doc-1.11.23-75.el10_1.aarch64.rpm;name=aarch64_cvs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_cvs-doc}"
SRC_URI[aarch64_cvs-doc.sha256sum] = "4c3e933661d8e01ce185e4644df70360934c89c5e9a966535c27fdf985efc383"

RDEPENDS:cvs = " \
 bash \
 glibc \
 krb5-libs \
 libxcrypt \
 pam-libs \
 vim-minimal \
 zlib-ng-compat \
 "
RDEPENDS:cvs-contrib = " \
 bash \
 cvs \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IO \
 perl-PathTools \
 perl-Perl4-CoreLibs \
 perl-interpreter \
 perl-libs \
 tcsh \
 "
RDEPENDS:cvs-doc = " \
 "
