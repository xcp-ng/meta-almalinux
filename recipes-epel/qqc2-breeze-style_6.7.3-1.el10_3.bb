# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qqc2-breeze-style"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 qqc2-breeze-style \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qqc2-breeze-style-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4aa106e9d4bad956e6f6a49da3e4b3a7e5f8ff7a1fbae8cacc0ac4ab064c26e4"

URI_x86_64_v2_qqc2-breeze-style = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qqc2-breeze-style-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qqc2-breeze-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qqc2-breeze-style}"
SRC_URI[x86_64_v2_qqc2-breeze-style.sha256sum] = "3f36f51144b914312aa94e680daf0d11ec159cfa48476337255bcc861403b345"

URI_aarch64_qqc2-breeze-style = "${EPEL_MIRROR}/aarch64/Packages/q/qqc2-breeze-style-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_qqc2-breeze-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_qqc2-breeze-style}"
SRC_URI[aarch64_qqc2-breeze-style.sha256sum] = "4a00d47a9f2b1473f2fc052155fae588f7ac2ea3e68a8de7cd1f296c72e03ed2"

RDEPENDS:qqc2-breeze-style = " \
 cmake-filesystem \
 glibc \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kquickcharts \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
