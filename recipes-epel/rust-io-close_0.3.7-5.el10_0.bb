# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-io-close"
PV = "0.3.7"
PR = "5.el10_0"
PACKAGES = " \
 rust-io-close+default-devel \
 rust-io-close-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-io-close-0.3.7-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7ab76ba1a8a2021fd668e18de8440580f142900c4a95e714b1e5c7ae03adadb"

URI_x86_64_v2_rust-io-close+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-close+default-devel-0.3.7-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-close+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-close+default-devel}"
SRC_URI[x86_64_v2_rust-io-close+default-devel.sha256sum] = "cfa7e321ead3acb0099de3949ae906ea4ff3d7577f9ac48f2d552b9aa1b171a3"

URI_x86_64_v2_rust-io-close-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-close-devel-0.3.7-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-close-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-close-devel}"
SRC_URI[x86_64_v2_rust-io-close-devel.sha256sum] = "8d4367f748f0c7b632105b0184caf3736fb6c0d63faff1a4903614a764ba5559"

URI_aarch64_rust-io-close+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-close+default-devel-0.3.7-5.el10_0.noarch.rpm;name=aarch64_rust-io-close+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-close+default-devel}"
SRC_URI[aarch64_rust-io-close+default-devel.sha256sum] = "a6bb0353141bfe9740dbf8654046392d10a2a8d3099558ad908078e3b8d3093d"

URI_aarch64_rust-io-close-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-close-devel-0.3.7-5.el10_0.noarch.rpm;name=aarch64_rust-io-close-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-close-devel}"
SRC_URI[aarch64_rust-io-close-devel.sha256sum] = "23b4be446f85d0c734da57f91d0f7698e225679cac0b992cdab465c423a1a9be"

RDEPENDS:rust-io-close+default-devel = " \
 cargo \
 rust-io-close-devel \
 "
RDEPENDS:rust-io-close-devel = " \
 cargo \
 rust-libc+default-devel \
 "
