# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-ocaml"
PV = "0.24.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-tree-sitter-ocaml+default-devel \
 rust-tree-sitter-ocaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-ocaml-0.24.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4fdbf3fc16e16fb66e397d5da74b39b8368b014e9be8abb01605f91312f6b3a4"

URI_x86_64_v2_rust-tree-sitter-ocaml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ocaml+default-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ocaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ocaml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ocaml+default-devel.sha256sum] = "e56397e82ba96c289915887f503e8eca455ca09844c72e616edfda9c638dffa5"

URI_x86_64_v2_rust-tree-sitter-ocaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-ocaml-devel-0.24.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-ocaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-ocaml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-ocaml-devel.sha256sum] = "1eb594193fd8547980ad301de1e160a1d8a0726041b18ee9680e635cccdfe301"

URI_aarch64_rust-tree-sitter-ocaml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ocaml+default-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-ocaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ocaml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-ocaml+default-devel.sha256sum] = "23d6e40d3977616b63ee380f1bfd45cb4d7a93ab30b7ba36aad9bf4a57b30f61"

URI_aarch64_rust-tree-sitter-ocaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-ocaml-devel-0.24.2-1.el10_1.noarch.rpm;name=aarch64_rust-tree-sitter-ocaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-ocaml-devel}"
SRC_URI[aarch64_rust-tree-sitter-ocaml-devel.sha256sum] = "cba77e65f095ddda5c9f87b3b81819e6f00717cded3ff12fa3398d8a22fedd8e"

RDEPENDS:rust-tree-sitter-ocaml+default-devel = " \
 cargo \
 rust-tree-sitter-ocaml-devel \
 "
RDEPENDS:rust-tree-sitter-ocaml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
