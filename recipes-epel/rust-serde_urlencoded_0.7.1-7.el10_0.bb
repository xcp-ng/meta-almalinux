# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_urlencoded"
PV = "0.7.1"
PR = "7.el10_0"
PACKAGES = " \
 rust-serde_urlencoded+default-devel \
 rust-serde_urlencoded-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_urlencoded-0.7.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2dea863468d4cd85de87d6b8682240e2651c6a2edeb586fda6cbc26e1b20d29c"

URI_x86_64_v2_rust-serde_urlencoded+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_urlencoded+default-devel-0.7.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_urlencoded+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_urlencoded+default-devel}"
SRC_URI[x86_64_v2_rust-serde_urlencoded+default-devel.sha256sum] = "0f793b757c9acd32f5889a55ce6194f3c22e3819e9af2a0583cb438e6ce06671"

URI_x86_64_v2_rust-serde_urlencoded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_urlencoded-devel-0.7.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_urlencoded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_urlencoded-devel}"
SRC_URI[x86_64_v2_rust-serde_urlencoded-devel.sha256sum] = "be9ff4fc3bfcce6747a40c7b593141dd0c75179198b72269b89cd8851522e152"

URI_aarch64_rust-serde_urlencoded+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_urlencoded+default-devel-0.7.1-7.el10_0.noarch.rpm;name=aarch64_rust-serde_urlencoded+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_urlencoded+default-devel}"
SRC_URI[aarch64_rust-serde_urlencoded+default-devel.sha256sum] = "62750c37ddc1b38a97a3bd9174c26663edf111a0dd80a3baaf970007623f3fda"

URI_aarch64_rust-serde_urlencoded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_urlencoded-devel-0.7.1-7.el10_0.noarch.rpm;name=aarch64_rust-serde_urlencoded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_urlencoded-devel}"
SRC_URI[aarch64_rust-serde_urlencoded-devel.sha256sum] = "1f528fc23e47b1c2ac3f913f92ddaf38137d42bbef1ef7a9eb725c375191a9b3"

RDEPENDS:rust-serde_urlencoded+default-devel = " \
 cargo \
 rust-serde_urlencoded-devel \
 "
RDEPENDS:rust-serde_urlencoded-devel = " \
 cargo \
 rust-form_urlencoded+default-devel \
 rust-itoa+default-devel \
 rust-ryu+default-devel \
 rust-serde+default-devel \
 "
