# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pulldown-cmark"
PV = "0.13.1"
PR = "1.el10_1"
PACKAGES = " \
 pulldown-cmark \
 rust-pulldown-cmark+default-devel \
 rust-pulldown-cmark+gen-tests-devel \
 rust-pulldown-cmark+getopts-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark+pulldown-cmark-escape-devel \
 rust-pulldown-cmark+serde-devel \
 rust-pulldown-cmark+simd-devel \
 rust-pulldown-cmark-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pulldown-cmark-0.13.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c57ccea5db03211f71cede3c669a5d229c4ce654f9b335406b04c618f5aea9f2"

URI_x86_64_v2_pulldown-cmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulldown-cmark-0.13.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulldown-cmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulldown-cmark}"
SRC_URI[x86_64_v2_pulldown-cmark.sha256sum] = "1adc016a69493d3fc3eb7252c7d38dda822fc10d72b1da9ce46d7e91208554e5"

URI_x86_64_v2_rust-pulldown-cmark+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+default-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+default-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+default-devel.sha256sum] = "43fa4e0b58abcf785648e1bbcdf443da944d55ef16f53efd47c6d75edeb0cadf"

URI_x86_64_v2_rust-pulldown-cmark+gen-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+gen-tests-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+gen-tests-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+gen-tests-devel.sha256sum] = "c04509c878412cde393fbee355403e5664a4a6bc6ab9e1b9408885f02541d91f"

URI_x86_64_v2_rust-pulldown-cmark+getopts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+getopts-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+getopts-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+getopts-devel.sha256sum] = "d9fdd1f7ad1c8b24cb1d308abc28a192d7d4ed277e5b7f47d51dc39232d89f05"

URI_x86_64_v2_rust-pulldown-cmark+html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+html-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+html-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+html-devel.sha256sum] = "8e2a54450c3235c4af58534b33e26b429bf2110a9ef7dce81569f79b7436a043"

URI_x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+pulldown-cmark-escape-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel.sha256sum] = "8bf683261db1eeab0de95e152b63214e4e622a07985c014de01b9d0c65210f01"

URI_x86_64_v2_rust-pulldown-cmark+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+serde-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+serde-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+serde-devel.sha256sum] = "b4f39e2b42b04aaacff3ae5a5fb9a93a7110790d5bbd7daf42e6886fe92b7220"

URI_x86_64_v2_rust-pulldown-cmark+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+simd-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+simd-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+simd-devel.sha256sum] = "8957954ca0561fa6713f005e43e87cbc1b66e7fcc0c94ce52ed9d72c30fa5328"

URI_x86_64_v2_rust-pulldown-cmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark-devel.sha256sum] = "43b29031c0008f0481d70b20cf0c9ebe4091f45547b2cdc4f4b4292f65f8a098"

URI_aarch64_pulldown-cmark = "${EPEL_MIRROR}/aarch64/Packages/p/pulldown-cmark-0.13.1-1.el10_1.aarch64.rpm;name=aarch64_pulldown-cmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulldown-cmark}"
SRC_URI[aarch64_pulldown-cmark.sha256sum] = "ef18f1193001d856bec2c8956026ef89e1806c81772409d4ebb4045bcf59f300"

URI_aarch64_rust-pulldown-cmark+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+default-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-pulldown-cmark+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+default-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+default-devel.sha256sum] = "3a0137d43b40e4b107f5000d20f2843c02afd299c030acbb06e41231749da4e9"

URI_aarch64_rust-pulldown-cmark+gen-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+gen-tests-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-pulldown-cmark+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+gen-tests-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+gen-tests-devel.sha256sum] = "03c5d54e6992a32643e8716192013a59d424085d23785bc9436adf70d134db7b"

URI_aarch64_rust-pulldown-cmark+getopts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+getopts-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-pulldown-cmark+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+getopts-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+getopts-devel.sha256sum] = "31383dbb55e6c56f163b6f880eba4a1675c85613a69e21cf3f87866cae3ac439"

URI_aarch64_rust-pulldown-cmark+html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+html-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-pulldown-cmark+html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+html-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+html-devel.sha256sum] = "bac1b0b7a4e3f8c6f6357e5832535e4e259fb33cd39e0511bf31740de4a84b17"

URI_aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+pulldown-cmark-escape-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel.sha256sum] = "73cb5f114375ee0c56d68d3cf83984336abbc14dfbb2b1f2d49b7f22b890a224"

URI_aarch64_rust-pulldown-cmark+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+serde-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-pulldown-cmark+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+serde-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+serde-devel.sha256sum] = "99ebfaae9be3f5b3c8a377ced413869bc02ab3fe9d5ae07ef1678c9d610fec07"

URI_aarch64_rust-pulldown-cmark+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+simd-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-pulldown-cmark+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+simd-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+simd-devel.sha256sum] = "1ac7d5837b5071ea79bc8f59db66e60455608216e453a019bfe9a95815fb87d5"

URI_aarch64_rust-pulldown-cmark-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark-devel}"
SRC_URI[aarch64_rust-pulldown-cmark-devel.sha256sum] = "16322b48824749a11b3865453927bb520a56c06318e73ee6a89ab2477172465e"

RDEPENDS:pulldown-cmark = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-pulldown-cmark+default-devel = " \
 cargo \
 rust-pulldown-cmark+getopts-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+gen-tests-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+getopts-devel = " \
 cargo \
 rust-getopts+default-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+html-devel = " \
 cargo \
 rust-pulldown-cmark+pulldown-cmark-escape-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+pulldown-cmark-escape-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-pulldown-cmark-escape+default-devel \
 "
RDEPENDS:rust-pulldown-cmark+serde-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-pulldown-cmark+simd-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-pulldown-cmark-escape+default-devel \
 rust-pulldown-cmark-escape+simd-devel \
 "
RDEPENDS:rust-pulldown-cmark-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-memchr+default-devel \
 rust-unicase+default-devel \
 "
