# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-pushd"
PV = "1.016"
PR = "23.el10"
PACKAGES = " \
 perl-File-pushd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-File-pushd-1.016-23.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc8453535d1daa395c9614a9c139be99062ef924708cd2b1d5ad6c967ddd795e"

URI_x86_64_v2_perl-File-pushd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-File-pushd-1.016-23.el10.noarch.rpm;name=x86_64_v2_perl-File-pushd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-pushd}"
SRC_URI[x86_64_v2_perl-File-pushd.sha256sum] = "a052e73d7b6a9c1738f7b31d94989823ebb9ae42c53039cd6b9ba32b6980d74c"

URI_aarch64_perl-File-pushd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-File-pushd-1.016-23.el10.noarch.rpm;name=aarch64_perl-File-pushd;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-pushd}"
SRC_URI[aarch64_perl-File-pushd.sha256sum] = "a052e73d7b6a9c1738f7b31d94989823ebb9ae42c53039cd6b9ba32b6980d74c"

RDEPENDS:perl-File-pushd = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Path \
 perl-File-Temp \
 perl-PathTools \
 perl-libs \
 perl-overload \
 "
