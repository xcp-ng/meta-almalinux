# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "msr-tools"
PV = "1.3"
PR = "27.el10_0"
PACKAGES:x86_64_v2 = " \
 msr-tools \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/m/msr-tools-1.3-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1efc9e9d21304d7df2a7c2d60f07f59b2229fcc8e850c681aad2b4cf443b3d6"

URI_x86_64_v2_msr-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/msr-tools-1.3-27.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_msr-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_msr-tools}"
SRC_URI[x86_64_v2_msr-tools.sha256sum] = "ed2109170d0ca8a70a76b414b6a7f345bbeb2beb28f01ed32f304550ff574f8f"

RDEPENDS:msr-tools = " \
 glibc \
 "
