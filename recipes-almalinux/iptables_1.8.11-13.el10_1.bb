# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iptables"
PV = "1.8.11"
PR = "13.el10_1"
PACKAGES = " \
 iptables-devel \
 iptables-libs \
 iptables-nft \
 iptables-nft-services \
 iptables-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/iptables-1.8.11-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab55b86c2fd896cfedcc58b79b51b33c41adc84f0760cf8433c42f60ba26c633"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - iptables-nft: (kernel-64k-debug-modules-extra if kernel-64k-debug-modules-core)
# - iptables-nft: (kernel-64k-modules-extra if kernel-64k-modules-core)
# - iptables-nft: (kernel-rt-64k-debug-modules-extra if kernel-rt-64k-debug-modules-core)
# - iptables-nft: (kernel-rt-64k-modules-extra if kernel-rt-64k-modules-core)
# - iptables-nft: (kernel-rt-debug-modules-extra if kernel-rt-debug-modules-core)
# - iptables-nft: (kernel-rt-modules-extra if kernel-rt-modules-core)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - iptables-nft: (kernel-rt-64k-debug-modules-extra if kernel-rt-64k-debug-modules-core)
# - iptables-nft: (kernel-rt-64k-modules-extra if kernel-rt-64k-modules-core)
# - iptables-nft: (kernel-rt-debug-modules-extra if kernel-rt-debug-modules-core)
# - iptables-nft: (kernel-rt-modules-extra if kernel-rt-modules-core)

URI_x86_64_v2_iptables-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-devel-1.8.11-13.el10_1.x86_64_v2.rpm;name=x86_64_v2_iptables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-devel}"
SRC_URI[x86_64_v2_iptables-devel.sha256sum] = "84900285d470aeca830dd65d770769d913e493588363cec40deb93d3bd9af132"

URI_x86_64_v2_iptables-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/iptables-libs-1.8.11-13.el10_1.x86_64_v2.rpm;name=x86_64_v2_iptables-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-libs}"
SRC_URI[x86_64_v2_iptables-libs.sha256sum] = "ba7068903814a9ddff3894806d26624cb5a257e187b919e73ccc1f4c45811e3c"

URI_x86_64_v2_iptables-nft = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-1.8.11-13.el10_1.x86_64_v2.rpm;name=x86_64_v2_iptables-nft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-nft}"
SRC_URI[x86_64_v2_iptables-nft.sha256sum] = "baac2fe6733eb5d64c72402ee19220918f674354a9bb011aa351c8f8f6fa7fdf"

URI_x86_64_v2_iptables-nft-services = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-nft-services-1.8.11-13.el10_1.noarch.rpm;name=x86_64_v2_iptables-nft-services;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-nft-services}"
SRC_URI[x86_64_v2_iptables-nft-services.sha256sum] = "50981e124d50d3689579362e985275b02a55db31689fb3a51c10bb7fca612a36"

URI_x86_64_v2_iptables-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/iptables-utils-1.8.11-13.el10_1.x86_64_v2.rpm;name=x86_64_v2_iptables-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iptables-utils}"
SRC_URI[x86_64_v2_iptables-utils.sha256sum] = "9c80756c141eb6c1d5616962d2de1d7777d4760fd6d2344781106cb86a99d64e"

URI_aarch64_iptables-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-devel-1.8.11-13.el10_1.aarch64.rpm;name=aarch64_iptables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-devel}"
SRC_URI[aarch64_iptables-devel.sha256sum] = "d2ad3412e714174bf2c8f59650c2666ccfe60f5a02f15d57847d6a117f5dfb1e"

URI_aarch64_iptables-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/iptables-libs-1.8.11-13.el10_1.aarch64.rpm;name=aarch64_iptables-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-libs}"
SRC_URI[aarch64_iptables-libs.sha256sum] = "29e7af87fe6c663bc5e54ea5d45d047ec0aaf2b2f3b2f010242468348a3f7bf9"

URI_aarch64_iptables-nft = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-1.8.11-13.el10_1.aarch64.rpm;name=aarch64_iptables-nft;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-nft}"
SRC_URI[aarch64_iptables-nft.sha256sum] = "ef3a2b5bb6e1c463faffe2de2c36f0088dc98f0c1954f9074f41be3295b226ae"

URI_aarch64_iptables-nft-services = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-nft-services-1.8.11-13.el10_1.noarch.rpm;name=aarch64_iptables-nft-services;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-nft-services}"
SRC_URI[aarch64_iptables-nft-services.sha256sum] = "50981e124d50d3689579362e985275b02a55db31689fb3a51c10bb7fca612a36"

URI_aarch64_iptables-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/iptables-utils-1.8.11-13.el10_1.aarch64.rpm;name=aarch64_iptables-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_iptables-utils}"
SRC_URI[aarch64_iptables-utils.sha256sum] = "9742095800809bfe584ebcc9845d815e2027bc463b9f9f09faf6b3766377a6e0"

RDEPENDS:iptables-devel = " \
 iptables-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:iptables-libs = " \
 glibc \
 libnetfilter_conntrack \
 "
RDEPENDS:iptables-nft:x86_64_v2 = " \
 alternatives \
 bash \
 glibc \
 iptables-libs \
 kernel-debug-modules-extra \
 kernel-modules-extra \
 libmnl \
 libnftnl \
 virtual//usr/bin/readlink \
"
RDEPENDS:iptables-nft:aarch64 = " \
 alternatives \
 bash \
 glibc \
 iptables-libs \
 kernel-64k-debug-modules-extra \
 kernel-64k-modules-extra \
 kernel-debug-modules-extra \
 kernel-modules-extra \
 libmnl \
 libnftnl \
 virtual//usr/bin/readlink \
"
RDEPENDS:iptables-nft-services = " \
 bash \
 iptables-nft \
 "
RDEPENDS:iptables-utils = " \
 bash \
 glibc \
 iptables-nft \
 libnfnetlink \
 libpcap \
 "
