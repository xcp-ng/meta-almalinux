# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "neon"
PV = "0.35.0"
PR = "1.el10_1"
PACKAGES = " \
 neon \
 neon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/neon-0.35.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e60783c3a92dec7ec71bb006c1d7347709907e0dd4b8591d5f1193c068222441"

URI_x86_64_v2_neon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neon-0.35.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_neon}"
SRC_URI[x86_64_v2_neon.sha256sum] = "3ba9a564c92ea6f448de139a97cdc46b85dea77f76b58cdc34e9e8050844119a"

URI_x86_64_v2_neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/neon-devel-0.35.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_neon-devel}"
SRC_URI[x86_64_v2_neon-devel.sha256sum] = "60411dd1758c49178a42f741ec23a5176e6d0d1df1033259d9ce605600a42673"

URI_aarch64_neon = "${EPEL_MIRROR}/aarch64/Packages/n/neon-0.35.0-1.el10_1.aarch64.rpm;name=aarch64_neon;unpack=0"
SRC_URI:append = " ${URI_aarch64_neon}"
SRC_URI[aarch64_neon.sha256sum] = "866df91ab6bee30a69c0f3d9c7be976e1a5654c345e225fb58641ebe803de7e3"

URI_aarch64_neon-devel = "${EPEL_MIRROR}/aarch64/Packages/n/neon-devel-0.35.0-1.el10_1.aarch64.rpm;name=aarch64_neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_neon-devel}"
SRC_URI[aarch64_neon-devel.sha256sum] = "012c2c2438d54749066ecf80ed0679a39e6c55b3ca093f639df1921c296f8789"

RDEPENDS:neon = " \
 expat \
 glibc \
 krb5-libs \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:neon-devel = " \
 bash \
 expat-devel \
 neon \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
