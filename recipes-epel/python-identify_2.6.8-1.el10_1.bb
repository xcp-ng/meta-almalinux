# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-identify"
PV = "2.6.8"
PR = "1.el10_1"
PACKAGES = " \
 python3-identify \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-identify-2.6.8-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6fa851d92332ffacd8b73203ef5e66cf86b372410cc0c77b8d0b449c055e588"

URI_x86_64_v2_python3-identify = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-identify-2.6.8-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-identify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-identify}"
SRC_URI[x86_64_v2_python3-identify.sha256sum] = "ea5ad8ac6f055010b6e78004ce0e26a2aa692810dfe26c40851a4974c29680c6"

URI_aarch64_python3-identify = "${EPEL_MIRROR}/aarch64/Packages/p/python3-identify-2.6.8-1.el10_1.noarch.rpm;name=aarch64_python3-identify;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-identify}"
SRC_URI[aarch64_python3-identify.sha256sum] = "fbc732b6cf87162072f66e765a5580b2bf8855335b780f2bbc1b9eb50ba97225"

RDEPENDS:python3-identify = " \
 python3 \
 "
