# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qatzip"
PV = "1.3.1"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 qatzip \
 qatzip-devel \
 qatzip-libs \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qatzip-1.3.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f6db4337ee7efff1898529bbbd35113f1977b9a2b4cd1c9b8304d38881792f5"

URI_x86_64_v2_qatzip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatzip-1.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatzip}"
SRC_URI[x86_64_v2_qatzip.sha256sum] = "ceb73109361e6d80c1c49cf807b8b05bd8c625ac368c5b7fbd1e9d35539e9b2e"

URI_x86_64_v2_qatzip-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qatzip-devel-1.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatzip-devel}"
SRC_URI[x86_64_v2_qatzip-devel.sha256sum] = "6a9ede64e061896b77fd811f35c0fcd651f29bc26c23d0cb5195d6ea25a4ad34"

URI_x86_64_v2_qatzip-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qatzip-libs-1.3.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qatzip-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qatzip-libs}"
SRC_URI[x86_64_v2_qatzip-libs.sha256sum] = "cc218e1f17d35003c77f78db7a7f1e779a5bed892daf600cbb71e7a594ae1ba2"

RDEPENDS:qatzip = " \
 glibc \
 lz4-libs \
 numactl-libs \
 qatlib \
 zlib-ng-compat \
 "
RDEPENDS:qatzip-devel = " \
 lz4-devel \
 pkgconf-pkg-config \
 qatzip-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:qatzip-libs = " \
 glibc \
 lz4-libs \
 numactl-libs \
 qatlib \
 zlib-ng-compat \
 "
