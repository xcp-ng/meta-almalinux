# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CPAN-Meta-Requirements"
PV = "2.143"
PR = "11.el10"
PACKAGES = " \
 perl-CPAN-Meta-Requirements \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-CPAN-Meta-Requirements-2.143-11.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6f044d595949c209ee1be89a6e1e8565dc11bfe6fcd1abd123927408487abd2b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-CPAN-Meta-Requirements-2.143-11.el10.noarch.rpm;name=x86_64_v2_perl-CPAN-Meta-Requirements;unpack=0"
SRC_URI[x86_64_v2_perl-CPAN-Meta-Requirements.sha256sum] = "cbc09bf15c43597169d02fe51d9b9842bc1d57e3bffcad81c2653a696b27e558"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-CPAN-Meta-Requirements-2.143-11.el10.noarch.rpm;name=aarch64_perl-CPAN-Meta-Requirements;unpack=0"
SRC_URI[aarch64_perl-CPAN-Meta-Requirements.sha256sum] = "cbc09bf15c43597169d02fe51d9b9842bc1d57e3bffcad81c2653a696b27e558"

RDEPENDS:perl-CPAN-Meta-Requirements = " \
 perl-B \
 perl-CPAN-Meta-Requirements \
 perl-Carp \
 perl-libs \
 perl-version \
 "
