# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jfrog-cli"
PV = "2.119.0"
PR = "1.el10_3"
PACKAGES = " \
 jfrog-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jfrog-cli-2.119.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "123da47f55f082e54edf00b2b351f39c94597ac01e066528f5df030eae90d9c7"

URI_x86_64_v2_jfrog-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jfrog-cli-2.119.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jfrog-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jfrog-cli}"
SRC_URI[x86_64_v2_jfrog-cli.sha256sum] = "b74967a46a9e74c0ea77ba97700b6de39bf4adf0a7cd3bb497ceddba01a96c08"

URI_aarch64_jfrog-cli = "${EPEL_MIRROR}/aarch64/Packages/j/jfrog-cli-2.119.0-1.el10_3.aarch64.rpm;name=aarch64_jfrog-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_jfrog-cli}"
SRC_URI[aarch64_jfrog-cli.sha256sum] = "91afcb52acaf0b6fb0175790742fbf35a8c478641c47f04f867ebe6856a4263f"

RDEPENDS:jfrog-cli = " \
 glibc \
 "
