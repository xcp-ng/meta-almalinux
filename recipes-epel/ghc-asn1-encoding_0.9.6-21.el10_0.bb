# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-asn1-encoding"
PV = "0.9.6"
PR = "21.el10_0"
PACKAGES = " \
 ghc-asn1-encoding \
 ghc-asn1-encoding-devel \
 ghc-asn1-encoding-doc \
 ghc-asn1-encoding-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-asn1-encoding-0.9.6-21.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bf5a7ce628a0873d6a614e0bcbf8e27ab536fa5f06ac3d0a64fea4b9844a1b5"

URI_x86_64_v2_ghc-asn1-encoding = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-encoding-0.9.6-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-asn1-encoding;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-encoding}"
SRC_URI[x86_64_v2_ghc-asn1-encoding.sha256sum] = "1ef1957f51dbb193ac22dbbf25d869c6091960f6d70d244374792b067141848c"

URI_x86_64_v2_ghc-asn1-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-encoding-devel-0.9.6-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-asn1-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-encoding-devel}"
SRC_URI[x86_64_v2_ghc-asn1-encoding-devel.sha256sum] = "6d4ccd891fdd8a17eddd37e77f9d8ad5144b6c26aabb01ba7360fdd5121de569"

URI_x86_64_v2_ghc-asn1-encoding-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-encoding-doc-0.9.6-21.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-asn1-encoding-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-encoding-doc}"
SRC_URI[x86_64_v2_ghc-asn1-encoding-doc.sha256sum] = "1893d7a8edb0f42e10f06db88e076376a6dca02d2d2114efed015f88c9c50f17"

URI_x86_64_v2_ghc-asn1-encoding-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-asn1-encoding-prof-0.9.6-21.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-asn1-encoding-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-asn1-encoding-prof}"
SRC_URI[x86_64_v2_ghc-asn1-encoding-prof.sha256sum] = "2fd88682fe45a2d78e9a74ed7dfb6a1c73a349bfc0a110db8a3f409471615c91"

URI_aarch64_ghc-asn1-encoding = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-encoding-0.9.6-21.el10_0.aarch64.rpm;name=aarch64_ghc-asn1-encoding;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-encoding}"
SRC_URI[aarch64_ghc-asn1-encoding.sha256sum] = "7503b02ab86bbff0af8cedf376e735b8adb544b895ff93a96e433ba700cb0e56"

URI_aarch64_ghc-asn1-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-encoding-devel-0.9.6-21.el10_0.aarch64.rpm;name=aarch64_ghc-asn1-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-encoding-devel}"
SRC_URI[aarch64_ghc-asn1-encoding-devel.sha256sum] = "d14e7482813e118b876c0d16bb5bcfa784b6e4c31877935a076fa25a0545aaf8"

URI_aarch64_ghc-asn1-encoding-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-encoding-doc-0.9.6-21.el10_0.noarch.rpm;name=aarch64_ghc-asn1-encoding-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-encoding-doc}"
SRC_URI[aarch64_ghc-asn1-encoding-doc.sha256sum] = "f39f7563ad3f99ac6be94550d002416ba3dbec70d1a94a5c27c8f6a9ba5e91c7"

URI_aarch64_ghc-asn1-encoding-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-asn1-encoding-prof-0.9.6-21.el10_0.aarch64.rpm;name=aarch64_ghc-asn1-encoding-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-asn1-encoding-prof}"
SRC_URI[aarch64_ghc-asn1-encoding-prof.sha256sum] = "c1e7e4e196f3e12947da1bf9815b01a11ad1d76377274bbb3913543e506e91ff"

RDEPENDS:ghc-asn1-encoding = " \
 ghc-array \
 ghc-asn1-types \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hourglass \
 ghc-memory \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-asn1-encoding-devel = " \
 ghc-asn1-encoding \
 ghc-asn1-types-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-hourglass-devel \
 "
RDEPENDS:ghc-asn1-encoding-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-asn1-encoding-prof = " \
 ghc-asn1-encoding-devel \
 ghc-asn1-types-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-hourglass-prof \
 "
