# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-network-byte-order"
PV = "0.1.7"
PR = "1.el10_0"
PACKAGES = " \
 ghc-network-byte-order \
 ghc-network-byte-order-devel \
 ghc-network-byte-order-doc \
 ghc-network-byte-order-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-network-byte-order-0.1.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c472a6da99bbcbe3b7f5da26ba417e502c1eeb12f61a3c72f61108221ae63443"

URI_x86_64_v2_ghc-network-byte-order = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-byte-order-0.1.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-byte-order;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-byte-order}"
SRC_URI[x86_64_v2_ghc-network-byte-order.sha256sum] = "069e37c86dab89e030671cab41334f05351a8d7455ea468c88c58142c19ce710"

URI_x86_64_v2_ghc-network-byte-order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-byte-order-devel-0.1.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-byte-order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-byte-order-devel}"
SRC_URI[x86_64_v2_ghc-network-byte-order-devel.sha256sum] = "8fd93f13c81bb4373a6d4b5cb97f548d3782dcf93a0bec406edc58b7b7a5803e"

URI_x86_64_v2_ghc-network-byte-order-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-byte-order-doc-0.1.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-network-byte-order-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-byte-order-doc}"
SRC_URI[x86_64_v2_ghc-network-byte-order-doc.sha256sum] = "52a5624522bd4ae2ec16f1f44117eb338135eafc5b66d992a047f3194165e203"

URI_x86_64_v2_ghc-network-byte-order-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-byte-order-prof-0.1.7-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-byte-order-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-byte-order-prof}"
SRC_URI[x86_64_v2_ghc-network-byte-order-prof.sha256sum] = "919843065a190161729c0061ff80e5a6c95b1370428110e840ed98677cfc6855"

URI_aarch64_ghc-network-byte-order = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-byte-order-0.1.7-1.el10_0.aarch64.rpm;name=aarch64_ghc-network-byte-order;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-byte-order}"
SRC_URI[aarch64_ghc-network-byte-order.sha256sum] = "19212758f7969334dedf763cf4d8a59acebaa0001cb19f3f270be4fdf92fb58b"

URI_aarch64_ghc-network-byte-order-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-byte-order-devel-0.1.7-1.el10_0.aarch64.rpm;name=aarch64_ghc-network-byte-order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-byte-order-devel}"
SRC_URI[aarch64_ghc-network-byte-order-devel.sha256sum] = "638d776cad7ff8ea4d598b33a5820bca4aac3c836642c58887435699e6558796"

URI_aarch64_ghc-network-byte-order-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-byte-order-doc-0.1.7-1.el10_0.noarch.rpm;name=aarch64_ghc-network-byte-order-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-byte-order-doc}"
SRC_URI[aarch64_ghc-network-byte-order-doc.sha256sum] = "c2de1f3288f390bdd14d3e88e46f9779d202ba6d22024cdd015df4abd86ac1b6"

URI_aarch64_ghc-network-byte-order-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-byte-order-prof-0.1.7-1.el10_0.aarch64.rpm;name=aarch64_ghc-network-byte-order-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-byte-order-prof}"
SRC_URI[aarch64_ghc-network-byte-order-prof.sha256sum] = "3defafd861b1b952cae6b1257372328cd8dd8bec5013f1e50da0a6cfe7f8ab6c"

RDEPENDS:ghc-network-byte-order = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-network-byte-order-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-network-byte-order \
 "
RDEPENDS:ghc-network-byte-order-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-network-byte-order-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-network-byte-order-devel \
 "
