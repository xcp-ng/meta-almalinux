# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-justbytes"
PV = "0.15.2"
PR = "7.el10"
PACKAGES = " \
 python3-justbytes \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-justbytes-0.15.2-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "62098e0eec0cc58ba32ae3905f404e590ed02b8719c114db71c5ba910b56e418"

URI_x86_64_v2_python3-justbytes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-justbytes-0.15.2-7.el10.noarch.rpm;name=x86_64_v2_python3-justbytes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-justbytes}"
SRC_URI[x86_64_v2_python3-justbytes.sha256sum] = "089c3921909f7016893a79b109272f1036b1d09dcc3c07c050bac272ff3c5429"

URI_aarch64_python3-justbytes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-justbytes-0.15.2-7.el10.noarch.rpm;name=aarch64_python3-justbytes;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-justbytes}"
SRC_URI[aarch64_python3-justbytes.sha256sum] = "089c3921909f7016893a79b109272f1036b1d09dcc3c07c050bac272ff3c5429"

RDEPENDS:python3-justbytes = " \
 python3 \
 python3-justbases \
 "
