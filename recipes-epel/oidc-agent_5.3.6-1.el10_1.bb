# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oidc-agent"
PV = "5.3.6"
PR = "1.el10_1"
PACKAGES = " \
 oidc-agent-cli \
 oidc-agent-desktop \
 oidc-agent-devel \
 oidc-agent-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oidc-agent-5.3.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbd8f72b373b97dba7a5ad6046569b6e48089f93c8d3271a7edc05fa1446376e"

URI_x86_64_v2_oidc-agent-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-cli-5.3.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-cli}"
SRC_URI[x86_64_v2_oidc-agent-cli.sha256sum] = "5d0a254a22dbff15ddd3079a75407de4c75101d56d4fbaa584ed3c768ec12584"

URI_x86_64_v2_oidc-agent-desktop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-desktop-5.3.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-desktop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-desktop}"
SRC_URI[x86_64_v2_oidc-agent-desktop.sha256sum] = "fc1a7e9a61f11bba99bcc013696f0ce0835fda567a807f3bac56f0c5d55f5151"

URI_x86_64_v2_oidc-agent-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-devel-5.3.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-devel}"
SRC_URI[x86_64_v2_oidc-agent-devel.sha256sum] = "1133b7b33ca905940e859bc53fe284fd97f60c8a9f15c19cfbd1582df7a5300b"

URI_x86_64_v2_oidc-agent-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-libs-5.3.6-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oidc-agent-libs}"
SRC_URI[x86_64_v2_oidc-agent-libs.sha256sum] = "f5eaa5348d84c9ecb03a5ac07838602ce6b436240bf1698a1a2d9900021dfdee"

URI_aarch64_oidc-agent-cli = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-cli-5.3.6-1.el10_1.aarch64.rpm;name=aarch64_oidc-agent-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-cli}"
SRC_URI[aarch64_oidc-agent-cli.sha256sum] = "dcd27a345ea1656de213b3cde680247be887f575cb259b1c3058e86aeacb344a"

URI_aarch64_oidc-agent-desktop = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-desktop-5.3.6-1.el10_1.aarch64.rpm;name=aarch64_oidc-agent-desktop;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-desktop}"
SRC_URI[aarch64_oidc-agent-desktop.sha256sum] = "4a8ada520a4030df0ec968dc4955fe57f2b453199c9fa4332cd3d0bbd63a9854"

URI_aarch64_oidc-agent-devel = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-devel-5.3.6-1.el10_1.aarch64.rpm;name=aarch64_oidc-agent-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-devel}"
SRC_URI[aarch64_oidc-agent-devel.sha256sum] = "9f08b850720c6a2592d54a11dbeccc2c8363a0ea7e215a68ffdd0b55ff6bdcbe"

URI_aarch64_oidc-agent-libs = "${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-libs-5.3.6-1.el10_1.aarch64.rpm;name=aarch64_oidc-agent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_oidc-agent-libs}"
SRC_URI[aarch64_oidc-agent-libs.sha256sum] = "96f59d9ce26608c1c6edc52472af6ac6d0a67bcd3099792e6fc2eebcfa96a61a"

RDEPENDS:oidc-agent-cli = " \
 bash \
 cjson \
 clibs-list \
 glibc \
 libmicrohttpd \
 libsodium \
 oidc-agent-libs \
 qrencode-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:oidc-agent-desktop = " \
 cjson \
 clibs-list \
 glib2 \
 glibc \
 gtk3 \
 javascriptcoregtk4.1 \
 libgcc \
 libsodium \
 libstdc++ \
 oidc-agent-cli \
 oidc-agent-libs \
 webkit2gtk4.1 \
 "
RDEPENDS:oidc-agent-devel = " \
 oidc-agent-libs \
 "
RDEPENDS:oidc-agent-libs = " \
 cjson \
 clibs-list \
 glibc \
 libsodium \
 "
