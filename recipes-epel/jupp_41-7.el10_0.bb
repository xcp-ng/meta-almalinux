# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jupp"
PV = "41"
PR = "7.el10_0"
PACKAGES = " \
 jupp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/jupp-41-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fd3ca3f9de385a7c5573e4c1dc146d54ebc415601c7f28b3621dda7dfb1e144"

URI_x86_64_v2_jupp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/jupp-41-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_jupp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_jupp}"
SRC_URI[x86_64_v2_jupp.sha256sum] = "ff354b0198916ee93da7ab0c0c71e983bffea3f2ea336620ec08265e9987af9f"

URI_aarch64_jupp = "${EPEL_MIRROR}/aarch64/Packages/j/jupp-41-7.el10_0.aarch64.rpm;name=aarch64_jupp;unpack=0"
SRC_URI:append = " ${URI_aarch64_jupp}"
SRC_URI[aarch64_jupp.sha256sum] = "9f9b5de220089498301ebb1bfe6bb315782ed58962678f5a6769d49f20d42f2e"

RDEPENDS:jupp = " \
 glibc \
 libselinux \
 ncurses-libs \
 "
