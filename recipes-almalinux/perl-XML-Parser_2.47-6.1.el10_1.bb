# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-XML-Parser"
PV = "2.47"
PR = "6.1.el10_1"
PACKAGES = " \
 perl-XML-Parser \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-XML-Parser-2.47-6.1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a4f2bb8c2d0403a70f8ed595c324af2357d98db3d2d01fa8e2a497de42ed767"

URI_x86_64_v2_perl-XML-Parser = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-XML-Parser-2.47-6.1.el10_1.x86_64_v2.rpm;name=x86_64_v2_perl-XML-Parser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-XML-Parser}"
SRC_URI[x86_64_v2_perl-XML-Parser.sha256sum] = "25bab2a85f1881b48a89a88ec07ce02b1c4b0739317c752181da04f388585ddb"

URI_aarch64_perl-XML-Parser = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-XML-Parser-2.47-6.1.el10_1.aarch64.rpm;name=aarch64_perl-XML-Parser;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-XML-Parser}"
SRC_URI[aarch64_perl-XML-Parser.sha256sum] = "cd9792480ac39c65febad007691832fca7127b597ca81e620f78ebd6bcc8eebb"

RDEPENDS:perl-XML-Parser = " \
 expat \
 glibc \
 perl-Carp \
 perl-IO \
 perl-PathTools \
 perl-URI \
 perl-libs \
 perl-libwww-perl \
 perl-overload \
 "
