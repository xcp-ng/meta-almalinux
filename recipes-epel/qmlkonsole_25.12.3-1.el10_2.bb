# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qmlkonsole"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 qmlkonsole \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qmlkonsole-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa6fe66a8e2630a225348816fb0b5e28065dbc6718802327f7d1c056741611c6"

URI_x86_64_v2_qmlkonsole = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qmlkonsole-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qmlkonsole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qmlkonsole}"
SRC_URI[x86_64_v2_qmlkonsole.sha256sum] = "f0a4e11e5054a58f821e1826977b0fcb47e4dc10c01697f2161ce1405ae50e13"

URI_aarch64_qmlkonsole = "${EPEL_MIRROR}/aarch64/Packages/q/qmlkonsole-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_qmlkonsole;unpack=0"
SRC_URI:append = " ${URI_aarch64_qmlkonsole}"
SRC_URI[aarch64_qmlkonsole.sha256sum] = "8e1c8db6a53bc07694e5bcce656ca7b220b1f6a361fd3fefafcd5a67ab60d19f"

RDEPENDS:qmlkonsole = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kpty \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
