# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "colorized-logs"
PV = "2.7"
PR = "1.el10_1"
PACKAGES = " \
 colorized-logs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/colorized-logs-2.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58f1ef9382199fa6893efb7948ca83474dfd02466e790315468306dc15801ff0"

URI_x86_64_v2_colorized-logs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/colorized-logs-2.7-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_colorized-logs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_colorized-logs}"
SRC_URI[x86_64_v2_colorized-logs.sha256sum] = "466fb0b1b23a807c68f58b18884d67a48f8244c216beef1b2599aa650cecd191"

URI_aarch64_colorized-logs = "${EPEL_MIRROR}/aarch64/Packages/c/colorized-logs-2.7-1.el10_1.aarch64.rpm;name=aarch64_colorized-logs;unpack=0"
SRC_URI:append = " ${URI_aarch64_colorized-logs}"
SRC_URI[aarch64_colorized-logs.sha256sum] = "271bf029989bb1ffe45f674b03000bd74dc0c4bd4e99e1faf44860701a1596e7"

RDEPENDS:colorized-logs = " \
 glibc \
 "
