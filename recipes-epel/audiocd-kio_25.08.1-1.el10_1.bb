# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "audiocd-kio"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 audiocd-kio \
 audiocd-kio-devel \
 audiocd-kio-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/audiocd-kio-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfed60b1b29bb5fb1157d07bc8c83a01cd9b0b93839f8445dafc6bed699c6fa1"

URI_x86_64_v2_audiocd-kio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio}"
SRC_URI[x86_64_v2_audiocd-kio.sha256sum] = "3148ae2945acb553b747b32fba323c9f9c17d7d76e395019c78d5d1cffc809ae"

URI_x86_64_v2_audiocd-kio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-devel-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_audiocd-kio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio-devel}"
SRC_URI[x86_64_v2_audiocd-kio-devel.sha256sum] = "0b84ef298bb36922bac03685d86a024762cad6f8a090c7aa93326f5a2319fa5d"

URI_x86_64_v2_audiocd-kio-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/audiocd-kio-doc-25.08.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_audiocd-kio-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_audiocd-kio-doc}"
SRC_URI[x86_64_v2_audiocd-kio-doc.sha256sum] = "7dc5abc7964f50c54c2ea80e820c60f874ce0a3bc9e8a7ce66390c9b7646a5b3"

URI_aarch64_audiocd-kio = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_audiocd-kio;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio}"
SRC_URI[aarch64_audiocd-kio.sha256sum] = "aa3e69e0345a1cb7a7e46e8324c96ea2a6c1bff8697378e14d9243af2c6e7d6a"

URI_aarch64_audiocd-kio-devel = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-devel-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_audiocd-kio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio-devel}"
SRC_URI[aarch64_audiocd-kio-devel.sha256sum] = "40aaf5e4e57114fac96f69370aef3e6f0d9265093f4c80b5239e55b27d220c65"

URI_aarch64_audiocd-kio-doc = "${EPEL_MIRROR}/aarch64/Packages/a/audiocd-kio-doc-25.08.1-1.el10_1.noarch.rpm;name=aarch64_audiocd-kio-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_audiocd-kio-doc}"
SRC_URI[aarch64_audiocd-kio-doc.sha256sum] = "30db1337883334513609339ec0956fe8350fefa617b303c3372e65470890d99e"

RDEPENDS:audiocd-kio = " \
 audiocd-kio-doc \
 cdparanoia-libs \
 flac-libs \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 libkcddb \
 libkcompactdisc \
 libogg \
 libstdc++ \
 libvorbis \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:audiocd-kio-devel = " \
 audiocd-kio \
 "
RDEPENDS:audiocd-kio-doc = " \
 audiocd-kio \
 "
