# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gsi-openssh"
PV = "9.9p1"
PR = "3.el10_0"
PACKAGES = " \
 gsi-openssh \
 gsi-openssh-clients \
 gsi-openssh-keysign \
 gsi-openssh-server \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gsi-openssh-9.9p1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eba4de9bfd0ed3441678661ca42212a5a78f4165e77eef18eb8e1856e13d0f4d"

URI_x86_64_v2_gsi-openssh = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-9.9p1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh}"
SRC_URI[x86_64_v2_gsi-openssh.sha256sum] = "df46b6e6a4654675a5a18e8f58201bea30221332931ab454741a216e894e4f6a"

URI_x86_64_v2_gsi-openssh-clients = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-clients-9.9p1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-clients}"
SRC_URI[x86_64_v2_gsi-openssh-clients.sha256sum] = "0913adc0b2d928e74f21fd4995a547f75a6341afdc699b7d024179e12c78506e"

URI_x86_64_v2_gsi-openssh-keysign = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-keysign-9.9p1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-keysign}"
SRC_URI[x86_64_v2_gsi-openssh-keysign.sha256sum] = "ea2ca8c1e87cc372f183866736407e1985f4a2df350f1dba74dd354eb62347b9"

URI_x86_64_v2_gsi-openssh-server = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gsi-openssh-server-9.9p1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gsi-openssh-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gsi-openssh-server}"
SRC_URI[x86_64_v2_gsi-openssh-server.sha256sum] = "7075c3fc7a4a338ac0f4b31c56d3125145bec5dd5cdfe9c2bd62bdd5320a6520"

URI_aarch64_gsi-openssh = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-9.9p1-3.el10_0.aarch64.rpm;name=aarch64_gsi-openssh;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh}"
SRC_URI[aarch64_gsi-openssh.sha256sum] = "31bbe7b43004209b4f34c5fa367b8a785ef62f1ab965a0a12d771af7c44c357f"

URI_aarch64_gsi-openssh-clients = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-clients-9.9p1-3.el10_0.aarch64.rpm;name=aarch64_gsi-openssh-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-clients}"
SRC_URI[aarch64_gsi-openssh-clients.sha256sum] = "09443e986ef042765557a271636667cae21e4ac9f564807a8a973fa745e85d26"

URI_aarch64_gsi-openssh-keysign = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-keysign-9.9p1-3.el10_0.aarch64.rpm;name=aarch64_gsi-openssh-keysign;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-keysign}"
SRC_URI[aarch64_gsi-openssh-keysign.sha256sum] = "4ded3219b54df2dae0b4b044dd661dfed0e74fdfb4c4556c95ae6646bf75f9f8"

URI_aarch64_gsi-openssh-server = "${EPEL_MIRROR}/aarch64/Packages/g/gsi-openssh-server-9.9p1-3.el10_0.aarch64.rpm;name=aarch64_gsi-openssh-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_gsi-openssh-server}"
SRC_URI[aarch64_gsi-openssh-server.sha256sum] = "0913e68669d18b548b4b50c448ff6dd3a78f928fdcf4a231ca956f81ccba74ee"

RDEPENDS:gsi-openssh = " \
 audit-libs \
 glibc \
 libgcc \
 libselinux \
 openssl-libs \
 util-linux \
 "
RDEPENDS:gsi-openssh-clients = " \
 crypto-policies \
 glibc \
 globus-gssapi-gsi \
 gsi-openssh \
 libedit \
 libfido2 \
 libgcc \
 libselinux \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-keysign = " \
 glibc \
 gsi-openssh \
 libgcc \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:gsi-openssh-server = " \
 audit-libs \
 bash \
 crypto-policies \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 gsi-openssh \
 libgcc \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam \
 pam-libs \
 policycoreutils-python-utils \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
