# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-data"
PV = "57.3.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-arrow-data+default-devel \
 rust-arrow-data+ffi-devel \
 rust-arrow-data+force_validate-devel \
 rust-arrow-data-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-data-57.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "251f2818b61ef8d2e2a1cb6ac0f2e8cec27680406e0c1ca34892b93a07f8e402"

URI_x86_64_v2_rust-arrow-data+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-data+default-devel-57.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-data+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-data+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-data+default-devel.sha256sum] = "f5fc51c857c0115dbd7c74ba7aedccbed9ca1975491cc423b7772fffc86e5f81"

URI_x86_64_v2_rust-arrow-data+ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-data+ffi-devel-57.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-data+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-data+ffi-devel}"
SRC_URI[x86_64_v2_rust-arrow-data+ffi-devel.sha256sum] = "bb07e40c00099394bfd35471af6d25d4b01c3be5dd25bda5698e97868a90b205"

URI_x86_64_v2_rust-arrow-data+force_validate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-data+force_validate-devel-57.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-data+force_validate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-data+force_validate-devel}"
SRC_URI[x86_64_v2_rust-arrow-data+force_validate-devel.sha256sum] = "62b732d54b001fcab17a92268b8b61a6a7bb97bd6ef1e619e086a46c6d65cdd0"

URI_x86_64_v2_rust-arrow-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-data-devel-57.3.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-data-devel}"
SRC_URI[x86_64_v2_rust-arrow-data-devel.sha256sum] = "8460be45b447a0ff754d69b8a4a8be55cb4388e2f794366838287201aa9512db"

URI_aarch64_rust-arrow-data+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-data+default-devel-57.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-arrow-data+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-data+default-devel}"
SRC_URI[aarch64_rust-arrow-data+default-devel.sha256sum] = "f491a87b766000efae924fc0eddcd4b06fdd5433989d79cccebbf59083261f9c"

URI_aarch64_rust-arrow-data+ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-data+ffi-devel-57.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-arrow-data+ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-data+ffi-devel}"
SRC_URI[aarch64_rust-arrow-data+ffi-devel.sha256sum] = "31207d9849320304602cd1f461a9c09da146b02b989da32ec0bc6d4981028268"

URI_aarch64_rust-arrow-data+force_validate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-data+force_validate-devel-57.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-arrow-data+force_validate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-data+force_validate-devel}"
SRC_URI[aarch64_rust-arrow-data+force_validate-devel.sha256sum] = "7ce701380fee640a1c0d0ecf03a2d8746bf6ff0fdcca63f3a4b316bfbb6b3fdc"

URI_aarch64_rust-arrow-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-data-devel-57.3.0-1.el10_3.noarch.rpm;name=aarch64_rust-arrow-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-data-devel}"
SRC_URI[aarch64_rust-arrow-data-devel.sha256sum] = "a6c82cf47c339f8438ccc343c7667711e874e6b8cb21606a8d684d27a762d88a"

RDEPENDS:rust-arrow-data+default-devel = " \
 cargo \
 rust-arrow-data-devel \
 "
RDEPENDS:rust-arrow-data+ffi-devel = " \
 cargo \
 rust-arrow-data-devel \
 rust-arrow-schema+ffi-devel \
 "
RDEPENDS:rust-arrow-data+force_validate-devel = " \
 cargo \
 rust-arrow-data-devel \
 "
RDEPENDS:rust-arrow-data-devel = " \
 cargo \
 rust \
 rust-arrow-buffer+default-devel \
 rust-arrow-schema+default-devel \
 rust-half-devel \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 rust-num-traits+std-devel \
 rust-num-traits-devel \
 "
