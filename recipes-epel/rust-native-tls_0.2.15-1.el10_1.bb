# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-native-tls"
PV = "0.2.15"
PR = "1.el10_1"
PACKAGES = " \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-native-tls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-native-tls-0.2.15-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d69debd4bbdde346724961933b8d885fef44bfd1645e4b2782647f370e6bc12e"

URI_x86_64_v2_rust-native-tls+alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls+alpn-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls+alpn-devel}"
SRC_URI[x86_64_v2_rust-native-tls+alpn-devel.sha256sum] = "649e8186f284c2eaf3f1c5d4f2e41ff31925514b20e9920ab5f3b729ed15f533"

URI_x86_64_v2_rust-native-tls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls+default-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls+default-devel}"
SRC_URI[x86_64_v2_rust-native-tls+default-devel.sha256sum] = "424df683df0786297d3393d05d8d23b053cb5d04fa9e2e33c007fc194e3a5476"

URI_x86_64_v2_rust-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-native-tls-devel-0.2.15-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-native-tls-devel}"
SRC_URI[x86_64_v2_rust-native-tls-devel.sha256sum] = "dea9bc35cef9d390d8e7298aaffa401e13c6b9e0bf8eaf749b89e8c6b0e9f9b0"

URI_aarch64_rust-native-tls+alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls+alpn-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-native-tls+alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls+alpn-devel}"
SRC_URI[aarch64_rust-native-tls+alpn-devel.sha256sum] = "1cdae2fc61cd78fe1fd22058aa0f7f22c76416c5e197060f961c85a8bf03d65c"

URI_aarch64_rust-native-tls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls+default-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-native-tls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls+default-devel}"
SRC_URI[aarch64_rust-native-tls+default-devel.sha256sum] = "008abdf7d9476d95d912987b02cdc634b6f5cc5be78a3811b73b7f8922aaf037"

URI_aarch64_rust-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-native-tls-devel-0.2.15-1.el10_1.noarch.rpm;name=aarch64_rust-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-native-tls-devel}"
SRC_URI[aarch64_rust-native-tls-devel.sha256sum] = "6c7aae2de480377d798e5cc8fe9c5b364196778adf7ff1a7f7352b88b3b4a867"

RDEPENDS:rust-native-tls+alpn-devel = " \
 cargo \
 rust-native-tls-devel \
 "
RDEPENDS:rust-native-tls+default-devel = " \
 cargo \
 rust-native-tls-devel \
 "
RDEPENDS:rust-native-tls-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-openssl+default-devel \
 rust-openssl-probe+default-devel \
 rust-openssl-sys+default-devel \
 "
