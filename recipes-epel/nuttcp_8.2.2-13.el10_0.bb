# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nuttcp"
PV = "8.2.2"
PR = "13.el10_0"
PACKAGES = " \
 nuttcp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nuttcp-8.2.2-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "59d79b01353b86a7a34100d7293a9645b6d8f74cc333015bd4a1c6587652a931"

URI_x86_64_v2_nuttcp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nuttcp-8.2.2-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nuttcp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nuttcp}"
SRC_URI[x86_64_v2_nuttcp.sha256sum] = "021289203c2d52077edd62c37ef7bc4f6eca01dab6c18216d30e7018ed5f03de"

URI_aarch64_nuttcp = "${EPEL_MIRROR}/aarch64/Packages/n/nuttcp-8.2.2-13.el10_0.aarch64.rpm;name=aarch64_nuttcp;unpack=0"
SRC_URI:append = " ${URI_aarch64_nuttcp}"
SRC_URI[aarch64_nuttcp.sha256sum] = "e26c4cc30beee72b3a25647749d25826477b19b858c7719f20b57345bbd382fa"

RDEPENDS:nuttcp = " \
 bash \
 glibc \
 systemd \
 "
