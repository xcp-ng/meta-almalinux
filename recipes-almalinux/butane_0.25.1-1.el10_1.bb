# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "butane"
PV = "0.25.1"
PR = "1.el10_1"
PACKAGES = " \
 butane \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/butane-0.25.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0eff080683429e8b956a57a53d72f7d45abe56d0fa6a07f4db4af43932a01e13"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/butane-0.25.1-1.el10_1.x86_64_v2.rpm;name=x86_64_v2_butane;unpack=0"
SRC_URI[x86_64_v2_butane.sha256sum] = "cf9213e19676460f5a4294611132db647262438def406139bb2d7c4f4b9a9c2b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/butane-0.25.1-1.el10_1.aarch64.rpm;name=aarch64_butane;unpack=0"
SRC_URI[aarch64_butane.sha256sum] = "d1584945879d20657effaa55bb0690bee49d1acf9f79756377a4f3576027b0cd"

RDEPENDS:butane = " \
 glibc \
 "
