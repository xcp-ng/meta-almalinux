# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-hash"
PV = "0.25.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-hash+default-devel \
 rust-gix-hash+document-features-devel \
 rust-gix-hash+serde-devel \
 rust-gix-hash+sha1-devel \
 rust-gix-hash+sha256-devel \
 rust-gix-hash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-hash-0.25.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd7adf53f90077ef52f8d6c8d054c51c2b16d5dc5b743df7edf110329274553f"

URI_x86_64_v2_rust-gix-hash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+default-devel-0.25.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+default-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+default-devel.sha256sum] = "7d07854f00d73d5c5d9a6fad500ea173b64a71ed8a27e02666920b3ae9d109f8"

URI_x86_64_v2_rust-gix-hash+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+document-features-devel-0.25.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+document-features-devel.sha256sum] = "8f598ac9b85cfc901895351225ed988fc6481031fff732976009af2ee3149895"

URI_x86_64_v2_rust-gix-hash+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+serde-devel-0.25.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+serde-devel.sha256sum] = "65bc2ea115fdb1004c4b41d1847c48e36455750440b77fdc319760394db767be"

URI_x86_64_v2_rust-gix-hash+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+sha1-devel-0.25.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+sha1-devel.sha256sum] = "1b8885f4a4bc10f957c36d4bd22de2b674eff55c7153e09a4b886f1ef74a2119"

URI_x86_64_v2_rust-gix-hash+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash+sha256-devel-0.25.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-hash+sha256-devel.sha256sum] = "1306fa9df203b71bec17022fe43b097dd476190ff871b2b2ba822b31f2161f1c"

URI_x86_64_v2_rust-gix-hash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hash-devel-0.25.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hash-devel}"
SRC_URI[x86_64_v2_rust-gix-hash-devel.sha256sum] = "d31b199da1e372decb3fd80741be46ddac7c56ed282539ce0383d6107391cc4a"

URI_aarch64_rust-gix-hash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+default-devel-0.25.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+default-devel}"
SRC_URI[aarch64_rust-gix-hash+default-devel.sha256sum] = "fced74f36e0a459572b6f0cce48dbd7d024905978113d7d33346ddc7244e73cd"

URI_aarch64_rust-gix-hash+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+document-features-devel-0.25.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hash+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+document-features-devel}"
SRC_URI[aarch64_rust-gix-hash+document-features-devel.sha256sum] = "cf3124916195807efa604a7f9d823fd534a83ab980df8f45c2c29054d1b0dc1c"

URI_aarch64_rust-gix-hash+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+serde-devel-0.25.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hash+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+serde-devel}"
SRC_URI[aarch64_rust-gix-hash+serde-devel.sha256sum] = "dae29ff090e886318b0379c8064606b991a5722c22304cfa11a6cf2458bbb63b"

URI_aarch64_rust-gix-hash+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+sha1-devel-0.25.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hash+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+sha1-devel}"
SRC_URI[aarch64_rust-gix-hash+sha1-devel.sha256sum] = "8f706367651f441589d111b234b3de57d3e2e6edee9f491b9b4f43ddac67ee6d"

URI_aarch64_rust-gix-hash+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash+sha256-devel-0.25.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hash+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash+sha256-devel}"
SRC_URI[aarch64_rust-gix-hash+sha256-devel.sha256sum] = "d1ed4e10d64b1bea31b742bdabd6f131d7fb63767a407b17a0903475a2babb8d"

URI_aarch64_rust-gix-hash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hash-devel-0.25.1-1.el10_3.noarch.rpm;name=aarch64_rust-gix-hash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hash-devel}"
SRC_URI[aarch64_rust-gix-hash-devel.sha256sum] = "ac43815303f658de4af2edaf7159e94f08c579f1f081ac63e8760e888507e8ef"

RDEPENDS:rust-gix-hash+default-devel = " \
 cargo \
 rust-gix-hash-devel \
 "
RDEPENDS:rust-gix-hash+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-hash-devel \
 "
RDEPENDS:rust-gix-hash+serde-devel = " \
 cargo \
 rust-faster-hex+serde-devel \
 rust-gix-hash-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-hash+sha1-devel = " \
 cargo \
 rust-gix-hash-devel \
 rust-sha1-checked-devel \
 "
RDEPENDS:rust-gix-hash+sha256-devel = " \
 cargo \
 rust-gix-hash-devel \
 rust-sha2-devel \
 "
RDEPENDS:rust-gix-hash-devel = " \
 cargo \
 rust \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-thiserror+default-devel \
 "
