# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "go-fdo-client"
PV = "1.0.0"
PR = "4.el10"
PACKAGES = " \
 go-fdo-client \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/go-fdo-client-1.0.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3f44807d4845329be2c1903eb1843c4baa56ee5ce5a022ce2a04f500a89f733"

URI_x86_64_v2_go-fdo-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-fdo-client-1.0.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_go-fdo-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-fdo-client}"
SRC_URI[x86_64_v2_go-fdo-client.sha256sum] = "711e17e98a188e8f569722af58fe86a8fd0ede297eed86a0616b078fcdc24cfe"

URI_aarch64_go-fdo-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-fdo-client-1.0.0-4.el10.aarch64.rpm;name=aarch64_go-fdo-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-fdo-client}"
SRC_URI[aarch64_go-fdo-client.sha256sum] = "9de7f09d8f04f9e825ae3880acb6e5cb2d70952faaf917cd1e2ef60374bffd1e"

RDEPENDS:go-fdo-client = " \
 glibc \
 "
