# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Specio"
PV = "0.48"
PR = "5.el10_0"
PACKAGES = " \
 perl-Specio \
 perl-Test-Specio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Specio-0.48-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb716fa7418df832e13342c49c5a8de7208150763b316e4789001ff4c2581f4c"

URI_x86_64_v2_perl-Specio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Specio-0.48-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Specio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Specio}"
SRC_URI[x86_64_v2_perl-Specio.sha256sum] = "7eee7f5880225f5d8e25411760ba7e27c63683d6f56f0d831df00b0b64a5010c"

URI_x86_64_v2_perl-Test-Specio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-Specio-0.48-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-Specio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-Specio}"
SRC_URI[x86_64_v2_perl-Test-Specio.sha256sum] = "ca7c147349f459530eff56357ac5e135a1dc37ccb17cd53fa6bef7166bc185e0"

URI_aarch64_perl-Specio = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Specio-0.48-5.el10_0.noarch.rpm;name=aarch64_perl-Specio;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Specio}"
SRC_URI[aarch64_perl-Specio.sha256sum] = "65e3045dab5f9329bda08776ffb513c05d2abf4685f656564794cc2c5579d43f"

URI_aarch64_perl-Test-Specio = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-Specio-0.48-5.el10_0.noarch.rpm;name=aarch64_perl-Test-Specio;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-Specio}"
SRC_URI[aarch64_perl-Test-Specio.sha256sum] = "7db474c55855e1a83df4b9fdad3d0f09df654804006b34ac31784fbd3b9467fe"

RDEPENDS:perl-Specio = " \
 perl-Carp \
 perl-Devel-StackTrace \
 perl-Eval-Closure \
 perl-Exporter \
 perl-MRO-Compat \
 perl-Module-Runtime \
 perl-Ref-Util \
 perl-Role-Tiny \
 perl-Scalar-List-Utils \
 perl-Specio \
 perl-Storable \
 perl-XString \
 perl-libs \
 perl-overload \
 perl-parent \
 perl-version \
 "
RDEPENDS:perl-Test-Specio = " \
 perl-Exporter \
 perl-IO \
 perl-Scalar-List-Utils \
 perl-Specio \
 perl-Sub-Quote \
 perl-Test-Fatal \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-libs \
 perl-overload \
 "
