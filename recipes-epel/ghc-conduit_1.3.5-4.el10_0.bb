# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-conduit"
PV = "1.3.5"
PR = "4.el10_0"
PACKAGES = " \
 ghc-conduit \
 ghc-conduit-devel \
 ghc-conduit-doc \
 ghc-conduit-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-conduit-1.3.5-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5b8c442d7b3eb393692e407d21aef4b0d7e641cefcbf73c03ced97353d765ea"

URI_x86_64_v2_ghc-conduit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-conduit-1.3.5-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-conduit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-conduit}"
SRC_URI[x86_64_v2_ghc-conduit.sha256sum] = "c5b27fad61ae048889d4d11cfbaa683b7757907d164b17e1e6e6f16845848cba"

URI_x86_64_v2_ghc-conduit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-conduit-devel-1.3.5-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-conduit-devel}"
SRC_URI[x86_64_v2_ghc-conduit-devel.sha256sum] = "1abf8aa49c9d7e867f8643695fdb417d8e25498dbd1087cc7b102f6d8cf3b644"

URI_x86_64_v2_ghc-conduit-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-conduit-doc-1.3.5-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-conduit-doc}"
SRC_URI[x86_64_v2_ghc-conduit-doc.sha256sum] = "80f8fd13e6c20ce1eff85f0410565958d692a2ef50bdb9161e591946030ee18a"

URI_x86_64_v2_ghc-conduit-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-conduit-prof-1.3.5-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-conduit-prof}"
SRC_URI[x86_64_v2_ghc-conduit-prof.sha256sum] = "3e94525e7db3f6ddf1430534a21343830b323ad68af9c2b4b1658f2dcba5a38b"

URI_aarch64_ghc-conduit = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-conduit-1.3.5-4.el10_0.aarch64.rpm;name=aarch64_ghc-conduit;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-conduit}"
SRC_URI[aarch64_ghc-conduit.sha256sum] = "5f4be0f02010a772a6d8bb032e12d1bb1df45a18a01648cf8d21841abc78f0fd"

URI_aarch64_ghc-conduit-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-conduit-devel-1.3.5-4.el10_0.aarch64.rpm;name=aarch64_ghc-conduit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-conduit-devel}"
SRC_URI[aarch64_ghc-conduit-devel.sha256sum] = "f5e7d1ce342648336e9724f12ba5f3a42f6e900beb93ad3dae47717eb3c233d5"

URI_aarch64_ghc-conduit-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-conduit-doc-1.3.5-4.el10_0.noarch.rpm;name=aarch64_ghc-conduit-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-conduit-doc}"
SRC_URI[aarch64_ghc-conduit-doc.sha256sum] = "1a66fac9ce0795e5fe361af4cd3e84f057f87f580a95b72d2b1bfb27a9ae488d"

URI_aarch64_ghc-conduit-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-conduit-prof-1.3.5-4.el10_0.aarch64.rpm;name=aarch64_ghc-conduit-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-conduit-prof}"
SRC_URI[aarch64_ghc-conduit-prof.sha256sum] = "3e27ff1517f5d657ab74524e7304f4c276205f8dc33bdd8f06846d750447121e"

RDEPENDS:ghc-conduit = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bitvec \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mono-traversable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-resourcet \
 ghc-split \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-vector \
 ghc-vector-algorithms \
 ghc-vector-stream \
 glibc \
 gmp \
 "
RDEPENDS:ghc-conduit-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-conduit \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-mono-traversable-devel \
 ghc-mtl-devel \
 ghc-primitive-devel \
 ghc-resourcet-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-unix-devel \
 ghc-unliftio-core-devel \
 ghc-vector-devel \
 "
RDEPENDS:ghc-conduit-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-conduit-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-conduit-devel \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-mono-traversable-prof \
 ghc-mtl-prof \
 ghc-primitive-prof \
 ghc-resourcet-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-unix-prof \
 ghc-unliftio-core-prof \
 ghc-vector-prof \
 "
