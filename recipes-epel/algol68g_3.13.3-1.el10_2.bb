# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "algol68g"
PV = "3.13.3"
PR = "1.el10_2"
PACKAGES = " \
 algol68g \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/algol68g-3.13.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6f67ec45568f0990a07a268c18cc53d9826ce7947e95b02c152e01c6404a61f8"

URI_x86_64_v2_algol68g = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/algol68g-3.13.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_algol68g;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_algol68g}"
SRC_URI[x86_64_v2_algol68g.sha256sum] = "cb7ab9078a3a6f02e3484d3359acb44b7a5ae26d4a77b24d79702abeffbbb37f"

URI_aarch64_algol68g = "${EPEL_MIRROR}/aarch64/Packages/a/algol68g-3.13.3-1.el10_2.aarch64.rpm;name=aarch64_algol68g;unpack=0"
SRC_URI:append = " ${URI_aarch64_algol68g}"
SRC_URI[aarch64_algol68g.sha256sum] = "00d6f02cecb7a0ab93e2881ff5684e007207a8964be89e525d95073c38388d57"

RDEPENDS:algol68g:x86_64_v2 = " \
 glibc \
 gmp \
 gsl \
 libRmath \
 libpq \
 libquadmath \
 mpfr \
 ncurses-libs \
 plotutils \
"
RDEPENDS:algol68g:aarch64 = " \
 glibc \
 gsl \
 libRmath \
 libpq \
 ncurses-libs \
 plotutils \
"
