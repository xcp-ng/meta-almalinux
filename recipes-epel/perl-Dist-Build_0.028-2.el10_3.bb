# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Dist-Build"
PV = "0.028"
PR = "2.el10_3"
PACKAGES = " \
 perl-Dist-Build \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Dist-Build-0.028-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b611f8440f33ed004a4e900350953f6a0c4bac9b1ed6ccb685e69c000dfb7ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Dist-Build-0.028-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Dist-Build;unpack=0"
SRC_URI[x86_64_v2_perl-Dist-Build.sha256sum] = "917c9a30f8e5160c0560f98ca923c25a3d7140290f6e29a8f579c865995ce4f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Dist-Build-0.028-2.el10_3.noarch.rpm;name=aarch64_perl-Dist-Build;unpack=0"
SRC_URI[aarch64_perl-Dist-Build.sha256sum] = "d43200679a2027f09872656ec010c805a1444b95059ed364075c5249f98fe599"

RDEPENDS:perl-Dist-Build = " \
 perl-CPAN-Meta \
 perl-CPAN-Requirements-Dynamic \
 perl-Carp \
 perl-Dist-Build \
 perl-Exporter \
 perl-ExtUtils-Builder \
 perl-ExtUtils-Builder-Compiler \
 perl-ExtUtils-Config \
 perl-ExtUtils-Helpers \
 perl-ExtUtils-Install \
 perl-ExtUtils-InstallPaths \
 perl-ExtUtils-Manifest \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-PathTools \
 perl-Perl-OSType \
 perl-Scalar-List-Utils \
 perl-Test-Harness \
 perl-Text-ParseWords \
 perl-libs \
 perl-parent \
 perl-podlators \
 perl-version \
 "
