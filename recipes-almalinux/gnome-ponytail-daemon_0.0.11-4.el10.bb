# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-ponytail-daemon"
PV = "0.0.11"
PR = "4.el10"
PACKAGES = " \
 gnome-ponytail-daemon \
 python3-gnome-ponytail-daemon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-ponytail-daemon-0.0.11-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90ad1e4f9b48ad16b285dd1ee544348cadb6f418873d37d57be4efe3073f22dd"

URI_x86_64_v2_gnome-ponytail-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-ponytail-daemon-0.0.11-4.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-ponytail-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-ponytail-daemon}"
SRC_URI[x86_64_v2_gnome-ponytail-daemon.sha256sum] = "66f6bbf326dfd4e380ccd47df70dfd8d6a813aa82fb30f3398ca803c0a4b6f32"

URI_x86_64_v2_python3-gnome-ponytail-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-gnome-ponytail-daemon-0.0.11-4.el10.noarch.rpm;name=x86_64_v2_python3-gnome-ponytail-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gnome-ponytail-daemon}"
SRC_URI[x86_64_v2_python3-gnome-ponytail-daemon.sha256sum] = "13eb4cb9455eeaed6901670bfc9414d0fba447f3144aaa6027426eae8c8a29d1"

URI_aarch64_gnome-ponytail-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-ponytail-daemon-0.0.11-4.el10.aarch64.rpm;name=aarch64_gnome-ponytail-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-ponytail-daemon}"
SRC_URI[aarch64_gnome-ponytail-daemon.sha256sum] = "2ba530759d7be99dd4000ac5abb96cd277000591179fa80e0ccf4e9103af3540"

URI_aarch64_python3-gnome-ponytail-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-gnome-ponytail-daemon-0.0.11-4.el10.noarch.rpm;name=aarch64_python3-gnome-ponytail-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gnome-ponytail-daemon}"
SRC_URI[aarch64_python3-gnome-ponytail-daemon.sha256sum] = "13eb4cb9455eeaed6901670bfc9414d0fba447f3144aaa6027426eae8c8a29d1"

RDEPENDS:gnome-ponytail-daemon = " \
 bash \
 glib2 \
 glibc \
 libei \
 libgcc \
 libxkbcommon \
 systemd \
 "
RDEPENDS:python3-gnome-ponytail-daemon = " \
 gnome-ponytail-daemon \
 python3 \
 python3-dbus \
 python3-gobject \
 "
