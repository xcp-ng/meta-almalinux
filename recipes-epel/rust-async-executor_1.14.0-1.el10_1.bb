# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-executor"
PV = "1.14.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-executor+default-devel \
 rust-async-executor+static-devel \
 rust-async-executor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-executor-1.14.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d647ebb927dc719b4d9e80c1f80b490b3562455abe3d0d053cc32764d5aa2cb"

URI_x86_64_v2_rust-async-executor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-executor+default-devel-1.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-executor+default-devel}"
SRC_URI[x86_64_v2_rust-async-executor+default-devel.sha256sum] = "cf6e479690736699f18ed4bb5548398e51b49835906f9f819664da5c1f94a280"

URI_x86_64_v2_rust-async-executor+static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-executor+static-devel-1.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-executor+static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-executor+static-devel}"
SRC_URI[x86_64_v2_rust-async-executor+static-devel.sha256sum] = "6133b21be51571603d3a050449a07292ce884eadc7a12fc0d9b09948b5f6e19a"

URI_x86_64_v2_rust-async-executor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-executor-devel-1.14.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-executor-devel}"
SRC_URI[x86_64_v2_rust-async-executor-devel.sha256sum] = "4407fd976faf6e6f8b53a605ab2f8456c12314327189676b7bb0b5f215504d95"

URI_aarch64_rust-async-executor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-executor+default-devel-1.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-executor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-executor+default-devel}"
SRC_URI[aarch64_rust-async-executor+default-devel.sha256sum] = "f2e55960e4c87e44951b96685f76443c964c76f5a90c3acc18b9a3e6506d609c"

URI_aarch64_rust-async-executor+static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-executor+static-devel-1.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-executor+static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-executor+static-devel}"
SRC_URI[aarch64_rust-async-executor+static-devel.sha256sum] = "6d4f7529687ea7e849272e12cdfe5e8698240b9e6a6a270b1a6d6a45c33ae139"

URI_aarch64_rust-async-executor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-executor-devel-1.14.0-1.el10_1.noarch.rpm;name=aarch64_rust-async-executor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-executor-devel}"
SRC_URI[aarch64_rust-async-executor-devel.sha256sum] = "78ff36715f3da4a8e1d4c38bdfdaa2b1e2647ac21e52def0e6329a4900395e41"

RDEPENDS:rust-async-executor+default-devel = " \
 cargo \
 rust-async-executor-devel \
 "
RDEPENDS:rust-async-executor+static-devel = " \
 cargo \
 rust-async-executor-devel \
 "
RDEPENDS:rust-async-executor-devel = " \
 cargo \
 rust \
 rust-async-task+default-devel \
 rust-concurrent-queue+default-devel \
 rust-fastrand+default-devel \
 rust-futures-lite-devel \
 rust-pin-project-lite+default-devel \
 rust-slab+default-devel \
 "
