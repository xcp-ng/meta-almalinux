# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrow-select"
PV = "57.3.0"
PR = "2.el10_3"
PACKAGES = " \
 rust-arrow-select+default-devel \
 rust-arrow-select-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrow-select-57.3.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a70a389f803dfc71e105f4fa256de88274e16de429108b3814d2c3b2cb44343"

URI_x86_64_v2_rust-arrow-select+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-select+default-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-select+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-select+default-devel}"
SRC_URI[x86_64_v2_rust-arrow-select+default-devel.sha256sum] = "d8cdac83379091914b915df1f089cbb23d8b752b31daa9fdb5de0b47a52a6312"

URI_x86_64_v2_rust-arrow-select-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrow-select-devel-57.3.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrow-select-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrow-select-devel}"
SRC_URI[x86_64_v2_rust-arrow-select-devel.sha256sum] = "6b4594b29f53c909c649fd4400d8febada7358c30097099c838f8d0c1377c17f"

URI_aarch64_rust-arrow-select+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-select+default-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-select+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-select+default-devel}"
SRC_URI[aarch64_rust-arrow-select+default-devel.sha256sum] = "92ce4ff0589912618260cc182d141582d8da43dbe73bba2a7efe5d8086188b67"

URI_aarch64_rust-arrow-select-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrow-select-devel-57.3.0-2.el10_3.noarch.rpm;name=aarch64_rust-arrow-select-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrow-select-devel}"
SRC_URI[aarch64_rust-arrow-select-devel.sha256sum] = "8cc8924d57b504b29a4bbd72c8d4fc18153b1f82dc70691c58a6a67650840072"

RDEPENDS:rust-arrow-select+default-devel = " \
 cargo \
 rust-arrow-select-devel \
 "
RDEPENDS:rust-arrow-select-devel = " \
 cargo \
 rust \
 rust-ahash-devel \
 rust-arrow-array+default-devel \
 rust-arrow-buffer+default-devel \
 rust-arrow-data+default-devel \
 rust-arrow-schema+default-devel \
 rust-num-traits+std-devel \
 rust-num-traits-devel \
 "
