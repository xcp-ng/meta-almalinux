# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mecab-ipadic"
PV = "2.7.0.20070801"
PR = "32.el10"
PACKAGES = " \
 mecab-ipadic \
 mecab-ipadic-EUCJP \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mecab-ipadic-2.7.0.20070801-32.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a18df1c9f5a83bd6b8382df46ef8ded7cb931114716127c08c7161ce3a2c7453"

URI_x86_64_v2_mecab-ipadic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mecab-ipadic-2.7.0.20070801-32.el10.x86_64_v2.rpm;name=x86_64_v2_mecab-ipadic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mecab-ipadic}"
SRC_URI[x86_64_v2_mecab-ipadic.sha256sum] = "686ab4406266700d15ac7785465b84534a30fc977bdee59533d1b88e44abc769"

URI_x86_64_v2_mecab-ipadic-EUCJP = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mecab-ipadic-EUCJP-2.7.0.20070801-32.el10.x86_64_v2.rpm;name=x86_64_v2_mecab-ipadic-EUCJP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mecab-ipadic-EUCJP}"
SRC_URI[x86_64_v2_mecab-ipadic-EUCJP.sha256sum] = "06c70ad5d24603757fb80937ae061efa4119b231f52a66e06116cdcedbee1931"

URI_aarch64_mecab-ipadic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mecab-ipadic-2.7.0.20070801-32.el10.aarch64.rpm;name=aarch64_mecab-ipadic;unpack=0"
SRC_URI:append = " ${URI_aarch64_mecab-ipadic}"
SRC_URI[aarch64_mecab-ipadic.sha256sum] = "6ff0cb8e776b141fb9ee2933c341940632af13e84c7668a7ec4c600e398c52d0"

URI_aarch64_mecab-ipadic-EUCJP = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mecab-ipadic-EUCJP-2.7.0.20070801-32.el10.aarch64.rpm;name=aarch64_mecab-ipadic-EUCJP;unpack=0"
SRC_URI:append = " ${URI_aarch64_mecab-ipadic-EUCJP}"
SRC_URI[aarch64_mecab-ipadic-EUCJP.sha256sum] = "ce6c6526c4c2fbe245cb0b319104fbd104cbc13f68a6cba2b5cd4144733de375"

RDEPENDS:mecab-ipadic = " \
 bash \
 mecab \
 "
RDEPENDS:mecab-ipadic-EUCJP = " \
 bash \
 mecab \
 "
