# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-socket2"
PV = "0.6.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-socket2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-socket2-0.6.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "528ec6c673e85290c7d08773b7fb64ae8fb2e5bb646ed3b68e3006dd7b90277e"

URI_x86_64_v2_rust-socket2+all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+all-devel-0.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2+all-devel}"
SRC_URI[x86_64_v2_rust-socket2+all-devel.sha256sum] = "d71a777b8e97ff2584749d73e341abfe5de9f4a60997d799c7a55f39e2a673a8"
RPROVIDES:rust-socket2+all-devel:x86_64_v2 = "virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

URI_x86_64_v2_rust-socket2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2+default-devel-0.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2+default-devel}"
SRC_URI[x86_64_v2_rust-socket2+default-devel.sha256sum] = "252412c915589b1d06268067941ac0a4bad1f6efdfaa8b9156116fac2910861e"
RPROVIDES:rust-socket2+default-devel:x86_64_v2 = "virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

URI_x86_64_v2_rust-socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-socket2-devel-0.6.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-socket2-devel}"
SRC_URI[x86_64_v2_rust-socket2-devel.sha256sum] = "56579d4cfe17a80740bb47b63138856ebfd8a370326c85bca7267a45c47c68b6"

URI_aarch64_rust-socket2+all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+all-devel-0.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-socket2+all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2+all-devel}"
SRC_URI[aarch64_rust-socket2+all-devel.sha256sum] = "d20a5cddccf560d7ea08ad1ff731424579ca19c420c3e11d45c129a30a274af0"
RPROVIDES:rust-socket2+all-devel:aarch64 = "virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~"

URI_aarch64_rust-socket2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2+default-devel-0.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-socket2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2+default-devel}"
SRC_URI[aarch64_rust-socket2+default-devel.sha256sum] = "20419f68f8b624cd4b1c8c8d4362cfa5eb675070fa20f740c27cc607806afcdd"
RPROVIDES:rust-socket2+default-devel:aarch64 = "virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

URI_aarch64_rust-socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-socket2-devel-0.6.4-1.el10_3.noarch.rpm;name=aarch64_rust-socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-socket2-devel}"
SRC_URI[aarch64_rust-socket2-devel.sha256sum] = "c66dc45455fac39ffcc279892f2738f503e2a4058251eb2c03b0dce3fc337e74"

RDEPENDS:rust-socket2+all-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2+default-devel = " \
 cargo \
 rust-socket2-devel \
 "
RDEPENDS:rust-socket2-devel = " \
 cargo \
 rust \
 rust-libc+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~ rpm/virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_socket2/all__ge_0.5.9_with_crate_socket2/all__lt_0.7.0~ rpm/virtual/crate_socket2/default__ge_0.5.9_with_crate_socket2/default__lt_0.7.0~"
