# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-karchive"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-karchive \
 kf6-karchive-devel \
 kf6-karchive-doc \
 kf6-karchive-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-karchive-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7b9f9737931ce8f04a8f7dcfd77235ad55adaeea824cfd05f7b8e277a8142203"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive;unpack=0"
SRC_URI[x86_64_v2_kf6-karchive.sha256sum] = "253aac14be1a81a0f7b8efcacbb3b9e95e0ce835759b2473ff4e16dda9bcb4e4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-karchive-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-karchive-devel.sha256sum] = "29f3f0191b5eee5359c1fa865e04393f52b030e8f0f3da13b1e0cb395a56d6aa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-karchive-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-karchive-doc.sha256sum] = "4acd8cdb6c66b0304416a550df670ffbed6cdb228220a7e74e90e5aa6a451a9a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-karchive-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-karchive-html;unpack=0"
SRC_URI[x86_64_v2_kf6-karchive-html.sha256sum] = "40e6ef371350f975d6796454767869fd64093b24c91a60b762d17292145953e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-karchive;unpack=0"
SRC_URI[aarch64_kf6-karchive.sha256sum] = "289d15087b389f2a20573367faee44bf1a180e97cd53f3e58af63d87f8feb149"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-karchive-devel;unpack=0"
SRC_URI[aarch64_kf6-karchive-devel.sha256sum] = "6503115ce9dc1629c0117f6d2cfa8cf7b17a470c72ba5bb3405479d39e03ca1b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-karchive-doc;unpack=0"
SRC_URI[aarch64_kf6-karchive-doc.sha256sum] = "102909d3ec7a44158b252526c43d87e9eae0b4b4678e62520ab86c5af9bd09cc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-karchive-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-karchive-html;unpack=0"
SRC_URI[aarch64_kf6-karchive-html.sha256sum] = "1709fade2b4aee0c03fecd952635ab90c2bfadc0420b44d5b2250017edba6434"

RDEPENDS:kf6-karchive = " \
 bzip2-libs \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libzstd \
 openssl-libs \
 qt6-qtbase \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:kf6-karchive-devel = " \
 cmake-filesystem \
 kf6-karchive \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-karchive-doc = " \
 "
RDEPENDS:kf6-karchive-html = " \
 "
