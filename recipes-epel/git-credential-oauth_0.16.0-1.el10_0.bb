# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "git-credential-oauth"
PV = "0.16.0"
PR = "1.el10_0"
PACKAGES = " \
 git-credential-oauth \
 golang-github-hickford-git-credential-oauth-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/git-credential-oauth-0.16.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03da265e6e01221e228b3631cc2468e1f570ea2b91816f817aba797d4b8e4ae1"

URI_x86_64_v2_git-credential-oauth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/git-credential-oauth-0.16.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_git-credential-oauth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_git-credential-oauth}"
SRC_URI[x86_64_v2_git-credential-oauth.sha256sum] = "dc89486e2b0f8b21d5df89a3f9feea3be01405faffdaaf4331dcfaa5b7158f28"

URI_x86_64_v2_golang-github-hickford-git-credential-oauth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-hickford-git-credential-oauth-devel-0.16.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-hickford-git-credential-oauth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-hickford-git-credential-oauth-devel}"
SRC_URI[x86_64_v2_golang-github-hickford-git-credential-oauth-devel.sha256sum] = "c952e04af007f64c1b91da9050669d2015e72266c533e82a459adf568e03ad60"

URI_aarch64_git-credential-oauth = "${EPEL_MIRROR}/aarch64/Packages/g/git-credential-oauth-0.16.0-1.el10_0.aarch64.rpm;name=aarch64_git-credential-oauth;unpack=0"
SRC_URI:append = " ${URI_aarch64_git-credential-oauth}"
SRC_URI[aarch64_git-credential-oauth.sha256sum] = "3bd3766184d41aa6b1d4e3d1a95f3ad60efd435218488520a9a9028f91ce1a05"

URI_aarch64_golang-github-hickford-git-credential-oauth-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hickford-git-credential-oauth-devel-0.16.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-hickford-git-credential-oauth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hickford-git-credential-oauth-devel}"
SRC_URI[aarch64_golang-github-hickford-git-credential-oauth-devel.sha256sum] = "e44832729feb8d2a62d1b16ffd294e20e8f70767ccd4d7e589a78068406bcefd"

RDEPENDS:git-credential-oauth = " \
 glibc \
 "
RDEPENDS:golang-github-hickford-git-credential-oauth-devel = " \
 go-filesystem \
 golang-x-oauth2-devel \
 "
