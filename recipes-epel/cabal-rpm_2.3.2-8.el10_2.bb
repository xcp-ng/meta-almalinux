# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cabal-rpm"
PV = "2.3.2"
PR = "8.el10_2"
PACKAGES:x86_64_v2 = " \
 cabal-rpm \
 ghc-html-entities \
 ghc-html-entities-devel \
 ghc-html-entities-doc \
"
PACKAGES:aarch64 = " \
 cabal-rpm \
 ghc-html-entities \
 ghc-html-entities-devel \
 ghc-html-entities-doc \
 ghc-html-entities-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/c/cabal-rpm-2.3.2-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ac2796a7de9fcaaef0707ebee1f7499672b87af062e7137031d1bce05237ef2"

URI_x86_64_v2_cabal-rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cabal-rpm-2.3.2-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cabal-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cabal-rpm}"
SRC_URI[x86_64_v2_cabal-rpm.sha256sum] = "6feec7f1c7cdf62be9cc2788ffea0e8336e1b0359b06e6776d75adc110859d23"

URI_x86_64_v2_ghc-html-entities = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-entities-1.1.4.7-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-html-entities;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-entities}"
SRC_URI[x86_64_v2_ghc-html-entities.sha256sum] = "1608a510da94ef71cde036da75874a5d2d7f87da354690b8b9f674f6efd2e18f"

URI_x86_64_v2_ghc-html-entities-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-entities-devel-1.1.4.7-8.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-html-entities-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-entities-devel}"
SRC_URI[x86_64_v2_ghc-html-entities-devel.sha256sum] = "a4f799e2e07078007d0ca322ee2e763f4ae098f2e68a7e4181eedca87c9b674f"

URI_x86_64_v2_ghc-html-entities-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-html-entities-doc-1.1.4.7-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-html-entities-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-html-entities-doc}"
SRC_URI[x86_64_v2_ghc-html-entities-doc.sha256sum] = "581286aac27524add77ce8a005d8bda94b62357632bd2dbba1b31048cf3690dc"

URI_aarch64_cabal-rpm = "${EPEL_MIRROR}/aarch64/Packages/c/cabal-rpm-2.3.2-8.el10_2.aarch64.rpm;name=aarch64_cabal-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_cabal-rpm}"
SRC_URI[aarch64_cabal-rpm.sha256sum] = "938e373e7810614ad0e0a497a7c5738ef716d2aac215aab29e0c12b3b297a784"

URI_aarch64_ghc-html-entities = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-entities-1.1.4.7-8.el10_2.aarch64.rpm;name=aarch64_ghc-html-entities;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-entities}"
SRC_URI[aarch64_ghc-html-entities.sha256sum] = "88edcb77f3d9514d6d7ec00ad3126b0edcdf3e54f17a91a411e986a1a0cea060"

URI_aarch64_ghc-html-entities-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-entities-devel-1.1.4.7-8.el10_2.aarch64.rpm;name=aarch64_ghc-html-entities-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-entities-devel}"
SRC_URI[aarch64_ghc-html-entities-devel.sha256sum] = "66a5ecb6333d9a3b250ccd10b80c35d454de8bf47c522d48f7f2b6d902945ac7"

URI_aarch64_ghc-html-entities-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-entities-doc-1.1.4.7-8.el10_2.noarch.rpm;name=aarch64_ghc-html-entities-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-entities-doc}"
SRC_URI[aarch64_ghc-html-entities-doc.sha256sum] = "4e381220434ca54ee1bbad33af5556c35c54aa8af39363d517c85b3b9841b462"

URI_aarch64_ghc-html-entities-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-html-entities-prof-1.1.4.7-8.el10_2.aarch64.rpm;name=aarch64_ghc-html-entities-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-html-entities-prof}"
SRC_URI[aarch64_ghc-html-entities-prof.sha256sum] = "787cfa256e8918d73620e476e6fc70d58ac747a03e710c83034e24430099d770"

RDEPENDS:cabal-rpm = " \
 cabal-install \
 dnf-plugins-core \
 dos2unix \
 ghc-rpm-macros \
 glibc \
 gmp \
 libffi \
 rpm-build \
 rpmdevtools \
 wget \
 zlib-ng-compat \
 "
RDEPENDS:ghc-html-entities = " \
 ghc-array \
 ghc-attoparsec \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-integer-logarithms \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-primitive \
 ghc-scientific \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-html-entities-devel = " \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-html-entities \
 ghc-text-devel \
 ghc-unordered-containers-devel \
 "
RDEPENDS:ghc-html-entities-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-html-entities-prof = " \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-html-entities-devel \
 ghc-text-prof \
 ghc-unordered-containers-prof \
 "
