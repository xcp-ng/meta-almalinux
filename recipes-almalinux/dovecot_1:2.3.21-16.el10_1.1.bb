# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dovecot"
PE = "1"
PV = "2.3.21"
PR = "16.el10_1.1"
PACKAGES = " \
 dovecot \
 dovecot-devel \
 dovecot-mysql \
 dovecot-pgsql \
 dovecot-pigeonhole \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dovecot-2.3.21-16.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f0ce91b31f09cb5472ab56154c62a852cc4ca3aa7e15c0b945753388c187459f"

URI_x86_64_v2_dovecot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-2.3.21-16.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_dovecot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot}"
SRC_URI[x86_64_v2_dovecot.sha256sum] = "f10f0d2b48c02bd9359c258896c86ee89c224f26efed5eedc56a117d93d5a7eb"

URI_x86_64_v2_dovecot-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dovecot-devel-2.3.21-16.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_dovecot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-devel}"
SRC_URI[x86_64_v2_dovecot-devel.sha256sum] = "0a8af554b484605b3d1ad4d1cde25df4593e48390f747791454770dfe942721c"

URI_x86_64_v2_dovecot-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-mysql-2.3.21-16.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_dovecot-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-mysql}"
SRC_URI[x86_64_v2_dovecot-mysql.sha256sum] = "02a3087877e5e1d80510e4155220150e7e0e4b68d48e18f00224c578f6898e9b"

URI_x86_64_v2_dovecot-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pgsql-2.3.21-16.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_dovecot-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-pgsql}"
SRC_URI[x86_64_v2_dovecot-pgsql.sha256sum] = "26c07f8898b2a18e0697781ecdfd671469355ca8f29f0a425b8fa5ebbaf30e7c"

URI_x86_64_v2_dovecot-pigeonhole = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dovecot-pigeonhole-2.3.21-16.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_dovecot-pigeonhole;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dovecot-pigeonhole}"
SRC_URI[x86_64_v2_dovecot-pigeonhole.sha256sum] = "fc1f048dc6e5bef19f0395c4066b8b06c672aa0b2304009d8e78c70611021283"

URI_aarch64_dovecot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-2.3.21-16.el10_1.1.aarch64.rpm;name=aarch64_dovecot;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot}"
SRC_URI[aarch64_dovecot.sha256sum] = "3d78e47e298f8af29d19931b81a70c04e952d234d20e37cb3d736a939315c3bc"

URI_aarch64_dovecot-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dovecot-devel-2.3.21-16.el10_1.1.aarch64.rpm;name=aarch64_dovecot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-devel}"
SRC_URI[aarch64_dovecot-devel.sha256sum] = "6bd3b24cb30faeed731f54df99196295da54305d7d39c50a1e4b264b773f3650"

URI_aarch64_dovecot-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-mysql-2.3.21-16.el10_1.1.aarch64.rpm;name=aarch64_dovecot-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-mysql}"
SRC_URI[aarch64_dovecot-mysql.sha256sum] = "2d1d35ef029ccd2207a9f96397ad509d0915010834a88e9dff576682e5a54270"

URI_aarch64_dovecot-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pgsql-2.3.21-16.el10_1.1.aarch64.rpm;name=aarch64_dovecot-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-pgsql}"
SRC_URI[aarch64_dovecot-pgsql.sha256sum] = "b3fcaeb6b47f6df3daaa09a03664b2188117f0cb8f1374b5ca231732751f2f0e"

URI_aarch64_dovecot-pigeonhole = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dovecot-pigeonhole-2.3.21-16.el10_1.1.aarch64.rpm;name=aarch64_dovecot-pigeonhole;unpack=0"
SRC_URI:append = " ${URI_aarch64_dovecot-pigeonhole}"
SRC_URI[aarch64_dovecot-pigeonhole.sha256sum] = "6c1e249cd951f112d9f48df9211b731c64ca1782fbb6086dba249ce1db034073"

RDEPENDS:dovecot = " \
 bash \
 bzip2-libs \
 expat \
 glibc \
 krb5-libs \
 libcap \
 libcom_err \
 libicu \
 libxcrypt \
 libzstd \
 lz4-libs \
 openldap \
 openssl \
 openssl-libs \
 pam-libs \
 shadow-utils \
 sqlite-libs \
 systemd \
 systemd-libs \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:dovecot-devel = " \
 dovecot \
 "
RDEPENDS:dovecot-mysql = " \
 dovecot \
 glibc \
 mariadb-connector-c \
 "
RDEPENDS:dovecot-pgsql = " \
 dovecot \
 glibc \
 libpq \
 "
RDEPENDS:dovecot-pigeonhole = " \
 dovecot \
 glibc \
 "
