# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-packetline"
PV = "0.19.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-packetline+async-io-devel \
 rust-gix-packetline+blocking-io-devel \
 rust-gix-packetline+default-devel \
 rust-gix-packetline+document-features-devel \
 rust-gix-packetline+futures-lite-devel \
 rust-gix-packetline+serde-devel \
 rust-gix-packetline-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-packetline-0.19.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44f28608f2b504d73e2f37007817b1a585e96958e8d0514e4b4b99b4cfd4d96d"

URI_x86_64_v2_rust-gix-packetline+async-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+async-io-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+async-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+async-io-devel.sha256sum] = "09d39ad6f644b5be7a398d13dd06f81cf887e84e3a6c3369e53d611145a7604d"

URI_x86_64_v2_rust-gix-packetline+blocking-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+blocking-io-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+blocking-io-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+blocking-io-devel.sha256sum] = "f7966ca76f86eec1a8582a6df6bd7881e0932b41837aff6ba6599c8b3035898d"

URI_x86_64_v2_rust-gix-packetline+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+default-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+default-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+default-devel.sha256sum] = "8275f5d7e4fe619f0b3d4367ee24fef0eb44323d76031a39ad48a19cb3351a13"

URI_x86_64_v2_rust-gix-packetline+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+document-features-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+document-features-devel.sha256sum] = "2fe516a183661b8dc3886a31132c47c4bd5cf024a75fe1964fb67067748a7206"

URI_x86_64_v2_rust-gix-packetline+futures-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+futures-lite-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+futures-lite-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+futures-lite-devel.sha256sum] = "8bdbcdcda901f2d52963190d5f681f5e31836d9617351404494a15d90aaf6283"

URI_x86_64_v2_rust-gix-packetline+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline+serde-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline+serde-devel.sha256sum] = "d5b9f55fc4e695f7d45d837a86c6402934bf8ed58182646ae0cc58fa4f37febc"

URI_x86_64_v2_rust-gix-packetline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-packetline-devel-0.19.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-packetline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-packetline-devel}"
SRC_URI[x86_64_v2_rust-gix-packetline-devel.sha256sum] = "a88f08a348a6fb63ce879d5c7e1fb02609a45dba4a21ec2837da3ee950717b42"

URI_aarch64_rust-gix-packetline+async-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+async-io-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline+async-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+async-io-devel}"
SRC_URI[aarch64_rust-gix-packetline+async-io-devel.sha256sum] = "5ac2bd74eeecb3a71dab64dc4194033450b2cbfa8abdeb3c63f70508e801161a"

URI_aarch64_rust-gix-packetline+blocking-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+blocking-io-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline+blocking-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+blocking-io-devel}"
SRC_URI[aarch64_rust-gix-packetline+blocking-io-devel.sha256sum] = "829255efc08c8f294bbd6e284a23afd9c5b5bcc5962b697bb942a52ca58ecf4d"

URI_aarch64_rust-gix-packetline+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+default-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+default-devel}"
SRC_URI[aarch64_rust-gix-packetline+default-devel.sha256sum] = "42646855e2c472653bcdbd0184303e17be467af5dcd3de7a015b5dff4d5285e1"

URI_aarch64_rust-gix-packetline+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+document-features-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+document-features-devel}"
SRC_URI[aarch64_rust-gix-packetline+document-features-devel.sha256sum] = "179c688a40e3aa66ca9885c30e60279cc59c2afa2f42dad7d84afc4544da7a57"

URI_aarch64_rust-gix-packetline+futures-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+futures-lite-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline+futures-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+futures-lite-devel}"
SRC_URI[aarch64_rust-gix-packetline+futures-lite-devel.sha256sum] = "454d3d7704e53fe93ea1e053fb20510bff2b4fa099919078d54c1ab86043ec9f"

URI_aarch64_rust-gix-packetline+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline+serde-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline+serde-devel}"
SRC_URI[aarch64_rust-gix-packetline+serde-devel.sha256sum] = "b62d7c74e97b029d4eb3d5ba05d799471c362b3f113e5ff9cb55734768337c31"

URI_aarch64_rust-gix-packetline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-packetline-devel-0.19.1-1.el10_1.noarch.rpm;name=aarch64_rust-gix-packetline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-packetline-devel}"
SRC_URI[aarch64_rust-gix-packetline-devel.sha256sum] = "65c5d1d33fb1e11fabf8f2758f64fb509f54225081c4d28bb4ec9f6f6a7d45b1"

RDEPENDS:rust-gix-packetline+async-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-gix-packetline+futures-lite-devel \
 rust-gix-packetline-devel \
 rust-pin-project-lite+default-devel \
 "
RDEPENDS:rust-gix-packetline+blocking-io-devel = " \
 cargo \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+default-devel = " \
 cargo \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+futures-lite-devel = " \
 cargo \
 rust-futures-lite+default-devel \
 rust-gix-packetline-devel \
 "
RDEPENDS:rust-gix-packetline+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-faster-hex+serde-devel \
 rust-gix-packetline-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-packetline-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-faster-hex+std-devel \
 rust-faster-hex-devel \
 rust-gix-trace+default-devel \
 rust-thiserror+default-devel \
 "
