# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-podman-sequoia"
PV = "0.2.0"
PR = "1.el10"
PACKAGES = " \
 podman-sequoia \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-podman-sequoia-0.2.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b72b29d9ca0bcf009a32de68bfb923948cef3f625efc763915d63cf85907a12c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-sequoia-0.2.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_podman-sequoia;unpack=0"
SRC_URI[x86_64_v2_podman-sequoia.sha256sum] = "d7a822e3cf94e6c8390edeeb7c2d94e3f7be1c3e1357205b16d5ce3c734f7fcc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-sequoia-0.2.0-1.el10.aarch64.rpm;name=aarch64_podman-sequoia;unpack=0"
SRC_URI[aarch64_podman-sequoia.sha256sum] = "212479af8c0573d644f7d90e8ee9f7f592546b4b116af3971b3d859d7e4169ac"

RDEPENDS:podman-sequoia = " \
 glibc \
 libgcc \
 openssl-libs \
 sqlite-libs \
 "
