# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mupdf"
PV = "1.25.2"
PR = "1.el10_0"
PACKAGES = " \
 mupdf \
 mupdf-cpp-devel \
 mupdf-cpp-libs \
 mupdf-devel \
 mupdf-libs \
 python3-mupdf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mupdf-1.25.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88c49d78d6e0511580df28e3bae71dced352033446341b7aa70986b260ca870c"

URI_x86_64_v2_mupdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-1.25.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf}"
SRC_URI[x86_64_v2_mupdf.sha256sum] = "8ed60c8057c54ab280c05d765130baf47628cbd656447cd7cf566c831763f11e"

URI_x86_64_v2_mupdf-cpp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-cpp-devel-1.25.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-cpp-devel}"
SRC_URI[x86_64_v2_mupdf-cpp-devel.sha256sum] = "0f5c9aedad3f874c6ede912ec7e833c0fba466754641860b6c8f3ce8d84bbd0e"

URI_x86_64_v2_mupdf-cpp-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-cpp-libs-1.25.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-cpp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-cpp-libs}"
SRC_URI[x86_64_v2_mupdf-cpp-libs.sha256sum] = "420bc35fbe98dc928d8e624fb36507f0674b09ceacc4c02f05cd2c567d8ca18a"

URI_x86_64_v2_mupdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-devel-1.25.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-devel}"
SRC_URI[x86_64_v2_mupdf-devel.sha256sum] = "b98554b03bcabc6fe1eac595029cf9be2d5bb11d6f49e37244bb83cb642a5c78"

URI_x86_64_v2_mupdf-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mupdf-libs-1.25.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mupdf-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mupdf-libs}"
SRC_URI[x86_64_v2_mupdf-libs.sha256sum] = "f7f6b7c7ea5003f86df6eb935abce54552905fddf7e15a9065203e4424386afa"

URI_x86_64_v2_python3-mupdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mupdf-1.25.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-mupdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mupdf}"
SRC_URI[x86_64_v2_python3-mupdf.sha256sum] = "de8cb7fa9fd02eddc1dc8d44eb8a0723a737cebdfc398c9720517fe54cabfe12"

URI_aarch64_mupdf = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-1.25.2-1.el10_0.aarch64.rpm;name=aarch64_mupdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf}"
SRC_URI[aarch64_mupdf.sha256sum] = "ce362adbdb379dec0dba9003f044c210998dcb441b59a36dc19efda77c267052"

URI_aarch64_mupdf-cpp-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-cpp-devel-1.25.2-1.el10_0.aarch64.rpm;name=aarch64_mupdf-cpp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-cpp-devel}"
SRC_URI[aarch64_mupdf-cpp-devel.sha256sum] = "722099a35277b36982f3eb60ddec06279edd2a1583d87cfea3af225f8c483cdf"

URI_aarch64_mupdf-cpp-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-cpp-libs-1.25.2-1.el10_0.aarch64.rpm;name=aarch64_mupdf-cpp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-cpp-libs}"
SRC_URI[aarch64_mupdf-cpp-libs.sha256sum] = "a84f1b2d71eafd02f899a49d44ac2118460ba84a984c4280ec0710c610910522"

URI_aarch64_mupdf-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-devel-1.25.2-1.el10_0.aarch64.rpm;name=aarch64_mupdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-devel}"
SRC_URI[aarch64_mupdf-devel.sha256sum] = "a1fb4839589a62ac2c243b565692ea20b4ef497dfb5b0b438c127cea1de69c25"

URI_aarch64_mupdf-libs = "${EPEL_MIRROR}/aarch64/Packages/m/mupdf-libs-1.25.2-1.el10_0.aarch64.rpm;name=aarch64_mupdf-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mupdf-libs}"
SRC_URI[aarch64_mupdf-libs.sha256sum] = "fa9e7c3003d4f7320573598fa99f8f87159aff0a1731a08d1c1cbc2e4ea71888"

URI_aarch64_python3-mupdf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mupdf-1.25.2-1.el10_0.aarch64.rpm;name=aarch64_python3-mupdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mupdf}"
SRC_URI[aarch64_python3-mupdf.sha256sum] = "9c5c7d46155d117ec974d9a39965a32e5054ab741ea123c9f2ad69bddd363982"

RDEPENDS:mupdf = " \
 freeglut \
 glibc \
 libX11 \
 libXext \
 libglvnd-glx \
 mupdf-libs \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:mupdf-cpp-devel = " \
 mupdf-cpp-libs \
 "
RDEPENDS:mupdf-cpp-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 mupdf-libs \
 "
RDEPENDS:mupdf-devel = " \
 mupdf-libs \
 "
RDEPENDS:mupdf-libs = " \
 freetype \
 glibc \
 gumbo-parser \
 harfbuzz \
 jbig2dec-libs \
 leptonica \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 openjpeg2 \
 tesseract \
 zlib-ng-compat \
 "
RDEPENDS:python3-mupdf = " \
 glibc \
 libgcc \
 libstdc++ \
 mupdf-cpp-libs \
 mupdf-libs \
 python3 \
 "
