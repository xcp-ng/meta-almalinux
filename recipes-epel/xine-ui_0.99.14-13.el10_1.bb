# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xine-ui"
PV = "0.99.14"
PR = "13.el10_1"
PACKAGES = " \
 xine-ui \
 xine-ui-aaxine \
 xine-ui-skins \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xine-ui-0.99.14-13.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b5a0d3c8d9c0fcc637b64a75c3c78f1619dfb3e5530e763c8599faa38c3ecce1"

URI_x86_64_v2_xine-ui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xine-ui-0.99.14-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xine-ui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xine-ui}"
SRC_URI[x86_64_v2_xine-ui.sha256sum] = "0a8a1f1c288ba17f47342e8a539fb9523a726e265cc4c46738977cf77ae82578"

URI_x86_64_v2_xine-ui-aaxine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xine-ui-aaxine-0.99.14-13.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xine-ui-aaxine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xine-ui-aaxine}"
SRC_URI[x86_64_v2_xine-ui-aaxine.sha256sum] = "3e6e671c3442abdd341dce4e4e829be0c15954db7974ec2718e130eeafe24c7f"

URI_x86_64_v2_xine-ui-skins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xine-ui-skins-0.99.14-13.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_xine-ui-skins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xine-ui-skins}"
SRC_URI[x86_64_v2_xine-ui-skins.sha256sum] = "b6a1c48ef1fa867db01a3e8f09873eaa1cfca96d63ca135b930446e20b229d06"

URI_aarch64_xine-ui = "${EPEL_MIRROR}/aarch64/Packages/x/xine-ui-0.99.14-13.el10_1.aarch64.rpm;name=aarch64_xine-ui;unpack=0"
SRC_URI:append = " ${URI_aarch64_xine-ui}"
SRC_URI[aarch64_xine-ui.sha256sum] = "d0a0503ec3ec9d1e3dbc30b84e712fc485261aa71d8ec1dcd57b2fc78d754311"

URI_aarch64_xine-ui-aaxine = "${EPEL_MIRROR}/aarch64/Packages/x/xine-ui-aaxine-0.99.14-13.el10_1.aarch64.rpm;name=aarch64_xine-ui-aaxine;unpack=0"
SRC_URI:append = " ${URI_aarch64_xine-ui-aaxine}"
SRC_URI[aarch64_xine-ui-aaxine.sha256sum] = "79b214d0e825324b8489b13d1167a7351a3cae86bd01a2e6d48cacc8f624ec94"

URI_aarch64_xine-ui-skins = "${EPEL_MIRROR}/aarch64/Packages/x/xine-ui-skins-0.99.14-13.el10_1.noarch.rpm;name=aarch64_xine-ui-skins;unpack=0"
SRC_URI:append = " ${URI_aarch64_xine-ui-skins}"
SRC_URI[aarch64_xine-ui-skins.sha256sum] = "df39d5bae3892ef2a7f31fd2b4ac299c49cbd37b169fe57f87f43eb2fcf9d6ba"

RDEPENDS:xine-ui = " \
 glibc \
 hicolor-icon-theme \
 libX11 \
 libXext \
 libXft \
 libXinerama \
 libXtst \
 libXv \
 libXxf86vm \
 libjpeg-turbo \
 libpng \
 lirc-libs \
 readline \
 virtual/libcurl.so.4___64bit_ \
 xine-lib \
 xine-lib-extras \
 "
RDEPENDS:xine-ui-aaxine = " \
 aalib-libs \
 glibc \
 libcaca \
 lirc-libs \
 xine-lib \
 xine-lib-extras \
 xine-ui \
 "
RDEPENDS:xine-ui-skins = " \
 bash \
 xine-ui \
 "
