# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qthttpserver"
PV = "6.8.1"
PR = "2.el10_0"
PACKAGES = " \
 qt6-qthttpserver \
 qt6-qthttpserver-devel \
 qt6-qthttpserver-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qthttpserver-6.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d4979c3b186f68118900e207c9bcffb465b032bd2efc422e62cfba73f1232aa"

URI_x86_64_v2_qt6-qthttpserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qthttpserver-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qthttpserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qthttpserver}"
SRC_URI[x86_64_v2_qt6-qthttpserver.sha256sum] = "e2ec7c4e22eeb291f24b90cfa97fa71d5bfcf57b339c38d6640f99ff80a2679e"

URI_x86_64_v2_qt6-qthttpserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qthttpserver-devel-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qthttpserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qthttpserver-devel}"
SRC_URI[x86_64_v2_qt6-qthttpserver-devel.sha256sum] = "9aaf17a2b268d8b0e60b2a241b325a79372f5d32215348a5227b24e2501caee6"

URI_x86_64_v2_qt6-qthttpserver-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qthttpserver-examples-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qthttpserver-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qthttpserver-examples}"
SRC_URI[x86_64_v2_qt6-qthttpserver-examples.sha256sum] = "31e590894ac22b3fe0a80601ec044ec4f6cc2a8179992cf74ac6ef25c6a6f47e"

URI_aarch64_qt6-qthttpserver = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qthttpserver-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qthttpserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qthttpserver}"
SRC_URI[aarch64_qt6-qthttpserver.sha256sum] = "baf79948230b30fd1d09bec3d6c87958474383e024baf18066a4863daec2d408"

URI_aarch64_qt6-qthttpserver-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qthttpserver-devel-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qthttpserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qthttpserver-devel}"
SRC_URI[aarch64_qt6-qthttpserver-devel.sha256sum] = "49b4582153087628063e69c441180a53aae80516f950d15b91c8d7632098d2d3"

URI_aarch64_qt6-qthttpserver-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qthttpserver-examples-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_qt6-qthttpserver-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qthttpserver-examples}"
SRC_URI[aarch64_qt6-qthttpserver-examples.sha256sum] = "73270f0f60532b9f1cf9d4a8ef6a10b67bf6643f81c56df7f76f123f9a1b4ff1"

RDEPENDS:qt6-qthttpserver = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtwebsockets \
 "
RDEPENDS:qt6-qthttpserver-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qthttpserver \
 qt6-qtwebsockets-devel \
 "
RDEPENDS:qt6-qthttpserver-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qthttpserver \
 qt6-qthttpserver-devel \
 "
