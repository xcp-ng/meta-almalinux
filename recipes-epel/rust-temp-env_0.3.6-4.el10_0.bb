# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-temp-env"
PV = "0.3.6"
PR = "4.el10_0"
PACKAGES = " \
 rust-temp-env+async_closure-devel \
 rust-temp-env+default-devel \
 rust-temp-env-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-temp-env-0.3.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1540997cb7170ce901b571bb54958c4ba13e94b1282610f3fa1e9499eb4636a0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-temp-env+async_closure-devel-0.3.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-temp-env+async_closure-devel;unpack=0"
SRC_URI[x86_64_v2_rust-temp-env+async_closure-devel.sha256sum] = "17033c8664f0905f4c05811073f13b20438841df9e408538587438728ce7e84f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-temp-env+default-devel-0.3.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-temp-env+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-temp-env+default-devel.sha256sum] = "09402582c4aadc1ae53845f2654f05f9ef91ae6f521904cbf4525ca0e6f2d091"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-temp-env-devel-0.3.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-temp-env-devel;unpack=0"
SRC_URI[x86_64_v2_rust-temp-env-devel.sha256sum] = "5ad39bf66c3843602bf04355ebc9b1c1fd14b35fc6ce3fad0712891d9d0fde5e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-temp-env+async_closure-devel-0.3.6-4.el10_0.noarch.rpm;name=aarch64_rust-temp-env+async_closure-devel;unpack=0"
SRC_URI[aarch64_rust-temp-env+async_closure-devel.sha256sum] = "0319d207c9564328e00e786fad92f2b870ee3b059f0fde437c2a65676ffb4d40"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-temp-env+default-devel-0.3.6-4.el10_0.noarch.rpm;name=aarch64_rust-temp-env+default-devel;unpack=0"
SRC_URI[aarch64_rust-temp-env+default-devel.sha256sum] = "9d0b3836d07779196bdae3f1d4a5bfaf0128e1ef4f465518b47abef8e2b7cec5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-temp-env-devel-0.3.6-4.el10_0.noarch.rpm;name=aarch64_rust-temp-env-devel;unpack=0"
SRC_URI[aarch64_rust-temp-env-devel.sha256sum] = "94b2ab2f669fb1807f663a34500e67242329892af7484fb2eacfca0e0bc283de"

RDEPENDS:rust-temp-env+async_closure-devel = " \
 cargo \
 rust-futures+default-devel \
 rust-temp-env-devel \
 "
RDEPENDS:rust-temp-env+default-devel = " \
 cargo \
 rust-temp-env-devel \
 "
RDEPENDS:rust-temp-env-devel = " \
 cargo \
 rust \
 rust-parking_lot+default-devel \
 "
