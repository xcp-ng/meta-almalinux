# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpminspect-data-centos"
PE = "1"
PV = "1.4"
PR = "7.el10_2"
PACKAGES = " \
 rpminspect-data-centos \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpminspect-data-centos-1.4-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba16dd8952dd6c4393d21e34c9b686888258873d8f520d7efdbc291d1f532984"

URI_x86_64_v2_rpminspect-data-centos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpminspect-data-centos-1.4-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rpminspect-data-centos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpminspect-data-centos}"
SRC_URI[x86_64_v2_rpminspect-data-centos.sha256sum] = "166fe25264452cd929a0e2bd475fb086a8adc6089f8509bb94f92356287bb2c3"

URI_aarch64_rpminspect-data-centos = "${EPEL_MIRROR}/aarch64/Packages/r/rpminspect-data-centos-1.4-7.el10_2.noarch.rpm;name=aarch64_rpminspect-data-centos;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpminspect-data-centos}"
SRC_URI[aarch64_rpminspect-data-centos.sha256sum] = "d0c4f9d3d40c322311a2f78057c3574057dabc5fa5202452fa5c14835b50398d"

RDEPENDS:rpminspect-data-centos = " \
 annobin-annocheck \
 bash \
 dash \
 fedora-license-data \
 html401-dtds \
 ksh \
 libabigail \
 rc \
 rpminspect \
 tcsh \
 xhtml1-dtds \
 zsh \
 "
