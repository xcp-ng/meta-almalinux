# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_parser"
PV = "1.0.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-toml_parser+alloc-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser+default-devel \
 rust-toml_parser+simd-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser+unsafe-devel \
 rust-toml_parser-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_parser-1.0.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bf0045e41e2966d9909b1660d777700666524d86821235cfb87536ace213c44"

URI_x86_64_v2_rust-toml_parser+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+alloc-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+alloc-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+alloc-devel.sha256sum] = "3ef22745c276f165291f68da1e18a417c43e82442022baabfd53ed3040d7bbef"

URI_x86_64_v2_rust-toml_parser+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+debug-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+debug-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+debug-devel.sha256sum] = "2bd86da5204025d31b82b7a86d46ad515084b13b0f788578b1bcdd0e90704e34"

URI_x86_64_v2_rust-toml_parser+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+default-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+default-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+default-devel.sha256sum] = "ce6fda083c1a7ec93f6f3088be01fd06d58b88cd5f906ca3f11f95a8051eb3e9"

URI_x86_64_v2_rust-toml_parser+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+simd-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+simd-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+simd-devel.sha256sum] = "5e7c91f4c207f6c244d0c32345874fb09ead38b5d95b332e9a2714aad048350c"

URI_x86_64_v2_rust-toml_parser+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+std-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+std-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+std-devel.sha256sum] = "5fb49a07efc5de7d2c753c058bee98c3ba504c7a014fa96a4e610ee9d3845716"

URI_x86_64_v2_rust-toml_parser+unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser+unsafe-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser+unsafe-devel}"
SRC_URI[x86_64_v2_rust-toml_parser+unsafe-devel.sha256sum] = "3c251483b7685bacc4e9ac0bce7a2df3b9d56a1aaf950b7b0d2cd897d5e0fee2"

URI_x86_64_v2_rust-toml_parser-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_parser-devel-1.0.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_parser-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_parser-devel}"
SRC_URI[x86_64_v2_rust-toml_parser-devel.sha256sum] = "2be444673fc4dd3eeb89a9d425c182ce22a8432aaeae8f0be5fc4df18141990c"

URI_aarch64_rust-toml_parser+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+alloc-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_parser+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+alloc-devel}"
SRC_URI[aarch64_rust-toml_parser+alloc-devel.sha256sum] = "49a9f33533e2af524994025462ebc57849b51214b7fab0fc782caf3ccc76791b"

URI_aarch64_rust-toml_parser+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+debug-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_parser+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+debug-devel}"
SRC_URI[aarch64_rust-toml_parser+debug-devel.sha256sum] = "b12db9b3b165a2bd9f205b90cf3eb42a595c19dcecbede3990b38394e07027cd"

URI_aarch64_rust-toml_parser+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+default-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_parser+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+default-devel}"
SRC_URI[aarch64_rust-toml_parser+default-devel.sha256sum] = "762e8ba486fde549326697ef6c511d8a57fe3a6c60588d5e1f209736f41664e3"

URI_aarch64_rust-toml_parser+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+simd-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_parser+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+simd-devel}"
SRC_URI[aarch64_rust-toml_parser+simd-devel.sha256sum] = "42a529bdbdc71565c88fcc93adad992204048ec796efa2a55a819310f338122b"

URI_aarch64_rust-toml_parser+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+std-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_parser+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+std-devel}"
SRC_URI[aarch64_rust-toml_parser+std-devel.sha256sum] = "ea011a4ab38171c5f547f8c7e6fd11de76cf13e64ab9becc5dfacd68fe91b772"

URI_aarch64_rust-toml_parser+unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser+unsafe-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_parser+unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser+unsafe-devel}"
SRC_URI[aarch64_rust-toml_parser+unsafe-devel.sha256sum] = "f04830d7cb96a7d5b0f448ecd634e776c6f2743b487287bdcdec7e32c9956fc3"

URI_aarch64_rust-toml_parser-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_parser-devel-1.0.6-1.el10_1.noarch.rpm;name=aarch64_rust-toml_parser-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_parser-devel}"
SRC_URI[aarch64_rust-toml_parser-devel.sha256sum] = "31e340caf2e3160e48bd2a5fb45250f9ac574c3bd209450d139f0282b653571b"

RDEPENDS:rust-toml_parser+alloc-devel = " \
 cargo \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+debug-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+default-devel = " \
 cargo \
 rust-toml_parser+std-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+simd-devel = " \
 cargo \
 rust-toml_parser-devel \
 rust-winnow+simd-devel \
 "
RDEPENDS:rust-toml_parser+std-devel = " \
 cargo \
 rust-toml_parser+alloc-devel \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser+unsafe-devel = " \
 cargo \
 rust-toml_parser-devel \
 "
RDEPENDS:rust-toml_parser-devel = " \
 cargo \
 rust \
 rust-winnow-devel \
 "
