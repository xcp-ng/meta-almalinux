# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-HTTP-Cache-Transparent"
PV = "1.4"
PR = "24.el10_0"
PACKAGES = " \
 perl-HTTP-Cache-Transparent \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-HTTP-Cache-Transparent-1.4-24.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4ca35ec7c41f578aa75d70b08703701b79c3dff1f2b3ba74d89dd22f4ee97c7c"

URI_x86_64_v2_perl-HTTP-Cache-Transparent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-HTTP-Cache-Transparent-1.4-24.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-HTTP-Cache-Transparent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-HTTP-Cache-Transparent}"
SRC_URI[x86_64_v2_perl-HTTP-Cache-Transparent.sha256sum] = "13727b90798f3debf6992ad80896c7053662ad5ad67cf85d07adfd68ca3cfafa"

URI_aarch64_perl-HTTP-Cache-Transparent = "${EPEL_MIRROR}/aarch64/Packages/p/perl-HTTP-Cache-Transparent-1.4-24.el10_0.noarch.rpm;name=aarch64_perl-HTTP-Cache-Transparent;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-HTTP-Cache-Transparent}"
SRC_URI[aarch64_perl-HTTP-Cache-Transparent.sha256sum] = "5f24375bf9f258def9111a04e5778473ec1ee7821f2391408d6962749dcfc046"

RDEPENDS:perl-HTTP-Cache-Transparent = " \
 perl-Carp \
 perl-Digest-MD5 \
 perl-File-Copy \
 perl-File-Path \
 perl-HTTP-Message \
 perl-IO \
 perl-PathTools \
 perl-libs \
 perl-libwww-perl \
 "
