# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libbz2-rs-sys"
PV = "0.1.3"
PR = "1.el10_1"
PACKAGES = " \
 rust-libbz2-rs-sys+c-allocator-devel \
 rust-libbz2-rs-sys+default-devel \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys+semver-prefix-devel \
 rust-libbz2-rs-sys+std-devel \
 rust-libbz2-rs-sys+stdio-devel \
 rust-libbz2-rs-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libbz2-rs-sys-0.1.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5ce6f417af7b7637a9bd1293d2390cf1dc571c878aa4a2c9e8f7bc49b65c0027"

URI_x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+c-allocator-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+c-allocator-devel.sha256sum] = "6ce086d4d059c74bad9214c81d689a2f4e4df802468c29d047f6e1b474381998"

URI_x86_64_v2_rust-libbz2-rs-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+default-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+default-devel.sha256sum] = "8085f851b0403b36951cae5a33318d0afcc6cd5ff456ff7f035a2a3207461ad1"

URI_x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+rust-allocator-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+rust-allocator-devel.sha256sum] = "4ce713b699b89f3fd7829d7f34ab359848b11ceab750ea52218cf5b4bdcf2621"

URI_x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+semver-prefix-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+semver-prefix-devel.sha256sum] = "d4d6db913aff0c8fd965f5488960e6f6be4a8c126830497f945a047d1488528b"

URI_x86_64_v2_rust-libbz2-rs-sys+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+std-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+std-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+std-devel.sha256sum] = "fc42dba6ccbe0d936a9cd48b95ec5c301af4d62260347d2742f0204476f10bbd"

URI_x86_64_v2_rust-libbz2-rs-sys+stdio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys+stdio-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys+stdio-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys+stdio-devel.sha256sum] = "d8e957008981b43c305aa71345c994fa343faa497ba3c2d5d372e8c2f9f8147b"

URI_x86_64_v2_rust-libbz2-rs-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libbz2-rs-sys-devel-0.1.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libbz2-rs-sys-devel}"
SRC_URI[x86_64_v2_rust-libbz2-rs-sys-devel.sha256sum] = "375343466cd509c8a4bb43f62bfbb03b9d424d1ede108e7b16bd2bce8d1cf883"

URI_aarch64_rust-libbz2-rs-sys+c-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+c-allocator-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+c-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+c-allocator-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+c-allocator-devel.sha256sum] = "4fdd9663cfcb94de5d0687a8462938b69d0568b5fc4fa8e67c1f3795573719f9"

URI_aarch64_rust-libbz2-rs-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+default-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+default-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+default-devel.sha256sum] = "e04f41208505b701964373def6e7d62cd0ae8a6ebb5ec0b268da959ffd97f884"

URI_aarch64_rust-libbz2-rs-sys+rust-allocator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+rust-allocator-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+rust-allocator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+rust-allocator-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+rust-allocator-devel.sha256sum] = "9022e011603475770226e7922bcd21ccffcb6ca08d4951817325b5a32b99b5bf"

URI_aarch64_rust-libbz2-rs-sys+semver-prefix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+semver-prefix-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+semver-prefix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+semver-prefix-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+semver-prefix-devel.sha256sum] = "251fc138e3ecaf16926107b37a64838fc97f468ec04080df77eb6a962acf2854"

URI_aarch64_rust-libbz2-rs-sys+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+std-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+std-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+std-devel.sha256sum] = "ed0837fa72077711e86385fbed2a2566135fb48c7c927eb1e4176b9255eba052"

URI_aarch64_rust-libbz2-rs-sys+stdio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys+stdio-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-libbz2-rs-sys+stdio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys+stdio-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys+stdio-devel.sha256sum] = "04ce0ab6468fedd3e4e6dc33de151b1b0b11b3011fee44eef8d8d45993f0eeb1"

URI_aarch64_rust-libbz2-rs-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libbz2-rs-sys-devel-0.1.3-1.el10_1.noarch.rpm;name=aarch64_rust-libbz2-rs-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libbz2-rs-sys-devel}"
SRC_URI[aarch64_rust-libbz2-rs-sys-devel.sha256sum] = "4e14284820e08b8c6a4d9a9f417a381cb19a05f852694a066692bbb5f104f66d"

RDEPENDS:rust-libbz2-rs-sys+c-allocator-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+default-devel = " \
 cargo \
 rust-libbz2-rs-sys+std-devel \
 rust-libbz2-rs-sys+stdio-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+rust-allocator-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+semver-prefix-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+std-devel = " \
 cargo \
 rust-libbz2-rs-sys+rust-allocator-devel \
 rust-libbz2-rs-sys-devel \
 "
RDEPENDS:rust-libbz2-rs-sys+stdio-devel = " \
 cargo \
 rust-libbz2-rs-sys-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-libbz2-rs-sys-devel = " \
 cargo \
 rust \
 "
