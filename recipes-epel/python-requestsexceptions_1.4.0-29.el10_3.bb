# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-requestsexceptions"
PV = "1.4.0"
PR = "29.el10_3"
PACKAGES = " \
 python3-requestsexceptions \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-requestsexceptions-1.4.0-29.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25e57f342af25b49715ad360541b1b899a845f6dbbb127b48fc1a197d71f4cd9"

URI_x86_64_v2_python3-requestsexceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-requestsexceptions-1.4.0-29.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-requestsexceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-requestsexceptions}"
SRC_URI[x86_64_v2_python3-requestsexceptions.sha256sum] = "d095784de533e5132da18b05561ee167c3fc0e99cdd4d93612ba7cd30aa3d8fb"

URI_aarch64_python3-requestsexceptions = "${EPEL_MIRROR}/aarch64/Packages/p/python3-requestsexceptions-1.4.0-29.el10_3.noarch.rpm;name=aarch64_python3-requestsexceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-requestsexceptions}"
SRC_URI[aarch64_python3-requestsexceptions.sha256sum] = "a5de95415eb8cc6781f046b3093089a7f742a268ab9f1761db2c0afdbce074e1"

RDEPENDS:python3-requestsexceptions = " \
 python3 \
 "
