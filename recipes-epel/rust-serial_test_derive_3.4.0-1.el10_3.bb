# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serial_test_derive"
PV = "3.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-serial_test_derive+async-devel \
 rust-serial_test_derive+default-devel \
 rust-serial_test_derive+file_locks-devel \
 rust-serial_test_derive+test_logging-devel \
 rust-serial_test_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serial_test_derive-3.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bf03af9f3b85365ca9a0e0930c064404633ada61a95beb782adb015df8f260d"

URI_x86_64_v2_rust-serial_test_derive+async-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+async-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+async-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+async-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+async-devel.sha256sum] = "5eb0142fddd1cd803ec50465988039b0307346794261465b72c92d574643c4d8"

URI_x86_64_v2_rust-serial_test_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+default-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+default-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+default-devel.sha256sum] = "6dc479eb602e868f960b693b8efecde4a31c0d486deeb6824ac1555243f29f27"

URI_x86_64_v2_rust-serial_test_derive+file_locks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+file_locks-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+file_locks-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+file_locks-devel.sha256sum] = "7a181fe6e4b89cd44e05e990301102a1d94a4746f296f88a26354827b5e6f45b"

URI_x86_64_v2_rust-serial_test_derive+test_logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive+test_logging-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive+test_logging-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive+test_logging-devel.sha256sum] = "9c20afea85c4511337d86e5339c75d61d257f898df361ab9068f833176da432d"

URI_x86_64_v2_rust-serial_test_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serial_test_derive-devel-3.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serial_test_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serial_test_derive-devel}"
SRC_URI[x86_64_v2_rust-serial_test_derive-devel.sha256sum] = "46385f2c693658dec4d953fa72e09d7b39ea1ee58c8cbf5612cc19acd3d33b6a"

URI_aarch64_rust-serial_test_derive+async-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+async-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test_derive+async-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+async-devel}"
SRC_URI[aarch64_rust-serial_test_derive+async-devel.sha256sum] = "c4930ba6ded0a326c326588876a4253dd8b987098d9d109c1477903f135a8aca"

URI_aarch64_rust-serial_test_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+default-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+default-devel}"
SRC_URI[aarch64_rust-serial_test_derive+default-devel.sha256sum] = "4ca001982d964223bb26e9486cf4172b0c69a5deb539f403055464f3d2abf940"

URI_aarch64_rust-serial_test_derive+file_locks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+file_locks-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test_derive+file_locks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+file_locks-devel}"
SRC_URI[aarch64_rust-serial_test_derive+file_locks-devel.sha256sum] = "4f190dd63bb301b9659dc6952a559e5d9c4027dd27e304d36ae4f25aa85e6934"

URI_aarch64_rust-serial_test_derive+test_logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive+test_logging-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test_derive+test_logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive+test_logging-devel}"
SRC_URI[aarch64_rust-serial_test_derive+test_logging-devel.sha256sum] = "d3cb487cf83ff433faaf09ef8485e25f5ab2ce9dee28b78b7f229534dad06a37"

URI_aarch64_rust-serial_test_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serial_test_derive-devel-3.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-serial_test_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serial_test_derive-devel}"
SRC_URI[aarch64_rust-serial_test_derive-devel.sha256sum] = "e28f47a8fe22264a54679881458a13cb0600876d34329888156db0e40e3fcb6c"

RDEPENDS:rust-serial_test_derive+async-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive+default-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive+file_locks-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive+test_logging-devel = " \
 cargo \
 rust-serial_test_derive-devel \
 "
RDEPENDS:rust-serial_test_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote-devel \
 rust-syn2+clone-impls-devel \
 rust-syn2+full-devel \
 rust-syn2+parsing-devel \
 rust-syn2+printing-devel \
 rust-syn2-devel \
 "
