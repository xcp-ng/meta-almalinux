# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quick-xml"
PV = "0.41.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-quick-xml+arbitrary-devel \
 rust-quick-xml+async-tokio-devel \
 rust-quick-xml+default-devel \
 rust-quick-xml+document-features-devel \
 rust-quick-xml+encoding-devel \
 rust-quick-xml+encoding_rs-devel \
 rust-quick-xml+escape-html-devel \
 rust-quick-xml+overlapped-lists-devel \
 rust-quick-xml+serde-devel \
 rust-quick-xml+serde-types-devel \
 rust-quick-xml+serialize-devel \
 rust-quick-xml+tokio-devel \
 rust-quick-xml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quick-xml-0.41.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6ea6ab2c83380101a9bfa77f472374bca9eef95d2fb26a4e7e239640d9cd73c6"

URI_x86_64_v2_rust-quick-xml+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+arbitrary-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+arbitrary-devel.sha256sum] = "42cf736784bb0ffa7bb35600fad5f454023c0fc7c0694583878b051c612bd6c7"

URI_x86_64_v2_rust-quick-xml+async-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+async-tokio-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+async-tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+async-tokio-devel.sha256sum] = "a397be386694d4456205f512fc6726acd62ceae2026bd6d46fea535f72a56a54"

URI_x86_64_v2_rust-quick-xml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+default-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+default-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+default-devel.sha256sum] = "516e765688ce0a24391f92e3c0e1f868f296224dd55fa07cfb9ac83d980e0dd8"

URI_x86_64_v2_rust-quick-xml+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+document-features-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+document-features-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+document-features-devel.sha256sum] = "80167cf2f6086236f737c91a97516c2a086a3cbaefe3ac16f2e0583bcee078ec"

URI_x86_64_v2_rust-quick-xml+encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+encoding-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+encoding-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+encoding-devel.sha256sum] = "c8d1cb4426a5b9aa5b346bef431165e6d24f84fece2185c1b57509b5c57793ed"

URI_x86_64_v2_rust-quick-xml+encoding_rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+encoding_rs-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+encoding_rs-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+encoding_rs-devel.sha256sum] = "aecd86f1ea7e695dd9c42726ce5a36fd45d8843062b4a59182ba852269f4577f"

URI_x86_64_v2_rust-quick-xml+escape-html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+escape-html-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+escape-html-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+escape-html-devel.sha256sum] = "debd8826719b57c9186ee441fe1fbc70a8e056861cf8b3d22158b89416c4fdd7"

URI_x86_64_v2_rust-quick-xml+overlapped-lists-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+overlapped-lists-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+overlapped-lists-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+overlapped-lists-devel.sha256sum] = "e10aba8c765847531abea7b0120841af59e787a71a11f837befbd2bd4c2ffe5a"

URI_x86_64_v2_rust-quick-xml+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serde-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+serde-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+serde-devel.sha256sum] = "7ceb10f238384359f967b85df6d24141eb838bc3131abe54127b573acc3ca3b6"

URI_x86_64_v2_rust-quick-xml+serde-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serde-types-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+serde-types-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+serde-types-devel.sha256sum] = "9affbb39b8fb00dba82ef95f3a9416c5dc46c95fc4169b175d745367b2c50eee"

URI_x86_64_v2_rust-quick-xml+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+serialize-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+serialize-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+serialize-devel.sha256sum] = "2ea24beca46af4a57c410a42c250f52166546896720b8e5d49f490125f9dd13c"

URI_x86_64_v2_rust-quick-xml+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml+tokio-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml+tokio-devel}"
SRC_URI[x86_64_v2_rust-quick-xml+tokio-devel.sha256sum] = "7099839d98c0034cfe383250fa745427b3411312845461e7371a236dcc7eb112"

URI_x86_64_v2_rust-quick-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quick-xml-devel-0.41.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quick-xml-devel}"
SRC_URI[x86_64_v2_rust-quick-xml-devel.sha256sum] = "703c5d59a98943c2a02894f8829551156bcd6779be441b09ad06236846cc088c"

URI_aarch64_rust-quick-xml+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+arbitrary-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+arbitrary-devel}"
SRC_URI[aarch64_rust-quick-xml+arbitrary-devel.sha256sum] = "68ac4a7b346f15335e9d13af23214106868c325376e0bc79df27266c17a429c6"

URI_aarch64_rust-quick-xml+async-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+async-tokio-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+async-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+async-tokio-devel}"
SRC_URI[aarch64_rust-quick-xml+async-tokio-devel.sha256sum] = "4c3c5996108069c939937f1bbfe06520d35e067e0e9df5bbc70e46824cad6d64"

URI_aarch64_rust-quick-xml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+default-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+default-devel}"
SRC_URI[aarch64_rust-quick-xml+default-devel.sha256sum] = "026371238a5f6d38c22634edf162680997bb81a12b7a00d4e165247e561b44de"

URI_aarch64_rust-quick-xml+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+document-features-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+document-features-devel}"
SRC_URI[aarch64_rust-quick-xml+document-features-devel.sha256sum] = "73f75d92cee4905656f41d56e0bcc80145766fc4300a1050038af7e3589cca02"

URI_aarch64_rust-quick-xml+encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+encoding-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+encoding-devel}"
SRC_URI[aarch64_rust-quick-xml+encoding-devel.sha256sum] = "a3d2cfd90a94dda12a4864854931e539a0e77ba205f32876eff606acc9393c34"

URI_aarch64_rust-quick-xml+encoding_rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+encoding_rs-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+encoding_rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+encoding_rs-devel}"
SRC_URI[aarch64_rust-quick-xml+encoding_rs-devel.sha256sum] = "1b015503c53b1c1722da5d266a1c54d539e4db53623be9bea3fc7b8c0a70d958"

URI_aarch64_rust-quick-xml+escape-html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+escape-html-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+escape-html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+escape-html-devel}"
SRC_URI[aarch64_rust-quick-xml+escape-html-devel.sha256sum] = "bf9cca763e57e5bd1f91cb959f6219d71021ba2420954daf7a96dbf1946642e5"

URI_aarch64_rust-quick-xml+overlapped-lists-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+overlapped-lists-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+overlapped-lists-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+overlapped-lists-devel}"
SRC_URI[aarch64_rust-quick-xml+overlapped-lists-devel.sha256sum] = "f629d66ad393a946b167365dc876442ca82c45edb1f20cf5cf4009d7b4559f88"

URI_aarch64_rust-quick-xml+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serde-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+serde-devel}"
SRC_URI[aarch64_rust-quick-xml+serde-devel.sha256sum] = "73f3849402911a29d5c813ac2a64f610ed8d0ef7fc93866894dad31712469583"

URI_aarch64_rust-quick-xml+serde-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serde-types-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+serde-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+serde-types-devel}"
SRC_URI[aarch64_rust-quick-xml+serde-types-devel.sha256sum] = "14e8b6c65fa40ee78dfa0cf08eed753711c34bf80eb4c7816602d2c5233751e9"

URI_aarch64_rust-quick-xml+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+serialize-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+serialize-devel}"
SRC_URI[aarch64_rust-quick-xml+serialize-devel.sha256sum] = "ecaa71516e0430da3137f078c4e0650ace563d6f04cd790cc163d69720b3142e"

URI_aarch64_rust-quick-xml+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml+tokio-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml+tokio-devel}"
SRC_URI[aarch64_rust-quick-xml+tokio-devel.sha256sum] = "5bf45a2800fcf8d3036628e3d52c4a434e0931dd49ce07e3704b2eb372a4da63"

URI_aarch64_rust-quick-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quick-xml-devel-0.41.0-1.el10_3.noarch.rpm;name=aarch64_rust-quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quick-xml-devel}"
SRC_URI[aarch64_rust-quick-xml-devel.sha256sum] = "aeb6da6e250d3968fdcc4d9584d212b79c3160706f01ddf17226942f0936c3a8"

RDEPENDS:rust-quick-xml+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+async-tokio-devel = " \
 cargo \
 rust-quick-xml+tokio-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+default-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+encoding-devel = " \
 cargo \
 rust-quick-xml+encoding_rs-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+encoding_rs-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+escape-html-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+overlapped-lists-devel = " \
 cargo \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+serde-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-serde+default-devel \
 "
RDEPENDS:rust-quick-xml+serde-types-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-quick-xml+serialize-devel = " \
 cargo \
 rust-quick-xml+serde-devel \
 rust-quick-xml-devel \
 "
RDEPENDS:rust-quick-xml+tokio-devel = " \
 cargo \
 rust-quick-xml-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-quick-xml-devel = " \
 cargo \
 rust \
 rust-memchr+default-devel \
 "
