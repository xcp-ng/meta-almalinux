# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "parallel"
PV = "20260722"
PR = "1.el10_3"
PACKAGES = " \
 parallel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/parallel-20260722-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "296af9d5b068d40b411814f19b65f058880b8587c2cd2290df50df7894741b67"

URI_x86_64_v2_parallel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parallel-20260722-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_parallel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parallel}"
SRC_URI[x86_64_v2_parallel.sha256sum] = "c41890ab11b6eb7085e4bb6cba28a74ddaf77795c9e4dd18a15a325865c89691"

URI_aarch64_parallel = "${EPEL_MIRROR}/aarch64/Packages/p/parallel-20260722-1.el10_3.noarch.rpm;name=aarch64_parallel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parallel}"
SRC_URI[aarch64_parallel.sha256sum] = "4fc75b2ca4c760386e9163d3a5068c3b91acc3f7e93696580acba4313dde37d5"

RDEPENDS:parallel = " \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-POSIX \
 perl-Symbol \
 perl-Thread-Queue \
 perl-interpreter \
 perl-libs \
 perl-threads \
 perl-threads-shared \
 "
