# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolourpaint"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kolourpaint \
 kolourpaint-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kolourpaint-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "172a230719b23340dd08c4a0000adc07e192152dfab0783ca5f9dd5dc3523422"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint;unpack=0"
SRC_URI[x86_64_v2_kolourpaint.sha256sum] = "eb07d4c6246237a1e0de7a06aef407190a4f02f242dccc88ddee39b51e2bc079"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolourpaint-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolourpaint-libs;unpack=0"
SRC_URI[x86_64_v2_kolourpaint-libs.sha256sum] = "42edc44bd261bb91c54c5f4f0a5936eb19f8121b936a8c8fdacb7fd8b287889d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kolourpaint;unpack=0"
SRC_URI[aarch64_kolourpaint.sha256sum] = "7f5caf01466e4732099ac3748ef89c850043a8cf7a3612642f9a9aef71c7fd3d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kolourpaint-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kolourpaint-libs;unpack=0"
SRC_URI[aarch64_kolourpaint-libs.sha256sum] = "32883647c196d9f2f297ba00c0f7df1c3c905dc7530341e7c5f0706f7d6b0a3e"

RDEPENDS:kolourpaint = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kolourpaint-libs \
 libksane \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kolourpaint-libs = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kolourpaint \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
