# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kleopatra"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kleopatra \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kleopatra-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c15643d319a23620071f49e7fb1ae65cdb45c3d9ff03bcad34b85203908d84e"

URI_x86_64_v2_kleopatra = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kleopatra-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kleopatra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kleopatra}"
SRC_URI[x86_64_v2_kleopatra.sha256sum] = "33b2d56e6c0611787595c01cadf229b1bd34f4f1588613d6d02a12eee07f4e73"

URI_aarch64_kleopatra = "${EPEL_MIRROR}/aarch64/Packages/k/kleopatra-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kleopatra;unpack=0"
SRC_URI:append = " ${URI_aarch64_kleopatra}"
SRC_URI[aarch64_kleopatra.sha256sum] = "3e55cf0066835aecceba2654c93da990b507bfcf196bd36b9f88f4438f9466e0"

RDEPENDS:kleopatra = " \
 akonadi-mime \
 glibc \
 gnupg2 \
 gnupg2-smime \
 gpgmepp \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kidentitymanagement \
 kmailtransport \
 kmime \
 libassuan \
 libgcc \
 libgpg-error \
 libkleo \
 libstdc++ \
 mimetreeparser \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
