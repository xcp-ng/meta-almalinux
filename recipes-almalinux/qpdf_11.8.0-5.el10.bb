# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qpdf"
PV = "11.8.0"
PR = "5.el10"
PACKAGES = " \
 qpdf \
 qpdf-devel \
 qpdf-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qpdf-11.8.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a494d9b4e5dc236bacbd015ecb525e09468d4636b78acf20020e5b16db316652"

URI_x86_64_v2_qpdf = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qpdf-11.8.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_qpdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpdf}"
SRC_URI[x86_64_v2_qpdf.sha256sum] = "1de67263ba3c868cad5c260e6a4d5fb491dd0ce6ca096f65c4474e393334bb0b"

URI_x86_64_v2_qpdf-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qpdf-devel-11.8.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_qpdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpdf-devel}"
SRC_URI[x86_64_v2_qpdf-devel.sha256sum] = "1911cfd02ed158ce5d74aeea568608db6b993c1cf085e3899a2240e0db5bae74"

URI_x86_64_v2_qpdf-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qpdf-libs-11.8.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_qpdf-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qpdf-libs}"
SRC_URI[x86_64_v2_qpdf-libs.sha256sum] = "7fd5e04cc71c47329a604f0d4adfd972cd163673be76e895191b4e403282653d"

URI_aarch64_qpdf = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qpdf-11.8.0-5.el10.aarch64.rpm;name=aarch64_qpdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpdf}"
SRC_URI[aarch64_qpdf.sha256sum] = "85a58d5d598b0501309a32d949851e7b7a213699535461eddd0b838312dd3912"

URI_aarch64_qpdf-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qpdf-devel-11.8.0-5.el10.aarch64.rpm;name=aarch64_qpdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpdf-devel}"
SRC_URI[aarch64_qpdf-devel.sha256sum] = "c2eaa5873d538d41faceb871406fe58879c6397a7b37488222ea38366fba6347"

URI_aarch64_qpdf-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qpdf-libs-11.8.0-5.el10.aarch64.rpm;name=aarch64_qpdf-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_qpdf-libs}"
SRC_URI[aarch64_qpdf-libs.sha256sum] = "0f8f423b1c17d000fb13807550922d6c2c87ff7b9638c6a04e6480f6730b1662"

RDEPENDS:qpdf = " \
 glibc \
 libgcc \
 libstdc++ \
 qpdf-libs \
 "
RDEPENDS:qpdf-devel = " \
 gnutls-devel \
 libjpeg-turbo-devel \
 pkgconf-pkg-config \
 qpdf-libs \
 zlib-ng-compat-devel \
 "
RDEPENDS:qpdf-libs = " \
 glibc \
 gnutls \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 zlib-ng-compat \
 "
