# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firejail"
PV = "0.9.80"
PR = "1.el10_3"
PACKAGES = " \
 firejail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/firejail-0.9.80-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3bba45a6556e6a4ca3b3b43059998568cb548ed9aa5f4c2ac882b8bc607759a6"

URI_x86_64_v2_firejail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/firejail-0.9.80-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_firejail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firejail}"
SRC_URI[x86_64_v2_firejail.sha256sum] = "3858540a1ec5a5874fda8d78482d17262c18ad21b87d313a59aa5725a4c7c820"

URI_aarch64_firejail = "${EPEL_MIRROR}/aarch64/Packages/f/firejail-0.9.80-1.el10_3.aarch64.rpm;name=aarch64_firejail;unpack=0"
SRC_URI:append = " ${URI_aarch64_firejail}"
SRC_URI[aarch64_firejail.sha256sum] = "777ab1e53696d3a01f27294cb038a6fae41634e7b6f7d36e5f525fb11c9a81ea"

RDEPENDS:firejail = " \
 bash \
 glibc \
 libselinux \
 python3 \
 xdg-dbus-proxy \
 "
