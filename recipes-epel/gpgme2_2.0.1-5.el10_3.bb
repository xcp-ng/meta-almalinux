# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpgme2"
PV = "2.0.1"
PR = "5.el10_3"
PACKAGES = " \
 gpgme2 \
 gpgme2-devel \
 gpgme2pp \
 gpgme2pp-devel \
 qgpgme2-common-devel \
 qgpgme2-qt6 \
 qgpgme2-qt6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpgme2-2.0.1-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d926c2409184828ea18a1d62f0a8e114945c5c290b258c3f80f8dc629af6cf4"

URI_x86_64_v2_gpgme2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpgme2-2.0.1-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpgme2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgme2}"
SRC_URI[x86_64_v2_gpgme2.sha256sum] = "9f2314a34ea29898f6d47de1076b2f1ee7c4e1541d6a129ad6c612eda8f1e3e9"

URI_x86_64_v2_gpgme2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpgme2-devel-2.0.1-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpgme2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgme2-devel}"
SRC_URI[x86_64_v2_gpgme2-devel.sha256sum] = "10a06290048d16481a1f00494f0bb78c40e8f3bbea19712cf3b39da31c7731cf"
RPROVIDES:gpgme2-devel:x86_64_v2 = "virtual/pkgconfig_gpgme_ virtual/pkgconfig_gpgme__ge_1.12.0 virtual/pkgconfig_gpgme__ge_1.8.0"

URI_x86_64_v2_gpgme2pp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpgme2pp-2.0.1-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpgme2pp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgme2pp}"
SRC_URI[x86_64_v2_gpgme2pp.sha256sum] = "5d57796c028ba3e202e32d6e274f6f5ef2b36487c52222e4cc6770ce43b6f7b2"

URI_x86_64_v2_gpgme2pp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpgme2pp-devel-2.0.1-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpgme2pp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpgme2pp-devel}"
SRC_URI[x86_64_v2_gpgme2pp-devel.sha256sum] = "67739a379dbbe0997eb38f9f6ceee253d712088b7f6d4c7f0e16089234ccfca8"
RPROVIDES:gpgme2pp-devel:x86_64_v2 = "virtual/cmake_Gpgmepp_"

URI_x86_64_v2_qgpgme2-common-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qgpgme2-common-devel-2.0.1-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qgpgme2-common-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qgpgme2-common-devel}"
SRC_URI[x86_64_v2_qgpgme2-common-devel.sha256sum] = "368a95f26f0c2a75b20f501b880291e15f7d2f4d32ae65fe9f3b42117d05e9f6"

URI_x86_64_v2_qgpgme2-qt6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qgpgme2-qt6-2.0.1-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qgpgme2-qt6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qgpgme2-qt6}"
SRC_URI[x86_64_v2_qgpgme2-qt6.sha256sum] = "d0b4d5fc73695985d957f172819043e6b62c7beb12768ad3c97fb30d0240a72e"

URI_x86_64_v2_qgpgme2-qt6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qgpgme2-qt6-devel-2.0.1-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qgpgme2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qgpgme2-qt6-devel}"
SRC_URI[x86_64_v2_qgpgme2-qt6-devel.sha256sum] = "fd528bbac53d08f841dd64c906b334fa78ee7a7c82694ace20fd53e4fda94e1b"
RPROVIDES:qgpgme2-qt6-devel:x86_64_v2 = "virtual/cmake_QGpgmeQt6_"

URI_aarch64_gpgme2 = "${EPEL_MIRROR}/aarch64/Packages/g/gpgme2-2.0.1-5.el10_3.aarch64.rpm;name=aarch64_gpgme2;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgme2}"
SRC_URI[aarch64_gpgme2.sha256sum] = "544dd5953293c3c05cf9a2ade62315ba070e792addcecc8acba157ecebc683d3"

URI_aarch64_gpgme2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gpgme2-devel-2.0.1-5.el10_3.aarch64.rpm;name=aarch64_gpgme2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgme2-devel}"
SRC_URI[aarch64_gpgme2-devel.sha256sum] = "b678c376078e28a50cc16dec550a1c45e0c2f2a53d8d24470f10c0e4cf88be4c"
RPROVIDES:gpgme2-devel:aarch64 = "virtual/pkgconfig_gpgme_ virtual/pkgconfig_gpgme__ge_1.12.0 virtual/pkgconfig_gpgme__ge_1.8.0"

URI_aarch64_gpgme2pp = "${EPEL_MIRROR}/aarch64/Packages/g/gpgme2pp-2.0.1-5.el10_3.aarch64.rpm;name=aarch64_gpgme2pp;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgme2pp}"
SRC_URI[aarch64_gpgme2pp.sha256sum] = "61c935e35f7e068596fbaa274370177ca38f8aab3e1d2c5b980588ec12a78a7f"

URI_aarch64_gpgme2pp-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gpgme2pp-devel-2.0.1-5.el10_3.aarch64.rpm;name=aarch64_gpgme2pp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpgme2pp-devel}"
SRC_URI[aarch64_gpgme2pp-devel.sha256sum] = "08cdf6d89d01d2b4d3c4c3efa9312fe08e0ce16f20b3998046d2e5f5b3f25e90"
RPROVIDES:gpgme2pp-devel:aarch64 = "virtual/cmake_Gpgmepp_"

URI_aarch64_qgpgme2-common-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qgpgme2-common-devel-2.0.1-5.el10_3.aarch64.rpm;name=aarch64_qgpgme2-common-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qgpgme2-common-devel}"
SRC_URI[aarch64_qgpgme2-common-devel.sha256sum] = "f1419db3745f355d868f8aac5ebea1dc6b3187c65bc7b6833dcdbec9584ddaf9"

URI_aarch64_qgpgme2-qt6 = "${EPEL_MIRROR}/aarch64/Packages/q/qgpgme2-qt6-2.0.1-5.el10_3.aarch64.rpm;name=aarch64_qgpgme2-qt6;unpack=0"
SRC_URI:append = " ${URI_aarch64_qgpgme2-qt6}"
SRC_URI[aarch64_qgpgme2-qt6.sha256sum] = "d3b22a415bc6b3d68306ae651ad3bb08a3707c8ed74d24aeae56ba556b3fc154"

URI_aarch64_qgpgme2-qt6-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qgpgme2-qt6-devel-2.0.1-5.el10_3.aarch64.rpm;name=aarch64_qgpgme2-qt6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qgpgme2-qt6-devel}"
SRC_URI[aarch64_qgpgme2-qt6-devel.sha256sum] = "735c8705ff6f9ef1f65d7d02e374b56dcd0dd355e4e1617a7b4404863bda8405"
RPROVIDES:qgpgme2-qt6-devel:aarch64 = "virtual/cmake_QGpgmeQt6_"

RDEPENDS:gpgme2 = " \
 glibc \
 gnupg2 \
 libassuan \
 libgpg-error \
 "
RDEPENDS:gpgme2-devel = " \
 bash \
 glib2-devel \
 glibc \
 gpgme2 \
 libassuan \
 libassuan-devel \
 libgpg-error \
 libgpg-error-devel \
 pkgconf-pkg-config \
 virtual/pkgconfig_gpgme_ \
 "
RDEPENDS:gpgme2pp = " \
 glibc \
 gpgme2 \
 libgcc \
 libstdc++ \
 "
RDEPENDS:gpgme2pp-devel = " \
 cmake-filesystem \
 gpgme2-devel \
 gpgme2pp \
 "
RDEPENDS:qgpgme2-common-devel = " \
 gpgme2pp-devel \
 "
RDEPENDS:qgpgme2-qt6 = " \
 glibc \
 gpgme2pp \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qgpgme2-qt6-devel = " \
 cmake-filesystem \
 qgpgme2-common-devel \
 qgpgme2-qt6 \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/cmake_Gpgmepp_ rpm/virtual/cmake_QGpgmeQt6_ rpm/virtual/pkgconfig_gpgme_ rpm/virtual/pkgconfig_gpgme__ge_1.12.0 rpm/virtual/pkgconfig_gpgme__ge_1.8.0"

PROVIDES:append:aarch64 = " rpm/virtual/cmake_Gpgmepp_ rpm/virtual/cmake_QGpgmeQt6_ rpm/virtual/pkgconfig_gpgme_ rpm/virtual/pkgconfig_gpgme__ge_1.12.0 rpm/virtual/pkgconfig_gpgme__ge_1.8.0"
