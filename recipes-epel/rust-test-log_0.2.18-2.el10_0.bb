# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-test-log"
PV = "0.2.18"
PR = "2.el10_0"
PACKAGES = " \
 rust-test-log+color-devel \
 rust-test-log+default-devel \
 rust-test-log+log-devel \
 rust-test-log+trace-devel \
 rust-test-log+unstable-devel \
 rust-test-log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-test-log-0.2.18-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4abf539160334887b05ce4f9dfcc963f78a9a7f67d5e32b57e6da89dc8494f9"

URI_x86_64_v2_rust-test-log+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+color-devel-0.2.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+color-devel}"
SRC_URI[x86_64_v2_rust-test-log+color-devel.sha256sum] = "48ca71cc8bd868388ac87b0227237d1c5348744ef27c4c03bee05ecb33b13208"

URI_x86_64_v2_rust-test-log+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+default-devel-0.2.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+default-devel}"
SRC_URI[x86_64_v2_rust-test-log+default-devel.sha256sum] = "281e56c12c5b092f7d9202602cf03102b619300f82a262b5d920c9ee12ca364b"

URI_x86_64_v2_rust-test-log+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+log-devel-0.2.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+log-devel}"
SRC_URI[x86_64_v2_rust-test-log+log-devel.sha256sum] = "0f20818c126cbeb00b7756b040b3b54ee0121015c29604e3778318cd00e46e14"

URI_x86_64_v2_rust-test-log+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+trace-devel-0.2.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+trace-devel}"
SRC_URI[x86_64_v2_rust-test-log+trace-devel.sha256sum] = "ef193ab0511e512731f44433b1773d9cc419dac43736784c9a932827c75808ef"

URI_x86_64_v2_rust-test-log+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log+unstable-devel-0.2.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log+unstable-devel}"
SRC_URI[x86_64_v2_rust-test-log+unstable-devel.sha256sum] = "d34f1d3026fbf701683e2dc8264ca8b96c85607a99be57bc2397e27cf54d417c"

URI_x86_64_v2_rust-test-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-test-log-devel-0.2.18-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-test-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-test-log-devel}"
SRC_URI[x86_64_v2_rust-test-log-devel.sha256sum] = "0c495ef78af1b6e49d302ff614c7891504c8beea2cccc891455906937397f0a2"

URI_aarch64_rust-test-log+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+color-devel-0.2.18-2.el10_0.noarch.rpm;name=aarch64_rust-test-log+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+color-devel}"
SRC_URI[aarch64_rust-test-log+color-devel.sha256sum] = "5268740d1ef0918b831966531fc6ff547843225d454d083352c635eb3e4c66b3"

URI_aarch64_rust-test-log+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+default-devel-0.2.18-2.el10_0.noarch.rpm;name=aarch64_rust-test-log+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+default-devel}"
SRC_URI[aarch64_rust-test-log+default-devel.sha256sum] = "d898350c48e3eef88810c8b3f71ad9518bc31d41e01033abd8eae35d0719797c"

URI_aarch64_rust-test-log+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+log-devel-0.2.18-2.el10_0.noarch.rpm;name=aarch64_rust-test-log+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+log-devel}"
SRC_URI[aarch64_rust-test-log+log-devel.sha256sum] = "877dd8a01f32efdd8e1f5ff74bcf141a230d9f2a29c2932ca41e42ac394da4db"

URI_aarch64_rust-test-log+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+trace-devel-0.2.18-2.el10_0.noarch.rpm;name=aarch64_rust-test-log+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+trace-devel}"
SRC_URI[aarch64_rust-test-log+trace-devel.sha256sum] = "db24b68cd5d70c484ce5eb2a728a545c3d9390b9049ab53d6d95dfb3983e4f5a"

URI_aarch64_rust-test-log+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log+unstable-devel-0.2.18-2.el10_0.noarch.rpm;name=aarch64_rust-test-log+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log+unstable-devel}"
SRC_URI[aarch64_rust-test-log+unstable-devel.sha256sum] = "71681b57cd2e07fbd0e4a370119e703b496e2e817c1b9fec21ac05bbf2fe3de0"

URI_aarch64_rust-test-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-test-log-devel-0.2.18-2.el10_0.noarch.rpm;name=aarch64_rust-test-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-test-log-devel}"
SRC_URI[aarch64_rust-test-log-devel.sha256sum] = "433a086ea06e73f5f61c3f80a7c5153fe0a1f10d55376fd77280e50bdf5d65d0"

RDEPENDS:rust-test-log+color-devel = " \
 cargo \
 rust-env_logger+auto-color-devel \
 rust-env_logger-devel \
 rust-test-log-devel \
 rust-tracing-subscriber+ansi-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-test-log+default-devel = " \
 cargo \
 rust-test-log+color-devel \
 rust-test-log+log-devel \
 rust-test-log-devel \
 "
RDEPENDS:rust-test-log+log-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-test-log-devel \
 rust-test-log-macros+log-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+tracing-log-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-test-log+trace-devel = " \
 cargo \
 rust-test-log-devel \
 rust-test-log-macros+trace-devel \
 rust-tracing-subscriber+env-filter-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber-devel \
 "
RDEPENDS:rust-test-log+unstable-devel = " \
 cargo \
 rust-test-log-devel \
 rust-test-log-macros+unstable-devel \
 "
RDEPENDS:rust-test-log-devel = " \
 cargo \
 rust \
 rust-test-log-macros+default-devel \
 "
