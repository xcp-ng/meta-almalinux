# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-configargparse"
PV = "1.7.5"
PR = "1.el10_2"
PACKAGES = " \
 python3-configargparse \
 python3-configargparse+yaml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-configargparse-1.7.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43b86c60fede222f1493e70ff81c8dd05b783a26a2fca78dd1c930433572788c"

URI_x86_64_v2_python3-configargparse = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse-1.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configargparse}"
SRC_URI[x86_64_v2_python3-configargparse.sha256sum] = "c4ad86f8d69345bb9370d11d7490073c889db7e596c055fd5a391625d6156f81"

URI_x86_64_v2_python3-configargparse+yaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-configargparse+yaml-1.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-configargparse+yaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-configargparse+yaml}"
SRC_URI[x86_64_v2_python3-configargparse+yaml.sha256sum] = "8995608a6b69a1afd660c36a52db62641b4f4e093c96ea2f5b74780d25eacb98"

URI_aarch64_python3-configargparse = "${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse-1.7.5-1.el10_2.noarch.rpm;name=aarch64_python3-configargparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configargparse}"
SRC_URI[aarch64_python3-configargparse.sha256sum] = "bb83f7d9553e0be4d388088b740a44d9129ed3c61f83a24020b0df01ca0e135c"

URI_aarch64_python3-configargparse+yaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-configargparse+yaml-1.7.5-1.el10_2.noarch.rpm;name=aarch64_python3-configargparse+yaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-configargparse+yaml}"
SRC_URI[aarch64_python3-configargparse+yaml.sha256sum] = "da4573df3efc04d724ae001569045e5f787be1666d6f782d6f95051ff720bbbf"

RDEPENDS:python3-configargparse = " \
 python3 \
 "
RDEPENDS:python3-configargparse+yaml = " \
 python3 \
 python3-configargparse \
 python3-pyyaml \
 "
