# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cppcheck"
PV = "2.18.2"
PR = "3.el10_2"
PACKAGES = " \
 cppcheck \
 cppcheck-gui \
 cppcheck-htmlreport \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/cppcheck-2.18.2-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5f6aabf431064a97f6d6bb4d305d3a36c3e7f880d60551ad78217eac7ee32770"

URI_x86_64_v2_cppcheck = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppcheck-2.18.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppcheck;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppcheck}"
SRC_URI[x86_64_v2_cppcheck.sha256sum] = "9bb5f812e6911d5dc33fc3722bd83fdf6ddadb29305f15568435b34c8623c922"

URI_x86_64_v2_cppcheck-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppcheck-gui-2.18.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppcheck-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppcheck-gui}"
SRC_URI[x86_64_v2_cppcheck-gui.sha256sum] = "c6e116a1c3f58c2dba625eb419c7a2e404e4efac3a1dad0ae433df4f320ad71c"

URI_x86_64_v2_cppcheck-htmlreport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cppcheck-htmlreport-2.18.2-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cppcheck-htmlreport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cppcheck-htmlreport}"
SRC_URI[x86_64_v2_cppcheck-htmlreport.sha256sum] = "6202090aeb478d433d647b5f10171487edfcd99248a23a29c59d327bbbc9ff7f"

URI_aarch64_cppcheck = "${EPEL_MIRROR}/aarch64/Packages/c/cppcheck-2.18.2-3.el10_2.aarch64.rpm;name=aarch64_cppcheck;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppcheck}"
SRC_URI[aarch64_cppcheck.sha256sum] = "7e227adcd7e4372138c86d56f41df1a849ef702a1dfc69960b350f87f5e0718a"

URI_aarch64_cppcheck-gui = "${EPEL_MIRROR}/aarch64/Packages/c/cppcheck-gui-2.18.2-3.el10_2.aarch64.rpm;name=aarch64_cppcheck-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppcheck-gui}"
SRC_URI[aarch64_cppcheck-gui.sha256sum] = "94ffe0c0b3a6da7cc8cca54100563ea12855b9d7a8a1e0882b832edb6804e805"

URI_aarch64_cppcheck-htmlreport = "${EPEL_MIRROR}/aarch64/Packages/c/cppcheck-htmlreport-2.18.2-3.el10_2.aarch64.rpm;name=aarch64_cppcheck-htmlreport;unpack=0"
SRC_URI:append = " ${URI_aarch64_cppcheck-htmlreport}"
SRC_URI[aarch64_cppcheck-htmlreport.sha256sum] = "576530a264322da7be4afdf7bcad470bc03fd4f15b3d7273b1aa010f9e059e22"

RDEPENDS:cppcheck = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 tinyxml2 \
 "
RDEPENDS:cppcheck-gui = " \
 cppcheck \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-help \
 tinyxml2 \
 "
RDEPENDS:cppcheck-htmlreport = " \
 cppcheck \
 python3 \
 python3-pygments \
 "
