# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rhel-system-roles"
PV = "1.95.7"
PR = "0.1.el10_0"
PACKAGES = " \
 rhel-system-roles \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rhel-system-roles-1.95.7-0.1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d414e7a155d867e2a3202a02bf2f46f06320f566da41251e4bc9feeb71c76ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rhel-system-roles-1.95.7-0.1.el10_0.noarch.rpm;name=x86_64_v2_rhel-system-roles;unpack=0"
SRC_URI[x86_64_v2_rhel-system-roles.sha256sum] = "6454808e10c45f9343630615fa4d0971e5708684d68a1f22cef3d75a59c8dea4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rhel-system-roles-1.95.7-0.1.el10_0.noarch.rpm;name=aarch64_rhel-system-roles;unpack=0"
SRC_URI[aarch64_rhel-system-roles.sha256sum] = "6454808e10c45f9343630615fa4d0971e5708684d68a1f22cef3d75a59c8dea4"

RDEPENDS:rhel-system-roles = " \
 ansible-core \
 bash \
 python-unversioned-command \
 virtual//usr/bin/env \
 "
