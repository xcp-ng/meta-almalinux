# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-LongString"
PV = "0.17"
PR = "25.el10_0"
PACKAGES = " \
 perl-Test-LongString \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Test-LongString-0.17-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "af1290494cc693ad5a61252ad7b26742a577eb1d4f79dbdaa2ff3957b96d9f52"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-LongString-0.17-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-LongString;unpack=0"
SRC_URI[x86_64_v2_perl-Test-LongString.sha256sum] = "178738015ef40e19b177a39808ca8e5ae65dda6b6112642412936529233811bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-LongString-0.17-25.el10_0.noarch.rpm;name=aarch64_perl-Test-LongString;unpack=0"
SRC_URI[aarch64_perl-Test-LongString.sha256sum] = "e1a771200023395d18a8d1995f5be14a624cf595cb72d015a447c7b7ce4e9bf8"

RDEPENDS:perl-Test-LongString = " \
 perl-Exporter \
 perl-Test-Simple \
 perl-libs \
 perl-vars \
 "
