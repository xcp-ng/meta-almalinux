# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-igbinary"
PV = "3.2.16"
PR = "3.el10_0"
PACKAGES = " \
 php-pecl-igbinary \
 php-pecl-igbinary-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-igbinary-3.2.16-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5244ce060d93b64488c1985299adc13746539ae8a3040e7a3f545c9eb6dc32a9"

URI_x86_64_v2_php-pecl-igbinary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-igbinary-3.2.16-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-igbinary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-igbinary}"
SRC_URI[x86_64_v2_php-pecl-igbinary.sha256sum] = "7425d4269b8d214bdbf09487a248bf45f6143994fd0da1867286f73601f37c19"

URI_x86_64_v2_php-pecl-igbinary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-igbinary-devel-3.2.16-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-igbinary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-igbinary-devel}"
SRC_URI[x86_64_v2_php-pecl-igbinary-devel.sha256sum] = "380a4b40a468326f3c31bea4ae060ac9d0f31da79652bf088b1faf68a9d5166d"

URI_aarch64_php-pecl-igbinary = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-igbinary-3.2.16-3.el10_0.aarch64.rpm;name=aarch64_php-pecl-igbinary;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-igbinary}"
SRC_URI[aarch64_php-pecl-igbinary.sha256sum] = "519544f51e70bebf5c9c3ea1a274bbabc107f23a4b7f1e16bef4fa63d94f2782"

URI_aarch64_php-pecl-igbinary-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-igbinary-devel-3.2.16-3.el10_0.aarch64.rpm;name=aarch64_php-pecl-igbinary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-igbinary-devel}"
SRC_URI[aarch64_php-pecl-igbinary-devel.sha256sum] = "ba549298dd1f9010a65cef104e95386a43c6f628efa11978ae7ae8b78dadcd85"

RDEPENDS:php-pecl-igbinary = " \
 glibc \
 php-common \
 "
RDEPENDS:php-pecl-igbinary-devel = " \
 php-devel \
 php-pecl-igbinary \
 "
