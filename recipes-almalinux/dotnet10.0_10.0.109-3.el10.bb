# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet10.0"
PV = "10.0.109"
PR = "3.el10"
PACKAGES = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-runtime-dbg-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-host \
 dotnet-hostfxr-10.0 \
 dotnet-runtime-10.0 \
 dotnet-runtime-dbg-10.0 \
 dotnet-sdk-10.0 \
 dotnet-sdk-10.0-source-built-artifacts \
 dotnet-sdk-aot-10.0 \
 dotnet-sdk-dbg-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet10.0-10.0.109-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0ccddfd16faab467b8fa4e8122e919d9205f6d64cbec90d4975b48254c70121"

URI_x86_64_v2_aspnetcore-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-10.0-10.0.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-10.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-10.0.sha256sum] = "f82190a1a9e05ec4a05fb742b760a7c810c0724991fb225c5658e50102779236"

URI_x86_64_v2_aspnetcore-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-runtime-dbg-10.0}"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-10.0.sha256sum] = "bd53bdd2eb93b10fca037068032241dad8c895bb1a3bfab993586d6d07021ff7"

URI_x86_64_v2_aspnetcore-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-10.0-10.0.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aspnetcore-targeting-pack-10.0}"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-10.0.sha256sum] = "c2f8ad1ece17400acb65070c761e1a5361eed305672957f54e616f102016bbbd"

URI_x86_64_v2_dotnet-apphost-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-10.0-10.0.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-apphost-pack-10.0}"
SRC_URI[x86_64_v2_dotnet-apphost-pack-10.0.sha256sum] = "f719982285b67522673e2237893dc10e9e16048222adc2e59843531edd3fc077"

URI_x86_64_v2_dotnet-host = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-host-10.0.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-host;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-host}"
SRC_URI[x86_64_v2_dotnet-host.sha256sum] = "7409358d07fc7174e34e964da2544354ce90468ca6765bd85f3a5ee4c53c4429"

URI_x86_64_v2_dotnet-hostfxr-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-10.0-10.0.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-hostfxr-10.0}"
SRC_URI[x86_64_v2_dotnet-hostfxr-10.0.sha256sum] = "423553b1178ad9d035a88f248d49503e4a1fe97b835ef1aa84a0aefcf0d3f0d6"

URI_x86_64_v2_dotnet-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-10.0-10.0.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-10.0}"
SRC_URI[x86_64_v2_dotnet-runtime-10.0.sha256sum] = "5521ba55817782c9efd558637df3f02debe8b50004f98e9cd9fd9b8b35e14d55"

URI_x86_64_v2_dotnet-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-10.0-10.0.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-runtime-dbg-10.0}"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-10.0.sha256sum] = "e70fe31271a94a37ece910006ab32d0ea01e147c6c7bee8ab829c0863a547acb"

URI_x86_64_v2_dotnet-sdk-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-10.0-10.0.109-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-10.0}"
SRC_URI[x86_64_v2_dotnet-sdk-10.0.sha256sum] = "f6e13cc94ce084cc83eb3b9b7fb913cfb75be0cf73b2a19ac49ba0b973a28386"

URI_x86_64_v2_dotnet-sdk-10.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.109-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-10.0-source-built-artifacts}"
SRC_URI[x86_64_v2_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "7e9f6f09d20552b9fb3a550d412c09a736cd1ec161ec79343dd1bb5f83079505"

URI_x86_64_v2_dotnet-sdk-aot-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-10.0-10.0.109-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-aot-10.0}"
SRC_URI[x86_64_v2_dotnet-sdk-aot-10.0.sha256sum] = "4b09d79722f90bb7fccc0b04c98979509a78d2f9fc0ba1dd4bf2d6f8a806f5f5"

URI_x86_64_v2_dotnet-sdk-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-10.0-10.0.109-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-sdk-dbg-10.0}"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-10.0.sha256sum] = "099e207c6c9265410eae40c5e7aa956775024b5a6079897efe9504ad67afc293"

URI_x86_64_v2_dotnet-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-10.0-10.0.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-targeting-pack-10.0}"
SRC_URI[x86_64_v2_dotnet-targeting-pack-10.0.sha256sum] = "2084a6472807e49c4df363594fd28b4050265b5667fe1824cc6c7d31c816a263"

URI_x86_64_v2_dotnet-templates-10.0 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-10.0-10.0.109-3.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-10.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dotnet-templates-10.0}"
SRC_URI[x86_64_v2_dotnet-templates-10.0.sha256sum] = "363998e0a06b7aabb10c094fe9df04160fcec464d760724bc60f98e909aaac09"

URI_aarch64_aspnetcore-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-10.0-10.0.9-3.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-10.0}"
SRC_URI[aarch64_aspnetcore-runtime-10.0.sha256sum] = "652c8ea217237f32949cc3ece6235d573074545864cead4aee857e09eade479b"

URI_aarch64_aspnetcore-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-10.0-10.0.9-3.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-runtime-dbg-10.0}"
SRC_URI[aarch64_aspnetcore-runtime-dbg-10.0.sha256sum] = "e3195fd35bdd54bfd9cc22ba875975bae54543471e58b210b81b1c91b9d63b8b"

URI_aarch64_aspnetcore-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-10.0-10.0.9-3.el10.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_aspnetcore-targeting-pack-10.0}"
SRC_URI[aarch64_aspnetcore-targeting-pack-10.0.sha256sum] = "e685884f79e2edc77d75a461f1bb83f5849318d00fcfbf07caf21596b5ae79a2"

URI_aarch64_dotnet-apphost-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-10.0-10.0.9-3.el10.aarch64.rpm;name=aarch64_dotnet-apphost-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-apphost-pack-10.0}"
SRC_URI[aarch64_dotnet-apphost-pack-10.0.sha256sum] = "6922ac6ac5c37ba8db3121c7a19cba182827c5f3eb76eac97dd05038e5bd1b48"

URI_aarch64_dotnet-host = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-host-10.0.9-3.el10.aarch64.rpm;name=aarch64_dotnet-host;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-host}"
SRC_URI[aarch64_dotnet-host.sha256sum] = "c6bd1d46ec5888326432d5845fa2805dc2d966c2ff483b3331fa2b58e8c33b17"

URI_aarch64_dotnet-hostfxr-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-10.0-10.0.9-3.el10.aarch64.rpm;name=aarch64_dotnet-hostfxr-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-hostfxr-10.0}"
SRC_URI[aarch64_dotnet-hostfxr-10.0.sha256sum] = "2befa0d5cd4e7b4d7594feeeeadf309f7513d435ce5799e56d46bef32a93d131"

URI_aarch64_dotnet-runtime-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-10.0-10.0.9-3.el10.aarch64.rpm;name=aarch64_dotnet-runtime-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-10.0}"
SRC_URI[aarch64_dotnet-runtime-10.0.sha256sum] = "606e2c32c9398f437685fe375dc4dd3e8cd21d1502152819aa73308763597388"

URI_aarch64_dotnet-runtime-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-10.0-10.0.9-3.el10.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-runtime-dbg-10.0}"
SRC_URI[aarch64_dotnet-runtime-dbg-10.0.sha256sum] = "431d3776b3013c5e302611d62b0c8d5c4f249e45ae9285a1c98d2aea42366f24"

URI_aarch64_dotnet-sdk-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-10.0-10.0.109-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-10.0}"
SRC_URI[aarch64_dotnet-sdk-10.0.sha256sum] = "73807ac1c56d66d5f01ef74bee2c7d76a8cb77fa3c27738a44eb4475b6db5b92"

URI_aarch64_dotnet-sdk-10.0-source-built-artifacts = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-10.0-source-built-artifacts-10.0.109-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-10.0-source-built-artifacts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-10.0-source-built-artifacts}"
SRC_URI[aarch64_dotnet-sdk-10.0-source-built-artifacts.sha256sum] = "014befaf33ed861137d9f16b5e7e12d6a18d414d0480f381e83e8067317a5845"

URI_aarch64_dotnet-sdk-aot-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-10.0-10.0.109-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-aot-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-aot-10.0}"
SRC_URI[aarch64_dotnet-sdk-aot-10.0.sha256sum] = "67f4f2e90824f226093fe4dccf76d1af5c8fa1a028e1114a989f60e5562a6f09"

URI_aarch64_dotnet-sdk-dbg-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-10.0-10.0.109-3.el10.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-sdk-dbg-10.0}"
SRC_URI[aarch64_dotnet-sdk-dbg-10.0.sha256sum] = "1f3ce3bc071e746d0bc0cf58e7e98cd30a9dc8e395b2b5171c8b68b766d4a711"

URI_aarch64_dotnet-targeting-pack-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-10.0-10.0.9-3.el10.aarch64.rpm;name=aarch64_dotnet-targeting-pack-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-targeting-pack-10.0}"
SRC_URI[aarch64_dotnet-targeting-pack-10.0.sha256sum] = "bac1bff0a082ef3dfa83e667c936d94f9fba0f6d07faf6e65008f0ed186ecbf7"

URI_aarch64_dotnet-templates-10.0 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-10.0-10.0.109-3.el10.aarch64.rpm;name=aarch64_dotnet-templates-10.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_dotnet-templates-10.0}"
SRC_URI[aarch64_dotnet-templates-10.0.sha256sum] = "1b3ecfe59c369008fdd2abf6624e80677df8a0512695d09c4eb49126fce8fc50"

RDEPENDS:aspnetcore-runtime-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-10.0 = " \
 aspnetcore-runtime-10.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-10.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-host = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-hostfxr-10.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-10.0 = " \
 dotnet-hostfxr-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-10.0 = " \
 dotnet-runtime-10.0 \
 "
RDEPENDS:dotnet-sdk-10.0 = " \
 aspnetcore-runtime-10.0 \
 aspnetcore-targeting-pack-10.0 \
 dotnet-apphost-pack-10.0 \
 dotnet-runtime-10.0 \
 dotnet-targeting-pack-10.0 \
 dotnet-templates-10.0 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-sdk-10.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-10.0 = " \
 brotli-devel \
 clang \
 dotnet-sdk-10.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-10.0 = " \
 dotnet-sdk-10.0 \
 "
RDEPENDS:dotnet-targeting-pack-10.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-10.0 = " \
 dotnet-host \
 "
