# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtbase"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtbase \
 qt5-qtbase-common \
 qt5-qtbase-devel \
 qt5-qtbase-examples \
 qt5-qtbase-gui \
 qt5-qtbase-mysql \
 qt5-qtbase-odbc \
 qt5-qtbase-postgresql \
 qt5-qtbase-private-devel \
 qt5-qtbase-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtbase-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bdfd11ddfd4811cdb5f2d83014af2510aa8cf9db1f9f8f4f91b9d64ebe37cfdc"

URI_x86_64_v2_qt5-qtbase = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase}"
SRC_URI[x86_64_v2_qt5-qtbase.sha256sum] = "3b7c7638c64ccee341010cd4c5c144896a12a91b59740d8fd88ababd869aec5e"

URI_x86_64_v2_qt5-qtbase-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-common-5.15.17-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-common}"
SRC_URI[x86_64_v2_qt5-qtbase-common.sha256sum] = "e29519417c56d89c0c7bac08e0097a7faec8e283b59c707f46368a4a8aaa8fc6"

URI_x86_64_v2_qt5-qtbase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-devel}"
SRC_URI[x86_64_v2_qt5-qtbase-devel.sha256sum] = "2f9b4efe6697ae0c6bae1b276115cd9e32bf6b2041208483657235ee78efd09e"

URI_x86_64_v2_qt5-qtbase-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-examples}"
SRC_URI[x86_64_v2_qt5-qtbase-examples.sha256sum] = "2bc6734a8cc769ac31ee18e31d9b1fd8e8c7c51f15bc7e3c7927be272eb56701"

URI_x86_64_v2_qt5-qtbase-gui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-gui-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-gui}"
SRC_URI[x86_64_v2_qt5-qtbase-gui.sha256sum] = "bbf9ee8de7a4123f3308838c98f9646eb499903d898afcb4ab75638ac6992dc1"

URI_x86_64_v2_qt5-qtbase-mysql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-mysql-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-mysql}"
SRC_URI[x86_64_v2_qt5-qtbase-mysql.sha256sum] = "099e1da07c4903dec65dd4e17f3b4e6e130955848dad0e308bff7ae62c045f9c"

URI_x86_64_v2_qt5-qtbase-odbc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-odbc-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-odbc}"
SRC_URI[x86_64_v2_qt5-qtbase-odbc.sha256sum] = "791c93e7217452130804600a5b706ed3aa51877124c4112272e7983709cce628"

URI_x86_64_v2_qt5-qtbase-postgresql = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-postgresql-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-postgresql}"
SRC_URI[x86_64_v2_qt5-qtbase-postgresql.sha256sum] = "692d564da089f23052cd39dfe81fbdb2694ab8d2c7ec9decb6f709f42718d218"

URI_x86_64_v2_qt5-qtbase-private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-private-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-private-devel}"
SRC_URI[x86_64_v2_qt5-qtbase-private-devel.sha256sum] = "29e0e0c02f6c6c4961a69dc1e5609ea64f2760adab0403c75979dcb5ca58c31b"

URI_x86_64_v2_qt5-qtbase-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtbase-static-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtbase-static}"
SRC_URI[x86_64_v2_qt5-qtbase-static.sha256sum] = "dd24126abadeae66d1b085cd7d8f3e5a743e1672cf0798490f5f0cb3aacadf0e"

URI_aarch64_qt5-qtbase = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtbase;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase}"
SRC_URI[aarch64_qt5-qtbase.sha256sum] = "dd577894d3b0cd6f1192a61d0abd0249bb3f6f620a1caa509acad8c57060d438"

URI_aarch64_qt5-qtbase-common = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-common-5.15.17-1.el10_1.noarch.rpm;name=aarch64_qt5-qtbase-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-common}"
SRC_URI[aarch64_qt5-qtbase-common.sha256sum] = "34747181244b887e1a550d4aeb193df59d071aa634ac1c275cae257d88e8bc99"

URI_aarch64_qt5-qtbase-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtbase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-devel}"
SRC_URI[aarch64_qt5-qtbase-devel.sha256sum] = "e6051084c20f9fdbc2760a51c9333a2fece03f5695d443e8f552076778fd812b"

URI_aarch64_qt5-qtbase-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtbase-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-examples}"
SRC_URI[aarch64_qt5-qtbase-examples.sha256sum] = "aa422ae90aaa215c0b03b9024e21a5b87955079fe5deb091a29a4797c750ede6"

URI_aarch64_qt5-qtbase-gui = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-gui-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtbase-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-gui}"
SRC_URI[aarch64_qt5-qtbase-gui.sha256sum] = "c2fb0016f01d0d602b658b5b7e28a54ebb9d6684d334f679891879ccd8fdee4f"

URI_aarch64_qt5-qtbase-mysql = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-mysql-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtbase-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-mysql}"
SRC_URI[aarch64_qt5-qtbase-mysql.sha256sum] = "18cedc842be89aed6b2a511400b6789465117ea592499f534e0bd707ee984a94"

URI_aarch64_qt5-qtbase-odbc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-odbc-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtbase-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-odbc}"
SRC_URI[aarch64_qt5-qtbase-odbc.sha256sum] = "bfc5802acab0fd3fdd44f355fef226461c27b7f7aef8a41b1774075cc98543d3"

URI_aarch64_qt5-qtbase-postgresql = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-postgresql-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtbase-postgresql;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-postgresql}"
SRC_URI[aarch64_qt5-qtbase-postgresql.sha256sum] = "125aa72e033c3967c00eb65110debc13e7679d8f1b452fa3676e105f43cc160a"

URI_aarch64_qt5-qtbase-private-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-private-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtbase-private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-private-devel}"
SRC_URI[aarch64_qt5-qtbase-private-devel.sha256sum] = "322b838a05be2ad9e5d0e351ad3ab484134f51269450e560673824e3c754396b"

URI_aarch64_qt5-qtbase-static = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtbase-static-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtbase-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtbase-static}"
SRC_URI[aarch64_qt5-qtbase-static.sha256sum] = "8faaaf9d3909e96d5f948da14f137f78691c3108bcad0424fae7192a65976adb"

RDEPENDS:qt5-qtbase = " \
 alternatives \
 bash \
 dbus-libs \
 double-conversion \
 glib2 \
 glibc \
 krb5-libs \
 libgcc \
 libicu \
 libproxy \
 libstdc++ \
 libzstd \
 openssl-libs \
 pcre2-utf16 \
 qt5-filesystem \
 qt5-qtbase-common \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtbase-common = " \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtbase-devel = " \
 bash \
 cmake-filesystem \
 glibc \
 libgcc \
 libglvnd-devel \
 libstdc++ \
 libzstd \
 perl-English \
 perl-File-Basename \
 perl-File-Find \
 perl-File-Path \
 perl-Getopt-Long \
 perl-IO \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 python3 \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtbase-gui \
 qt5-rpm-macros \
 vulkan-loader-devel \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtbase-examples = " \
 glibc \
 libglvnd-glx \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:qt5-qtbase-gui = " \
 bash \
 cups-libs \
 fontconfig \
 freetype \
 glib2 \
 glibc \
 glx-utils \
 harfbuzz \
 libICE \
 libSM \
 libX11 \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libglvnd-glx \
 libinput \
 libjpeg-turbo \
 libpng \
 libstdc++ \
 libxcb \
 libxkbcommon \
 libxkbcommon-x11 \
 mesa-libgbm \
 qt5-qtbase \
 systemd-libs \
 xcb-util-image \
 xcb-util-keysyms \
 xcb-util-renderutil \
 xcb-util-wm \
 zlib-ng-compat \
 "
RDEPENDS:qt5-qtbase-mysql = " \
 glibc \
 libstdc++ \
 mariadb-connector-c \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtbase-odbc = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 unixODBC \
 "
RDEPENDS:qt5-qtbase-postgresql = " \
 glibc \
 libpq \
 libstdc++ \
 qt5-qtbase \
 "
RDEPENDS:qt5-qtbase-private-devel = " \
 cups-devel \
 qt5-qtbase-devel \
 "
RDEPENDS:qt5-qtbase-static = " \
 cmake-filesystem \
 fontconfig-devel \
 glib2-devel \
 libinput-devel \
 libxkbcommon-devel \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 zlib-ng-compat-devel \
 "
