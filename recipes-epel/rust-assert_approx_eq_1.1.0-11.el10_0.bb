# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-assert_approx_eq"
PV = "1.1.0"
PR = "11.el10_0"
PACKAGES = " \
 rust-assert_approx_eq+default-devel \
 rust-assert_approx_eq-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-assert_approx_eq-1.1.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06918814c32b4ab843ce6a3b8921c48751b6ed5dd924dbdc75e6d0399707cb4c"

URI_x86_64_v2_rust-assert_approx_eq+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_approx_eq+default-devel-1.1.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_approx_eq+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_approx_eq+default-devel}"
SRC_URI[x86_64_v2_rust-assert_approx_eq+default-devel.sha256sum] = "eb83535c85d87c4b0382f82bf81e99aa4e23dd48bcc17a76162cc099a6d5953b"

URI_x86_64_v2_rust-assert_approx_eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-assert_approx_eq-devel-1.1.0-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-assert_approx_eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-assert_approx_eq-devel}"
SRC_URI[x86_64_v2_rust-assert_approx_eq-devel.sha256sum] = "99b423f5c0b080b153113e8d8387ae0a977734f991c46b570384164ba7aae557"

URI_aarch64_rust-assert_approx_eq+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_approx_eq+default-devel-1.1.0-11.el10_0.noarch.rpm;name=aarch64_rust-assert_approx_eq+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_approx_eq+default-devel}"
SRC_URI[aarch64_rust-assert_approx_eq+default-devel.sha256sum] = "58398e3aaf99a9d18e63e3c877f3507d1c17f2f0d71c50154e534f843e8c8e85"

URI_aarch64_rust-assert_approx_eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-assert_approx_eq-devel-1.1.0-11.el10_0.noarch.rpm;name=aarch64_rust-assert_approx_eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-assert_approx_eq-devel}"
SRC_URI[aarch64_rust-assert_approx_eq-devel.sha256sum] = "0ad3251ae2f4df3cae90169e4bc6055798495e741aacea6aef30704949b77320"

RDEPENDS:rust-assert_approx_eq+default-devel = " \
 cargo \
 rust-assert_approx_eq-devel \
 "
RDEPENDS:rust-assert_approx_eq-devel = " \
 cargo \
 "
