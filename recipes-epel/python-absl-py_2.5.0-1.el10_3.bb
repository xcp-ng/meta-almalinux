# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-absl-py"
PV = "2.5.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-absl-py \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-absl-py-2.5.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "360ebefa6ae2d5e3913c1f282b773d63c65daa2bb5d3fa59e43c98bea3868500"

URI_x86_64_v2_python3-absl-py = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-absl-py-2.5.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-absl-py;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-absl-py}"
SRC_URI[x86_64_v2_python3-absl-py.sha256sum] = "26c386c84d2d072ed9a5dd6e4693d7188d03d70557298167897fa5bd8860b401"

URI_aarch64_python3-absl-py = "${EPEL_MIRROR}/aarch64/Packages/p/python3-absl-py-2.5.0-1.el10_3.noarch.rpm;name=aarch64_python3-absl-py;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-absl-py}"
SRC_URI[aarch64_python3-absl-py.sha256sum] = "de66c09a7a310e7a30408b76c3d30a0af0c03582307ac10bfc81cef746607ed0"

RDEPENDS:python3-absl-py = " \
 python3 \
 "
