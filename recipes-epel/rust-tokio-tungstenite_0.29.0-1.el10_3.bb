# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-tungstenite"
PV = "0.29.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+connect-devel \
 rust-tokio-tungstenite+default-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+native-tls-crate-devel \
 rust-tokio-tungstenite+native-tls-devel \
 rust-tokio-tungstenite+rustls-devel \
 rust-tokio-tungstenite+rustls-native-certs-devel \
 rust-tokio-tungstenite+rustls-pki-types-devel \
 rust-tokio-tungstenite+rustls-tls-native-roots-devel \
 rust-tokio-tungstenite+rustls-tls-webpki-roots-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-native-tls-devel \
 rust-tokio-tungstenite+tokio-rustls-devel \
 rust-tokio-tungstenite+url-devel \
 rust-tokio-tungstenite+webpki-roots-devel \
 rust-tokio-tungstenite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-tungstenite-0.29.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "24f8ebb6d2e9f271eaa765a2b66c2e17543debaf528b5486d838dd9e14214955"

URI_x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+__rustls-tls-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel.sha256sum] = "79287cb8e489d40338fda35ad8fd462ff72886874929abfa655213303d23f321"

URI_x86_64_v2_rust-tokio-tungstenite+connect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+connect-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+connect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+connect-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+connect-devel.sha256sum] = "33e3a0f19d8de915e7572271dc70a89f2b807f107f2b1a5f94269c4eddac0682"

URI_x86_64_v2_rust-tokio-tungstenite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+default-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+default-devel.sha256sum] = "5507b88ef0c2fba6f8ffd987b3b454f38497c5ac8fef9dd613fdac34b8d039ee"

URI_x86_64_v2_rust-tokio-tungstenite+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+handshake-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+handshake-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+handshake-devel.sha256sum] = "662c25de506f35e1b6572349fb56d0df4089c8e06f14be51c34db7c8a11c9a69"

URI_x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+native-tls-crate-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel.sha256sum] = "19979c9af15c9c2ad87b437dbdeed742d871f043bd64f943b757379b7c84af39"

URI_x86_64_v2_rust-tokio-tungstenite+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+native-tls-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+native-tls-devel.sha256sum] = "cceb5823fc997bfd979019774db6e0b542c098d95c95cc31593dd4aa202540c9"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-devel.sha256sum] = "09e7300ad3f0ecc7ebb9e2633e529fcfa07b4d4f796d032e50ea64dc4b795fc3"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-native-certs-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel.sha256sum] = "d85423c7fbf7f07abc6d2e18e363365eb1467f99eb8c03d949135bfad602a9d1"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-pki-types-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel.sha256sum] = "acc52eb821b3cf67c2e78f7661fe6f00259cf927059bf39ab6f01280b3a962ec"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-tls-native-roots-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "5c3a13b8389e7b9c7205c12227701f4951b2fed750e9a982de589bdabcce7fe1"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-tls-webpki-roots-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "4267d194c7e081b75dfc052193ab99a6d23a6d2bcf355600efd1105f2b0b6b47"

URI_x86_64_v2_rust-tokio-tungstenite+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+stream-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+stream-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+stream-devel.sha256sum] = "bd0087289d7a2a710138c3ca7dbeee744ce2eb7dc3ca15954c6c4be192dfc8de"

URI_x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+tokio-native-tls-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel.sha256sum] = "e6d660b81fb3a8dfb6d3b7c87f7f60520be5fe98c508456fdd8d2976245dbbc1"

URI_x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+tokio-rustls-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel.sha256sum] = "87b1c7eb95ef349d14e140dd70ca244e90f262ecfd5b7a811538ad1ee226b618"

URI_x86_64_v2_rust-tokio-tungstenite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+url-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+url-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+url-devel.sha256sum] = "9df9c72e50036631a1ad3fdf67b012d38d250157c7d71d3aefbd0fcc8505e5ec"

URI_x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+webpki-roots-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel.sha256sum] = "1cebf61a79044c46af9768e5bde3a9e1599dee310695f17bcb761ebe408056f3"

URI_x86_64_v2_rust-tokio-tungstenite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite-devel-0.29.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite-devel.sha256sum] = "a16fe9d74860e12600f2be81c797da2faf2f321dfbfc477a934880358b7e1eb5"

URI_aarch64_rust-tokio-tungstenite+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+__rustls-tls-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+__rustls-tls-devel.sha256sum] = "401a23f453ebde7b65fc9fab2e0690954ae38c9dc6615247e51aeef34b636dff"

URI_aarch64_rust-tokio-tungstenite+connect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+connect-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+connect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+connect-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+connect-devel.sha256sum] = "5609c4ea7756cb275fd6961c1138d091e7308fd982a675c94fb9ce279c31c95e"

URI_aarch64_rust-tokio-tungstenite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+default-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+default-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+default-devel.sha256sum] = "c39c646dd43028de49955bccac67721b5dafe266a4623ad034fc19486bd1164a"

URI_aarch64_rust-tokio-tungstenite+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+handshake-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+handshake-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+handshake-devel.sha256sum] = "421c0eebd98a9fb7f06b7c807ddc898fd155244d47650246866239be88072094"

URI_aarch64_rust-tokio-tungstenite+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+native-tls-crate-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+native-tls-crate-devel.sha256sum] = "8e69df3eed4b12ad4af82349891f68264c8dfcac116e00d5f6af610c07ff3999"

URI_aarch64_rust-tokio-tungstenite+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+native-tls-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+native-tls-devel.sha256sum] = "a0493067d9ae83c6143a9ce2a95773b73a6b69a9b500e7f33451daefeee52737"

URI_aarch64_rust-tokio-tungstenite+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-devel.sha256sum] = "455bd9d2c93b416a4e7a6750f302f829cb6e6c60d03deeb314eb78445b783dbc"

URI_aarch64_rust-tokio-tungstenite+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-native-certs-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-native-certs-devel.sha256sum] = "0ffc76ab88352a4e7896a7955ff468a6810ca9dd15c08e3694eca9ab440fa0c2"

URI_aarch64_rust-tokio-tungstenite+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-pki-types-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-pki-types-devel.sha256sum] = "745e347e7fd7838e7b615f585888d1154af9f80dfa77fedcf2acee13702a48cc"

URI_aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-tls-native-roots-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "56a3b6d7b11090378deaf3b7b19a9865793d3af1d0d35abfd84d828a20bdf328"

URI_aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-tls-webpki-roots-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "93aa9f972c0dc9096e1c19a14bbd8f42734cc03e7214c85ddfebad2c0816204f"

URI_aarch64_rust-tokio-tungstenite+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+stream-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+stream-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+stream-devel.sha256sum] = "e6b96f37fee06b3f462c02c8d9cfc81d3ac3c196bc425ce99bfc39cdb9a14385"

URI_aarch64_rust-tokio-tungstenite+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+tokio-native-tls-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+tokio-native-tls-devel.sha256sum] = "37e169449368b703eca6c27aff62898368373b404b294918eeab0203d0a50e8e"

URI_aarch64_rust-tokio-tungstenite+tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+tokio-rustls-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+tokio-rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+tokio-rustls-devel.sha256sum] = "f5b4a2bed34d33f77ae3b30e44b2cdeaf5e8a274eb81f7fa4f77d3123b3b959f"

URI_aarch64_rust-tokio-tungstenite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+url-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+url-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+url-devel.sha256sum] = "d56f4927af1f64f6e7f7bba15c72bc747484f99f6d300957d09e2ce1f1d963c2"

URI_aarch64_rust-tokio-tungstenite+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+webpki-roots-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+webpki-roots-devel.sha256sum] = "1444d91eb1cf3917a4ef3647b61a64d46250caf387fd42da4a52de7c124d3313"

URI_aarch64_rust-tokio-tungstenite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite-devel-0.29.0-1.el10_3.noarch.rpm;name=aarch64_rust-tokio-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite-devel.sha256sum] = "16661cbc57277fcd31bb10892e36498c40b73a245f85d6103072f604557ec848"

RDEPENDS:rust-tokio-tungstenite+__rustls-tls-devel = " \
 cargo \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+rustls-devel \
 rust-tokio-tungstenite+rustls-pki-types-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-rustls-devel \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+__rustls-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite+connect-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+default-devel = " \
 cargo \
 rust-tokio-tungstenite+connect-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+handshake-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+handshake-devel \
 "
RDEPENDS:rust-tokio-tungstenite+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+native-tls-devel = " \
 cargo \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+native-tls-crate-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-native-tls-devel \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+native-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-devel = " \
 cargo \
 rust-rustls-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+rustls-native-certs-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+webpki-roots-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+stream-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+tokio-native-tls-devel = " \
 cargo \
 rust-tokio-native-tls+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+tokio-rustls-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+url-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+url-devel \
 "
RDEPENDS:rust-tokio-tungstenite+webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-webpki-roots0.26+default-devel \
 "
RDEPENDS:rust-tokio-tungstenite-devel = " \
 cargo \
 rust \
 rust-futures-util+sink-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-log+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 rust-tungstenite-devel \
 "
