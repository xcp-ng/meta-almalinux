# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-predicates-tree"
PV = "1.0.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-predicates-tree+default-devel \
 rust-predicates-tree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-predicates-tree-1.0.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cd626229e1d9461c84dcbf8d5d10328ae275c4cea42931c9426814575b665ebe"

URI_x86_64_v2_rust-predicates-tree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-tree+default-devel-1.0.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-tree+default-devel}"
SRC_URI[x86_64_v2_rust-predicates-tree+default-devel.sha256sum] = "11c28ceb2e3f620f3fcde7db1e818b22b926453bbac26baa0f6717b4f27bc632"

URI_x86_64_v2_rust-predicates-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-predicates-tree-devel-1.0.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-predicates-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-predicates-tree-devel}"
SRC_URI[x86_64_v2_rust-predicates-tree-devel.sha256sum] = "4ad8e719853d6dcd775216c72f8db09e3ba7dedeae4b5d2b51f52fcc18c95052"

URI_aarch64_rust-predicates-tree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-tree+default-devel-1.0.13-1.el10_2.noarch.rpm;name=aarch64_rust-predicates-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-tree+default-devel}"
SRC_URI[aarch64_rust-predicates-tree+default-devel.sha256sum] = "6eb724ce1693a4867b8243946c7f1fc30d0f38421ccd47b8ae3f838f1a287c2b"

URI_aarch64_rust-predicates-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-predicates-tree-devel-1.0.13-1.el10_2.noarch.rpm;name=aarch64_rust-predicates-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-predicates-tree-devel}"
SRC_URI[aarch64_rust-predicates-tree-devel.sha256sum] = "7b11ba2aa6bf444f9979a0bca67734622a9259d8b4138fcd4155e33b2bc01861"

RDEPENDS:rust-predicates-tree+default-devel = " \
 cargo \
 rust-predicates-tree-devel \
 "
RDEPENDS:rust-predicates-tree-devel = " \
 cargo \
 rust \
 rust-predicates-core+default-devel \
 rust-termtree0.5+default-devel \
 "
