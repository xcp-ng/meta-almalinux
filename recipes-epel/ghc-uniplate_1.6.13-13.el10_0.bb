# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-uniplate"
PV = "1.6.13"
PR = "13.el10_0"
PACKAGES = " \
 ghc-uniplate \
 ghc-uniplate-devel \
 ghc-uniplate-doc \
 ghc-uniplate-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-uniplate-1.6.13-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57ff9cc59e1cc99d717da00d25b25e05bdc418a06359142f6366986050806f8c"

URI_x86_64_v2_ghc-uniplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uniplate-1.6.13-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uniplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uniplate}"
SRC_URI[x86_64_v2_ghc-uniplate.sha256sum] = "2b2aec660e628c7e123bc56c8cc638fdb56b53ab696dcdcec057f12580023267"

URI_x86_64_v2_ghc-uniplate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uniplate-devel-1.6.13-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uniplate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uniplate-devel}"
SRC_URI[x86_64_v2_ghc-uniplate-devel.sha256sum] = "a7ba1c3e7f7b4b09e007e265be272ab04fd2d8c2dbc4841b345cb3f291fe2cac"

URI_x86_64_v2_ghc-uniplate-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uniplate-doc-1.6.13-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-uniplate-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uniplate-doc}"
SRC_URI[x86_64_v2_ghc-uniplate-doc.sha256sum] = "86bcfdb687c3b5a7e244853fe601ca3cf3a439993d71bd51de89e8eae2e6d20c"

URI_x86_64_v2_ghc-uniplate-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-uniplate-prof-1.6.13-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-uniplate-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-uniplate-prof}"
SRC_URI[x86_64_v2_ghc-uniplate-prof.sha256sum] = "d6f9a06d5385730d28a80d0ae129c4ea980baf8df9a9c95016856c097b3b6c87"

URI_aarch64_ghc-uniplate = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uniplate-1.6.13-13.el10_0.aarch64.rpm;name=aarch64_ghc-uniplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uniplate}"
SRC_URI[aarch64_ghc-uniplate.sha256sum] = "cd27b48c55d880344a28382a85329a847ebc62ce7001a241e6ee984df8852d99"

URI_aarch64_ghc-uniplate-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uniplate-devel-1.6.13-13.el10_0.aarch64.rpm;name=aarch64_ghc-uniplate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uniplate-devel}"
SRC_URI[aarch64_ghc-uniplate-devel.sha256sum] = "72064fed6d2874dd5a3d73cdc2c2ebc5ba5103d7717600a448b14f9bbc2427a7"

URI_aarch64_ghc-uniplate-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uniplate-doc-1.6.13-13.el10_0.noarch.rpm;name=aarch64_ghc-uniplate-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uniplate-doc}"
SRC_URI[aarch64_ghc-uniplate-doc.sha256sum] = "da52283f978d18a5d7d17134e963aea770f49b3a253e89fc10b20d3967dd68f7"

URI_aarch64_ghc-uniplate-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-uniplate-prof-1.6.13-13.el10_0.aarch64.rpm;name=aarch64_ghc-uniplate-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-uniplate-prof}"
SRC_URI[aarch64_ghc-uniplate-prof.sha256sum] = "284ea0bbf1bc33026147ab9e51f07e0799fb2e2a2e72a77c0e92a630caa78338"

RDEPENDS:ghc-uniplate = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-syb \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unordered-containers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-uniplate-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-hashable-devel \
 ghc-syb-devel \
 ghc-uniplate \
 ghc-unordered-containers-devel \
 "
RDEPENDS:ghc-uniplate-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-uniplate-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-hashable-prof \
 ghc-syb-prof \
 ghc-uniplate-devel \
 ghc-unordered-containers-prof \
 "
