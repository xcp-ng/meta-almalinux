# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtgrpc"
PV = "6.10.1"
PR = "1.el10_2"
PACKAGES = " \
 qt6-qtgrpc \
 qt6-qtgrpc-devel \
 qt6-qtgrpc-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtgrpc-6.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6737f977bdc58f70df669d2e05715146f2e4562d276adfdd7c36e1077db4123"

URI_x86_64_v2_qt6-qtgrpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgrpc-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgrpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgrpc}"
SRC_URI[x86_64_v2_qt6-qtgrpc.sha256sum] = "f8303798b119f56fe2ce22a576aa606f3f6bcbb17cfe98e6281f2e5408c4ecb3"

URI_x86_64_v2_qt6-qtgrpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgrpc-devel-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgrpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgrpc-devel}"
SRC_URI[x86_64_v2_qt6-qtgrpc-devel.sha256sum] = "83a75c5c18864db71837af87a6bbcb533488ccb060ac8f945c8e0512df92a407"

URI_x86_64_v2_qt6-qtgrpc-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtgrpc-examples-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtgrpc-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtgrpc-examples}"
SRC_URI[x86_64_v2_qt6-qtgrpc-examples.sha256sum] = "6742bf17d1f212784f707ea7a8b95904f84f39ee1520eef8b1b8cd8af5476e51"

URI_aarch64_qt6-qtgrpc = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgrpc-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtgrpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgrpc}"
SRC_URI[aarch64_qt6-qtgrpc.sha256sum] = "4ca8ed703b88a295e1c28ee2889f8fdfce2989f5001ecc12638a0c6bdf9afd01"

URI_aarch64_qt6-qtgrpc-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgrpc-devel-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtgrpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgrpc-devel}"
SRC_URI[aarch64_qt6-qtgrpc-devel.sha256sum] = "52f471d2cc5914b292ffbd3d4fc3589aa5468c96f2232abe8da4c8244f484534"

URI_aarch64_qt6-qtgrpc-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtgrpc-examples-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtgrpc-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtgrpc-examples}"
SRC_URI[aarch64_qt6-qtgrpc-examples.sha256sum] = "6d385df580bd52ee786f83f25e99b2bad431ec117b45592346fe06babc35ac4d"

RDEPENDS:qt6-qtgrpc = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtgrpc-devel = " \
 cmake-filesystem \
 glibc \
 grpc-devel \
 libgcc \
 libstdc++ \
 pkgconf-pkg-config \
 protobuf \
 protobuf-compiler \
 protobuf-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtgrpc \
 qt6-qtgrpc-devel \
 "
RDEPENDS:qt6-qtgrpc-examples = " \
 abseil-cpp \
 bash \
 glibc \
 grpc \
 grpc-cpp \
 libgcc \
 libstdc++ \
 protobuf \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtgrpc \
 "
