# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sort-Key"
PV = "1.33"
PR = "32.el10_0"
PACKAGES = " \
 perl-Sort-Key \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Sort-Key-1.33-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "878b90a158b6c65440b69598e85d976d67d56a00b2892cb39aad6a58e621a5a5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sort-Key-1.33-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sort-Key;unpack=0"
SRC_URI[x86_64_v2_perl-Sort-Key.sha256sum] = "09d314d7a04e44d15a64949b576285c4cd23b7f94c994a6308e17d4d274fd984"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Sort-Key-1.33-32.el10_0.aarch64.rpm;name=aarch64_perl-Sort-Key;unpack=0"
SRC_URI[aarch64_perl-Sort-Key.sha256sum] = "4746405a6588047b4020536bc998c7269ebf85997f44bbf63e626069843391ec"

RDEPENDS:perl-Sort-Key = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Sort-Key \
 perl-constant \
 perl-libs \
 perl-locale \
 "
