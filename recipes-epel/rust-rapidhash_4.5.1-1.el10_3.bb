# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rapidhash"
PV = "4.5.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-rapidhash+default-devel \
 rust-rapidhash+getrandom_03-devel \
 rust-rapidhash+getrandom_04-devel \
 rust-rapidhash+nightly-devel \
 rust-rapidhash+rand-devel \
 rust-rapidhash+rng-devel \
 rust-rapidhash+std-devel \
 rust-rapidhash+unsafe-devel \
 rust-rapidhash-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rapidhash-4.5.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4acecc41fe268c14a9be3c38fddbc2fa61bd9b6a2b7ad75f2e5ad0eec5513fa8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidhash+default-devel-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidhash+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidhash+default-devel.sha256sum] = "3e179242f469393b67bfc1f875f881d4c430710cab6d6b45b160d4b39dd639fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidhash+getrandom_03-devel-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidhash+getrandom_03-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidhash+getrandom_03-devel.sha256sum] = "2a7e9a0e790952dd3fbb311910bab0fb4d2a69299f6cb9535c9eeaf9ff70d4d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidhash+getrandom_04-devel-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidhash+getrandom_04-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidhash+getrandom_04-devel.sha256sum] = "9d14b6b9e90bec7ad64e06db259f2992c16f01e289f64c49bd07291eb033996f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidhash+nightly-devel-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidhash+nightly-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidhash+nightly-devel.sha256sum] = "3b4651dbf3f38d440a534cea0f822e67d88e92b5a0d1c2ac5fcb436ad0a0c5c4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidhash+rand-devel-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidhash+rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidhash+rand-devel.sha256sum] = "295d9e2902521afb0a8fea33e3b78c173751744e36ccf104d5912295a6a2e651"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidhash+rng-devel-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidhash+rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidhash+rng-devel.sha256sum] = "25d11a1a6cbc67fef4a362576463fa6742c15f55aed0d966bafc9b1165e8aeaf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidhash+std-devel-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidhash+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidhash+std-devel.sha256sum] = "221c209e01cd84207d9a07bc902851a147da424f6d404c41ff41d6183a53ff7c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidhash+unsafe-devel-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidhash+unsafe-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidhash+unsafe-devel.sha256sum] = "7e81fa2b96b8a1f30ae5a1ad2cc9989b7c9580e68d27be808d939cd63f04d0a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rapidhash-devel-4.5.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rapidhash-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rapidhash-devel.sha256sum] = "d48096852a801e5766ff9bff06548b0ceff0d69da67551f4d6bbd662753375b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidhash+default-devel-4.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rapidhash+default-devel;unpack=0"
SRC_URI[aarch64_rust-rapidhash+default-devel.sha256sum] = "a0af29a4ecfbbfec740e95c67f5e59bfeb5c819f68eed37bd1c5c47f072f9035"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidhash+getrandom_03-devel-4.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rapidhash+getrandom_03-devel;unpack=0"
SRC_URI[aarch64_rust-rapidhash+getrandom_03-devel.sha256sum] = "7e77c31cf9d326ffa99c493dddae9d540a7ce024048bed191c4fb2f26b26368b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidhash+getrandom_04-devel-4.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rapidhash+getrandom_04-devel;unpack=0"
SRC_URI[aarch64_rust-rapidhash+getrandom_04-devel.sha256sum] = "905de014c5e50de4e0007b11e02be3a52ad640c07af8fd30bac46cd5fa36129d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidhash+nightly-devel-4.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rapidhash+nightly-devel;unpack=0"
SRC_URI[aarch64_rust-rapidhash+nightly-devel.sha256sum] = "cad67cb472843a06193bd1bbf3276bc8ea59f6f4ccb70c7168706d35139a2ba3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidhash+rand-devel-4.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rapidhash+rand-devel;unpack=0"
SRC_URI[aarch64_rust-rapidhash+rand-devel.sha256sum] = "07b76131f75a20211396d27114a56a1fde633389bd459cada3926df7aab1f9fc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidhash+rng-devel-4.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rapidhash+rng-devel;unpack=0"
SRC_URI[aarch64_rust-rapidhash+rng-devel.sha256sum] = "b94f2c8e6128534bc172f01a98d3ea39218f28455af7153fe93a636cb960f35b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidhash+std-devel-4.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rapidhash+std-devel;unpack=0"
SRC_URI[aarch64_rust-rapidhash+std-devel.sha256sum] = "969179e7df878d95dad1734f3830064cde321d11ccf7ab9f1009ec04ab00f448"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidhash+unsafe-devel-4.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rapidhash+unsafe-devel;unpack=0"
SRC_URI[aarch64_rust-rapidhash+unsafe-devel.sha256sum] = "130a3cc2011f67ac4b35b686640a65423ee2d718de94e41ac698901fbfa4ccc9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rapidhash-devel-4.5.1-1.el10_3.noarch.rpm;name=aarch64_rust-rapidhash-devel;unpack=0"
SRC_URI[aarch64_rust-rapidhash-devel.sha256sum] = "753f199b728015f059eb8a8fdc7546d98e02c86417ab59595f570fb6b1c0fdda"

RDEPENDS:rust-rapidhash+default-devel = " \
 cargo \
 rust-rapidhash+std-devel \
 rust-rapidhash-devel \
 "
RDEPENDS:rust-rapidhash+getrandom_03-devel = " \
 cargo \
 rust-getrandom0.3-devel \
 rust-rapidhash-devel \
 "
RDEPENDS:rust-rapidhash+getrandom_04-devel = " \
 cargo \
 rust-getrandom-devel \
 rust-rapidhash-devel \
 "
RDEPENDS:rust-rapidhash+nightly-devel = " \
 cargo \
 rust-rapidhash-devel \
 "
RDEPENDS:rust-rapidhash+rand-devel = " \
 cargo \
 rust-rapidhash+getrandom_03-devel \
 rust-rapidhash+std-devel \
 rust-rapidhash-devel \
 "
RDEPENDS:rust-rapidhash+rng-devel = " \
 cargo \
 rust-rand_core0.9-devel \
 rust-rapidhash-devel \
 "
RDEPENDS:rust-rapidhash+std-devel = " \
 cargo \
 rust-rapidhash-devel \
 "
RDEPENDS:rust-rapidhash+unsafe-devel = " \
 cargo \
 rust-rapidhash-devel \
 "
RDEPENDS:rust-rapidhash-devel = " \
 cargo \
 rust \
 rust-rustversion+default-devel \
 "
