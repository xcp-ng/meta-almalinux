# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "subscription-manager"
PV = "1.30.12"
PR = "1.el10.alma.1"
PACKAGES = " \
 libdnf-plugin-subscription-manager \
 python3-cloud-what \
 python3-subscription-manager-rhsm \
 subscription-manager \
 subscription-manager-plugin-ostree \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/subscription-manager-1.30.12-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9020514c252490223fed8e8f52a5c499588ac53d624c3d36329a8f7ffc79b29c"

URI_x86_64_v2_libdnf-plugin-subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libdnf-plugin-subscription-manager-1.30.12-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdnf-plugin-subscription-manager}"
SRC_URI[x86_64_v2_libdnf-plugin-subscription-manager.sha256sum] = "b78308c90e77036f11cbeb65e47ad23bd67080ed37eae3a9a4e25ea6e674cb2c"

URI_x86_64_v2_python3-cloud-what = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-cloud-what-1.30.12-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-cloud-what;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cloud-what}"
SRC_URI[x86_64_v2_python3-cloud-what.sha256sum] = "f0add241e0ffa8ae4f7463e000ae2760944f6109df12798cd18f60932bb4c3c4"

URI_x86_64_v2_python3-subscription-manager-rhsm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-subscription-manager-rhsm-1.30.12-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_python3-subscription-manager-rhsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-subscription-manager-rhsm}"
SRC_URI[x86_64_v2_python3-subscription-manager-rhsm.sha256sum] = "ce4d1272fd283a478db722770282f7e50d3af7f9462e9dbf9721adcfa6ca5978"

URI_x86_64_v2_subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-1.30.12-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subscription-manager}"
SRC_URI[x86_64_v2_subscription-manager.sha256sum] = "1cd6847a3f8480105e7ee055d33e60f0592936c8fc6c2ad8c56af9e72ec34a6a"

URI_x86_64_v2_subscription-manager-plugin-ostree = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/subscription-manager-plugin-ostree-1.30.12-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_subscription-manager-plugin-ostree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subscription-manager-plugin-ostree}"
SRC_URI[x86_64_v2_subscription-manager-plugin-ostree.sha256sum] = "3b897fd8023c028226b22a08cb46ee47f50cc91f616633597c6c7a15e891398e"

URI_aarch64_libdnf-plugin-subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libdnf-plugin-subscription-manager-1.30.12-1.el10.alma.1.aarch64.rpm;name=aarch64_libdnf-plugin-subscription-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdnf-plugin-subscription-manager}"
SRC_URI[aarch64_libdnf-plugin-subscription-manager.sha256sum] = "55d83dba05ebe9fd8d6ff9795fdb76333c03cf5ddf92f9704806b280b4738944"

URI_aarch64_python3-cloud-what = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-cloud-what-1.30.12-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-cloud-what;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cloud-what}"
SRC_URI[aarch64_python3-cloud-what.sha256sum] = "11d7bfa65750e84ac8ada3046e01381a2e3e49ca2cc36ee61b7c25d6ba26e613"

URI_aarch64_python3-subscription-manager-rhsm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-subscription-manager-rhsm-1.30.12-1.el10.alma.1.aarch64.rpm;name=aarch64_python3-subscription-manager-rhsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-subscription-manager-rhsm}"
SRC_URI[aarch64_python3-subscription-manager-rhsm.sha256sum] = "6d4c745a69a53f9f4e137a2a81b5efbf8c32309666802a2c59c64c36c504b944"

URI_aarch64_subscription-manager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-1.30.12-1.el10.alma.1.aarch64.rpm;name=aarch64_subscription-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_subscription-manager}"
SRC_URI[aarch64_subscription-manager.sha256sum] = "696e90e876608b7e8e9542a41c450b343eaa0ca30c16fabb47845c0e89519991"

URI_aarch64_subscription-manager-plugin-ostree = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/subscription-manager-plugin-ostree-1.30.12-1.el10.alma.1.aarch64.rpm;name=aarch64_subscription-manager-plugin-ostree;unpack=0"
SRC_URI:append = " ${URI_aarch64_subscription-manager-plugin-ostree}"
SRC_URI[aarch64_subscription-manager-plugin-ostree.sha256sum] = "d1ca596e4f60ed1173377748cbe29635bb8520dc47b7582695da933b23fde55d"

RDEPENDS:libdnf-plugin-subscription-manager = " \
 glib2 \
 glibc \
 json-c \
 libdnf \
 librepo \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3-cloud-what = " \
 dmidecode \
 python3 \
 python3-requests \
 "
RDEPENDS:python3-subscription-manager-rhsm = " \
 glibc \
 openssl-libs \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-iniparse \
 python3-rpm \
 subscription-manager-rhsm-certificates \
 "
RDEPENDS:subscription-manager = " \
 bash \
 dmidecode \
 findutils \
 glib2 \
 glibc \
 iproute \
 libdnf-plugin-subscription-manager \
 python3 \
 python3-cloud-what \
 python3-dateutil \
 python3-dbus \
 python3-decorator \
 python3-dnf \
 python3-dnf-plugins-core \
 python3-gobject-base \
 python3-iniparse \
 python3-inotify \
 python3-librepo \
 python3-subscription-manager-rhsm \
 subscription-manager-rhsm-certificates \
 systemd \
 virt-what \
 "
RDEPENDS:subscription-manager-plugin-ostree = " \
 python3 \
 python3-gobject-base \
 python3-iniparse \
 subscription-manager \
 "
