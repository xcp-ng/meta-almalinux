# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "civetweb"
PV = "1.16"
PR = "5.el10_0"
PACKAGES = " \
 civetweb \
 civetweb-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/civetweb-1.16-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a1b26950464b790131b1aced3fccf8fddc79e6c727bddb8d62158a9d56a4460"

URI_x86_64_v2_civetweb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-1.16-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_civetweb}"
SRC_URI[x86_64_v2_civetweb.sha256sum] = "1856bd175967a2429a0e63399276df827d3a445425dd19c3514baec96d46c082"

URI_x86_64_v2_civetweb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/civetweb-devel-1.16-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_civetweb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_civetweb-devel}"
SRC_URI[x86_64_v2_civetweb-devel.sha256sum] = "ba1b98594890e58e9bc3d1ea8f0f40d8bec26943ecafb3a64f43574c028f14a0"

URI_aarch64_civetweb = "${EPEL_MIRROR}/aarch64/Packages/c/civetweb-1.16-5.el10_0.aarch64.rpm;name=aarch64_civetweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_civetweb}"
SRC_URI[aarch64_civetweb.sha256sum] = "955db0b8c8250419387b15fb44f079ae1fd2948918bc3e32d25c3f68c3cbf805"

URI_aarch64_civetweb-devel = "${EPEL_MIRROR}/aarch64/Packages/c/civetweb-devel-1.16-5.el10_0.aarch64.rpm;name=aarch64_civetweb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_civetweb-devel}"
SRC_URI[aarch64_civetweb-devel.sha256sum] = "b7446cae149fdd4b5bf9b750e9ba1f09d3a09757714f7ebd040fb261b8e41cf2"

RDEPENDS:civetweb = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:civetweb-devel = " \
 civetweb \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
