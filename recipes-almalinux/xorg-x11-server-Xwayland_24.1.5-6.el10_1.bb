# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-server-Xwayland"
PV = "24.1.5"
PR = "6.el10_1"
PACKAGES = " \
 xorg-x11-server-Xwayland \
 xorg-x11-server-Xwayland-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xorg-x11-server-Xwayland-24.1.5-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d645fedd46ef687b70dbbd2a12aec886f361d742ff06ee35555f2bb4ca9391ec"

URI_x86_64_v2_xorg-x11-server-Xwayland = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-24.1.5-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-server-Xwayland}"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland.sha256sum] = "a641c793216e1ed202508ce4261b7876a01d23b0ed1bb5259da375c640cd091c"

URI_x86_64_v2_xorg-x11-server-Xwayland-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-devel-24.1.5-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xorg-x11-server-Xwayland-devel}"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland-devel.sha256sum] = "94fdc4e33e5af210cc0dac64e517c22ac6d3e92c0c841c420f8a27a8bc71bb36"

URI_aarch64_xorg-x11-server-Xwayland = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xorg-x11-server-Xwayland-24.1.5-6.el10_1.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-server-Xwayland}"
SRC_URI[aarch64_xorg-x11-server-Xwayland.sha256sum] = "ef0533fb8c3a69915908d5dd74b086225c4f8e0b8540ddfc7e09a585df585b91"

URI_aarch64_xorg-x11-server-Xwayland-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xorg-x11-server-Xwayland-devel-24.1.5-6.el10_1.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_xorg-x11-server-Xwayland-devel}"
SRC_URI[aarch64_xorg-x11-server-Xwayland-devel.sha256sum] = "f3b053d182a0f0187d74a547c9dbcb084ec5e4d4f99916e0a2e13017e3482047"

RDEPENDS:xorg-x11-server-Xwayland = " \
 audit-libs \
 glibc \
 libXau \
 libXdmcp \
 libXfont2 \
 libdecor \
 libdrm \
 libei \
 libepoxy \
 libglvnd-egl \
 libglvnd-glx \
 liboeffis \
 libselinux \
 libtirpc \
 libwayland-client \
 libxcvt \
 libxshmfence \
 mesa-libgbm \
 openssl-libs \
 pixman \
 xkbcomp \
 xkeyboard-config \
 "
RDEPENDS:xorg-x11-server-Xwayland-devel = " \
 pkgconf-pkg-config \
 xorg-x11-server-Xwayland \
 "
