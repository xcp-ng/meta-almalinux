# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opendkim"
PV = "2.11.0"
PR = "0.42.el10_1"
PACKAGES = " \
 libopendkim \
 libopendkim-devel \
 opendkim \
 opendkim-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/opendkim-2.11.0-0.42.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99832a1f2dec85fe8b68ecacbf2d723cc2c77876aaa06601d647ce039c8a67e1"

URI_x86_64_v2_libopendkim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendkim-2.11.0-0.42.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendkim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendkim}"
SRC_URI[x86_64_v2_libopendkim.sha256sum] = "2876b7c899e9552f8f4535ffdce88a77f1386f07cb841dc8376d82d71277232b"

URI_x86_64_v2_libopendkim-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libopendkim-devel-2.11.0-0.42.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libopendkim-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libopendkim-devel}"
SRC_URI[x86_64_v2_libopendkim-devel.sha256sum] = "4c2572daeb4003f07e30a1f5ca69c15b17b9879aa01f85618dfcf93e2bcfa68b"

URI_x86_64_v2_opendkim = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendkim-2.11.0-0.42.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendkim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendkim}"
SRC_URI[x86_64_v2_opendkim.sha256sum] = "a808bdf6a0d3ae025d3933e0e5429651f2fa9e606f40636dac8374ef43b71f68"

URI_x86_64_v2_opendkim-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opendkim-tools-2.11.0-0.42.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opendkim-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_opendkim-tools}"
SRC_URI[x86_64_v2_opendkim-tools.sha256sum] = "8efef476f826042988c6874c9df4b6e37bc0d576afbd1de6af7421b7ff8972f2"

URI_aarch64_libopendkim = "${EPEL_MIRROR}/aarch64/Packages/l/libopendkim-2.11.0-0.42.el10_1.aarch64.rpm;name=aarch64_libopendkim;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendkim}"
SRC_URI[aarch64_libopendkim.sha256sum] = "41947784623a3fb87b5b2a2f58b51126aeaf641d6615f8c1ae1d6467757255d9"

URI_aarch64_libopendkim-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libopendkim-devel-2.11.0-0.42.el10_1.aarch64.rpm;name=aarch64_libopendkim-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libopendkim-devel}"
SRC_URI[aarch64_libopendkim-devel.sha256sum] = "cde45539f58df2daa3eaab3fdd5587d2a3e97b8f0625678e51851913d348c440"

URI_aarch64_opendkim = "${EPEL_MIRROR}/aarch64/Packages/o/opendkim-2.11.0-0.42.el10_1.aarch64.rpm;name=aarch64_opendkim;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendkim}"
SRC_URI[aarch64_opendkim.sha256sum] = "157b9e3457530c792dd87be9a26fa7be737c92c46284b1fcce10f8491155ee96"

URI_aarch64_opendkim-tools = "${EPEL_MIRROR}/aarch64/Packages/o/opendkim-tools-2.11.0-0.42.el10_1.aarch64.rpm;name=aarch64_opendkim-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_opendkim-tools}"
SRC_URI[aarch64_opendkim-tools.sha256sum] = "d0f08be733eac6bb179206252ee6987340b7e39c9f857965f486b4bce665a9ee"

RDEPENDS:libopendkim = " \
 glibc \
 libdb \
 openssl-libs \
 "
RDEPENDS:libopendkim-devel = " \
 libopendkim \
 pkgconf-pkg-config \
 "
RDEPENDS:opendkim = " \
 bash \
 glibc \
 libdb \
 libmemcached-awesome \
 libopendkim \
 lua-libs \
 opendbx \
 openldap \
 openssl-libs \
 sendmail-milter \
 systemd \
 "
RDEPENDS:opendkim-tools = " \
 glibc \
 libdb \
 libmemcached-awesome \
 libopendkim \
 lua-libs \
 opendbx \
 openldap \
 openssl-libs \
 perl-interpreter \
 "
