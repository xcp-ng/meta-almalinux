# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkleo"
PV = "26.04.3"
PR = "1.1.el10_3"
PACKAGES = " \
 libkleo \
 libkleo-devel \
 libkleo-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkleo-26.04.3-1.1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5b664df9f73f3c193f5c120a331f4f8292d1dd085ed052176f6bf9f60f94237"

URI_x86_64_v2_libkleo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-26.04.3-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo}"
SRC_URI[x86_64_v2_libkleo.sha256sum] = "fe7fac90d3c8139e7057cd28e092efcb0c575d72f2329660cfcd2913c1f4524e"

URI_x86_64_v2_libkleo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-devel-26.04.3-1.1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkleo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo-devel}"
SRC_URI[x86_64_v2_libkleo-devel.sha256sum] = "4d788501b5a0dbfcb4708c4a0c8783d027518251d4f24d19638701059043d39b"

URI_x86_64_v2_libkleo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkleo-doc-26.04.3-1.1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libkleo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkleo-doc}"
SRC_URI[x86_64_v2_libkleo-doc.sha256sum] = "f0d741f4f0dea28a71f6cd989af5975dfe36482d04f7b77b1f23d15994a814e4"

URI_aarch64_libkleo = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-26.04.3-1.1.el10_3.aarch64.rpm;name=aarch64_libkleo;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo}"
SRC_URI[aarch64_libkleo.sha256sum] = "f5a80e40ad4346f821838eea42082125ee7051476583968306f3daffce6cecf7"

URI_aarch64_libkleo-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-devel-26.04.3-1.1.el10_3.aarch64.rpm;name=aarch64_libkleo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo-devel}"
SRC_URI[aarch64_libkleo-devel.sha256sum] = "83fe216c4433341ea5943a3edc14c756b2dca3e22a2636e3ebbd824e10faa9d6"

URI_aarch64_libkleo-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkleo-doc-26.04.3-1.1.el10_3.noarch.rpm;name=aarch64_libkleo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkleo-doc}"
SRC_URI[aarch64_libkleo-doc.sha256sum] = "9d1018f055ec524b303803d72ca6aacd043afd24c37e18451c2e42318b25e1b1"

RDEPENDS:libkleo = " \
 glibc \
 gpgme2pp \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwidgetsaddons \
 libgcc \
 libstdc++ \
 qgpgme2-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkleo-devel = " \
 cmake-filesystem \
 libkleo \
 virtual/cmake_Gpgmepp_ \
 virtual/cmake_QGpgmeQt6_ \
 "
RDEPENDS:libkleo-doc = " \
 "
