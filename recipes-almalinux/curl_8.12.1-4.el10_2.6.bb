# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "curl"
PV = "8.12.1"
PR = "4.el10_2.6"
PACKAGES = " \
 curl \
 libcurl \
 libcurl-devel \
 libcurl-minimal \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/curl-8.12.1-4.el10_2.6.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6ef040dbb26a37e86440efb5939b7f9a375124f31e9e533fcb4252d770cd2bb6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/curl-8.12.1-4.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_curl;unpack=0"
SRC_URI[x86_64_v2_curl.sha256sum] = "2930323182c8d2ee22db0a21111c67f56250589e8db3ae139619a95e1119d8e1"
RPROVIDES:curl:append:x86_64_v2 = " virtual/wget_or_curl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcurl-8.12.1-4.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_libcurl;unpack=0"
SRC_URI[x86_64_v2_libcurl.sha256sum] = "bfb3d81c02331711c1043cd2f507d53b2e22ec151b4eb10d6e40026a97a42e5f"
RPROVIDES:libcurl:append:x86_64_v2 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2 virtual/libcurl_x86-64_ virtual/libcurl_x86-64__eq_8.12.1-4.el10_2.6 virtual/libcurl_x86-64__ge_7.29.0 virtual/libcurl_x86-64__ge_7.52.0 virtual/libcurl_x86-64__ge_8.12.1-4.el10_2.6 virtual/libcurl_x86-64__ge_8.9.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcurl-devel-8.12.1-4.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_libcurl-devel;unpack=0"
SRC_URI[x86_64_v2_libcurl-devel.sha256sum] = "fde46a8d542aca0fc9793624cf8279c49f00bee64671ef8fb0badaf93a92ceb4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libcurl-minimal-8.12.1-4.el10_2.6.x86_64_v2.rpm;name=x86_64_v2_libcurl-minimal;unpack=0"
SRC_URI[x86_64_v2_libcurl-minimal.sha256sum] = "dca951bbe13f4cc3d0ed9f49ef39777810652fcc5f724c274e8bd7ce705f93d4"
RPROVIDES:libcurl-minimal:append:x86_64_v2 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2 virtual/libcurl_x86-64_ virtual/libcurl_x86-64__eq_8.12.1-4.el10_2.6 virtual/libcurl_x86-64__ge_7.29.0 virtual/libcurl_x86-64__ge_7.52.0 virtual/libcurl_x86-64__ge_8.12.1-4.el10_2.6 virtual/libcurl_x86-64__ge_8.9.1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/curl-8.12.1-4.el10_2.6.aarch64.rpm;name=aarch64_curl;unpack=0"
SRC_URI[aarch64_curl.sha256sum] = "be3e4907d769439a6ce7d9a5961448616a41a7163ede1cc386bbfdaa450a30c5"
RPROVIDES:curl:append:aarch64 = " virtual/wget_or_curl"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcurl-8.12.1-4.el10_2.6.aarch64.rpm;name=aarch64_libcurl;unpack=0"
SRC_URI[aarch64_libcurl.sha256sum] = "df586437241ebf91ac9cb1944e140e98a71e57af51fe8a6663b77ddb97546a6f"
RPROVIDES:libcurl:append:aarch64 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_aarch-64_ virtual/libcurl_aarch-64__eq_8.12.1-4.el10_2.6 virtual/libcurl_aarch-64__ge_7.29.0 virtual/libcurl_aarch-64__ge_7.52.0 virtual/libcurl_aarch-64__ge_8.12.1-4.el10_2.6 virtual/libcurl_aarch-64__ge_8.9.1 virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcurl-devel-8.12.1-4.el10_2.6.aarch64.rpm;name=aarch64_libcurl-devel;unpack=0"
SRC_URI[aarch64_libcurl-devel.sha256sum] = "0b9e321b52def8c8435f0844d4b62d745a8dd40e455cb96fb5c73b3169bffed8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libcurl-minimal-8.12.1-4.el10_2.6.aarch64.rpm;name=aarch64_libcurl-minimal;unpack=0"
SRC_URI[aarch64_libcurl-minimal.sha256sum] = "4cb721d013db197d3dc1ad65b90f6983e5b61eab93de0844e3845eaeb2074f5f"
RPROVIDES:libcurl-minimal:append:aarch64 = " virtual/libcurl virtual/libcurl.so.4___64bit_ virtual/libcurl_aarch-64_ virtual/libcurl_aarch-64__eq_8.12.1-4.el10_2.6 virtual/libcurl_aarch-64__ge_7.29.0 virtual/libcurl_aarch-64__ge_7.52.0 virtual/libcurl_aarch-64__ge_8.12.1-4.el10_2.6 virtual/libcurl_aarch-64__ge_8.9.1 virtual/libcurl_ge_7.12.0 virtual/libcurl_ge_7.21.7-2"

RDEPENDS:curl:x86_64_v2 = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__ge_8.12.1-4.el10_2.6 \
"
RDEPENDS:curl:aarch64 = " \
 glibc \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__ge_8.12.1-4.el10_2.6 \
"
RDEPENDS:libcurl = " \
 glibc \
 krb5-libs \
 libbrotli \
 libidn2 \
 libnghttp2 \
 libpsl \
 libssh \
 openldap \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:libcurl-devel:x86_64_v2 = " \
 bash \
 brotli-devel \
 krb5-devel \
 libidn2-devel \
 libnghttp2-devel \
 libpsl-devel \
 libssh-devel \
 openssl-devel \
 pkgconf-pkg-config \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_x86-64__eq_8.12.1-4.el10_2.6 \
 zlib-ng-compat-devel \
"
RDEPENDS:libcurl-devel:aarch64 = " \
 bash \
 brotli-devel \
 krb5-devel \
 libidn2-devel \
 libnghttp2-devel \
 libpsl-devel \
 libssh-devel \
 openssl-devel \
 pkgconf-pkg-config \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_aarch-64__eq_8.12.1-4.el10_2.6 \
 zlib-ng-compat-devel \
"
RDEPENDS:libcurl-minimal = " \
 glibc \
 krb5-libs \
 libidn2 \
 libnghttp2 \
 openssl-libs \
 zlib-ng-compat \
 "
