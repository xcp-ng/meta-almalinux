# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "verilator"
PV = "5.030"
PR = "12.el10_0"
PACKAGES = " \
 verilator \
 verilator-devel \
 verilator-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/verilator-5.030-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e739688a7699aea6f4b58d0b5f5c22550314a3ffa08a41edf4cccbe596acda1c"

URI_x86_64_v2_verilator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/verilator-5.030-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_verilator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_verilator}"
SRC_URI[x86_64_v2_verilator.sha256sum] = "060b1739c2144ccca497763f4e0c8e207922511d2d461f20ac1d1da827110897"

URI_x86_64_v2_verilator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/verilator-devel-5.030-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_verilator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_verilator-devel}"
SRC_URI[x86_64_v2_verilator-devel.sha256sum] = "fbf4e553a97f0b4dac7fd955ced6c0c3f338c01592b3f53194ade3acb4fe8494"

URI_x86_64_v2_verilator-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/verilator-doc-5.030-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_verilator-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_verilator-doc}"
SRC_URI[x86_64_v2_verilator-doc.sha256sum] = "9704584c39ea0d18aa2d35331ae3deb3cf471f82cbb3a4d30a8911a2e34884ff"

URI_aarch64_verilator = "${EPEL_MIRROR}/aarch64/Packages/v/verilator-5.030-12.el10_0.aarch64.rpm;name=aarch64_verilator;unpack=0"
SRC_URI:append = " ${URI_aarch64_verilator}"
SRC_URI[aarch64_verilator.sha256sum] = "a86e5c5dae8702303f39e4e2ca924a030af947777213d1032d620d804c1d24fa"

URI_aarch64_verilator-devel = "${EPEL_MIRROR}/aarch64/Packages/v/verilator-devel-5.030-12.el10_0.aarch64.rpm;name=aarch64_verilator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_verilator-devel}"
SRC_URI[aarch64_verilator-devel.sha256sum] = "7705f71089577c3894a05383eebfb2d2d842a641ae19ca68cc9ae830e2ec7801"

URI_aarch64_verilator-doc = "${EPEL_MIRROR}/aarch64/Packages/v/verilator-doc-5.030-12.el10_0.noarch.rpm;name=aarch64_verilator-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_verilator-doc}"
SRC_URI[aarch64_verilator-doc.sha256sum] = "380b5e566173034008a29abc2f364126da6346353692c1daf2569db26155c819"

RDEPENDS:verilator = " \
 glibc \
 libgcc \
 libstdc++ \
 perl-FindBin \
 perl-Getopt-Long \
 perl-IO \
 perl-PathTools \
 perl-Pod-Usage \
 perl-interpreter \
 perl-libs \
 perl-vars \
 python3 \
 verilator-devel \
 "
RDEPENDS:verilator-devel = " \
 pkgconf-pkg-config \
 verilator \
 "
RDEPENDS:verilator-doc = " \
 verilator \
 "
