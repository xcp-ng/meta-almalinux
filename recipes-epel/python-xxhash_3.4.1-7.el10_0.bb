# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-xxhash"
PV = "3.4.1"
PR = "7.el10_0"
PACKAGES = " \
 python3-xxhash \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-xxhash-3.4.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b88d09a659f3289b42669ee8b4218d938fa840db00bc40771e5d668c37dff4e"

URI_x86_64_v2_python3-xxhash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xxhash-3.4.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-xxhash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-xxhash}"
SRC_URI[x86_64_v2_python3-xxhash.sha256sum] = "709fec57181d217c56f04532645e7839aac287ad1f681549d5e04e1fc8bac555"

URI_aarch64_python3-xxhash = "${EPEL_MIRROR}/aarch64/Packages/p/python3-xxhash-3.4.1-7.el10_0.aarch64.rpm;name=aarch64_python3-xxhash;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-xxhash}"
SRC_URI[aarch64_python3-xxhash.sha256sum] = "2801736faeb6c13dd0f81b8b008a318d246bcc7f8eecfc7560d8899c4b5893c3"

RDEPENDS:python3-xxhash = " \
 glibc \
 python3 \
 xxhash-libs \
 "
