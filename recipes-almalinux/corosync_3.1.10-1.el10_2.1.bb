# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "corosync"
PV = "3.1.10"
PR = "1.el10_2.1"
PACKAGES = " \
 corosync-vqsim \
 corosynclib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/corosync-3.1.10-1.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cdb07f1fb7ad126c52f3b052be54e9e6c7c0d784fbbac70274ce22d0c9a0fe90"

URI_x86_64_v2_corosync-vqsim = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/corosync-vqsim-3.1.10-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_corosync-vqsim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_corosync-vqsim}"
SRC_URI[x86_64_v2_corosync-vqsim.sha256sum] = "c0bca146081fc7ef341e760cca971c1e74c09f6d5335342c4d35b83463185b4a"

URI_x86_64_v2_corosynclib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/corosynclib-3.1.10-1.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_corosynclib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_corosynclib}"
SRC_URI[x86_64_v2_corosynclib.sha256sum] = "17ee57c47daff63921244fd1ac9512112c6303ae2d9639170368be3d78b5ca8d"

URI_aarch64_corosync-vqsim = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/corosync-vqsim-3.1.10-1.el10_2.1.aarch64.rpm;name=aarch64_corosync-vqsim;unpack=0"
SRC_URI:append = " ${URI_aarch64_corosync-vqsim}"
SRC_URI[aarch64_corosync-vqsim.sha256sum] = "e68dbc8ed3154bff923dea43b37c29e5c55720e73d70eaef36344cd95397066a"

URI_aarch64_corosynclib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/corosynclib-3.1.10-1.el10_2.1.aarch64.rpm;name=aarch64_corosynclib;unpack=0"
SRC_URI:append = " ${URI_aarch64_corosynclib}"
SRC_URI[aarch64_corosynclib.sha256sum] = "5867f003f9fd32f9035dbccf0e1f413065abbf96bf9b34e8b32c8f745a46d65f"

RDEPENDS:corosync-vqsim = " \
 corosynclib \
 glibc \
 libknet1 \
 libqb \
 pkgconf-pkg-config \
 readline \
 "
RDEPENDS:corosynclib = " \
 glibc \
 libqb \
 "
