# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "util-linux"
PV = "2.40.2"
PR = "20.el10"
PACKAGES = " \
 libblkid \
 libblkid-devel \
 libfdisk \
 libfdisk-devel \
 libmount \
 libmount-devel \
 libsmartcols \
 libsmartcols-devel \
 libuuid \
 libuuid-devel \
 python3-libmount \
 util-linux \
 util-linux-core \
 uuidd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/util-linux-2.40.2-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e3e226265fcace8ba26bea472c32e710badb405205fbdd82b0224e6a5dbdb46"

URI_x86_64_v2_libblkid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libblkid-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libblkid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkid}"
SRC_URI[x86_64_v2_libblkid.sha256sum] = "cf5a24429559be40fefe8416912ab76f0b9f76ed81d7a2d2a2651ebf273e3f5a"

URI_x86_64_v2_libblkid-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libblkid-devel-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libblkid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libblkid-devel}"
SRC_URI[x86_64_v2_libblkid-devel.sha256sum] = "36d4359ff368b69068b5d142b157a6ee6f073a158dad957b98304b2cd0d3090b"

URI_x86_64_v2_libfdisk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libfdisk-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libfdisk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdisk}"
SRC_URI[x86_64_v2_libfdisk.sha256sum] = "924e4703829669950db25794db208ab3e0cb5c8fcc9a17001b57c4298cf5353a"

URI_x86_64_v2_libfdisk-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libfdisk-devel-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libfdisk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libfdisk-devel}"
SRC_URI[x86_64_v2_libfdisk-devel.sha256sum] = "d6608bbc08ac9537074ca4fe7609a525f359e69121d7114ded9d7b223c4150eb"

URI_x86_64_v2_libmount = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libmount-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libmount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmount}"
SRC_URI[x86_64_v2_libmount.sha256sum] = "0e3933b642792b44ea992528ab1778dcd4065b9f13d214aed02be650f00cde78"

URI_x86_64_v2_libmount-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libmount-devel-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libmount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmount-devel}"
SRC_URI[x86_64_v2_libmount-devel.sha256sum] = "801872e8a0eb9b56d091a34d8775a93947c274420f65e1e1d5df40d67e1e70c7"

URI_x86_64_v2_libsmartcols = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmartcols-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libsmartcols;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmartcols}"
SRC_URI[x86_64_v2_libsmartcols.sha256sum] = "86f5c2d5e2a8863a266e59c553f4f34fade0050a5304858b2d4a1ebbd583878b"

URI_x86_64_v2_libsmartcols-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmartcols-devel-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libsmartcols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmartcols-devel}"
SRC_URI[x86_64_v2_libsmartcols-devel.sha256sum] = "d238948b7424dc713cd69341c589e5a7a77e0e5e49693d5daa53d575ca2b606e"

URI_x86_64_v2_libuuid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libuuid-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libuuid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuuid}"
SRC_URI[x86_64_v2_libuuid.sha256sum] = "ce85653ecffffda3d84fbf0d0d79c47bc77a62dca22984471dcb51577d649c04"

URI_x86_64_v2_libuuid-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libuuid-devel-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_libuuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libuuid-devel}"
SRC_URI[x86_64_v2_libuuid-devel.sha256sum] = "d7f90e9f0f8e20f3d89a14adcf867beda4a4616543a33606c565be5915f92c6e"

URI_x86_64_v2_python3-libmount = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libmount-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libmount;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libmount}"
SRC_URI[x86_64_v2_python3-libmount.sha256sum] = "3fd0d6fe4a511d4955953a8d0ff473872773ee878fc04d58736fc756daf70380"

URI_x86_64_v2_util-linux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_util-linux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_util-linux}"
SRC_URI[x86_64_v2_util-linux.sha256sum] = "593cd1c7ba567e676e5d8af8a1a5e31d6b9e265cb32e9b73f5f0708523d0fd6a"
RPROVIDES:util-linux:x86_64_v2 = "virtual/util-linux-core_or_util-linux"

URI_x86_64_v2_util-linux-core = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/util-linux-core-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_util-linux-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_util-linux-core}"
SRC_URI[x86_64_v2_util-linux-core.sha256sum] = "ea494c24374242b264dd8e48e56668493676c95514b67aa17fd5e9f88219dfcc"
RPROVIDES:util-linux-core:x86_64_v2 = "virtual/util-linux-core_or_util-linux"

URI_x86_64_v2_uuidd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/uuidd-2.40.2-20.el10.x86_64_v2.rpm;name=x86_64_v2_uuidd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_uuidd}"
SRC_URI[x86_64_v2_uuidd.sha256sum] = "67ff8e10331cb6bdd825975c6bd23d71a87d7e6bc4c1162ad4fa0bf151b4d9a3"

URI_aarch64_libblkid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libblkid-2.40.2-20.el10.aarch64.rpm;name=aarch64_libblkid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkid}"
SRC_URI[aarch64_libblkid.sha256sum] = "142a27f26cceb695652216d58d6ae3c5815a9963a8835d3fe752fa7f31741a75"

URI_aarch64_libblkid-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libblkid-devel-2.40.2-20.el10.aarch64.rpm;name=aarch64_libblkid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libblkid-devel}"
SRC_URI[aarch64_libblkid-devel.sha256sum] = "f9b247726ad9ee7920a0a093101424999c80d925751008fb5a9ecc6655c5eff3"

URI_aarch64_libfdisk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libfdisk-2.40.2-20.el10.aarch64.rpm;name=aarch64_libfdisk;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdisk}"
SRC_URI[aarch64_libfdisk.sha256sum] = "bd2376ea42ae88b4d8763d7dc166b78f3c05646d2cfb5bac76a31fe3227911c0"

URI_aarch64_libfdisk-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libfdisk-devel-2.40.2-20.el10.aarch64.rpm;name=aarch64_libfdisk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libfdisk-devel}"
SRC_URI[aarch64_libfdisk-devel.sha256sum] = "5d4d830e0c18bfaa82c0eed8f738731e30c3899af688bfa13e0e35e0864ccd10"

URI_aarch64_libmount = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libmount-2.40.2-20.el10.aarch64.rpm;name=aarch64_libmount;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmount}"
SRC_URI[aarch64_libmount.sha256sum] = "72585b579da0ea552caf3e84cbc8124532d745b8c1c069f8ba1cf181d57ebe38"

URI_aarch64_libmount-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libmount-devel-2.40.2-20.el10.aarch64.rpm;name=aarch64_libmount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmount-devel}"
SRC_URI[aarch64_libmount-devel.sha256sum] = "a8661de788d70d14045b33520f0041643848cd45630ea87e89e243e67dde9303"

URI_aarch64_libsmartcols = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmartcols-2.40.2-20.el10.aarch64.rpm;name=aarch64_libsmartcols;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmartcols}"
SRC_URI[aarch64_libsmartcols.sha256sum] = "ac431615afbba8fb9be1445206d917878ee73781dd22bb51c33c149722a748ab"

URI_aarch64_libsmartcols-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmartcols-devel-2.40.2-20.el10.aarch64.rpm;name=aarch64_libsmartcols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmartcols-devel}"
SRC_URI[aarch64_libsmartcols-devel.sha256sum] = "2022a3a5e069b066f2b373986c6a55950bbdda8b1f9b7d6afb35b3230d43b695"

URI_aarch64_libuuid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libuuid-2.40.2-20.el10.aarch64.rpm;name=aarch64_libuuid;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuuid}"
SRC_URI[aarch64_libuuid.sha256sum] = "3727d3c2f5fb2dbe1d1401fd3736724ec903d794e172d54369f079ce76101ebe"

URI_aarch64_libuuid-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libuuid-devel-2.40.2-20.el10.aarch64.rpm;name=aarch64_libuuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libuuid-devel}"
SRC_URI[aarch64_libuuid-devel.sha256sum] = "ba4c9a9a2cb65f548061df45b6a906b756ad4a4ac435725921367de60a2b06bd"

URI_aarch64_python3-libmount = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libmount-2.40.2-20.el10.aarch64.rpm;name=aarch64_python3-libmount;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libmount}"
SRC_URI[aarch64_python3-libmount.sha256sum] = "7e27e5bc1cf64fb42b733eb08c60937875738c9b57610b80898531946fdae573"

URI_aarch64_util-linux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-2.40.2-20.el10.aarch64.rpm;name=aarch64_util-linux;unpack=0"
SRC_URI:append = " ${URI_aarch64_util-linux}"
SRC_URI[aarch64_util-linux.sha256sum] = "cdb94397fc54a747d0cbd7e9e2c3400b79ab28273c215e2a6af6e894aca308ba"
RPROVIDES:util-linux:aarch64 = "virtual/util-linux-core_or_util-linux"

URI_aarch64_util-linux-core = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/util-linux-core-2.40.2-20.el10.aarch64.rpm;name=aarch64_util-linux-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_util-linux-core}"
SRC_URI[aarch64_util-linux-core.sha256sum] = "03a99c8e01374fb21289f1a24b2ab1c4810ae273783c10648850ac7590963569"
RPROVIDES:util-linux-core:aarch64 = "virtual/util-linux-core_or_util-linux"

URI_aarch64_uuidd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/uuidd-2.40.2-20.el10.aarch64.rpm;name=aarch64_uuidd;unpack=0"
SRC_URI:append = " ${URI_aarch64_uuidd}"
SRC_URI[aarch64_uuidd.sha256sum] = "2e50343d5ff1f8eafc2f34a7f430755a51c345a800b52bb79d578ff1d2c138d0"

RDEPENDS:libblkid = " \
 glibc \
 libuuid \
 "
RDEPENDS:libblkid-devel = " \
 libblkid \
 pkgconf-pkg-config \
 "
RDEPENDS:libfdisk = " \
 glibc \
 libblkid \
 libuuid \
 "
RDEPENDS:libfdisk-devel = " \
 libblkid-devel \
 libfdisk \
 libuuid-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libmount = " \
 glibc \
 libblkid \
 libselinux \
 libuuid \
 "
RDEPENDS:libmount-devel = " \
 libblkid-devel \
 libmount \
 libselinux-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmartcols = " \
 glibc \
 "
RDEPENDS:libsmartcols-devel = " \
 libsmartcols \
 pkgconf-pkg-config \
 "
RDEPENDS:libuuid = " \
 glibc \
 "
RDEPENDS:libuuid-devel = " \
 libuuid \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libmount = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 python3 \
 "
RDEPENDS:util-linux = " \
 audit-libs \
 authselect-libs \
 bash \
 glibc \
 libblkid \
 libcap-ng \
 libfdisk \
 libmount \
 libselinux \
 libsmartcols \
 libutempter \
 libuuid \
 ncurses-libs \
 pam \
 pam-libs \
 readline \
 shadow-utils \
 systemd-libs \
 util-linux-core \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:util-linux-core = " \
 glibc \
 libblkid \
 libmount \
 libselinux \
 libsmartcols \
 libuuid \
 libxcrypt \
 ncurses-libs \
 systemd-libs \
 "
RDEPENDS:uuidd = " \
 bash \
 glibc \
 libuuid \
 shadow-utils \
 systemd-libs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/util-linux-core_or_util-linux"

PROVIDES:append:aarch64 = " rpm/virtual/util-linux-core_or_util-linux"
