# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-syntax-highlighting"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-syntax-highlighting \
 kf6-syntax-highlighting-devel \
 kf6-syntax-highlighting-doc \
 kf6-syntax-highlighting-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-syntax-highlighting-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ef4ad978c3e045fd2004834f0dd1ee05c2f69e9fa842ee538a8153b91a995d63"

URI_x86_64_v2_kf6-syntax-highlighting = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting.sha256sum] = "add926b7e0bc252790f54100f9ebedb091c295ae48535953f7b29c7920e3e585"

URI_x86_64_v2_kf6-syntax-highlighting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-devel}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-devel.sha256sum] = "a4a6bbf0344968b844ab38ee503ffcbc56c7701330638c8617b201af31b55acb"

URI_x86_64_v2_kf6-syntax-highlighting-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-doc}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-doc.sha256sum] = "f3678a27491d6cd9da88f3ebad7841d7b4bfde226418f4d5ac0aafd182b42dae"

URI_x86_64_v2_kf6-syntax-highlighting-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-syntax-highlighting-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-syntax-highlighting-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-syntax-highlighting-html}"
SRC_URI[x86_64_v2_kf6-syntax-highlighting-html.sha256sum] = "98ffdd231093caeb9ac60b16f745a0d7e085edd1886f6ed9ece2503f3d906902"

URI_aarch64_kf6-syntax-highlighting = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-syntax-highlighting;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting}"
SRC_URI[aarch64_kf6-syntax-highlighting.sha256sum] = "85488195c6ac0e1e758b2b8c3f947ae9b9b32f4421ffc2cc623e85b910a21e15"

URI_aarch64_kf6-syntax-highlighting-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-syntax-highlighting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-devel}"
SRC_URI[aarch64_kf6-syntax-highlighting-devel.sha256sum] = "ce3ad35d24f4a1729d8f688d344ac79fdb5521c3dca3d99e1caec099640f538e"

URI_aarch64_kf6-syntax-highlighting-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-syntax-highlighting-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-doc}"
SRC_URI[aarch64_kf6-syntax-highlighting-doc.sha256sum] = "2462434049f34bcb8c82196365e1dc7258606dd028e640406ed6626dcdb83e50"

URI_aarch64_kf6-syntax-highlighting-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-syntax-highlighting-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-syntax-highlighting-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-syntax-highlighting-html}"
SRC_URI[aarch64_kf6-syntax-highlighting-html.sha256sum] = "e864a8b8e135a5d8c564c5c2d9df5a663d7a7a309b5d75cb793529a1f17dfec8"

RDEPENDS:kf6-syntax-highlighting = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-syntax-highlighting-devel = " \
 cmake-filesystem \
 kf6-syntax-highlighting \
 "
RDEPENDS:kf6-syntax-highlighting-doc = " \
 "
RDEPENDS:kf6-syntax-highlighting-html = " \
 "
