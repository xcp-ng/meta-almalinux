# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-event-listener-strategy"
PV = "0.5.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-event-listener-strategy+default-devel \
 rust-event-listener-strategy+portable-atomic-devel \
 rust-event-listener-strategy+std-devel \
 rust-event-listener-strategy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-event-listener-strategy-0.5.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2861ae6a7b1a05d0e22ef64f6b6c30e1162897e46ff5a5dd07384989e4f259f4"

URI_x86_64_v2_rust-event-listener-strategy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-strategy+default-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-strategy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-strategy+default-devel}"
SRC_URI[x86_64_v2_rust-event-listener-strategy+default-devel.sha256sum] = "7518041d79336bd68a62afa859675b814378959cbda85af1a37adc9cf0b83ab2"

URI_x86_64_v2_rust-event-listener-strategy+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-strategy+portable-atomic-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-strategy+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-strategy+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-event-listener-strategy+portable-atomic-devel.sha256sum] = "646dd9b891e29661e696dd786ba9dd934207c9d914cac60af0da9d28244f5e75"

URI_x86_64_v2_rust-event-listener-strategy+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-strategy+std-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-strategy+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-strategy+std-devel}"
SRC_URI[x86_64_v2_rust-event-listener-strategy+std-devel.sha256sum] = "a603ada739d431c6519978c57b251a1152bab237d5c795e0af358f15510d1a0a"

URI_x86_64_v2_rust-event-listener-strategy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-event-listener-strategy-devel-0.5.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-event-listener-strategy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-event-listener-strategy-devel}"
SRC_URI[x86_64_v2_rust-event-listener-strategy-devel.sha256sum] = "5ec30ecd875ae8dd524e86f305181df3cb5376f9946d720010b053c096372eea"

URI_aarch64_rust-event-listener-strategy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-strategy+default-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener-strategy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-strategy+default-devel}"
SRC_URI[aarch64_rust-event-listener-strategy+default-devel.sha256sum] = "71b4e00da6190eb9b43d58f4ce946f17806157575a2be1041c21791aaf82e5c4"

URI_aarch64_rust-event-listener-strategy+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-strategy+portable-atomic-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener-strategy+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-strategy+portable-atomic-devel}"
SRC_URI[aarch64_rust-event-listener-strategy+portable-atomic-devel.sha256sum] = "177107c5e1cd05415d000408d8075473bd5fdf2bf7c198ff9b1f4c079d2c0bc7"

URI_aarch64_rust-event-listener-strategy+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-strategy+std-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener-strategy+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-strategy+std-devel}"
SRC_URI[aarch64_rust-event-listener-strategy+std-devel.sha256sum] = "3c24152f52e33d0fe148d3c0a9d478517d62526c8887b83853d50011e254fc19"

URI_aarch64_rust-event-listener-strategy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-event-listener-strategy-devel-0.5.4-1.el10_0.noarch.rpm;name=aarch64_rust-event-listener-strategy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-event-listener-strategy-devel}"
SRC_URI[aarch64_rust-event-listener-strategy-devel.sha256sum] = "a493fbed456c021cdff508fe4a615925401d7fd9d2daf2ef34a2a31ec40afdc2"

RDEPENDS:rust-event-listener-strategy+default-devel = " \
 cargo \
 rust-event-listener-strategy+std-devel \
 rust-event-listener-strategy-devel \
 "
RDEPENDS:rust-event-listener-strategy+portable-atomic-devel = " \
 cargo \
 rust-event-listener+portable-atomic-devel \
 rust-event-listener-strategy-devel \
 "
RDEPENDS:rust-event-listener-strategy+std-devel = " \
 cargo \
 rust-event-listener+std-devel \
 rust-event-listener-strategy-devel \
 "
RDEPENDS:rust-event-listener-strategy-devel = " \
 cargo \
 rust \
 rust-event-listener-devel \
 rust-pin-project-lite+default-devel \
 "
