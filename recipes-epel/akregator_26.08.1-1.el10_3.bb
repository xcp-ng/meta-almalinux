# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akregator"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 akregator \
 akregator-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/akregator-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a01e39a8866789a8daf9b713b4a84c82248ef7478ebafaaa1475bc8d7546ac6f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator;unpack=0"
SRC_URI[x86_64_v2_akregator.sha256sum] = "5ec0da0d9cec32d51ae2eb882cea061e28d64d472167edcda8c21c3ac9deaad0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akregator-libs-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akregator-libs;unpack=0"
SRC_URI[x86_64_v2_akregator-libs.sha256sum] = "d5b00c510b82a530791dc2a35f452105037d8c30273de403ea445d9ef5deacdb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akregator-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akregator;unpack=0"
SRC_URI[aarch64_akregator.sha256sum] = "399e2d0024bc8883eaaf145637570e50208ab7df113b08cd9d6274a3aa365787"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/a/akregator-libs-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_akregator-libs;unpack=0"
SRC_URI[aarch64_akregator-libs.sha256sum] = "1b6145d468aa756400bbeaa1bdd7c0455c4ab768c29a48b45a88228208ccec17"

RDEPENDS:akregator = " \
 akregator-libs \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:akregator-libs = " \
 akregator \
 glibc \
 grantleetheme \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktexttemplate \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syndication \
 kontactinterface \
 ktextaddons-qt6 \
 libgcc \
 libkdepim \
 libstdc++ \
 messagelib \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
