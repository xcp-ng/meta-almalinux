# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spamassassin-iXhash2"
PV = "4.00"
PR = "6.el10_3"
PACKAGES = " \
 spamassassin-iXhash2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spamassassin-iXhash2-4.00-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eed72f345e607fbaecb95278bdfdf81799fbb6dac6ee345285d34b72a3d093fe"

URI_x86_64_v2_spamassassin-iXhash2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamassassin-iXhash2-4.00-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_spamassassin-iXhash2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spamassassin-iXhash2}"
SRC_URI[x86_64_v2_spamassassin-iXhash2.sha256sum] = "1f220ffb926c38f358e10a262cdf21ae066ef4d42e7067abf2813acf064e833a"

URI_aarch64_spamassassin-iXhash2 = "${EPEL_MIRROR}/aarch64/Packages/s/spamassassin-iXhash2-4.00-6.el10_3.noarch.rpm;name=aarch64_spamassassin-iXhash2;unpack=0"
SRC_URI:append = " ${URI_aarch64_spamassassin-iXhash2}"
SRC_URI[aarch64_spamassassin-iXhash2.sha256sum] = "66245e8f4f8fbd9d74ac639b613de360ef1cf95fcdeb5e6bec07210096913c62"

RDEPENDS:spamassassin-iXhash2 = " \
 perl-Digest-MD5 \
 perl-libs \
 perl-vars \
 spamassassin \
 "
