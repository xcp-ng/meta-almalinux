# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-http-send-reqwest"
PV = "4.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-http-send-reqwest+default-devel \
 rust-reqsign-http-send-reqwest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-http-send-reqwest-4.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "351e1b5a8fdfb0c2b9ad705bde01c64879eb8ec106a0aab80c039e9f1eaa0e61"

URI_x86_64_v2_rust-reqsign-http-send-reqwest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-http-send-reqwest+default-devel-4.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-http-send-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-http-send-reqwest+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-http-send-reqwest+default-devel.sha256sum] = "d49a1100696bb38fbf844f71028987ba79d35f69b3d493683e67a6d0a687c13a"

URI_x86_64_v2_rust-reqsign-http-send-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-http-send-reqwest-devel-4.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-http-send-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-http-send-reqwest-devel}"
SRC_URI[x86_64_v2_rust-reqsign-http-send-reqwest-devel.sha256sum] = "242f0a667eed3fc237c4b36935352bf45b5aa3befc7cbd0b2dd98248f2e4f5f7"

URI_aarch64_rust-reqsign-http-send-reqwest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-http-send-reqwest+default-devel-4.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-http-send-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-http-send-reqwest+default-devel}"
SRC_URI[aarch64_rust-reqsign-http-send-reqwest+default-devel.sha256sum] = "a23ab1e9986e0b04930cbfabd4441b38b19da46c27a93a0ca73762891ae5c4b2"

URI_aarch64_rust-reqsign-http-send-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-http-send-reqwest-devel-4.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-http-send-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-http-send-reqwest-devel}"
SRC_URI[aarch64_rust-reqsign-http-send-reqwest-devel.sha256sum] = "49bf1854d5f20e41b290ebc83441db39bfac799276e5dccfc47c05e701e1f284"

RDEPENDS:rust-reqsign-http-send-reqwest+default-devel = " \
 cargo \
 rust-reqsign-http-send-reqwest-devel \
 "
RDEPENDS:rust-reqsign-http-send-reqwest-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body-util+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqwest-devel \
 "
