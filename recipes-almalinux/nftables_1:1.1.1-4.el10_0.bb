# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nftables"
PE = "1"
PV = "1.1.1"
PR = "4.el10_0"
PACKAGES = " \
 nftables \
 nftables-devel \
 python3-nftables \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nftables-1.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5557665a3447bf6833b089ecfa59d28c0ea9e59e4cec0f9c94307b9e23ab8b59"

URI_x86_64_v2_nftables = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/nftables-1.1.1-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nftables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nftables}"
SRC_URI[x86_64_v2_nftables.sha256sum] = "ecdbdfb488a04b3bb88159b99ee298ac1de833dea5f73ee8d045f2cc9a4b3509"

URI_x86_64_v2_nftables-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nftables-devel-1.1.1-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_nftables-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nftables-devel}"
SRC_URI[x86_64_v2_nftables-devel.sha256sum] = "cbd7abdfd92444c059ef5be1fcd200f033848f171d5dd830ebe022a60819a4ec"

URI_x86_64_v2_python3-nftables = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-nftables-1.1.1-4.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-nftables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-nftables}"
SRC_URI[x86_64_v2_python3-nftables.sha256sum] = "c5e96971cb817c862da2680a018cbab4c602326df6f1fbbfc85531a032906e73"

URI_aarch64_nftables = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/nftables-1.1.1-4.el10_0.aarch64.rpm;name=aarch64_nftables;unpack=0"
SRC_URI:append = " ${URI_aarch64_nftables}"
SRC_URI[aarch64_nftables.sha256sum] = "e9a63a91d99ed6e53372045a7d241d9a8500db45cb5ff55c14b09e00c0b25adb"

URI_aarch64_nftables-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nftables-devel-1.1.1-4.el10_0.aarch64.rpm;name=aarch64_nftables-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nftables-devel}"
SRC_URI[aarch64_nftables-devel.sha256sum] = "fcfaa52ab25194ef04c415e59f0fac77b9506cc49cdd4244d0b3011af974d8f7"

URI_aarch64_python3-nftables = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-nftables-1.1.1-4.el10_0.aarch64.rpm;name=aarch64_python3-nftables;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-nftables}"
SRC_URI[aarch64_python3-nftables.sha256sum] = "bed07e9a86df23b22dc83eed659154308e4e07d2158b7b59b34561f84083aa67"

RDEPENDS:nftables = " \
 bash \
 glibc \
 gmp \
 iptables-libs \
 jansson \
 libmnl \
 libnftnl \
 readline \
 "
RDEPENDS:nftables-devel = " \
 nftables \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-nftables = " \
 nftables \
 python3 \
 "
