# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-c"
PV = "0.10.19"
PR = "2.el10_2"
PACKAGES = " \
 cargo-c \
 rust-cargo-c+default-devel \
 rust-cargo-c-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-c-0.10.19-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3010017cc287eb543e3293114cac02e97133917c9dd94f10307ce62da4882b4f"

URI_x86_64_v2_cargo-c = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cargo-c-0.10.19-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cargo-c;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cargo-c}"
SRC_URI[x86_64_v2_cargo-c.sha256sum] = "cf2925abbf87147e08ebbddd28bf3f8b6e0850a40cc9f01e569ac76843bb63de"

URI_x86_64_v2_rust-cargo-c+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-c+default-devel-0.10.19-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-c+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-c+default-devel.sha256sum] = "2121c18f4a38b6746b51525776210b3f59df1c9d27d53fee809619c2cf9f2c3d"

URI_x86_64_v2_rust-cargo-c-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-c-devel-0.10.19-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-c-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-c-devel}"
SRC_URI[x86_64_v2_rust-cargo-c-devel.sha256sum] = "b3cfc3b588ef39718d837b320e74e0af7642041264320436cd55a5d932e9a46d"

URI_aarch64_cargo-c = "${EPEL_MIRROR}/aarch64/Packages/c/cargo-c-0.10.19-2.el10_2.aarch64.rpm;name=aarch64_cargo-c;unpack=0"
SRC_URI:append = " ${URI_aarch64_cargo-c}"
SRC_URI[aarch64_cargo-c.sha256sum] = "457db32c06761bae6471708b8dfd98221ec66371e3e20a285aaf46ac972cc038"

URI_aarch64_rust-cargo-c+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-c+default-devel-0.10.19-2.el10_2.noarch.rpm;name=aarch64_rust-cargo-c+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-c+default-devel}"
SRC_URI[aarch64_rust-cargo-c+default-devel.sha256sum] = "2fb7e99b2ed605034b7ddddba2a5fd7ee60018ec1ac7ca450e421c8f6e093484"

URI_aarch64_rust-cargo-c-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-c-devel-0.10.19-2.el10_2.noarch.rpm;name=aarch64_rust-cargo-c-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-c-devel}"
SRC_URI[aarch64_rust-cargo-c-devel.sha256sum] = "d7df31ed94dd81d3d19095862e2545933a9f044aafbc615140c0d3aa6d529675"

RDEPENDS:cargo-c = " \
 glibc \
 libgcc \
 libssh2 \
 openssl-libs \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:rust-cargo-c+default-devel = " \
 cargo \
 rust-cargo-c-devel \
 "
RDEPENDS:rust-cargo-c-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-cargo+default-devel \
 rust-cargo-platform+default-devel \
 rust-cargo-util+default-devel \
 rust-cbindgen-devel \
 rust-cc+default-devel \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+string-devel \
 rust-clap+wrap_help-devel \
 rust-glob+default-devel \
 rust-implib+default-devel \
 rust-itertools+default-devel \
 rust-log+default-devel \
 rust-object+pe-devel \
 rust-object+read_core-devel \
 rust-object+std-devel \
 rust-object-devel \
 rust-regex+default-devel \
 rust-semver+default-devel \
 rust-serde+default-devel \
 rust-serde_derive+default-devel \
 rust-serde_json+default-devel \
 rust-toml0.9+default-devel \
 "
