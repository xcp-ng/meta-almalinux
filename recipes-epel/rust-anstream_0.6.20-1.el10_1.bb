# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstream"
PV = "0.6.20"
PR = "1.el10_1"
PACKAGES = " \
 rust-anstream+auto-devel \
 rust-anstream+default-devel \
 rust-anstream+test-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstream-0.6.20-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "368ea7b41c9b7d7770056046eec9227d9df1feeca959713d0b60efee454c9417"

URI_x86_64_v2_rust-anstream+auto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+auto-devel-0.6.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+auto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+auto-devel}"
SRC_URI[x86_64_v2_rust-anstream+auto-devel.sha256sum] = "170524aa722a0a3261b30f1ec3dc233fa3709a25f68dfba48dd9aa01547a84ca"

URI_x86_64_v2_rust-anstream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+default-devel-0.6.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+default-devel}"
SRC_URI[x86_64_v2_rust-anstream+default-devel.sha256sum] = "c42b642fa1ed27f0f44d754326a519fbdc0dca5d7f0e36dcf23313185a226f6a"

URI_x86_64_v2_rust-anstream+test-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+test-devel-0.6.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+test-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+test-devel}"
SRC_URI[x86_64_v2_rust-anstream+test-devel.sha256sum] = "c81813dc6293f339fd794cae02511e79a94131fe51fb2e545d0df20c3b7af0dc"

URI_x86_64_v2_rust-anstream+wincon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream+wincon-devel-0.6.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream+wincon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream+wincon-devel}"
SRC_URI[x86_64_v2_rust-anstream+wincon-devel.sha256sum] = "ea7ae31f0f29413ac9f00af5413857f4fe7c994ce7a56e474dfaa7f0e3ef7c46"

URI_x86_64_v2_rust-anstream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstream-devel-0.6.20-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstream-devel}"
SRC_URI[x86_64_v2_rust-anstream-devel.sha256sum] = "54faf797545a7ffaed145a8976ccdc530957a6104b31e80141e60768706be3ef"

URI_aarch64_rust-anstream+auto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+auto-devel-0.6.20-1.el10_1.noarch.rpm;name=aarch64_rust-anstream+auto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+auto-devel}"
SRC_URI[aarch64_rust-anstream+auto-devel.sha256sum] = "673b724ed1a470c168814b95297e589da5ab86e970ef1be4cdf64b0f18bfbf00"

URI_aarch64_rust-anstream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+default-devel-0.6.20-1.el10_1.noarch.rpm;name=aarch64_rust-anstream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+default-devel}"
SRC_URI[aarch64_rust-anstream+default-devel.sha256sum] = "615e39bf73393b130d00eb8b7fc8a4ac5bd777f908f9c97ab08a6de1d95dd915"

URI_aarch64_rust-anstream+test-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+test-devel-0.6.20-1.el10_1.noarch.rpm;name=aarch64_rust-anstream+test-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+test-devel}"
SRC_URI[aarch64_rust-anstream+test-devel.sha256sum] = "bce5a5411f53a45929a6667093cd0b445d27e5a8e0b59bcb71f606fee1eebe7d"

URI_aarch64_rust-anstream+wincon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream+wincon-devel-0.6.20-1.el10_1.noarch.rpm;name=aarch64_rust-anstream+wincon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream+wincon-devel}"
SRC_URI[aarch64_rust-anstream+wincon-devel.sha256sum] = "dd7ef6726f1a2247711db4f5cc8bc4613466cd5bc8dfacf029dd234f0426dae8"

URI_aarch64_rust-anstream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstream-devel-0.6.20-1.el10_1.noarch.rpm;name=aarch64_rust-anstream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstream-devel}"
SRC_URI[aarch64_rust-anstream-devel.sha256sum] = "36d21c6233dbf4536683bd8bde4cf540cce555377e6ef830673825a2f3631032"

RDEPENDS:rust-anstream+auto-devel = " \
 cargo \
 rust-anstream-devel \
 rust-anstyle-query+default-devel \
 "
RDEPENDS:rust-anstream+default-devel = " \
 cargo \
 rust-anstream+auto-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 "
RDEPENDS:rust-anstream+test-devel = " \
 cargo \
 rust-anstream-devel \
 "
RDEPENDS:rust-anstream+wincon-devel = " \
 cargo \
 rust-anstream-devel \
 "
RDEPENDS:rust-anstream-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-anstyle-parse+default-devel \
 rust-colorchoice+default-devel \
 rust-utf8parse+default-devel \
 "
