# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html5ever"
PV = "0.35.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-html5ever+default-devel \
 rust-html5ever+trace_tokenizer-devel \
 rust-html5ever-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html5ever-0.35.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21c5b1217993d615a1fa3fdaa8c2bb2e4d2907aa6cefa698809680e00ec0a235"

URI_x86_64_v2_rust-html5ever+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever+default-devel-0.35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever+default-devel}"
SRC_URI[x86_64_v2_rust-html5ever+default-devel.sha256sum] = "1f0f0a779f589674f18b501764f13ea6bdac9a97316904a6afae48679c696ea4"

URI_x86_64_v2_rust-html5ever+trace_tokenizer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever+trace_tokenizer-devel-0.35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever+trace_tokenizer-devel}"
SRC_URI[x86_64_v2_rust-html5ever+trace_tokenizer-devel.sha256sum] = "40c6d030adb7793c1b1adbddd6c259d758b594429f5a9cbc3dba2a3b8b005649"

URI_x86_64_v2_rust-html5ever-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html5ever-devel-0.35.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html5ever-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html5ever-devel}"
SRC_URI[x86_64_v2_rust-html5ever-devel.sha256sum] = "edf996d29e45a962fa653fda118aca9e1195e4d2fab2a2901c21f93178074f6a"

URI_aarch64_rust-html5ever+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever+default-devel-0.35.0-1.el10_2.noarch.rpm;name=aarch64_rust-html5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever+default-devel}"
SRC_URI[aarch64_rust-html5ever+default-devel.sha256sum] = "ac5b526d081359d6c4af78faf26edec98c1cb229d1aeb0aaf7eb779a582b3544"

URI_aarch64_rust-html5ever+trace_tokenizer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever+trace_tokenizer-devel-0.35.0-1.el10_2.noarch.rpm;name=aarch64_rust-html5ever+trace_tokenizer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever+trace_tokenizer-devel}"
SRC_URI[aarch64_rust-html5ever+trace_tokenizer-devel.sha256sum] = "ab4e851dca115ca6c0f6cab58ba0a382779f7c12650f9acb1534af47a54de3b5"

URI_aarch64_rust-html5ever-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html5ever-devel-0.35.0-1.el10_2.noarch.rpm;name=aarch64_rust-html5ever-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html5ever-devel}"
SRC_URI[aarch64_rust-html5ever-devel.sha256sum] = "ce75f2e03cb206c9d49c4bb18d10b9329ed24468a21f2e535abe8c70dac34cca"

RDEPENDS:rust-html5ever+default-devel = " \
 cargo \
 rust-html5ever-devel \
 "
RDEPENDS:rust-html5ever+trace_tokenizer-devel = " \
 cargo \
 rust-html5ever-devel \
 "
RDEPENDS:rust-html5ever-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-markup5ever+default-devel \
 rust-match_token+default-devel \
 "
