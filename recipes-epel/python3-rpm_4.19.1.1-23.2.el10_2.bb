# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-rpm"
PV = "4.19.1.1"
PR = "23.2.el10_2"
PACKAGES = " \
 python3.13-rpm \
 python3.14-rpm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-rpm-4.19.1.1-23.2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8bd4ae801a85d4e26c7954160957d263cabe101cc94e60db32a422b8ddadaa85"

URI_x86_64_v2_python3.13-rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.13-rpm-4.19.1.1-23.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.13-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.13-rpm}"
SRC_URI[x86_64_v2_python3.13-rpm.sha256sum] = "3bbf95970f6fc2d7234d1b6c062248adb26d6480f6035f2ee9295e4fe4050807"

URI_x86_64_v2_python3.14-rpm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3.14-rpm-4.19.1.1-23.2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3.14-rpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-rpm}"
SRC_URI[x86_64_v2_python3.14-rpm.sha256sum] = "86bcbc767f6451f92db5297b4753ae6cee9364f4f8e370c5b163fc552bf1920d"

URI_aarch64_python3.13-rpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3.13-rpm-4.19.1.1-23.2.el10_2.aarch64.rpm;name=aarch64_python3.13-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.13-rpm}"
SRC_URI[aarch64_python3.13-rpm.sha256sum] = "2195eee38bb26b02a1fc74d4dfaa7746e2a558254daf5811e0b989d3b1ad25fa"

URI_aarch64_python3.14-rpm = "${EPEL_MIRROR}/aarch64/Packages/p/python3.14-rpm-4.19.1.1-23.2.el10_2.aarch64.rpm;name=aarch64_python3.14-rpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-rpm}"
SRC_URI[aarch64_python3.14-rpm.sha256sum] = "2abec843c87718bea0bd225735ec25f6df34c4b8cf62bdd870a199124abf2e0d"

RDEPENDS:python3.13-rpm = " \
 glibc \
 python3.13 \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
RDEPENDS:python3.14-rpm = " \
 glibc \
 python3.14 \
 rpm-build-libs \
 rpm-libs \
 rpm-sign-libs \
 "
