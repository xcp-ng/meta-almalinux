# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netplan"
PV = "1.2.1"
PR = "2.el10_3"
PACKAGES = " \
 netplan \
 netplan-default-backend-NetworkManager \
 netplan-default-backend-networkd \
 netplan-devel \
 netplan-libs \
 python3-netplan \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/netplan-1.2.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e5d776085f617d332b830a39f5fa7d162f9a73641586b7130aae9031f861b35a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-1.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netplan;unpack=0"
SRC_URI[x86_64_v2_netplan.sha256sum] = "94c3974f5a98a4b032ccc35c1e74994df357265b62236198cb6abde85b76ca5d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-default-backend-NetworkManager-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_netplan-default-backend-NetworkManager;unpack=0"
SRC_URI[x86_64_v2_netplan-default-backend-NetworkManager.sha256sum] = "480f384f38b1622910cfe63bfcd688c63afac96b91c62153192c381deb26664c"
RPROVIDES:netplan-default-backend-NetworkManager:append:x86_64_v2 = " virtual/netplan-default-backend"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-default-backend-networkd-1.2.1-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_netplan-default-backend-networkd;unpack=0"
SRC_URI[x86_64_v2_netplan-default-backend-networkd.sha256sum] = "9cc9ead059323d798b22f77107a1fd60519b6f845134a26d5fdb6dbf619d216d"
RPROVIDES:netplan-default-backend-networkd:append:x86_64_v2 = " virtual/netplan-default-backend"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-devel-1.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netplan-devel;unpack=0"
SRC_URI[x86_64_v2_netplan-devel.sha256sum] = "787466cb29444ff8cd6430e3df34f351be614b3554d469f96c6bf3800afad30e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netplan-libs-1.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netplan-libs;unpack=0"
SRC_URI[x86_64_v2_netplan-libs.sha256sum] = "1a611e94310677a58b916d12393f9e09612ce6dd103482e5619ccf1d7196aeb6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-netplan-1.2.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-netplan;unpack=0"
SRC_URI[x86_64_v2_python3-netplan.sha256sum] = "a2a6360d46526f31e2bff5cc905838bc11c0934a83cb3631f3ecf0b205bfa16e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netplan-1.2.1-2.el10_3.aarch64.rpm;name=aarch64_netplan;unpack=0"
SRC_URI[aarch64_netplan.sha256sum] = "5f3ec38ae7fd793515025830fecd4115b6cb1ea669e717a90ab3e2dcb567418b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netplan-default-backend-NetworkManager-1.2.1-2.el10_3.noarch.rpm;name=aarch64_netplan-default-backend-NetworkManager;unpack=0"
SRC_URI[aarch64_netplan-default-backend-NetworkManager.sha256sum] = "4909ae6fa721c015b0818e19c1e8801c4e183b36fbd59198756156078296914a"
RPROVIDES:netplan-default-backend-NetworkManager:append:aarch64 = " virtual/netplan-default-backend"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netplan-default-backend-networkd-1.2.1-2.el10_3.noarch.rpm;name=aarch64_netplan-default-backend-networkd;unpack=0"
SRC_URI[aarch64_netplan-default-backend-networkd.sha256sum] = "37bf0614c2e51df17e3a6370adc12fdefb2bfadc15e160ce0b04cf45a064f557"
RPROVIDES:netplan-default-backend-networkd:append:aarch64 = " virtual/netplan-default-backend"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netplan-devel-1.2.1-2.el10_3.aarch64.rpm;name=aarch64_netplan-devel;unpack=0"
SRC_URI[aarch64_netplan-devel.sha256sum] = "c541f42ff15fa75d68b5428b9ab6fbd755aeb821c72a0467963cc1f560d276d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netplan-libs-1.2.1-2.el10_3.aarch64.rpm;name=aarch64_netplan-libs;unpack=0"
SRC_URI[aarch64_netplan-libs.sha256sum] = "917dea27a68d262c5137a6c9964b5f8e9c80a6779341175e84f4961c0e59c531"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-netplan-1.2.1-2.el10_3.aarch64.rpm;name=aarch64_python3-netplan;unpack=0"
SRC_URI[aarch64_python3-netplan.sha256sum] = "353a13e3990bfb3974ba7047d353fb6d34a2b6ed16cdd2c5cded504cdf215d12"

RDEPENDS:netplan = " \
 dbus-common \
 glib2 \
 glibc \
 iproute \
 libgcc \
 netplan-libs \
 python3 \
 python3-netifaces \
 python3-netplan \
 python3-pyyaml \
 systemd-libs \
 virtual/netplan-default-backend \
 "
RDEPENDS:netplan-default-backend-NetworkManager = " \
 NetworkManager \
 NetworkManager-config-server \
 netplan \
 "
RDEPENDS:netplan-default-backend-networkd = " \
 netplan \
 systemd-networkd \
 "
RDEPENDS:netplan-devel = " \
 glib2-devel \
 libuuid-devel \
 libyaml-devel \
 netplan-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:netplan-libs = " \
 glib2 \
 glibc \
 libgcc \
 libuuid \
 libyaml \
 "
RDEPENDS:python3-netplan = " \
 glibc \
 netplan-libs \
 python3 \
 python3-cffi \
 "
