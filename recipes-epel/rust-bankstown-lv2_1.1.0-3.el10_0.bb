# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bankstown-lv2"
PV = "1.1.0"
PR = "3.el10_0"
PACKAGES = " \
 lv2-bankstown \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bankstown-lv2-1.1.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "89c3e91326058e9aefeca3d5419597437cfcd0f30b0494e2690fd37cc658fbdf"

URI_x86_64_v2_lv2-bankstown = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lv2-bankstown-1.1.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lv2-bankstown;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lv2-bankstown}"
SRC_URI[x86_64_v2_lv2-bankstown.sha256sum] = "9ca5e40f031c92dfaf0505c652e23254a711165cad28ee762eff7d3d7e384bda"

URI_aarch64_lv2-bankstown = "${EPEL_MIRROR}/aarch64/Packages/l/lv2-bankstown-1.1.0-3.el10_0.aarch64.rpm;name=aarch64_lv2-bankstown;unpack=0"
SRC_URI:append = " ${URI_aarch64_lv2-bankstown}"
SRC_URI[aarch64_lv2-bankstown.sha256sum] = "44a1749842896285bdd833d7651a308bb4819544bb9f2d1afc9d768b3168e8b9"

RDEPENDS:lv2-bankstown = " \
 glibc \
 libgcc \
 lv2 \
 "
