# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nvtop"
PV = "3.3.2"
PR = "1.el10_3"
PACKAGES = " \
 nvtop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nvtop-3.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b31f93002969d02ddd7cd90484bc9bae5cd2e3c94f70b618f654c15d05900cf"

URI_x86_64_v2_nvtop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nvtop-3.3.2-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nvtop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nvtop}"
SRC_URI[x86_64_v2_nvtop.sha256sum] = "76d7d12455eb63dbaae62f626e2784c9e52367183c81c6da29837f9f3c04386f"

URI_aarch64_nvtop = "${EPEL_MIRROR}/aarch64/Packages/n/nvtop-3.3.2-1.el10_3.aarch64.rpm;name=aarch64_nvtop;unpack=0"
SRC_URI:append = " ${URI_aarch64_nvtop}"
SRC_URI[aarch64_nvtop.sha256sum] = "681b1788a65838590fb53857019e26206fde2f9df249342fb5a80a4f648c463c"

RDEPENDS:nvtop = " \
 glibc \
 hicolor-icon-theme \
 ncurses-libs \
 systemd-libs \
 "
