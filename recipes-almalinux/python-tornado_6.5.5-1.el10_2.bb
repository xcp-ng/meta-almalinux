# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tornado"
PV = "6.5.5"
PR = "1.el10_2"
PACKAGES = " \
 python3-tornado \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-tornado-6.5.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6524796c3fdf88fc45d7cf1c358f8368677b0d9ecfccb92ca7445170cc8dfd88"

URI_x86_64_v2_python3-tornado = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-tornado-6.5.5-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-tornado;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tornado}"
SRC_URI[x86_64_v2_python3-tornado.sha256sum] = "bea5502d3a4a8cd6e8b8c5f35b98b2b05ddfd7ae7b06c436f40a10d07f929e70"

URI_aarch64_python3-tornado = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-tornado-6.5.5-1.el10_2.aarch64.rpm;name=aarch64_python3-tornado;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tornado}"
SRC_URI[aarch64_python3-tornado.sha256sum] = "2c7978345b875f667e1ef6d83fe3c9cd5446d27328df86a8726258330b720984"

RDEPENDS:python3-tornado = " \
 glibc \
 python3 \
 "
