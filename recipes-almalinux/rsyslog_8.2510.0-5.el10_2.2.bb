# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsyslog"
PV = "8.2510.0"
PR = "5.el10_2.2"
PACKAGES = " \
 rsyslog \
 rsyslog-crypto \
 rsyslog-doc \
 rsyslog-elasticsearch \
 rsyslog-gnutls \
 rsyslog-gssapi \
 rsyslog-kafka \
 rsyslog-mmaudit \
 rsyslog-mmfields \
 rsyslog-mmjsonparse \
 rsyslog-mmkubernetes \
 rsyslog-mmnormalize \
 rsyslog-mmsnmptrapd \
 rsyslog-mysql \
 rsyslog-omamqp1 \
 rsyslog-openssl \
 rsyslog-pgsql \
 rsyslog-relp \
 rsyslog-snmp \
 rsyslog-udpspoof \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rsyslog-8.2510.0-5.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a9837461e18928c9aa110594d9dbbd3d845fe4b9540a88223b14d34414f4f045"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog;unpack=0"
SRC_URI[x86_64_v2_rsyslog.sha256sum] = "beb712e49a6ed857c266ae8b294d5341b1a113be3afd85f3b439753b304ebb61"
RPROVIDES:rsyslog:append:x86_64_v2 = " virtual/syslog"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-crypto-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-crypto;unpack=0"
SRC_URI[x86_64_v2_rsyslog-crypto.sha256sum] = "938347beda97f1a59387a5cbc3d52b2425d1908e338108d94a1043213ce39f35"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-doc-8.2510.0-5.el10_2.2.noarch.rpm;name=x86_64_v2_rsyslog-doc;unpack=0"
SRC_URI[x86_64_v2_rsyslog-doc.sha256sum] = "d0db75ed47fc8d888cb8c7c423f927c07b67ef296633a799feaa348cac1a5e74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-elasticsearch-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-elasticsearch;unpack=0"
SRC_URI[x86_64_v2_rsyslog-elasticsearch.sha256sum] = "7954c896e0efeb9e5783142d36d06ef84509bfb3f012fb43ce4d2537222b9466"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gnutls-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gnutls;unpack=0"
SRC_URI[x86_64_v2_rsyslog-gnutls.sha256sum] = "d9f3dcf46541e17416a211783480e0aa40c3d59683bbfeb00ef4d9ae445e49c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gssapi-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gssapi;unpack=0"
SRC_URI[x86_64_v2_rsyslog-gssapi.sha256sum] = "d18923fdf16af8412f5fc17e5264260507d9b4a8e613943dc75fe7c9508bf2d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-kafka-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-kafka;unpack=0"
SRC_URI[x86_64_v2_rsyslog-kafka.sha256sum] = "f90196e0e0a71f0f9a2ec080435ac0732106cf526182c42b6ff45f94471d8e73"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmaudit-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmaudit;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmaudit.sha256sum] = "5273d81bb31ac3376f54ef4920fa8c64ba4b57ba33623da3a00061ef4d066be1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmfields-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmfields;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmfields.sha256sum] = "64874563c20924371810d8ec4dd77c91ee3771834a161bed74dcf57bfc1186ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmjsonparse-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmjsonparse;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmjsonparse.sha256sum] = "a0ffd2c95f9609bda2276c8c472f7b1c2cd8ac9c8026a2045dd867133b345a4a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmkubernetes-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmkubernetes;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmkubernetes.sha256sum] = "33e93d0e61aeb5e49da1d7a32942f87bf097af7f81b2bf7ae01b6c61db13888a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmnormalize-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmnormalize;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmnormalize.sha256sum] = "23b488b3f2f030764387d419b10ec8079983b83b79d54847b938bde796aca1dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmsnmptrapd-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mmsnmptrapd.sha256sum] = "d5500357f4479beb40f5f5ee557a60a92c2f3f78d2a097cdbe446cdd1ae3a2d2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mysql-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mysql;unpack=0"
SRC_URI[x86_64_v2_rsyslog-mysql.sha256sum] = "28a3b0a5fbbd8c9f5a14530c32594f13e2275880cae387a22218b2d5adaddc23"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-omamqp1-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-omamqp1;unpack=0"
SRC_URI[x86_64_v2_rsyslog-omamqp1.sha256sum] = "ca622904d07583136b7da2e3e75d7ffcbad90b136037c6177d736af2e7c46233"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-openssl-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-openssl;unpack=0"
SRC_URI[x86_64_v2_rsyslog-openssl.sha256sum] = "6a2f7224fff4047129ef991a16273ef782e58ccc7734cc6feaf883688413ca9b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-pgsql-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-pgsql;unpack=0"
SRC_URI[x86_64_v2_rsyslog-pgsql.sha256sum] = "081ef5ad23f0b3f93388def11e09da655d772f4b0d2bf7c2f5e22f759255a4c1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-relp-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-relp;unpack=0"
SRC_URI[x86_64_v2_rsyslog-relp.sha256sum] = "fc7fb3e67595a9d500bb9bc6c9e0cff619ed02a2862e3fa3d69a90da84091148"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-snmp-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-snmp;unpack=0"
SRC_URI[x86_64_v2_rsyslog-snmp.sha256sum] = "7d8df4d5a7635c931f6f24636957255fa55c37b660e039615b722aad00ba5e62"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-udpspoof-8.2510.0-5.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_rsyslog-udpspoof;unpack=0"
SRC_URI[x86_64_v2_rsyslog-udpspoof.sha256sum] = "a4ddd0f759af576fd0b7d5a972ee59b6280eddf8e3a11203a3f6a39cc6ed7867"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog;unpack=0"
SRC_URI[aarch64_rsyslog.sha256sum] = "a3e147075e2ce41eecbf44527f9965b8eb2db10f08d1c7c125adfee967efe88d"
RPROVIDES:rsyslog:append:aarch64 = " virtual/syslog"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-crypto-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-crypto;unpack=0"
SRC_URI[aarch64_rsyslog-crypto.sha256sum] = "3bcb49d3a4becd1ec4ac96f77510ac2a2ee115279a87e0032b745ff0f02a119f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-doc-8.2510.0-5.el10_2.2.noarch.rpm;name=aarch64_rsyslog-doc;unpack=0"
SRC_URI[aarch64_rsyslog-doc.sha256sum] = "d0db75ed47fc8d888cb8c7c423f927c07b67ef296633a799feaa348cac1a5e74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-elasticsearch-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-elasticsearch;unpack=0"
SRC_URI[aarch64_rsyslog-elasticsearch.sha256sum] = "86aeac847ad606eb37579eee1b9d422b56915aba38f6bd4fe95b85f566b28675"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gnutls-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-gnutls;unpack=0"
SRC_URI[aarch64_rsyslog-gnutls.sha256sum] = "84ce3cccd3b215c99723837ec40b0282f0cf0413313f673033fe2ed030c28ce1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gssapi-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-gssapi;unpack=0"
SRC_URI[aarch64_rsyslog-gssapi.sha256sum] = "f4fdcd37a1407674a5b3f6ff85a12cd5f360007f9b40f2331f5fe885fd6c6858"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-kafka-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-kafka;unpack=0"
SRC_URI[aarch64_rsyslog-kafka.sha256sum] = "657a64e07b467b748e9ab4e8980f2f36bfd07b8b92fd25538482dbe0f67f280d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmaudit-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-mmaudit;unpack=0"
SRC_URI[aarch64_rsyslog-mmaudit.sha256sum] = "613bebb74ccaea773e9c5d35b3c7e9f8304d5bb295168a9adabde7650b6a24b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmfields-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-mmfields;unpack=0"
SRC_URI[aarch64_rsyslog-mmfields.sha256sum] = "a356d6e940a3cdffc5eaa0527e5b7859d3212acc2423efcedb88c238596c1a63"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmjsonparse-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-mmjsonparse;unpack=0"
SRC_URI[aarch64_rsyslog-mmjsonparse.sha256sum] = "377e468067cf5630fc0bba2c795a1c94402d41a8c9cee30748ff5851d37fe246"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmkubernetes-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-mmkubernetes;unpack=0"
SRC_URI[aarch64_rsyslog-mmkubernetes.sha256sum] = "d5784dd4e4c7ffccfed1730eae2678f68041c144d68410522139edb1af1c3618"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmnormalize-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-mmnormalize;unpack=0"
SRC_URI[aarch64_rsyslog-mmnormalize.sha256sum] = "dee68afb54cdab6aedc3029079e02be71f882b688d9a5336d4170c03fa93575a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmsnmptrapd-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI[aarch64_rsyslog-mmsnmptrapd.sha256sum] = "eb88e4540879fc2ccd6792d8061b25a57eb9d9af069262a4e47def17090d2b56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mysql-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-mysql;unpack=0"
SRC_URI[aarch64_rsyslog-mysql.sha256sum] = "3af40aef6197a9d48ec189fc4505f53c4808256671c2af02bd29d57c5efc32a6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-omamqp1-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-omamqp1;unpack=0"
SRC_URI[aarch64_rsyslog-omamqp1.sha256sum] = "fdc971de536742687aba0791f9dbb240e6741d214fe20445dc54918e81645df9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-openssl-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-openssl;unpack=0"
SRC_URI[aarch64_rsyslog-openssl.sha256sum] = "1f36b60a5e936a494c64a6f872a5665248bf375d70dd02f8f333a3da75a9121d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-pgsql-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-pgsql;unpack=0"
SRC_URI[aarch64_rsyslog-pgsql.sha256sum] = "a1ec00072d94d6b56e5fd989d21125eccf206d091e3b6d909f10a6f65866f41d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-relp-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-relp;unpack=0"
SRC_URI[aarch64_rsyslog-relp.sha256sum] = "84e4acb9f61fe23da43139ffdec7aebd7feabac49e32412c6cf99d614c6c701a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-snmp-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-snmp;unpack=0"
SRC_URI[aarch64_rsyslog-snmp.sha256sum] = "c385f293a6097ed4dc186d7b651905cb7440ff212e30ebc100588e2e234446e4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-udpspoof-8.2510.0-5.el10_2.2.aarch64.rpm;name=aarch64_rsyslog-udpspoof;unpack=0"
SRC_URI[aarch64_rsyslog-udpspoof.sha256sum] = "50acc9a2ee9f74f3a9c396019c4a450aa6804bc572cbe0c37688958025a2264d"

RDEPENDS:rsyslog = " \
 bash \
 glibc \
 libcap-ng \
 libestr \
 libfastjson \
 libgcc \
 libuuid \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:rsyslog-crypto = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-doc = " \
 "
RDEPENDS:rsyslog-elasticsearch = " \
 glibc \
 libcap-ng \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-gnutls = " \
 glibc \
 gnutls \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-gssapi = " \
 glibc \
 krb5-libs \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-kafka = " \
 glibc \
 libcap-ng \
 librdkafka \
 rsyslog \
 "
RDEPENDS:rsyslog-mmaudit = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmfields = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmjsonparse = " \
 glibc \
 libcap-ng \
 libfastjson \
 rsyslog \
 "
RDEPENDS:rsyslog-mmkubernetes = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-mmnormalize = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 "
RDEPENDS:rsyslog-mmsnmptrapd = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mysql = " \
 glibc \
 mariadb-connector-c \
 rsyslog \
 "
RDEPENDS:rsyslog-omamqp1 = " \
 cyrus-sasl-lib \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-openssl = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-pgsql = " \
 glibc \
 libcap-ng \
 libpq \
 rsyslog \
 "
RDEPENDS:rsyslog-relp = " \
 glibc \
 libcap-ng \
 librelp \
 rsyslog \
 "
RDEPENDS:rsyslog-snmp = " \
 glibc \
 libcap-ng \
 net-snmp-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-udpspoof = " \
 glibc \
 libcap-ng \
 libnet \
 rsyslog \
 "
