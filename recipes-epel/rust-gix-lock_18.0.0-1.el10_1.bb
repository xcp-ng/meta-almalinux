# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-lock"
PV = "18.0.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-lock+default-devel \
 rust-gix-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-lock-18.0.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17b21a6651f479a522e924e987adf8371055f7d35f98c784817903e4bca2ad0a"

URI_x86_64_v2_rust-gix-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-lock+default-devel-18.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-lock+default-devel}"
SRC_URI[x86_64_v2_rust-gix-lock+default-devel.sha256sum] = "f441f64d16e13fd7fcc29acfac5699ee38cb93183a8b214b9ce0cd10b165d2ad"

URI_x86_64_v2_rust-gix-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-lock-devel-18.0.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-lock-devel}"
SRC_URI[x86_64_v2_rust-gix-lock-devel.sha256sum] = "54ba12bcade2677c5eacfca5eb4b57f0d742d8482808a562a794c7a79fa44bb3"

URI_aarch64_rust-gix-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-lock+default-devel-18.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-lock+default-devel}"
SRC_URI[aarch64_rust-gix-lock+default-devel.sha256sum] = "bdcca61b854fe621fdea4ae48acd4f2f0198ca392b90dd6b94617c47cfb5f405"

URI_aarch64_rust-gix-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-lock-devel-18.0.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-lock-devel}"
SRC_URI[aarch64_rust-gix-lock-devel.sha256sum] = "ad0460808c25c19f621e7dbf7bd4f9a9b6027c8c7f170dd205642bbbc5d4a0ff"

RDEPENDS:rust-gix-lock+default-devel = " \
 cargo \
 rust-gix-lock-devel \
 "
RDEPENDS:rust-gix-lock-devel = " \
 cargo \
 rust \
 rust-gix-tempfile-devel \
 rust-gix-utils-devel \
 rust-thiserror+default-devel \
 "
