# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_plurals"
PV = "2.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-icu_plurals+compiled_data-devel \
 rust-icu_plurals+datagen-devel \
 rust-icu_plurals+default-devel \
 rust-icu_plurals+icu_normalizer_data-devel \
 rust-icu_plurals+serde-devel \
 rust-icu_plurals+unstable-devel \
 rust-icu_plurals-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_plurals-2.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d46db5a7dc66c0d39c921c55fad7a9cd9e4a72df25dc81b3549c9638d77996bf"

URI_x86_64_v2_rust-icu_plurals+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+compiled_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+compiled_data-devel.sha256sum] = "22093b4217d3ec14cd380602f22c32a7b86e863ef18d69aacfdbd7f0e6722a59"

URI_x86_64_v2_rust-icu_plurals+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+datagen-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+datagen-devel.sha256sum] = "50a9ce1361d3600a401ccd4c844b4680214a21681f917d6cf35941bf0e532cf6"

URI_x86_64_v2_rust-icu_plurals+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+default-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+default-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+default-devel.sha256sum] = "0ec3ca4c32adc514f1b42c1e8502c775eb190a2a17b5134dcc863d28626c7f32"

URI_x86_64_v2_rust-icu_plurals+icu_normalizer_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+icu_normalizer_data-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+icu_normalizer_data-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+icu_normalizer_data-devel.sha256sum] = "c5fcd58facaa8b9aeaaf1c00fd00260f5e8408209da40e333a2ba42d756c3760"

URI_x86_64_v2_rust-icu_plurals+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+serde-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+serde-devel.sha256sum] = "87125e6646b481a19251c0a60e4f52804226f00bf8ee87d4267f47fe3063bfcd"

URI_x86_64_v2_rust-icu_plurals+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals+unstable-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals+unstable-devel.sha256sum] = "42a8bf27db72297434738941324e185100fb0715eb51c3948c17fb212cc450b4"

URI_x86_64_v2_rust-icu_plurals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_plurals-devel-2.2.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_plurals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_plurals-devel}"
SRC_URI[x86_64_v2_rust-icu_plurals-devel.sha256sum] = "f7256069f705342b47225ae118744b64f6f702c85076f325a84120bc1de8783e"

URI_aarch64_rust-icu_plurals+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+compiled_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_plurals+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_plurals+compiled_data-devel.sha256sum] = "b3c9191450aafc36a3835cf17cd57da273da6abde948cc5c5fc565c7e6ff643d"

URI_aarch64_rust-icu_plurals+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+datagen-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_plurals+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+datagen-devel}"
SRC_URI[aarch64_rust-icu_plurals+datagen-devel.sha256sum] = "a581f82cd03c56d530861e79eae4b7f7ff7bd3f88ff923ee0f9f2712335a18f6"

URI_aarch64_rust-icu_plurals+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+default-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_plurals+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+default-devel}"
SRC_URI[aarch64_rust-icu_plurals+default-devel.sha256sum] = "a4d8c9470e6a6acbed70950757f638a6f64dc7c53c5cd2cd3e2198de55bed869"

URI_aarch64_rust-icu_plurals+icu_normalizer_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+icu_normalizer_data-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_plurals+icu_normalizer_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+icu_normalizer_data-devel}"
SRC_URI[aarch64_rust-icu_plurals+icu_normalizer_data-devel.sha256sum] = "80b6040447a64589fe138569c2a7a385a46493956b682de6c6e29e8c5fbfb5b6"

URI_aarch64_rust-icu_plurals+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+serde-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_plurals+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+serde-devel}"
SRC_URI[aarch64_rust-icu_plurals+serde-devel.sha256sum] = "b950da799d6db954fbcd2b580a239e296d35310d7a5a37b1d3801825e8a9f2be"

URI_aarch64_rust-icu_plurals+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals+unstable-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_plurals+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals+unstable-devel}"
SRC_URI[aarch64_rust-icu_plurals+unstable-devel.sha256sum] = "6df0bc4f981d427a0ab5e65e13b80f467688d2e359f9222e1209df7942f73089"

URI_aarch64_rust-icu_plurals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_plurals-devel-2.2.0-1.el10_3.noarch.rpm;name=aarch64_rust-icu_plurals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_plurals-devel}"
SRC_URI[aarch64_rust-icu_plurals-devel.sha256sum] = "8cc56faf4c3d71786831ae7b046d040986d0abae65b5fcdeed69985b8fb99510"

RDEPENDS:rust-icu_plurals+compiled_data-devel = " \
 cargo \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_plurals-devel \
 rust-icu_plurals_data-devel \
 rust-icu_provider+baked-devel \
 "
RDEPENDS:rust-icu_plurals+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_plurals+serde-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+export-devel \
 rust-zerovec+databake-devel \
 "
RDEPENDS:rust-icu_plurals+default-devel = " \
 cargo \
 rust-icu_plurals+compiled_data-devel \
 rust-icu_plurals-devel \
 "
RDEPENDS:rust-icu_plurals+icu_normalizer_data-devel = " \
 cargo \
 rust-icu_plurals-devel \
 "
RDEPENDS:rust-icu_plurals+serde-devel = " \
 cargo \
 rust-displaydoc-devel \
 rust-icu_plurals-devel \
 rust-icu_provider+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_plurals+unstable-devel = " \
 cargo \
 rust-icu_plurals-devel \
 "
RDEPENDS:rust-icu_plurals-devel = " \
 cargo \
 rust \
 rust-fixed_decimal-devel \
 rust-icu_provider+alloc-devel \
 rust-icu_provider-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
