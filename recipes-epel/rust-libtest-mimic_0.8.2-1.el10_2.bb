# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libtest-mimic"
PV = "0.8.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-libtest-mimic+default-devel \
 rust-libtest-mimic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libtest-mimic-0.8.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9149124ad39551e31475478ccb009f0cc328d2aa464828c312de6e26bec7fe0f"

URI_x86_64_v2_rust-libtest-mimic+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libtest-mimic+default-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libtest-mimic+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libtest-mimic+default-devel}"
SRC_URI[x86_64_v2_rust-libtest-mimic+default-devel.sha256sum] = "bb0320ed6e26487dd72cc198cccdd39ba26158fe25196cbecbcb0b1e3606806b"

URI_x86_64_v2_rust-libtest-mimic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libtest-mimic-devel-0.8.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libtest-mimic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libtest-mimic-devel}"
SRC_URI[x86_64_v2_rust-libtest-mimic-devel.sha256sum] = "4939f4e90b482e8af932554ebfffc0f8c0101730c949006ad9e9f3bae311cef3"

URI_aarch64_rust-libtest-mimic+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libtest-mimic+default-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-libtest-mimic+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libtest-mimic+default-devel}"
SRC_URI[aarch64_rust-libtest-mimic+default-devel.sha256sum] = "28fa2f915d2a53fdddee79aee3ae8a3db48db9889e3ac4b2e02a2f77ce21f911"

URI_aarch64_rust-libtest-mimic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libtest-mimic-devel-0.8.2-1.el10_2.noarch.rpm;name=aarch64_rust-libtest-mimic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libtest-mimic-devel}"
SRC_URI[aarch64_rust-libtest-mimic-devel.sha256sum] = "1883b1f7ea91f509120ab88cd3d6cffa6d6369b5b00fbbfef53de02d728eafa4"

RDEPENDS:rust-libtest-mimic+default-devel = " \
 cargo \
 rust-libtest-mimic-devel \
 "
RDEPENDS:rust-libtest-mimic-devel = " \
 cargo \
 rust \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-escape8259+default-devel \
 "
