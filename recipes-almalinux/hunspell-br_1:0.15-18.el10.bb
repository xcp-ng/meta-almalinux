# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-br"
PE = "1"
PV = "0.15"
PR = "18.el10"
PACKAGES = " \
 hunspell-br \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-br-0.15-18.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8971d7e33d5ea4b43c610b18be5b50721cfa64c5ad61412f744d5946cff054ac"

URI_x86_64_v2_hunspell-br = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-br-0.15-18.el10.noarch.rpm;name=x86_64_v2_hunspell-br;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-br}"
SRC_URI[x86_64_v2_hunspell-br.sha256sum] = "e33ae5e8aaaecf8ca2bd33759b0e1db292508bfa02904bc563ac3013e0275b7f"

URI_aarch64_hunspell-br = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-br-0.15-18.el10.noarch.rpm;name=aarch64_hunspell-br;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-br}"
SRC_URI[aarch64_hunspell-br.sha256sum] = "e33ae5e8aaaecf8ca2bd33759b0e1db292508bfa02904bc563ac3013e0275b7f"

RDEPENDS:hunspell-br = " \
 hunspell-filesystem \
 "
