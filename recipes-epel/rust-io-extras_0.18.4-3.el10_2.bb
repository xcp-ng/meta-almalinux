# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-io-extras"
PV = "0.18.4"
PR = "3.el10_2"
PACKAGES = " \
 rust-io-extras+async-std-devel \
 rust-io-extras+default-devel \
 rust-io-extras+mio-devel \
 rust-io-extras+os_pipe-devel \
 rust-io-extras+socket2-devel \
 rust-io-extras+tokio-devel \
 rust-io-extras+use_async_std-devel \
 rust-io-extras+use_mio_net-devel \
 rust-io-extras+use_mio_os_ext-devel \
 rust-io-extras+use_os_pipe-devel \
 rust-io-extras+use_socket2-devel \
 rust-io-extras+use_tokio-devel \
 rust-io-extras-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-io-extras-0.18.4-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b4b0a9112b6b2da69efe95fad3cefce5ffbd9fb041b4e87beac8a0b6cc53cee"

URI_x86_64_v2_rust-io-extras+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+async-std-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+async-std-devel}"
SRC_URI[x86_64_v2_rust-io-extras+async-std-devel.sha256sum] = "29631426b565819bf3f95d83d5db8ec3590a86f26f962c3a3ec4776c22bdeab8"

URI_x86_64_v2_rust-io-extras+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+default-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+default-devel}"
SRC_URI[x86_64_v2_rust-io-extras+default-devel.sha256sum] = "a085a76f194693db357d4442c8d4f2824e8f50b70b556ebbecb54cec0c16628f"

URI_x86_64_v2_rust-io-extras+mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+mio-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+mio-devel}"
SRC_URI[x86_64_v2_rust-io-extras+mio-devel.sha256sum] = "aa393a23b93c17630a9ea4f562c761d145943d12db5160355f9e9e2ca9ac8b1f"

URI_x86_64_v2_rust-io-extras+os_pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+os_pipe-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+os_pipe-devel}"
SRC_URI[x86_64_v2_rust-io-extras+os_pipe-devel.sha256sum] = "3ea64380089a661e1f7cd432f6c355008ef38321e7bad72e012ddc9bae575476"

URI_x86_64_v2_rust-io-extras+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+socket2-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+socket2-devel}"
SRC_URI[x86_64_v2_rust-io-extras+socket2-devel.sha256sum] = "ba63b49c955b36d2599afaae3988f22652132d8b1e2057d01dec666e330423e9"

URI_x86_64_v2_rust-io-extras+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+tokio-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+tokio-devel}"
SRC_URI[x86_64_v2_rust-io-extras+tokio-devel.sha256sum] = "be6faf252e35db2924f75a1347a05d111c53e70b8966541dd69206a2040635ac"

URI_x86_64_v2_rust-io-extras+use_async_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_async_std-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_async_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+use_async_std-devel}"
SRC_URI[x86_64_v2_rust-io-extras+use_async_std-devel.sha256sum] = "b3488832ff1edfe5fbc792ec6661383ed749aaa309befb22279551f9af7f48c9"

URI_x86_64_v2_rust-io-extras+use_mio_net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_mio_net-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_mio_net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+use_mio_net-devel}"
SRC_URI[x86_64_v2_rust-io-extras+use_mio_net-devel.sha256sum] = "54e04a316e1f1151ac327c5ad47153c9340eb4a57385bde36ee26ea3294f32c1"

URI_x86_64_v2_rust-io-extras+use_mio_os_ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_mio_os_ext-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_mio_os_ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+use_mio_os_ext-devel}"
SRC_URI[x86_64_v2_rust-io-extras+use_mio_os_ext-devel.sha256sum] = "79f97cf1a9e214f3070c5df2e0e34e77973240b1f754ff5a48bc8537cda61b6b"

URI_x86_64_v2_rust-io-extras+use_os_pipe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_os_pipe-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+use_os_pipe-devel}"
SRC_URI[x86_64_v2_rust-io-extras+use_os_pipe-devel.sha256sum] = "9afe001b388de7cf8fa94821dbeb90d4298bcd36d4499d38b2b815690ebf5ad9"

URI_x86_64_v2_rust-io-extras+use_socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_socket2-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+use_socket2-devel}"
SRC_URI[x86_64_v2_rust-io-extras+use_socket2-devel.sha256sum] = "8a1bb15698032ad8f44e2b9370419238bbdbcac46f5623790d4392f9788bcba9"

URI_x86_64_v2_rust-io-extras+use_tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras+use_tokio-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras+use_tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras+use_tokio-devel}"
SRC_URI[x86_64_v2_rust-io-extras+use_tokio-devel.sha256sum] = "ea21d8aaddd45463f8142ed396534319367a64b839a51a7563af270876b07e06"

URI_x86_64_v2_rust-io-extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-io-extras-devel-0.18.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-io-extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-io-extras-devel}"
SRC_URI[x86_64_v2_rust-io-extras-devel.sha256sum] = "28c002a099d387eed97663c06088d6a122535becca1df8c02e6fddd6ffff8c7a"

URI_aarch64_rust-io-extras+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+async-std-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+async-std-devel}"
SRC_URI[aarch64_rust-io-extras+async-std-devel.sha256sum] = "40b6c6cf830ac7dc79cb0b395264c24343cb388add481f76ea46f0db2d9054e2"

URI_aarch64_rust-io-extras+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+default-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+default-devel}"
SRC_URI[aarch64_rust-io-extras+default-devel.sha256sum] = "6ab74506b258323d568681cf7bf0edb0e3437c53e55a823038a2603d47af7ab3"

URI_aarch64_rust-io-extras+mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+mio-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+mio-devel}"
SRC_URI[aarch64_rust-io-extras+mio-devel.sha256sum] = "367e88e4da356b550b1a5a2d433ddab71d23e7df30e29c54423433c8972a7e72"

URI_aarch64_rust-io-extras+os_pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+os_pipe-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+os_pipe-devel}"
SRC_URI[aarch64_rust-io-extras+os_pipe-devel.sha256sum] = "89c6523f88651179efa03b324e9343fa4119a9a552cb243a517c68db8b46fd0a"

URI_aarch64_rust-io-extras+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+socket2-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+socket2-devel}"
SRC_URI[aarch64_rust-io-extras+socket2-devel.sha256sum] = "e9d1296f54aaf422cf1a8e61d507eda55d4a131f340b063d2c787a6c5786c235"

URI_aarch64_rust-io-extras+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+tokio-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+tokio-devel}"
SRC_URI[aarch64_rust-io-extras+tokio-devel.sha256sum] = "f746b7be19be05501c65b13b6a669e3279daddd6c335f672ededc64a6f2f9db6"

URI_aarch64_rust-io-extras+use_async_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_async_std-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+use_async_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+use_async_std-devel}"
SRC_URI[aarch64_rust-io-extras+use_async_std-devel.sha256sum] = "8f7ccc32fe0851dec9218374356b578c058d9ccffabbe03b3daaeaca48f0de70"

URI_aarch64_rust-io-extras+use_mio_net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_mio_net-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+use_mio_net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+use_mio_net-devel}"
SRC_URI[aarch64_rust-io-extras+use_mio_net-devel.sha256sum] = "c3ca62ebcf3dab806d9da56d377999f1f876041e5434966e138fd67ae95122eb"

URI_aarch64_rust-io-extras+use_mio_os_ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_mio_os_ext-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+use_mio_os_ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+use_mio_os_ext-devel}"
SRC_URI[aarch64_rust-io-extras+use_mio_os_ext-devel.sha256sum] = "020babafd33318a08866bd66a3c6457b8c4cba1cc55981af621f527fac0cd5b3"

URI_aarch64_rust-io-extras+use_os_pipe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_os_pipe-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+use_os_pipe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+use_os_pipe-devel}"
SRC_URI[aarch64_rust-io-extras+use_os_pipe-devel.sha256sum] = "946386adb2533b5cf1003308f692f9698b3d398d27c1ff7c003a7ee57741467c"

URI_aarch64_rust-io-extras+use_socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_socket2-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+use_socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+use_socket2-devel}"
SRC_URI[aarch64_rust-io-extras+use_socket2-devel.sha256sum] = "524f60f227a8086a200af7170b6a23c59d9f55a7e7b0e869b0061be2ee3e4ed5"

URI_aarch64_rust-io-extras+use_tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras+use_tokio-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras+use_tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras+use_tokio-devel}"
SRC_URI[aarch64_rust-io-extras+use_tokio-devel.sha256sum] = "434e9b7d3d7b07c1480f2abc85d0de81d7040e847451bee3dd166a1666c53175"

URI_aarch64_rust-io-extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-io-extras-devel-0.18.4-3.el10_2.noarch.rpm;name=aarch64_rust-io-extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-io-extras-devel}"
SRC_URI[aarch64_rust-io-extras-devel.sha256sum] = "6cb7e08923da38ab45086bee9ba98a6496d4d4abdb0630d8ac64d8e7d542c572"

RDEPENDS:rust-io-extras+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-async-std+io_safety-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+default-devel = " \
 cargo \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+mio-devel = " \
 cargo \
 rust-io-extras-devel \
 rust-mio+default-devel \
 "
RDEPENDS:rust-io-extras+os_pipe-devel = " \
 cargo \
 rust-io-extras-devel \
 rust-os_pipe+default-devel \
 "
RDEPENDS:rust-io-extras+socket2-devel = " \
 cargo \
 rust-io-extras-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-io-extras+tokio-devel = " \
 cargo \
 rust-io-extras-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-std-devel \
 rust-tokio+net-devel \
 rust-tokio+process-devel \
 "
RDEPENDS:rust-io-extras+use_async_std-devel = " \
 cargo \
 rust-io-extras+async-std-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+use_mio_net-devel = " \
 cargo \
 rust-io-extras+mio-devel \
 rust-io-extras-devel \
 rust-mio+default-devel \
 rust-mio+net-devel \
 "
RDEPENDS:rust-io-extras+use_mio_os_ext-devel = " \
 cargo \
 rust-io-extras+mio-devel \
 rust-io-extras-devel \
 rust-mio+default-devel \
 rust-mio+os-ext-devel \
 "
RDEPENDS:rust-io-extras+use_os_pipe-devel = " \
 cargo \
 rust-io-extras+os_pipe-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+use_socket2-devel = " \
 cargo \
 rust-io-extras+socket2-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras+use_tokio-devel = " \
 cargo \
 rust-io-extras+tokio-devel \
 rust-io-extras-devel \
 "
RDEPENDS:rust-io-extras-devel = " \
 cargo \
 rust \
 rust-io-lifetimes+default-devel \
 "
