# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-primefield"
PV = "0.14.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-primefield+default-devel \
 rust-primefield-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-primefield-0.14.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "219511f31d33127f1a1e93ec8c2488fca1b05648d7c5269a76e608c2ace9d476"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primefield+default-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primefield+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-primefield+default-devel.sha256sum] = "c88a760a25e14038df6b5ffe5f91140c1b278b1c44c734345a124ff79679aa3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primefield-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primefield-devel;unpack=0"
SRC_URI[x86_64_v2_rust-primefield-devel.sha256sum] = "8cad22a500accee325c63894365be3e511f7bf83bbfe3afd247d3c633e7d56b8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-primefield+default-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-primefield+default-devel;unpack=0"
SRC_URI[aarch64_rust-primefield+default-devel.sha256sum] = "f0d11d7f94c5230368a01c2500851b961f31c71516fd78c7ed80a4b928fbe2fe"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-primefield-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-primefield-devel;unpack=0"
SRC_URI[aarch64_rust-primefield-devel.sha256sum] = "c6c6544795f5bb53ae27f898ec52a387881613f628c59581f8f26ff836210a92"

RDEPENDS:rust-primefield+default-devel = " \
 cargo \
 rust-primefield-devel \
 "
RDEPENDS:rust-primefield-devel = " \
 cargo \
 rust \
 rust-crypto-bigint+hybrid-array-devel \
 rust-crypto-bigint+rand_core-devel \
 rust-crypto-bigint+subtle-devel \
 rust-crypto-bigint-devel \
 rust-crypto-common+default-devel \
 rust-crypto-common+rand_core-devel \
 rust-ff-devel \
 rust-rand_core-devel \
 rust-subtle+const-generics-devel \
 rust-subtle-devel \
 rust-zeroize-devel \
 "
