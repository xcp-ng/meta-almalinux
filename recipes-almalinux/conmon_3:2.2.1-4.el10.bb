# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conmon"
PE = "3"
PV = "2.2.1"
PR = "4.el10"
PACKAGES = " \
 conmon \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/conmon-2.2.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b355764356126d1980ead124715d46336b799ddb90517651830b8350b34552b"

URI_x86_64_v2_conmon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/conmon-2.2.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_conmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conmon}"
SRC_URI[x86_64_v2_conmon.sha256sum] = "60ac0012b843abb353e8b81e8293463a169f546a1f12d9c268e2a8f7a2156c54"

URI_aarch64_conmon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/conmon-2.2.1-4.el10.aarch64.rpm;name=aarch64_conmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_conmon}"
SRC_URI[aarch64_conmon.sha256sum] = "460bfa0acf1d828339ba49bc2d3174f75c5b7a607b79ef9925d254b16325383b"

RDEPENDS:conmon = " \
 glib2 \
 glibc \
 libgcc \
 libseccomp \
 systemd-libs \
 "
