# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-grep-printer"
PV = "0.2.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-grep-printer+default-devel \
 rust-grep-printer+serde-devel \
 rust-grep-printer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-grep-printer-0.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f78ae6162ff3039e80f2aae57e60e58c3b630c32a05b2e3742206ec72433171"

URI_x86_64_v2_rust-grep-printer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-printer+default-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-printer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-printer+default-devel}"
SRC_URI[x86_64_v2_rust-grep-printer+default-devel.sha256sum] = "1fbba486664904e0573149044a0005ba19ef66c65154ba6b3c64fbca5824b978"

URI_x86_64_v2_rust-grep-printer+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-printer+serde-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-printer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-printer+serde-devel}"
SRC_URI[x86_64_v2_rust-grep-printer+serde-devel.sha256sum] = "0a90ea259edd17b9f1f6eaf00ec4604c0ca34ec686f924fc22d0e4ad6e49d0af"

URI_x86_64_v2_rust-grep-printer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-grep-printer-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-grep-printer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-grep-printer-devel}"
SRC_URI[x86_64_v2_rust-grep-printer-devel.sha256sum] = "6ebf861577eaf8a23b0af7bf01820938faab079cfb8cb22c8cf620c6bf1a9c64"

URI_aarch64_rust-grep-printer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-printer+default-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-grep-printer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-printer+default-devel}"
SRC_URI[aarch64_rust-grep-printer+default-devel.sha256sum] = "cb475872f1414919794ad53d3c71355f799199456b18c8f7435d78680be0befd"

URI_aarch64_rust-grep-printer+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-printer+serde-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-grep-printer+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-printer+serde-devel}"
SRC_URI[aarch64_rust-grep-printer+serde-devel.sha256sum] = "1e18622fdc34fe2bfffe6f045b032f1e0733592f5ced386275be4f87e4f72379"

URI_aarch64_rust-grep-printer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-grep-printer-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-grep-printer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-grep-printer-devel}"
SRC_URI[aarch64_rust-grep-printer-devel.sha256sum] = "e26dba37e1a1e409dd4cfc0d7301e06d3263fa0991250c52b098990d9432d920"

RDEPENDS:rust-grep-printer+default-devel = " \
 cargo \
 rust-grep-printer+serde-devel \
 rust-grep-printer-devel \
 "
RDEPENDS:rust-grep-printer+serde-devel = " \
 cargo \
 rust-grep-printer-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-grep-printer-devel = " \
 cargo \
 rust-bstr+default-devel \
 rust-grep-matcher+default-devel \
 rust-grep-searcher+default-devel \
 rust-log+default-devel \
 rust-termcolor+default-devel \
 "
