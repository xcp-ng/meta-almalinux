# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tonic-types"
PV = "0.14.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-tonic-types+default-devel \
 rust-tonic-types-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tonic-types-0.14.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee894b4d6140e8c449f28a5dcd8147e14d2401c8825aa74f40cc016de4145a48"

URI_x86_64_v2_rust-tonic-types+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic-types+default-devel-0.14.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic-types+default-devel}"
SRC_URI[x86_64_v2_rust-tonic-types+default-devel.sha256sum] = "b2c9277c1623a192b8875cd9746a41bc97b8c9437cf65fc034e3ede5207b1edc"

URI_x86_64_v2_rust-tonic-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tonic-types-devel-0.14.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tonic-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tonic-types-devel}"
SRC_URI[x86_64_v2_rust-tonic-types-devel.sha256sum] = "0457e5ad967910e26485c8d5453c337cea20fb9259c51c941d007355cdb641df"

URI_aarch64_rust-tonic-types+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic-types+default-devel-0.14.5-1.el10_3.noarch.rpm;name=aarch64_rust-tonic-types+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic-types+default-devel}"
SRC_URI[aarch64_rust-tonic-types+default-devel.sha256sum] = "8490cb5b6df2e4b8ecc776a33065b9a78c07b7c88543a8061da553911ebcac92"

URI_aarch64_rust-tonic-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tonic-types-devel-0.14.5-1.el10_3.noarch.rpm;name=aarch64_rust-tonic-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tonic-types-devel}"
SRC_URI[aarch64_rust-tonic-types-devel.sha256sum] = "026c2d3a123c60eae20825355cf7e98b909ba958ed188263ce57ef7cccfbc2e1"

RDEPENDS:rust-tonic-types+default-devel = " \
 cargo \
 rust-tonic-types-devel \
 "
RDEPENDS:rust-tonic-types-devel = " \
 cargo \
 rust \
 rust-prettyplease+default-devel \
 rust-prost+default-devel \
 rust-prost-types+default-devel \
 rust-protox+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-tempfile+default-devel \
 rust-tonic-devel \
 rust-tonic-prost-build-devel \
 "
