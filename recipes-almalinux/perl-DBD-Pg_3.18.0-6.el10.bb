# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-DBD-Pg"
PV = "3.18.0"
PR = "6.el10"
PACKAGES = " \
 perl-DBD-Pg \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-DBD-Pg-3.18.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "681d3173f708e559bd1b605b5aaad72f2ea8f33d7868ec000046e5c2e6f63097"

URI_x86_64_v2_perl-DBD-Pg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-DBD-Pg-3.18.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_perl-DBD-Pg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-DBD-Pg}"
SRC_URI[x86_64_v2_perl-DBD-Pg.sha256sum] = "973626c4c6a59fc2d40897c23bf741a24f2e30c6cb79e3878229c47147f524fb"

URI_aarch64_perl-DBD-Pg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-DBD-Pg-3.18.0-6.el10.aarch64.rpm;name=aarch64_perl-DBD-Pg;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-DBD-Pg}"
SRC_URI[aarch64_perl-DBD-Pg.sha256sum] = "b7d6df0eec5ff5674c714b5b603787e82a4e4f55339dfae5ac9bea156ebc5478"

RDEPENDS:perl-DBD-Pg = " \
 glibc \
 libpq \
 perl-DBI \
 perl-Exporter \
 perl-constant \
 perl-libs \
 perl-version \
 "
