# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rsconf"
PV = "0.2.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-rsconf+default-devel \
 rust-rsconf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rsconf-0.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b7398ff35087879df5f9d4056b54a78adc84edd3506a9048d162f1878bf1f18"

URI_x86_64_v2_rust-rsconf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsconf+default-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsconf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsconf+default-devel}"
SRC_URI[x86_64_v2_rust-rsconf+default-devel.sha256sum] = "c7494c688e3e0af71cde2ce397f26cf72acaf50a668a46ca69b7bd9a797e4d3c"

URI_x86_64_v2_rust-rsconf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rsconf-devel-0.2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rsconf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rsconf-devel}"
SRC_URI[x86_64_v2_rust-rsconf-devel.sha256sum] = "caaef8cfa3331f90e6d39e359832d99a53dac26e35663ce3dd7175f8db99057b"

URI_aarch64_rust-rsconf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsconf+default-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-rsconf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsconf+default-devel}"
SRC_URI[aarch64_rust-rsconf+default-devel.sha256sum] = "667b5bea3c526a3f3dc4ac01a1faadf25ae64bcc0216f15d5d8c47c9dc6d45ee"

URI_aarch64_rust-rsconf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rsconf-devel-0.2.2-1.el10_0.noarch.rpm;name=aarch64_rust-rsconf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rsconf-devel}"
SRC_URI[aarch64_rust-rsconf-devel.sha256sum] = "64b2bca8dbbf2c0f8860f8202073fdf36561ebb6e9fb0d1565ad6f9512ecca2c"

RDEPENDS:rust-rsconf+default-devel = " \
 cargo \
 rust-rsconf-devel \
 "
RDEPENDS:rust-rsconf-devel = " \
 cargo \
 rust-cc+default-devel \
 "
