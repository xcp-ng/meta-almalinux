# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-httparse"
PV = "1.10.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-httparse+default-devel \
 rust-httparse+std-devel \
 rust-httparse-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-httparse-1.10.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e50395af7979179c753ee28e4ec1c4a4f8c06c7ad2c6ba9dad39571fc8acb68a"

URI_x86_64_v2_rust-httparse+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-httparse+default-devel-1.10.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-httparse+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-httparse+default-devel}"
SRC_URI[x86_64_v2_rust-httparse+default-devel.sha256sum] = "36aef8c4cbdd71052809e9aa1e9cb2506576f57b0c9c517550806490bc0a9505"

URI_x86_64_v2_rust-httparse+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-httparse+std-devel-1.10.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-httparse+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-httparse+std-devel}"
SRC_URI[x86_64_v2_rust-httparse+std-devel.sha256sum] = "c7d64df3b6193e7a85aa3310ca435a039b079ae5927c6f144e65066ebb6988d3"

URI_x86_64_v2_rust-httparse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-httparse-devel-1.10.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-httparse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-httparse-devel}"
SRC_URI[x86_64_v2_rust-httparse-devel.sha256sum] = "a8f1327246b28275ea0c22ff433890d72b78446788a9db3dcb43b42762b3c1ab"

URI_aarch64_rust-httparse+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-httparse+default-devel-1.10.1-1.el10_1.noarch.rpm;name=aarch64_rust-httparse+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-httparse+default-devel}"
SRC_URI[aarch64_rust-httparse+default-devel.sha256sum] = "5ef42596432fe1e47db292f5ca8ad4192d2fc5b8f7931e7fb32089e13840329e"

URI_aarch64_rust-httparse+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-httparse+std-devel-1.10.1-1.el10_1.noarch.rpm;name=aarch64_rust-httparse+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-httparse+std-devel}"
SRC_URI[aarch64_rust-httparse+std-devel.sha256sum] = "e40f88abdff2f17e445bd83e447a1e5be749e9230979369658f798d32eaab16c"

URI_aarch64_rust-httparse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-httparse-devel-1.10.1-1.el10_1.noarch.rpm;name=aarch64_rust-httparse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-httparse-devel}"
SRC_URI[aarch64_rust-httparse-devel.sha256sum] = "6fc563c24f149689ca9f7607c80406f799c2e5f68e05e3a784b84da6e81ee199"

RDEPENDS:rust-httparse+default-devel = " \
 cargo \
 rust-httparse+std-devel \
 rust-httparse-devel \
 "
RDEPENDS:rust-httparse+std-devel = " \
 cargo \
 rust-httparse-devel \
 "
RDEPENDS:rust-httparse-devel = " \
 cargo \
 "
