# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch"
PV = "2.25.0"
PR = "7.el10_1"
PACKAGES = " \
 onefetch \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-2.25.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da9579b2c58ab842fb30da9cdabb931e3631e70d6b74eb03147ae8397ac96184"

URI_x86_64_v2_onefetch = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/onefetch-2.25.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_onefetch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_onefetch}"
SRC_URI[x86_64_v2_onefetch.sha256sum] = "cc8e9b9f69dd9d93e751b1de94d2280d99543202f39b2871de5a92177424c3eb"

URI_aarch64_onefetch = "${EPEL_MIRROR}/aarch64/Packages/o/onefetch-2.25.0-7.el10_1.aarch64.rpm;name=aarch64_onefetch;unpack=0"
SRC_URI:append = " ${URI_aarch64_onefetch}"
SRC_URI[aarch64_onefetch.sha256sum] = "d74dd5c20b2e5ec807a342557800eea201b4ad0791b35a48ba85d2719dc8cabc"

RDEPENDS:onefetch = " \
 glibc \
 libgcc \
 libzstd \
 "
