# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "star"
PV = "1.6"
PR = "18.el10_0.alma.1"
PACKAGES = " \
 rmt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/star-1.6-18.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "51f86774a1b318c62645e925590d14e6c290c82b117c74f252de51ad79fed197"

URI_x86_64_v2_rmt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rmt-1.6-18.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_rmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rmt}"
SRC_URI[x86_64_v2_rmt.sha256sum] = "b307649a25f79cb9818d5b14bc7cc6e7a8520afe330292f00dada0ef420bc6a8"

URI_aarch64_rmt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rmt-1.6-18.el10_0.alma.1.aarch64.rpm;name=aarch64_rmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_rmt}"
SRC_URI[aarch64_rmt.sha256sum] = "ba4dbce7b4e65ae29069d4f21fbfae9f9e24449baf00542b1d2a8f1e5694689d"

RDEPENDS:rmt = " \
 glibc \
 "
