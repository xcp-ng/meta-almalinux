# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtmultimedia"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtmultimedia \
 qt5-qtmultimedia-devel \
 qt5-qtmultimedia-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtmultimedia-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee2fd1bb38ed1010801d00eba7b9f2173aedeaa21fc338c34a1c2d3cd51463e5"

URI_x86_64_v2_qt5-qtmultimedia = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtmultimedia-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtmultimedia}"
SRC_URI[x86_64_v2_qt5-qtmultimedia.sha256sum] = "f8d0bcc1589cddd58618ddd84860e7f7d27b21c4212d3b0b2531100eab0903b6"

URI_x86_64_v2_qt5-qtmultimedia-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtmultimedia-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtmultimedia-devel}"
SRC_URI[x86_64_v2_qt5-qtmultimedia-devel.sha256sum] = "efc1eebfa900dff6c27dd0d3e32ef152082e40d6df37ff22dd4735aef1cd58d6"

URI_x86_64_v2_qt5-qtmultimedia-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtmultimedia-examples-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtmultimedia-examples}"
SRC_URI[x86_64_v2_qt5-qtmultimedia-examples.sha256sum] = "867a1a68cae0c348a134ed11f817228b78c4665dde9f67c1628dbb13479650af"

URI_aarch64_qt5-qtmultimedia = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtmultimedia-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtmultimedia}"
SRC_URI[aarch64_qt5-qtmultimedia.sha256sum] = "3f2cb423cd77bf690d86628e392b861bf091230b9a9bbd7c21a91f48cc536eff"

URI_aarch64_qt5-qtmultimedia-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtmultimedia-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtmultimedia-devel}"
SRC_URI[aarch64_qt5-qtmultimedia-devel.sha256sum] = "afbe36c7127b16a0ad93437beb999213528fd770908ba4a78d6da4f7d1b5d01b"

URI_aarch64_qt5-qtmultimedia-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtmultimedia-examples-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtmultimedia-examples}"
SRC_URI[aarch64_qt5-qtmultimedia-examples.sha256sum] = "0e36e888771caf2b2007e7abd9acd19d4e8d015b839966bcd6a519b63bab9083"

RDEPENDS:qt5-qtmultimedia = " \
 alsa-lib \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 libglvnd-glx \
 libstdc++ \
 openal-soft \
 pulseaudio-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtmultimedia-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtmultimedia \
 qt5-qtmultimedia-devel \
 "
RDEPENDS:qt5-qtmultimedia-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtmultimedia \
 "
