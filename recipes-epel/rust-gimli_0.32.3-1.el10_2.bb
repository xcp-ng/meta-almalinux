# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gimli"
PV = "0.32.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-gimli+default-devel \
 rust-gimli+endian-reader-devel \
 rust-gimli+fallible-iterator-devel \
 rust-gimli+read-all-devel \
 rust-gimli+read-core-devel \
 rust-gimli+read-devel \
 rust-gimli+std-devel \
 rust-gimli+write-devel \
 rust-gimli-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gimli-0.32.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8d29df43ad3ad87d439987f257c8a428086e32c7e91af4b0ab626fa1ef4753af"

URI_x86_64_v2_rust-gimli+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+default-devel-0.32.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+default-devel}"
SRC_URI[x86_64_v2_rust-gimli+default-devel.sha256sum] = "bf106552898a1c7519cfbd5b5c7c765a3af69d221cc5fb685f4506d13eb22b09"

URI_x86_64_v2_rust-gimli+endian-reader-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+endian-reader-devel-0.32.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+endian-reader-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+endian-reader-devel}"
SRC_URI[x86_64_v2_rust-gimli+endian-reader-devel.sha256sum] = "30f0158bbc4b4734500a49e2d9bb4441bf1b56dfb9e61a7902d3c7fd607c0557"

URI_x86_64_v2_rust-gimli+fallible-iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+fallible-iterator-devel-0.32.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+fallible-iterator-devel}"
SRC_URI[x86_64_v2_rust-gimli+fallible-iterator-devel.sha256sum] = "66a02fd285cadb096faeb1d647399464280d89e5eb71ad8d67b0ff030980446b"

URI_x86_64_v2_rust-gimli+read-all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+read-all-devel-0.32.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+read-all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+read-all-devel}"
SRC_URI[x86_64_v2_rust-gimli+read-all-devel.sha256sum] = "bf045dc3cc90deddf791f7f2bcd29a948282d5152988d8b2db28d01752e1c5c1"

URI_x86_64_v2_rust-gimli+read-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+read-core-devel-0.32.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+read-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+read-core-devel}"
SRC_URI[x86_64_v2_rust-gimli+read-core-devel.sha256sum] = "b6b617035fa491dd5f2a70699b028e8d7fd9e60207add14b77aeaceded36e163"

URI_x86_64_v2_rust-gimli+read-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+read-devel-0.32.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+read-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+read-devel}"
SRC_URI[x86_64_v2_rust-gimli+read-devel.sha256sum] = "a96dae22127906a0d6d2c8e4a264d03dd3047b05b3a5306187238c7845863aa5"

URI_x86_64_v2_rust-gimli+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+std-devel-0.32.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+std-devel}"
SRC_URI[x86_64_v2_rust-gimli+std-devel.sha256sum] = "d4138753d15dd2ed4833aade8cc25a4e5204f97775a063575b94f3bcf51224a7"

URI_x86_64_v2_rust-gimli+write-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli+write-devel-0.32.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli+write-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli+write-devel}"
SRC_URI[x86_64_v2_rust-gimli+write-devel.sha256sum] = "f021906b6ced213c9b75496905ad3406951a83c32f2545a9508ac347f369fb2b"

URI_x86_64_v2_rust-gimli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gimli-devel-0.32.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gimli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gimli-devel}"
SRC_URI[x86_64_v2_rust-gimli-devel.sha256sum] = "609759561ee66c60520946db6cc1af6bf4ddee933c821bb5fd618ccf688614ed"

URI_aarch64_rust-gimli+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+default-devel-0.32.3-1.el10_2.noarch.rpm;name=aarch64_rust-gimli+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+default-devel}"
SRC_URI[aarch64_rust-gimli+default-devel.sha256sum] = "01d987fff267666e5ecb4f38217ce0eca7824beef6c9c54a8607712bdbfe0c66"

URI_aarch64_rust-gimli+endian-reader-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+endian-reader-devel-0.32.3-1.el10_2.noarch.rpm;name=aarch64_rust-gimli+endian-reader-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+endian-reader-devel}"
SRC_URI[aarch64_rust-gimli+endian-reader-devel.sha256sum] = "1c3ede14a1b18e1394521cff1a5793f2ad4c692cd27fcc4ea8942aa2a6b3793e"

URI_aarch64_rust-gimli+fallible-iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+fallible-iterator-devel-0.32.3-1.el10_2.noarch.rpm;name=aarch64_rust-gimli+fallible-iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+fallible-iterator-devel}"
SRC_URI[aarch64_rust-gimli+fallible-iterator-devel.sha256sum] = "98b32337e84ed0e117e4a6cae5f373aa5ef92772c07c1ed551094244f9053186"

URI_aarch64_rust-gimli+read-all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+read-all-devel-0.32.3-1.el10_2.noarch.rpm;name=aarch64_rust-gimli+read-all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+read-all-devel}"
SRC_URI[aarch64_rust-gimli+read-all-devel.sha256sum] = "55185c1250ddd7c8d6eaced5138470691daab4b1a940a76380707a6ca6687719"

URI_aarch64_rust-gimli+read-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+read-core-devel-0.32.3-1.el10_2.noarch.rpm;name=aarch64_rust-gimli+read-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+read-core-devel}"
SRC_URI[aarch64_rust-gimli+read-core-devel.sha256sum] = "7a61532d3a7d926a95789315f5d2c97eaf4605fda98cddbb971e8730458a421b"

URI_aarch64_rust-gimli+read-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+read-devel-0.32.3-1.el10_2.noarch.rpm;name=aarch64_rust-gimli+read-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+read-devel}"
SRC_URI[aarch64_rust-gimli+read-devel.sha256sum] = "246859f3077577d727f6c5b078b00defdc6a7763d8427abc73aabef03b60f2f8"

URI_aarch64_rust-gimli+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+std-devel-0.32.3-1.el10_2.noarch.rpm;name=aarch64_rust-gimli+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+std-devel}"
SRC_URI[aarch64_rust-gimli+std-devel.sha256sum] = "ceb36c303aa18728406cce60e1c1aa4ff7493ad582758b0fc19b737db1bee8b2"

URI_aarch64_rust-gimli+write-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli+write-devel-0.32.3-1.el10_2.noarch.rpm;name=aarch64_rust-gimli+write-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli+write-devel}"
SRC_URI[aarch64_rust-gimli+write-devel.sha256sum] = "1ec84b8f4aa4dc08c3355ce1de8be14955632c8ccd89303bd39a9e6dddc836d2"

URI_aarch64_rust-gimli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gimli-devel-0.32.3-1.el10_2.noarch.rpm;name=aarch64_rust-gimli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gimli-devel}"
SRC_URI[aarch64_rust-gimli-devel.sha256sum] = "cbddd4e9d781b9aacd82ca5d659cd506709a940ce381355724bf70f4a97f17e5"

RDEPENDS:rust-gimli+default-devel = " \
 cargo \
 rust-gimli+read-all-devel \
 rust-gimli+write-devel \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+endian-reader-devel = " \
 cargo \
 rust-gimli+read-devel \
 rust-gimli-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-gimli+fallible-iterator-devel = " \
 cargo \
 rust-fallible-iterator-devel \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+read-all-devel = " \
 cargo \
 rust-gimli+endian-reader-devel \
 rust-gimli+fallible-iterator-devel \
 rust-gimli+read-devel \
 rust-gimli+std-devel \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+read-core-devel = " \
 cargo \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+read-devel = " \
 cargo \
 rust-gimli+read-core-devel \
 rust-gimli-devel \
 "
RDEPENDS:rust-gimli+std-devel = " \
 cargo \
 rust-fallible-iterator+std-devel \
 rust-fallible-iterator-devel \
 rust-gimli-devel \
 rust-stable_deref_trait+std-devel \
 rust-stable_deref_trait-devel \
 "
RDEPENDS:rust-gimli+write-devel = " \
 cargo \
 rust-gimli-devel \
 rust-indexmap+default-devel \
 "
RDEPENDS:rust-gimli-devel = " \
 cargo \
 rust \
 "
