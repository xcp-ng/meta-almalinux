# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "delve"
PV = "1.25.2"
PR = "3.el10_1"
PACKAGES = " \
 delve \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/delve-1.25.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4979729fa6346a70d83936d0615cbb4687731237623356060c6fe127e730762"

URI_x86_64_v2_delve = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/delve-1.25.2-3.el10_1.x86_64_v2.rpm;name=x86_64_v2_delve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_delve}"
SRC_URI[x86_64_v2_delve.sha256sum] = "ce74bc201a0b349b28426f4ae677d03902bf1eaa3d105b9147be5fe1d3ad59ce"

URI_aarch64_delve = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/delve-1.25.2-3.el10_1.aarch64.rpm;name=aarch64_delve;unpack=0"
SRC_URI:append = " ${URI_aarch64_delve}"
SRC_URI[aarch64_delve.sha256sum] = "79895b5ba81f2bf55eb2636c1594476ee3735754a0f008fe09467ec01835662c"

RDEPENDS:delve = " \
 glibc \
 "
