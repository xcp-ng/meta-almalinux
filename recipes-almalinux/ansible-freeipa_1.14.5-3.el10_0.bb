# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-freeipa"
PV = "1.14.5"
PR = "3.el10_0"
PACKAGES = " \
 ansible-freeipa \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-freeipa-1.14.5-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f74358bec829598895ef5775e9b8e5ee0e79ce079beb1850c9493087b7f3414a"

URI_x86_64_v2_ansible-freeipa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-freeipa-1.14.5-3.el10_0.noarch.rpm;name=x86_64_v2_ansible-freeipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ansible-freeipa}"
SRC_URI[x86_64_v2_ansible-freeipa.sha256sum] = "c120d7c278dbc67cbf9872cdf1e61d7999daf19ceafc535007a2d9f3db642fa3"

URI_aarch64_ansible-freeipa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-freeipa-1.14.5-3.el10_0.noarch.rpm;name=aarch64_ansible-freeipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_ansible-freeipa}"
SRC_URI[aarch64_ansible-freeipa.sha256sum] = "c120d7c278dbc67cbf9872cdf1e61d7999daf19ceafc535007a2d9f3db642fa3"

RDEPENDS:ansible-freeipa = " \
 ansible-core \
 bash \
 python3 \
 "
