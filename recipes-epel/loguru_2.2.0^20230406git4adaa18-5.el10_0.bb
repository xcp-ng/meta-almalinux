# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "loguru"
PV = "2.2.0^20230406git4adaa18"
PR = "5.el10_0"
PACKAGES = " \
 loguru \
 loguru-devel \
 loguru-doc \
 loguru-lnav \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/loguru-2.2.0^20230406git4adaa18-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1797999dc25612c2cc08ed2c856f6bec64aa815bd58eff551da8e7546ef7d5b"

URI_x86_64_v2_loguru = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/loguru-2.2.0^20230406git4adaa18-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_loguru;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_loguru}"
SRC_URI[x86_64_v2_loguru.sha256sum] = "924ef98c00f975e90891ed22c23ff920fb089b1ecade001b3529fdae35eefbb3"

URI_x86_64_v2_loguru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/loguru-devel-2.2.0^20230406git4adaa18-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_loguru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_loguru-devel}"
SRC_URI[x86_64_v2_loguru-devel.sha256sum] = "4e5345f1e59b6ace67951869496a3630046fc17db19eadeea67aa631e132f00c"

URI_x86_64_v2_loguru-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/loguru-doc-2.2.0^20230406git4adaa18-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_loguru-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_loguru-doc}"
SRC_URI[x86_64_v2_loguru-doc.sha256sum] = "3345ad3bb4d4274b576ffbdeed51129dbeb21c20f5f2759569cd891d869a6169"

URI_x86_64_v2_loguru-lnav = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/loguru-lnav-2.2.0^20230406git4adaa18-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_loguru-lnav;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_loguru-lnav}"
SRC_URI[x86_64_v2_loguru-lnav.sha256sum] = "cc30456c540aadfa2e81d2a0c81095af73f557332ead8171a53a03bd19971283"

URI_aarch64_loguru = "${EPEL_MIRROR}/aarch64/Packages/l/loguru-2.2.0^20230406git4adaa18-5.el10_0.aarch64.rpm;name=aarch64_loguru;unpack=0"
SRC_URI:append = " ${URI_aarch64_loguru}"
SRC_URI[aarch64_loguru.sha256sum] = "8def4e3a747b57e4d0a53b28f074023b755ff3cd92909b7a6251874042500626"

URI_aarch64_loguru-devel = "${EPEL_MIRROR}/aarch64/Packages/l/loguru-devel-2.2.0^20230406git4adaa18-5.el10_0.aarch64.rpm;name=aarch64_loguru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_loguru-devel}"
SRC_URI[aarch64_loguru-devel.sha256sum] = "8f6b454d563b7c61f4c7fda3fe640460f71109a5d238e1ac0afbbf7e81bc4001"

URI_aarch64_loguru-doc = "${EPEL_MIRROR}/aarch64/Packages/l/loguru-doc-2.2.0^20230406git4adaa18-5.el10_0.noarch.rpm;name=aarch64_loguru-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_loguru-doc}"
SRC_URI[aarch64_loguru-doc.sha256sum] = "9c83b0673e95bf1f198fa20a47e3b2eae41ee4d54c0074260c1b15c7b4c134bd"

URI_aarch64_loguru-lnav = "${EPEL_MIRROR}/aarch64/Packages/l/loguru-lnav-2.2.0^20230406git4adaa18-5.el10_0.noarch.rpm;name=aarch64_loguru-lnav;unpack=0"
SRC_URI:append = " ${URI_aarch64_loguru-lnav}"
SRC_URI[aarch64_loguru-lnav.sha256sum] = "3b8398d3efe73e6977038fa02c9a7e1ecce605e6b3bd3b3b01982ddbf12b609e"

RDEPENDS:loguru = " \
 glibc \
 libgcc \
 libstdc++ \
 loguru-lnav \
 "
RDEPENDS:loguru-devel = " \
 cmake-filesystem \
 loguru \
 pkgconf-pkg-config \
 "
RDEPENDS:loguru-doc = " \
 "
RDEPENDS:loguru-lnav = " \
 "
