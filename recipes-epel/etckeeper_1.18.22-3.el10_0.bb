# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "etckeeper"
PV = "1.18.22"
PR = "3.el10_0"
PACKAGES = " \
 etckeeper \
 etckeeper-dnf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/etckeeper-1.18.22-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b975434d08399dc007f52c9f33f1665a1d82a6ea10fdca3380e6a12b517fd710"

URI_x86_64_v2_etckeeper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/etckeeper-1.18.22-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_etckeeper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_etckeeper}"
SRC_URI[x86_64_v2_etckeeper.sha256sum] = "3a7ca1f0bfb67952d058925cb7683817d29252037e0a5f851d200e5ee6ec1a12"

URI_x86_64_v2_etckeeper-dnf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/etckeeper-dnf-1.18.22-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_etckeeper-dnf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_etckeeper-dnf}"
SRC_URI[x86_64_v2_etckeeper-dnf.sha256sum] = "83bf1e2528472692d3e57f7990c744da00f7a8302a3199f1c7788f1d76e4d1a8"

URI_aarch64_etckeeper = "${EPEL_MIRROR}/aarch64/Packages/e/etckeeper-1.18.22-3.el10_0.noarch.rpm;name=aarch64_etckeeper;unpack=0"
SRC_URI:append = " ${URI_aarch64_etckeeper}"
SRC_URI[aarch64_etckeeper.sha256sum] = "73877f805b8522c0733e8bd9ec6edc078316adfe5c4518d50fa89ae727f778c5"

URI_aarch64_etckeeper-dnf = "${EPEL_MIRROR}/aarch64/Packages/e/etckeeper-dnf-1.18.22-3.el10_0.noarch.rpm;name=aarch64_etckeeper-dnf;unpack=0"
SRC_URI:append = " ${URI_aarch64_etckeeper-dnf}"
SRC_URI[aarch64_etckeeper-dnf.sha256sum] = "bfde13c89d4168159125306c2d17733db6845ec1ae0aa3af3c85f4e030b9826b"

RDEPENDS:etckeeper = " \
 bash \
 crontabs \
 etckeeper-dnf \
 findutils \
 git-core \
 hostname \
 perl-interpreter \
 systemd \
 which \
 "
RDEPENDS:etckeeper-dnf = " \
 dnf-plugins-core \
 etckeeper \
 python3 \
 python3-dnf \
 "
