# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "incidenceeditor"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 incidenceeditor \
 incidenceeditor-devel \
 incidenceeditor-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/incidenceeditor-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4786716e4865afb91d96d04cc3ff847fc9dc080e1acb720ac8a4eec1ba43c399"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_incidenceeditor;unpack=0"
SRC_URI[x86_64_v2_incidenceeditor.sha256sum] = "3662409053c09d992ad8d8c2ca5c8b22d2e349cb57fa8c4f7e6e03478c74316c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_incidenceeditor-devel;unpack=0"
SRC_URI[x86_64_v2_incidenceeditor-devel.sha256sum] = "402e6c06a105fb3c2239999b3e754f88b8f4e523f979bc04792d26ebc69b9ae0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/incidenceeditor-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_incidenceeditor-doc;unpack=0"
SRC_URI[x86_64_v2_incidenceeditor-doc.sha256sum] = "3f7c3d75a1ab516c334edf76fa98a215fcdc63c651924d4f52605e817c049437"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_incidenceeditor;unpack=0"
SRC_URI[aarch64_incidenceeditor.sha256sum] = "758bbe8384498e467cca2945b14c7771b94e9f8c2850fe313dbc3567edf302f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_incidenceeditor-devel;unpack=0"
SRC_URI[aarch64_incidenceeditor-devel.sha256sum] = "c65ed74c2d5bf93e9c8e85699ffacb10e0ab343466363bbb5e3e0ebb4ad60dd1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/incidenceeditor-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_incidenceeditor-doc;unpack=0"
SRC_URI[aarch64_incidenceeditor-doc.sha256sum] = "529db8369e604d14c4fbb2f714a606e8199325147733abf6adb6240e233ce599"

RDEPENDS:incidenceeditor = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-server \
 calendarsupport \
 eventviews \
 glibc \
 kcalutils \
 kdiagram \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemmodels \
 kf6-kmime \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kidentitymanagement \
 kldap \
 kpimtextedit \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:incidenceeditor-devel = " \
 calendarsupport-devel \
 cmake-filesystem \
 eventviews-devel \
 incidenceeditor \
 kcalutils-devel \
 kf6-kcalendarcore-devel \
 kf6-kmime-devel \
 "
RDEPENDS:incidenceeditor-doc = " \
 "
