# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wcd"
PV = "6.0.5"
PR = "7.el10_0"
PACKAGES = " \
 wcd \
 wcd-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/w/wcd-6.0.5-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cd608ae7fd1f07cc8357280e4b6c0d073954b256ecaa19a9fed6fb306c9c5c8"

URI_x86_64_v2_wcd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wcd-6.0.5-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wcd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wcd}"
SRC_URI[x86_64_v2_wcd.sha256sum] = "25367fef913dbff8d720478ac2a149549e42d87632f5d32f04f87c7c5edda29f"

URI_x86_64_v2_wcd-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wcd-doc-6.0.5-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_wcd-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wcd-doc}"
SRC_URI[x86_64_v2_wcd-doc.sha256sum] = "cc1f794bbaa9133e89958e93414275c3259cc38c22a070f895a1b4f269fa2965"

URI_aarch64_wcd = "${EPEL_MIRROR}/aarch64/Packages/w/wcd-6.0.5-7.el10_0.aarch64.rpm;name=aarch64_wcd;unpack=0"
SRC_URI:append = " ${URI_aarch64_wcd}"
SRC_URI[aarch64_wcd.sha256sum] = "e5eb768efdb82da84702f0bd8328a765e327126c7fa5bf101069def151b4800d"

URI_aarch64_wcd-doc = "${EPEL_MIRROR}/aarch64/Packages/w/wcd-doc-6.0.5-7.el10_0.noarch.rpm;name=aarch64_wcd-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_wcd-doc}"
SRC_URI[aarch64_wcd-doc.sha256sum] = "34ce831668f2544d1e0b06ed7f1e8745bda9fdbba8ce03417d5189a6bced1c5e"

RDEPENDS:wcd = " \
 glibc \
 libunistring \
 ncurses-libs \
 "
RDEPENDS:wcd-doc = " \
 "
