# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grafana"
PV = "10.2.6"
PR = "28.el10_2.5"
PACKAGES = " \
 grafana \
 grafana-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/grafana-10.2.6-28.el10_2.5.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "24794d0d9a4c9c666957fb58979b084dc5e5518b7aed643a0dd210d7795b6695"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-10.2.6-28.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_grafana;unpack=0"
SRC_URI[x86_64_v2_grafana.sha256sum] = "9b58891106e4b6b72aacf4babac72cc860581dca726fa96db8e5cce3bd3f854d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/grafana-selinux-10.2.6-28.el10_2.5.x86_64_v2.rpm;name=x86_64_v2_grafana-selinux;unpack=0"
SRC_URI[x86_64_v2_grafana-selinux.sha256sum] = "784505e71a9a19a2ece531afe2604f4137169e25ded4964a7c955dda7d86aa67"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-10.2.6-28.el10_2.5.aarch64.rpm;name=aarch64_grafana;unpack=0"
SRC_URI[aarch64_grafana.sha256sum] = "90dbee124f568b825f0c76fa3af854360f8e307313962d083bffb693e6a97be4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/grafana-selinux-10.2.6-28.el10_2.5.aarch64.rpm;name=aarch64_grafana-selinux;unpack=0"
SRC_URI[aarch64_grafana-selinux.sha256sum] = "7f196888ac72fba3281b39d9f563f4d7e032f4263ec060fb2b762187f5d5b5ed"

RDEPENDS:grafana = " \
 bash \
 glibc \
 grafana-selinux \
 shadow-utils \
 shared-mime-info \
 systemd \
 "
RDEPENDS:grafana-selinux = " \
 bash \
 policycoreutils-python-utils \
 virtual/selinux-policy-any \
 "
