# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpublictransport"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kpublictransport \
 kpublictransport-devel \
 kpublictransport-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kpublictransport-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "569e56199c1487cefaf429c2c7d0fecbe62b7c67ed40aea0e87d4cc702692ec3"

URI_x86_64_v2_kpublictransport = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport}"
SRC_URI[x86_64_v2_kpublictransport.sha256sum] = "998f76430304ea7104693bad5cd409ee4a716951a99dd2c377814d9df37e8a2b"

URI_x86_64_v2_kpublictransport-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-devel-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpublictransport-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport-devel}"
SRC_URI[x86_64_v2_kpublictransport-devel.sha256sum] = "662eae048b7f4310a29e56d954c5de7f32c7a18762fafc4703d8d54549e1661c"

URI_x86_64_v2_kpublictransport-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpublictransport-doc-24.12.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kpublictransport-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpublictransport-doc}"
SRC_URI[x86_64_v2_kpublictransport-doc.sha256sum] = "5f3c5dbc1fdad9b1fc9f6040b038ba7e7c6b712650befc7bb67af54883830feb"

URI_aarch64_kpublictransport = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kpublictransport;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport}"
SRC_URI[aarch64_kpublictransport.sha256sum] = "90e4f23f3c4ab5792ef534f11ed54f6ad222380583ff9ecf55de1330c9e1485b"

URI_aarch64_kpublictransport-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-devel-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kpublictransport-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport-devel}"
SRC_URI[aarch64_kpublictransport-devel.sha256sum] = "efe46c42f89f9ee4dd1d11e90e6134bdba6ae34c5aab177bb779a886645a1536"

URI_aarch64_kpublictransport-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kpublictransport-doc-24.12.3-1.el10_0.noarch.rpm;name=aarch64_kpublictransport-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpublictransport-doc}"
SRC_URI[aarch64_kpublictransport-doc.sha256sum] = "6831936dc684e04eecfe7a167742644967c2fa6bee1a62436efb73ef96a34180"

RDEPENDS:kpublictransport = " \
 glibc \
 kf6-ki18n \
 kf6-networkmanager-qt \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:kpublictransport-devel = " \
 cmake-filesystem \
 kpublictransport \
 "
RDEPENDS:kpublictransport-doc = " \
 "
