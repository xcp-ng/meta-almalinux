# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gtkmm3.0"
PV = "3.24.10"
PR = "2.el10_1"
PACKAGES = " \
 gtkmm3.0 \
 gtkmm3.0-devel \
 gtkmm3.0-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gtkmm3.0-3.24.10-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ec875fce3da924af68cafae998f2686d5f5e06fca4a147f2081982143495c0f"

URI_x86_64_v2_gtkmm3.0 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkmm3.0-3.24.10-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtkmm3.0;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkmm3.0}"
SRC_URI[x86_64_v2_gtkmm3.0.sha256sum] = "6411269f677f28abb6e695b2bb44e5e4a6010f8606e5e3e6ac4eb5a1bc110736"

URI_x86_64_v2_gtkmm3.0-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkmm3.0-devel-3.24.10-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gtkmm3.0-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkmm3.0-devel}"
SRC_URI[x86_64_v2_gtkmm3.0-devel.sha256sum] = "1617a0a0ef94e22af2800b369f5fbcb4a155a42f334490ff966c42f22f89f58f"

URI_x86_64_v2_gtkmm3.0-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gtkmm3.0-doc-3.24.10-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gtkmm3.0-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gtkmm3.0-doc}"
SRC_URI[x86_64_v2_gtkmm3.0-doc.sha256sum] = "9068a2303e4f678f772d39e3c7e316595a45422a9a797ad4c6c02f11605e8019"

URI_aarch64_gtkmm3.0 = "${EPEL_MIRROR}/aarch64/Packages/g/gtkmm3.0-3.24.10-2.el10_1.aarch64.rpm;name=aarch64_gtkmm3.0;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkmm3.0}"
SRC_URI[aarch64_gtkmm3.0.sha256sum] = "ac80fdf2140381c4f40be5aa7af799fd7ece48653cdabaaff39cdc379de0f439"

URI_aarch64_gtkmm3.0-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gtkmm3.0-devel-3.24.10-2.el10_1.aarch64.rpm;name=aarch64_gtkmm3.0-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkmm3.0-devel}"
SRC_URI[aarch64_gtkmm3.0-devel.sha256sum] = "66c3c7afcc94b0dcb401ddb10e102bc54eabd2f4f0c4fd2cbe3e1bea27e21610"

URI_aarch64_gtkmm3.0-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gtkmm3.0-doc-3.24.10-2.el10_1.noarch.rpm;name=aarch64_gtkmm3.0-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gtkmm3.0-doc}"
SRC_URI[aarch64_gtkmm3.0-doc.sha256sum] = "686ec31fea40ace4e3449cc53b5b3c9610b9bc922b23598c26c2c73b11e5fd79"

RDEPENDS:gtkmm3.0 = " \
 atkmm \
 cairomm \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 glibmm2.4 \
 gtk3 \
 libgcc \
 libsigc++20 \
 libstdc++ \
 pangomm \
 "
RDEPENDS:gtkmm3.0-devel = " \
 atkmm-devel \
 cairomm-devel \
 gdk-pixbuf2-devel \
 glibmm2.4-devel \
 gtk3-devel \
 gtkmm3.0 \
 gtkmm3.0-devel \
 pangomm-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:gtkmm3.0-doc = " \
 glibmm2.4-doc \
 gtkmm3.0 \
 "
