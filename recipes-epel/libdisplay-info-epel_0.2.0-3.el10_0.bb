# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdisplay-info-epel"
PV = "0.2.0"
PR = "3.el10_0"
PACKAGES = " \
 libdisplay-info-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libdisplay-info-epel-0.2.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f718ab243a11e794ebf9aa6400531febe3b39bb5370002e128f914eb60a8d3a9"

URI_x86_64_v2_libdisplay-info-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdisplay-info-tools-0.2.0-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdisplay-info-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libdisplay-info-tools}"
SRC_URI[x86_64_v2_libdisplay-info-tools.sha256sum] = "5a605deb8b00cadbaf94fbd90ca46f445c7e7e23c365cb0bc9348e2c457cdaad"

URI_aarch64_libdisplay-info-tools = "${EPEL_MIRROR}/aarch64/Packages/l/libdisplay-info-tools-0.2.0-3.el10_0.aarch64.rpm;name=aarch64_libdisplay-info-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libdisplay-info-tools}"
SRC_URI[aarch64_libdisplay-info-tools.sha256sum] = "8ff0b156caa3281a3461780a42fdb18b573e71c3e562b93e1611ed5e02935cac"

RDEPENDS:libdisplay-info-tools = " \
 glibc \
 libdisplay-info \
 "
