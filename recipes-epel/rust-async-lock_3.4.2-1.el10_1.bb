# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-lock"
PV = "3.4.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-async-lock+default-devel \
 rust-async-lock+std-devel \
 rust-async-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-lock-3.4.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e99db917764490502d0c4da7fa4f2e147c1f3a0855514958360756affb83c957"

URI_x86_64_v2_rust-async-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-lock+default-devel-3.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-lock+default-devel}"
SRC_URI[x86_64_v2_rust-async-lock+default-devel.sha256sum] = "12e5792e10302dbe581711e4b9d9b189e48621c77867fca5493867eed24213f1"

URI_x86_64_v2_rust-async-lock+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-lock+std-devel-3.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-lock+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-lock+std-devel}"
SRC_URI[x86_64_v2_rust-async-lock+std-devel.sha256sum] = "6b2fab7f2415f9472c6c4615dd9baa8775f287925db76a5f41fec5d088b02403"

URI_x86_64_v2_rust-async-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-lock-devel-3.4.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-lock-devel}"
SRC_URI[x86_64_v2_rust-async-lock-devel.sha256sum] = "3f4f06ad468fcb6c2b6e3fa5033962df46649e71f2377b61bbc8e2cd24351833"

URI_aarch64_rust-async-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-lock+default-devel-3.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-lock+default-devel}"
SRC_URI[aarch64_rust-async-lock+default-devel.sha256sum] = "2cb6dfa5106554f1a4be888ab2c7043ae85b30b1ca06a86f2e3aca717d9fcf0b"

URI_aarch64_rust-async-lock+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-lock+std-devel-3.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-lock+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-lock+std-devel}"
SRC_URI[aarch64_rust-async-lock+std-devel.sha256sum] = "7b330ec56c2908a483e65c080215812bba76fbb2cea57b13177fb52b0a805569"

URI_aarch64_rust-async-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-lock-devel-3.4.2-1.el10_1.noarch.rpm;name=aarch64_rust-async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-lock-devel}"
SRC_URI[aarch64_rust-async-lock-devel.sha256sum] = "6b3c13b230325be33d4e058348fd73dcb7404ca24c8c6d00a9f54581f2a70a8e"

RDEPENDS:rust-async-lock+default-devel = " \
 cargo \
 rust-async-lock+std-devel \
 rust-async-lock-devel \
 "
RDEPENDS:rust-async-lock+std-devel = " \
 cargo \
 rust-async-lock-devel \
 rust-event-listener+std-devel \
 rust-event-listener-strategy+std-devel \
 "
RDEPENDS:rust-async-lock-devel = " \
 cargo \
 rust \
 rust-event-listener-devel \
 rust-event-listener-strategy-devel \
 rust-pin-project-lite+default-devel \
 "
