# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xrootd"
PE = "1"
PV = "6.1.1"
PR = "1.el10_2"
PACKAGES = " \
 python3-xrootd \
 xrootd \
 xrootd-client \
 xrootd-client-devel \
 xrootd-client-libs \
 xrootd-devel \
 xrootd-doc \
 xrootd-fuse \
 xrootd-libs \
 xrootd-private-devel \
 xrootd-scitokens \
 xrootd-selinux \
 xrootd-server \
 xrootd-server-devel \
 xrootd-server-libs \
 xrootd-voms \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/x/xrootd-6.1.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d563ab75bfc5a3a290f731df274a3d449a945f4158dcfc37f6f83b0772687fa3"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - xrootd-scitokens: libSciTokens.so.0()(64bit)

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-xrootd-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-xrootd;unpack=0"
SRC_URI[x86_64_v2_python3-xrootd.sha256sum] = "2de04b36110b6e7458888c9f1375f758320a7acd825719f9e6ecdb7069ddaf29"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd;unpack=0"
SRC_URI[x86_64_v2_xrootd.sha256sum] = "7ff6861f24304d6162665c18c8a2801820d349eaa05cc7392ddfd912726d4157"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client;unpack=0"
SRC_URI[x86_64_v2_xrootd-client.sha256sum] = "20cf70dd19914ad567d850cf552d54484fbe6302ec2aa371738c0e418686d470"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-devel-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client-devel;unpack=0"
SRC_URI[x86_64_v2_xrootd-client-devel.sha256sum] = "fa79ab249b7956415097861072ab1acfd1c34a441089a1654475641fbc98fdd0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-client-libs-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-client-libs;unpack=0"
SRC_URI[x86_64_v2_xrootd-client-libs.sha256sum] = "96a6345147df26e303763ef57e7df9d7b00d77ebfb7f068849c1b5f0781330fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-devel-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-devel;unpack=0"
SRC_URI[x86_64_v2_xrootd-devel.sha256sum] = "3e7db0e3d1ec60f09184d4084c934de9204f1819bd418974b8d3df5dd337b224"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-doc-6.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_xrootd-doc;unpack=0"
SRC_URI[x86_64_v2_xrootd-doc.sha256sum] = "97930e06816eae313d0de647ae3d42656822433393f9ec744e1063e67a3746d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-fuse-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-fuse;unpack=0"
SRC_URI[x86_64_v2_xrootd-fuse.sha256sum] = "2907cef44082b821e678d3948ac05dbf4916389432588dfc84ff8b3378bd7621"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-libs-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-libs;unpack=0"
SRC_URI[x86_64_v2_xrootd-libs.sha256sum] = "b3fb6221b46c00dcb27c036d99ea2b7794d096bc5e978a7923a8f302a793dbd3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-private-devel-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-private-devel;unpack=0"
SRC_URI[x86_64_v2_xrootd-private-devel.sha256sum] = "de73415cc0cd66129c98e47ca6b75b9f5f1e4028aba582975f99e7b68f889fe0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-scitokens-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-scitokens;unpack=0"
SRC_URI[x86_64_v2_xrootd-scitokens.sha256sum] = "7c93e58adf5628e3e1288f611d87e50c5e184f1b392b08fd42ba0c662ea6324a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-selinux-6.1.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_xrootd-selinux;unpack=0"
SRC_URI[x86_64_v2_xrootd-selinux.sha256sum] = "b14a6e672eb85456079dd8add00ce9b921f4da6adc5ce9d452c2fc0d89fb7332"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server;unpack=0"
SRC_URI[x86_64_v2_xrootd-server.sha256sum] = "ccb818f0021277711c6c3bc59304039351310d4945d3b3a391ad4c8c4517c431"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-devel-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server-devel;unpack=0"
SRC_URI[x86_64_v2_xrootd-server-devel.sha256sum] = "b60811c8d82d585d4c51b6a76ff14128cf5a5a65e0ace9636a47aed0e52b236d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-server-libs-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-server-libs;unpack=0"
SRC_URI[x86_64_v2_xrootd-server-libs.sha256sum] = "03bde665cd023899132fa862e15aee7d7dde1c727ee6bcd3c1300553227e28dc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xrootd-voms-6.1.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xrootd-voms;unpack=0"
SRC_URI[x86_64_v2_xrootd-voms.sha256sum] = "8b0bc3841e7848eaa7a842c2a663750db73540d97f90e3c87d71cfd66472942a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-xrootd-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_python3-xrootd;unpack=0"
SRC_URI[aarch64_python3-xrootd.sha256sum] = "2979302e68a2e6134871484952b0b93487ca087bd9f921109b5664be700718b4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd;unpack=0"
SRC_URI[aarch64_xrootd.sha256sum] = "8399453d33f6bd90273ed4b8a2493253b356d04766608456471d699d519c13b0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-client;unpack=0"
SRC_URI[aarch64_xrootd-client.sha256sum] = "6095039c263fbdeb3b7acac0c07a1f5667771701401dc311fa5d4e1239df547f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-devel-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-client-devel;unpack=0"
SRC_URI[aarch64_xrootd-client-devel.sha256sum] = "5497ff825bca1eb3f441c7d8fa4266631e455a67c6a86a49ad89c7de86434cd7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-client-libs-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-client-libs;unpack=0"
SRC_URI[aarch64_xrootd-client-libs.sha256sum] = "5bbbda2372a3e61d9bb7bb32faaf5661e16f44546a5c1d3bf281b3c3f639fb80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-devel-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-devel;unpack=0"
SRC_URI[aarch64_xrootd-devel.sha256sum] = "bbb62fdeebcde3994d9de38cf3e5bf4ba78cd228f13ec01da3c819cfc269d78b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-doc-6.1.1-1.el10_2.noarch.rpm;name=aarch64_xrootd-doc;unpack=0"
SRC_URI[aarch64_xrootd-doc.sha256sum] = "2e575e7ea019cb9c1401dcedaddb88aacb260741e5e1f580ab6b914416a5b4ed"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-fuse-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-fuse;unpack=0"
SRC_URI[aarch64_xrootd-fuse.sha256sum] = "2ffc57490850d2b2fdc36df01ee67e872cd70a2064dadd1de73cf616b7efff83"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-libs-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-libs;unpack=0"
SRC_URI[aarch64_xrootd-libs.sha256sum] = "68ff572eb7f8dcc05655c2004393fbb5019dc4d9090ec6db100d2d5968a2deac"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-private-devel-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-private-devel;unpack=0"
SRC_URI[aarch64_xrootd-private-devel.sha256sum] = "aefbae00f11040d11021537e48bc19841272709423d49eba95dc115740bb6e96"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-scitokens-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-scitokens;unpack=0"
SRC_URI[aarch64_xrootd-scitokens.sha256sum] = "431d79bf449cf0c4956ae060f7a81a84b2cc6abdc3973ba48321316074664ff2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-selinux-6.1.1-1.el10_2.noarch.rpm;name=aarch64_xrootd-selinux;unpack=0"
SRC_URI[aarch64_xrootd-selinux.sha256sum] = "4ab311cdaf85f938a4f78b5e14b603e4575c0bac35a84f4fd7b14fcf112f5224"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-server;unpack=0"
SRC_URI[aarch64_xrootd-server.sha256sum] = "4fc01d41eddb2ea6ae47633bb0a3b8b98ea7c7e8e85e7abb7f735897f67bee80"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-devel-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-server-devel;unpack=0"
SRC_URI[aarch64_xrootd-server-devel.sha256sum] = "867e44d0824c689edf497a423e6ce6f92fa92b0a9f86d49c07a2a3bf05f8adf5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-server-libs-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-server-libs;unpack=0"
SRC_URI[aarch64_xrootd-server-libs.sha256sum] = "8776637130fe6b44dbbad269f4646d7626bb8e67586f4b934337fedc974aa7bb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/x/xrootd-voms-6.1.1-1.el10_2.aarch64.rpm;name=aarch64_xrootd-voms;unpack=0"
SRC_URI[aarch64_xrootd-voms.sha256sum] = "27290bfaa9933f86173644ad1577f87fe3c84e4f2a7b4ab3cdb9accfe029a6ac"

RDEPENDS:python3-xrootd = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd = " \
 xrootd-selinux \
 xrootd-server \
 "
RDEPENDS:xrootd-client = " \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 xrootd-client-libs \
 xrootd-libs \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-client-devel = " \
 xrootd-client-libs \
 xrootd-devel \
 "
RDEPENDS:xrootd-client-libs = " \
 glibc \
 isa-l \
 libgcc \
 libstdc++ \
 libuuid \
 openssl-libs \
 tinyxml \
 virtual/libcurl.so.4___64bit_ \
 xrootd-libs \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-devel = " \
 bash \
 cmake-filesystem \
 xrootd-libs \
 "
RDEPENDS:xrootd-doc = " \
 "
RDEPENDS:xrootd-fuse = " \
 fuse \
 fuse-libs \
 glibc \
 libgcc \
 libstdc++ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd-libs = " \
 glibc \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 libxcrypt \
 libxml2 \
 openssl-libs \
 systemd-libs \
 tinyxml \
 zlib-ng-compat \
 "
RDEPENDS:xrootd-private-devel = " \
 xrootd-client-devel \
 xrootd-client-libs \
 xrootd-devel \
 xrootd-server-devel \
 "
RDEPENDS:xrootd-scitokens:x86_64_v2 = " \
 glibc \
 libgcc \
 libstdc++ \
 xrootd-libs \
 xrootd-server \
"
RDEPENDS:xrootd-scitokens:aarch64 = " \
 glibc \
 libgcc \
 libstdc++ \
 scitokens-cpp \
 xrootd-libs \
 xrootd-server \
"
RDEPENDS:xrootd-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 "
RDEPENDS:xrootd-server = " \
 bash \
 expect \
 glibc \
 libgcc \
 libstdc++ \
 logrotate \
 perl-Exporter \
 perl-IO \
 perl-IPC-Open3 \
 perl-PathTools \
 perl-Socket \
 perl-interpreter \
 readline \
 shadow-utils \
 systemd \
 xrootd-client-libs \
 xrootd-libs \
 xrootd-server-libs \
 "
RDEPENDS:xrootd-server-devel = " \
 xrootd-client-devel \
 xrootd-devel \
 xrootd-server-libs \
 "
RDEPENDS:xrootd-server-libs = " \
 glibc \
 json-c \
 libgcc \
 libmacaroons \
 libstdc++ \
 libuuid \
 libzip \
 openssl-libs \
 virtual/libcurl.so.4___64bit_ \
 xrootd-client-libs \
 xrootd-libs \
 "
RDEPENDS:xrootd-voms = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 voms \
 xrootd-libs \
 "
