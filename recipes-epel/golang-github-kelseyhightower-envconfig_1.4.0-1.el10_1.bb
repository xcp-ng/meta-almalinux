# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kelseyhightower-envconfig"
PV = "1.4.0"
PR = "1.el10_1"
PACKAGES = " \
 golang-github-kelseyhightower-envconfig-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kelseyhightower-envconfig-1.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41f6e272cba611e8104c660dd90d690f2defd453ba745aa2128e13b388ea8d85"

URI_x86_64_v2_golang-github-kelseyhightower-envconfig-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-kelseyhightower-envconfig-devel-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-kelseyhightower-envconfig-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-kelseyhightower-envconfig-devel}"
SRC_URI[x86_64_v2_golang-github-kelseyhightower-envconfig-devel.sha256sum] = "efd1a8cbc0085f716bacdfcc513b2dfad8c149b3443ff22ea9390cba2defacbf"

URI_aarch64_golang-github-kelseyhightower-envconfig-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kelseyhightower-envconfig-devel-1.4.0-1.el10_1.noarch.rpm;name=aarch64_golang-github-kelseyhightower-envconfig-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kelseyhightower-envconfig-devel}"
SRC_URI[aarch64_golang-github-kelseyhightower-envconfig-devel.sha256sum] = "87128837f7c4247c4b9661cd2f4c9e11b73586b2f712ea5fd7a83bb6b4391bb4"

RDEPENDS:golang-github-kelseyhightower-envconfig-devel = " \
 go-filesystem \
 "
