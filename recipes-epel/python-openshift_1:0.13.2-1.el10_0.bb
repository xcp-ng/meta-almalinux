# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openshift"
PE = "1"
PV = "0.13.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-openshift \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openshift-0.13.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac4d0b53e79a165ea6e034aa35e14566f69b70b03d43655fdd98dd6ed75e748c"

URI_x86_64_v2_python3-openshift = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openshift-0.13.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-openshift;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openshift}"
SRC_URI[x86_64_v2_python3-openshift.sha256sum] = "00bb83caa631c9a6d94809ff917e06ce34e4be803818410bb30d849e5df7310a"

URI_aarch64_python3-openshift = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openshift-0.13.2-1.el10_0.noarch.rpm;name=aarch64_python3-openshift;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openshift}"
SRC_URI[aarch64_python3-openshift.sha256sum] = "2fbe7d7546313525800fb896156360cd7ea1ab8049e4ef5a9010e746c2205610"

RDEPENDS:python3-openshift = " \
 python3 \
 python3-dictdiffer \
 python3-jinja2 \
 python3-kubernetes \
 python3-python-string-utils \
 python3-requests \
 python3-ruamel-yaml \
 python3-six \
 "
