# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jiff-core"
PV = "0.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-jiff-core+alloc-devel \
 rust-jiff-core+default-devel \
 rust-jiff-core+logging-devel \
 rust-jiff-core+std-devel \
 rust-jiff-core+tz-fat-devel \
 rust-jiff-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jiff-core-0.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6b902b3a753ed7df681f2b064923b5d887a70739fcad82c5596bf45f4a7bd39f"

URI_x86_64_v2_rust-jiff-core+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+alloc-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+alloc-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+alloc-devel.sha256sum] = "86d39e41a8ba44f66e114695173cb269b23fec6dd2a92e73f58324c8c947a1c3"

URI_x86_64_v2_rust-jiff-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+default-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+default-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+default-devel.sha256sum] = "b9dc127009dbaf7ee31909991cceb5ddfb1296a68ad31627915a0f781794d356"

URI_x86_64_v2_rust-jiff-core+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+logging-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+logging-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+logging-devel.sha256sum] = "91586b5c3f2638fb7a6217c1db92ba4ed6e51fd7006b11d4237cf4b39202ef2f"

URI_x86_64_v2_rust-jiff-core+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+std-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+std-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+std-devel.sha256sum] = "ac5be72ba69315732c4bac8462a38186efb5e69fbf551601f5b9b2dbeac503d8"

URI_x86_64_v2_rust-jiff-core+tz-fat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core+tz-fat-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core+tz-fat-devel}"
SRC_URI[x86_64_v2_rust-jiff-core+tz-fat-devel.sha256sum] = "08a09a4e1ef2718d84d07aa52e0a70c4f4f3a1393affbab2d7df89dac5ae343c"

URI_x86_64_v2_rust-jiff-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jiff-core-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jiff-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jiff-core-devel}"
SRC_URI[x86_64_v2_rust-jiff-core-devel.sha256sum] = "6412b04df533ac954e2e71fdd235e9f5684d59a74dd3184983353c4b4926bb11"

URI_aarch64_rust-jiff-core+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+alloc-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-jiff-core+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+alloc-devel}"
SRC_URI[aarch64_rust-jiff-core+alloc-devel.sha256sum] = "5845b981c4bff4e7db74eedeaed939a6770d3aacf4542dde5dcce8013994e338"

URI_aarch64_rust-jiff-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+default-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-jiff-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+default-devel}"
SRC_URI[aarch64_rust-jiff-core+default-devel.sha256sum] = "6e09a1108cffe01396901fdccbf62142bf105a916c8ac1a411c8997c53ef1cab"

URI_aarch64_rust-jiff-core+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+logging-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-jiff-core+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+logging-devel}"
SRC_URI[aarch64_rust-jiff-core+logging-devel.sha256sum] = "a0b4537ab271bc0cb26a5dde30b666af95483b19e7983baf5683c02556cbd606"

URI_aarch64_rust-jiff-core+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+std-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-jiff-core+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+std-devel}"
SRC_URI[aarch64_rust-jiff-core+std-devel.sha256sum] = "7d6197b6ff8a3ef3c2d44d721b5073465addb91a4f81f9423b88466a849d86d6"

URI_aarch64_rust-jiff-core+tz-fat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core+tz-fat-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-jiff-core+tz-fat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core+tz-fat-devel}"
SRC_URI[aarch64_rust-jiff-core+tz-fat-devel.sha256sum] = "c311c1548d7c650316867ff32a79344a55ecd54c494f7c4f3b3b7e888e1a03df"

URI_aarch64_rust-jiff-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jiff-core-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-jiff-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jiff-core-devel}"
SRC_URI[aarch64_rust-jiff-core-devel.sha256sum] = "fc08806cf3aa02b441313741c900ff2b9a2841853a9e607a6f91b86895274860"

RDEPENDS:rust-jiff-core+alloc-devel = " \
 cargo \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core+default-devel = " \
 cargo \
 rust-jiff-core+std-devel \
 rust-jiff-core+tz-fat-devel \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core+logging-devel = " \
 cargo \
 rust-jiff-core-devel \
 rust-log-devel \
 "
RDEPENDS:rust-jiff-core+std-devel = " \
 cargo \
 rust-jiff-core+alloc-devel \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core+tz-fat-devel = " \
 cargo \
 rust-jiff-core-devel \
 "
RDEPENDS:rust-jiff-core-devel = " \
 cargo \
 rust \
 "
