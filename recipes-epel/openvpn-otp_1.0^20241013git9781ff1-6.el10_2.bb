# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvpn-otp"
PV = "1.0^20241013git9781ff1"
PR = "6.el10_2"
PACKAGES = " \
 openvpn-otp \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/openvpn-otp-1.0^20241013git9781ff1-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5c49d48e74169fc90e65779a73f287deeac38af7629c575985564a35dc73d2dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvpn-otp-1.0^20241013git9781ff1-6.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvpn-otp;unpack=0"
SRC_URI[x86_64_v2_openvpn-otp.sha256sum] = "637a8b1e39f6f6c1d082114ec7e344fee3e63a3738c47b1ef5083a5c25498d22"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/openvpn-otp-1.0^20241013git9781ff1-6.el10_2.aarch64.rpm;name=aarch64_openvpn-otp;unpack=0"
SRC_URI[aarch64_openvpn-otp.sha256sum] = "7d9ee3e51000eef1e4cd714b65dc239922cb0d6d67e4e0bbf15babe911ab7515"

RDEPENDS:openvpn-otp = " \
 glibc \
 openvpn \
 "
