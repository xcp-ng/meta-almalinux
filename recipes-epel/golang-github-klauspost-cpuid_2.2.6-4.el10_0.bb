# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-klauspost-cpuid"
PV = "2.2.6"
PR = "4.el10_0"
PACKAGES = " \
 compat-golang-github-klauspost-cpuid2-devel \
 golang-github-klauspost-cpuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-klauspost-cpuid-2.2.6-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "71a92da6af76100fe3bde3f10a7eb87e5e898b681e13a34ab99c5d4aa1f9a11e"

URI_x86_64_v2_compat-golang-github-klauspost-cpuid2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-klauspost-cpuid2-devel-2.2.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-klauspost-cpuid2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-klauspost-cpuid2-devel}"
SRC_URI[x86_64_v2_compat-golang-github-klauspost-cpuid2-devel.sha256sum] = "11e3b73da22395923aa56781934c6447fbf29817beff8c2d96ed16f85238a585"

URI_x86_64_v2_golang-github-klauspost-cpuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-klauspost-cpuid-devel-2.2.6-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-klauspost-cpuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-klauspost-cpuid-devel}"
SRC_URI[x86_64_v2_golang-github-klauspost-cpuid-devel.sha256sum] = "16690492c0c946973cc17fc34e0d26b76b0eca90a71d9243fbb383573f8768be"

URI_aarch64_compat-golang-github-klauspost-cpuid2-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-klauspost-cpuid2-devel-2.2.6-4.el10_0.noarch.rpm;name=aarch64_compat-golang-github-klauspost-cpuid2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-klauspost-cpuid2-devel}"
SRC_URI[aarch64_compat-golang-github-klauspost-cpuid2-devel.sha256sum] = "b2ec4edf3a384e9d056742427e3c7148eb25bed6e2db52c7108ffc48381e483c"

URI_aarch64_golang-github-klauspost-cpuid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-klauspost-cpuid-devel-2.2.6-4.el10_0.noarch.rpm;name=aarch64_golang-github-klauspost-cpuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-klauspost-cpuid-devel}"
SRC_URI[aarch64_golang-github-klauspost-cpuid-devel.sha256sum] = "18cce4fe0c4d28d44025939ecc954c840f503c1a4462f90d17f79643e3948436"

RDEPENDS:compat-golang-github-klauspost-cpuid2-devel = " \
 go-filesystem \
 golang-github-klauspost-cpuid-devel \
 "
RDEPENDS:golang-github-klauspost-cpuid-devel = " \
 go-filesystem \
 "
