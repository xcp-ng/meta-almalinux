# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-TabularDisplay"
PV = "1.38"
PR = "33.el10_1"
PACKAGES = " \
 perl-Text-TabularDisplay \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-TabularDisplay-1.38-33.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80cb7b12dbc46dc44d4fe7630974158071920266eff8bd6a7ad24ed23e69bb51"

URI_x86_64_v2_perl-Text-TabularDisplay = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-TabularDisplay-1.38-33.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-TabularDisplay;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-TabularDisplay}"
SRC_URI[x86_64_v2_perl-Text-TabularDisplay.sha256sum] = "a3c7032a0b4a7af9c8b806b3ae0fb2e7267d13bec5773440c2e61eaadf314af5"

URI_aarch64_perl-Text-TabularDisplay = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-TabularDisplay-1.38-33.el10_1.noarch.rpm;name=aarch64_perl-Text-TabularDisplay;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-TabularDisplay}"
SRC_URI[aarch64_perl-Text-TabularDisplay.sha256sum] = "e6110fb98fcb334eb1fde8a23c8f21f3a475f77908bfd2ef3dc0802d7bd5e2ac"

RDEPENDS:perl-Text-TabularDisplay = " \
 perl-libs \
 perl-vars \
 "
