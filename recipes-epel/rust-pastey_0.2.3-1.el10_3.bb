# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pastey"
PV = "0.2.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-pastey+default-devel \
 rust-pastey-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-pastey-0.2.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4711072e2e090f41bbb41711529c1ad42205596bf367a064611b278c7b3eaf25"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pastey+default-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pastey+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pastey+default-devel.sha256sum] = "9f4ec424313fc7dbebb8b6a4065786d398d7b46833c0742192895831d9f79f44"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pastey-devel-0.2.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pastey-devel;unpack=0"
SRC_URI[x86_64_v2_rust-pastey-devel.sha256sum] = "0dc025135be0e7b3aceb7945569059183fc29eef406e619eac1340a9f1d343f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pastey+default-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-pastey+default-devel;unpack=0"
SRC_URI[aarch64_rust-pastey+default-devel.sha256sum] = "315511f7193b420ff9e9ad135198c5831b24b88dde5da4a222cb65a2149a2d72"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-pastey-devel-0.2.3-1.el10_3.noarch.rpm;name=aarch64_rust-pastey-devel;unpack=0"
SRC_URI[aarch64_rust-pastey-devel.sha256sum] = "a4f480b9ac9dc30fd1b604ba8853de4358c8bf550e736fa24ff94f9b3790ddb3"

RDEPENDS:rust-pastey+default-devel = " \
 cargo \
 rust-pastey-devel \
 "
RDEPENDS:rust-pastey-devel = " \
 cargo \
 rust \
 "
