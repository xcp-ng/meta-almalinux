# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsyslog"
PV = "8.2506.0"
PR = "2.el10"
PACKAGES = " \
 rsyslog \
 rsyslog-crypto \
 rsyslog-doc \
 rsyslog-elasticsearch \
 rsyslog-gnutls \
 rsyslog-gssapi \
 rsyslog-kafka \
 rsyslog-mmaudit \
 rsyslog-mmfields \
 rsyslog-mmjsonparse \
 rsyslog-mmkubernetes \
 rsyslog-mmnormalize \
 rsyslog-mmsnmptrapd \
 rsyslog-mysql \
 rsyslog-omamqp1 \
 rsyslog-openssl \
 rsyslog-pgsql \
 rsyslog-relp \
 rsyslog-snmp \
 rsyslog-udpspoof \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rsyslog-8.2506.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5059ece145b930e990e718ac38cd49f0aed3ce9eccc28ec9ab07ea8d00ad0f78"

URI_x86_64_v2_rsyslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog}"
SRC_URI[x86_64_v2_rsyslog.sha256sum] = "44d3b59bef3477b5d94cfa6a5767058b446c3cef521c3f12a978625f90b1d5ff"
RPROVIDES:rsyslog:x86_64_v2 = "virtual/syslog"

URI_x86_64_v2_rsyslog-crypto = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-crypto-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-crypto;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-crypto}"
SRC_URI[x86_64_v2_rsyslog-crypto.sha256sum] = "448033f2c1a2e2afb7ae4e74f7eea876ad6852fe3a840fa9e92bb8ca84e81182"

URI_x86_64_v2_rsyslog-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-doc-8.2506.0-2.el10.noarch.rpm;name=x86_64_v2_rsyslog-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-doc}"
SRC_URI[x86_64_v2_rsyslog-doc.sha256sum] = "cfe46445da37a6c9882e477be38400b7d97afc464e9ee43c83f31ac722cbf4e5"

URI_x86_64_v2_rsyslog-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-elasticsearch-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-elasticsearch}"
SRC_URI[x86_64_v2_rsyslog-elasticsearch.sha256sum] = "814dfe9d8806c80dc9b02465169628ad75ff1aa3c541c91355b46b77800e74c0"

URI_x86_64_v2_rsyslog-gnutls = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gnutls-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gnutls;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-gnutls}"
SRC_URI[x86_64_v2_rsyslog-gnutls.sha256sum] = "c6454ebc797214971d7ebfe03d996b82a2da2d8cab92ae26c97e622d8b660cea"

URI_x86_64_v2_rsyslog-gssapi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-gssapi-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-gssapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-gssapi}"
SRC_URI[x86_64_v2_rsyslog-gssapi.sha256sum] = "cf9bfb489b16e28ed9fda60f63abb4a8e34d3273bcae1f51a685baa8691281cd"

URI_x86_64_v2_rsyslog-kafka = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-kafka-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-kafka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-kafka}"
SRC_URI[x86_64_v2_rsyslog-kafka.sha256sum] = "d27acb155cefb7ea6fe3912115c1a16b86bc609ac1f0fd5afc086cd8f07a05a5"

URI_x86_64_v2_rsyslog-mmaudit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmaudit-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmaudit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmaudit}"
SRC_URI[x86_64_v2_rsyslog-mmaudit.sha256sum] = "b8475b6c9044399079bde4499c8f168f7ea07826656953ea867be57a23df486c"

URI_x86_64_v2_rsyslog-mmfields = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmfields-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmfields;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmfields}"
SRC_URI[x86_64_v2_rsyslog-mmfields.sha256sum] = "b0c801a7005552146ec367c23e4727a424b8433be963d23b39e9f26dcab3b66c"

URI_x86_64_v2_rsyslog-mmjsonparse = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmjsonparse-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmjsonparse;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmjsonparse}"
SRC_URI[x86_64_v2_rsyslog-mmjsonparse.sha256sum] = "5057f01973212e259fecec7c1ac19d7027d9d4b458393c1a0708fb5cd9506c3b"

URI_x86_64_v2_rsyslog-mmkubernetes = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmkubernetes-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmkubernetes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmkubernetes}"
SRC_URI[x86_64_v2_rsyslog-mmkubernetes.sha256sum] = "afe9c8d399f3c9b40e2b77b02dcd57524940b825e8f9cfbc1a09c220190fba0f"

URI_x86_64_v2_rsyslog-mmnormalize = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmnormalize-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmnormalize;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmnormalize}"
SRC_URI[x86_64_v2_rsyslog-mmnormalize.sha256sum] = "13fdcb4cdc7e68f5f08d4042ec56003dd0cd9461880eaa814dde34b716f957c5"

URI_x86_64_v2_rsyslog-mmsnmptrapd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mmsnmptrapd-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mmsnmptrapd}"
SRC_URI[x86_64_v2_rsyslog-mmsnmptrapd.sha256sum] = "9d851707951e9e05c607e0c4b9e88e9e8052eec6e9d0924d929f3a782fc98a43"

URI_x86_64_v2_rsyslog-mysql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-mysql-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-mysql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-mysql}"
SRC_URI[x86_64_v2_rsyslog-mysql.sha256sum] = "bafc21b863d9d0d600fc3c8b8e21846f4566e10cc4b858d5add8175c510a4286"

URI_x86_64_v2_rsyslog-omamqp1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-omamqp1-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-omamqp1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-omamqp1}"
SRC_URI[x86_64_v2_rsyslog-omamqp1.sha256sum] = "e079785367d34fb198905f8788a22a27798f0aff80826c7342944e93febe347f"

URI_x86_64_v2_rsyslog-openssl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-openssl-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-openssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-openssl}"
SRC_URI[x86_64_v2_rsyslog-openssl.sha256sum] = "496aa6002753872bf14b15057bb169d24c907db84ea572ba0abe607a92c7962f"

URI_x86_64_v2_rsyslog-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-pgsql-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-pgsql}"
SRC_URI[x86_64_v2_rsyslog-pgsql.sha256sum] = "82d1cbcf46a6d6ecd2a810832aa25bc22b23bdf84e7139c7c09d10f5fd57b262"

URI_x86_64_v2_rsyslog-relp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-relp-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-relp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-relp}"
SRC_URI[x86_64_v2_rsyslog-relp.sha256sum] = "53aa104592527b8cc8a5dca8897edad2dc99dd584b49fbd6fee3dc795c95d96c"

URI_x86_64_v2_rsyslog-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-snmp-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-snmp}"
SRC_URI[x86_64_v2_rsyslog-snmp.sha256sum] = "df69400ebbd0c10f9555afca9e2b41c4ae04e0588b92c11a73728bd2b43e69ad"

URI_x86_64_v2_rsyslog-udpspoof = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsyslog-udpspoof-8.2506.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsyslog-udpspoof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsyslog-udpspoof}"
SRC_URI[x86_64_v2_rsyslog-udpspoof.sha256sum] = "eaecf38109764462227009e8277822ae73d5d535e475896f867107b776a244ff"

URI_aarch64_rsyslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog}"
SRC_URI[aarch64_rsyslog.sha256sum] = "b4aa4075b3544edc91c8cbbaa7c10ce5885ba2fdd28c963e8655f60c595337e7"
RPROVIDES:rsyslog:aarch64 = "virtual/syslog"

URI_aarch64_rsyslog-crypto = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-crypto-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-crypto;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-crypto}"
SRC_URI[aarch64_rsyslog-crypto.sha256sum] = "4c4fcf709bc65eb68c5ec8e97d821d856dc52939fb2f15d8264c441f45f8f966"

URI_aarch64_rsyslog-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-doc-8.2506.0-2.el10.noarch.rpm;name=aarch64_rsyslog-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-doc}"
SRC_URI[aarch64_rsyslog-doc.sha256sum] = "cfe46445da37a6c9882e477be38400b7d97afc464e9ee43c83f31ac722cbf4e5"

URI_aarch64_rsyslog-elasticsearch = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-elasticsearch-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-elasticsearch;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-elasticsearch}"
SRC_URI[aarch64_rsyslog-elasticsearch.sha256sum] = "d53678bc3c0a6acd8a5436b7fad94895080decf98a95cf78c8ca06242a809a15"

URI_aarch64_rsyslog-gnutls = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gnutls-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-gnutls;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-gnutls}"
SRC_URI[aarch64_rsyslog-gnutls.sha256sum] = "76650c557954697879b25cc596ea605294ba364c9b83d2a8dbddfaded437cd89"

URI_aarch64_rsyslog-gssapi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-gssapi-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-gssapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-gssapi}"
SRC_URI[aarch64_rsyslog-gssapi.sha256sum] = "6ea369fabe37e1654b984ee47012ec9c7146a11ec360dbacf47e5dc053895b8f"

URI_aarch64_rsyslog-kafka = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-kafka-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-kafka;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-kafka}"
SRC_URI[aarch64_rsyslog-kafka.sha256sum] = "d88b95e3b4a53b7cb44ac418763a76e4756c0210d532b444ff3e3c33b42a3d73"

URI_aarch64_rsyslog-mmaudit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmaudit-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-mmaudit;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmaudit}"
SRC_URI[aarch64_rsyslog-mmaudit.sha256sum] = "6ea4c2132659b81e80a77c3123675327dd12940c10d60469c71078dcb3d4e796"

URI_aarch64_rsyslog-mmfields = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmfields-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-mmfields;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmfields}"
SRC_URI[aarch64_rsyslog-mmfields.sha256sum] = "fbf05079b4c6d4267c9ea4e93d421f4c774bf3a905068d1077268852a31c4942"

URI_aarch64_rsyslog-mmjsonparse = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmjsonparse-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-mmjsonparse;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmjsonparse}"
SRC_URI[aarch64_rsyslog-mmjsonparse.sha256sum] = "f398524add844d4f8d74eecd31675d8e1d628a3d2dd3afcc0c328e27b88a27ef"

URI_aarch64_rsyslog-mmkubernetes = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmkubernetes-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-mmkubernetes;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmkubernetes}"
SRC_URI[aarch64_rsyslog-mmkubernetes.sha256sum] = "14c588b40015c6c343dc77d3545109aabf202b4a9d38fdb72dcc22e794693462"

URI_aarch64_rsyslog-mmnormalize = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmnormalize-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-mmnormalize;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmnormalize}"
SRC_URI[aarch64_rsyslog-mmnormalize.sha256sum] = "78dffba03463ab38169681f967ea58c9ac78336a9b11ca71711abc3c03a54e5e"

URI_aarch64_rsyslog-mmsnmptrapd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mmsnmptrapd-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-mmsnmptrapd;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mmsnmptrapd}"
SRC_URI[aarch64_rsyslog-mmsnmptrapd.sha256sum] = "881d9228b8e7304550b3f3ad9a571690234d0ba27508dacfce2349b968fbf823"

URI_aarch64_rsyslog-mysql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-mysql-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-mysql;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-mysql}"
SRC_URI[aarch64_rsyslog-mysql.sha256sum] = "d28dd69edb4221d27ffe40c8fcb6f2d05f1106404a5b603e43d3a9d49377a76b"

URI_aarch64_rsyslog-omamqp1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-omamqp1-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-omamqp1;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-omamqp1}"
SRC_URI[aarch64_rsyslog-omamqp1.sha256sum] = "32b414fd32892ab8cc738b6d11aab4c7aea0ce528f7c3d3da5ef603627dc4201"

URI_aarch64_rsyslog-openssl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-openssl-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-openssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-openssl}"
SRC_URI[aarch64_rsyslog-openssl.sha256sum] = "ce548b793c468c4861f81b4006c11fd3c5419fc4685475108d160016342da918"

URI_aarch64_rsyslog-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-pgsql-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-pgsql}"
SRC_URI[aarch64_rsyslog-pgsql.sha256sum] = "53ca14e49a6c8ca38993d4a230c5741a073fcafacb2a880b4449edca58521429"

URI_aarch64_rsyslog-relp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-relp-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-relp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-relp}"
SRC_URI[aarch64_rsyslog-relp.sha256sum] = "c8811c4423ab76978b721096e0b75eba1545f56616ee641de373b08cbef2ff0a"

URI_aarch64_rsyslog-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-snmp-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-snmp}"
SRC_URI[aarch64_rsyslog-snmp.sha256sum] = "374f5e6c91fda2ef5c28932873937ee3f486b4357647cc5efccdbf0fbb92d1e1"

URI_aarch64_rsyslog-udpspoof = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsyslog-udpspoof-8.2506.0-2.el10.aarch64.rpm;name=aarch64_rsyslog-udpspoof;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsyslog-udpspoof}"
SRC_URI[aarch64_rsyslog-udpspoof.sha256sum] = "7bbaeb60f09027e65521c1714ce2261bf41ed4d17a6d49d2d8d164d3922f6af3"

RDEPENDS:rsyslog = " \
 bash \
 glibc \
 libcap-ng \
 libestr \
 libfastjson \
 libgcc \
 libuuid \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
RDEPENDS:rsyslog-crypto = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-doc = " \
 "
RDEPENDS:rsyslog-elasticsearch = " \
 glibc \
 libcap-ng \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-gnutls = " \
 glibc \
 gnutls \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-gssapi = " \
 glibc \
 krb5-libs \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-kafka = " \
 glibc \
 libcap-ng \
 librdkafka \
 rsyslog \
 "
RDEPENDS:rsyslog-mmaudit = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmfields = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mmjsonparse = " \
 glibc \
 libcap-ng \
 libfastjson \
 rsyslog \
 "
RDEPENDS:rsyslog-mmkubernetes = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:rsyslog-mmnormalize = " \
 glibc \
 libcap-ng \
 libfastjson \
 liblognorm \
 rsyslog \
 "
RDEPENDS:rsyslog-mmsnmptrapd = " \
 glibc \
 libcap-ng \
 rsyslog \
 "
RDEPENDS:rsyslog-mysql = " \
 glibc \
 mariadb-connector-c \
 rsyslog \
 "
RDEPENDS:rsyslog-omamqp1 = " \
 cyrus-sasl-lib \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-openssl = " \
 glibc \
 libcap-ng \
 openssl-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-pgsql = " \
 glibc \
 libcap-ng \
 libpq \
 rsyslog \
 "
RDEPENDS:rsyslog-relp = " \
 glibc \
 libcap-ng \
 librelp \
 rsyslog \
 "
RDEPENDS:rsyslog-snmp = " \
 glibc \
 libcap-ng \
 net-snmp-libs \
 rsyslog \
 "
RDEPENDS:rsyslog-udpspoof = " \
 glibc \
 libcap-ng \
 libnet \
 rsyslog \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/syslog"
