# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_tr"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_tr+default-devel \
 rust-uu_tr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_tr-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4847bce270a24f40e99b71202a9bc09a714288e2df36fbf4c30310f2088780f4"

URI_x86_64_v2_rust-uu_tr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tr+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_tr+default-devel}"
SRC_URI[x86_64_v2_rust-uu_tr+default-devel.sha256sum] = "a2ee16d44437f4559218552e7205343e75ffb6004e73c6887e1e1bdf4677dc81"

URI_x86_64_v2_rust-uu_tr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_tr-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_tr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_tr-devel}"
SRC_URI[x86_64_v2_rust-uu_tr-devel.sha256sum] = "87ff5e58284bfcb8dfe22f930d2a5253637ff9479114854e99d56ef49353d302"

URI_aarch64_rust-uu_tr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tr+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_tr+default-devel}"
SRC_URI[aarch64_rust-uu_tr+default-devel.sha256sum] = "e4b8154ba8d332b3f7f20a2ac59f7a0776480ae9f60f1cc5168054af9a0074c9"

URI_aarch64_rust-uu_tr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_tr-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_tr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_tr-devel}"
SRC_URI[aarch64_rust-uu_tr-devel.sha256sum] = "65fd9b9f391295c565d6cc591843fe0a410aa553d888f74888831a2521c5b57c"

RDEPENDS:rust-uu_tr+default-devel = " \
 cargo \
 rust-uu_tr-devel \
 "
RDEPENDS:rust-uu_tr-devel = " \
 cargo \
 rust \
 rust-bytecount+default-devel \
 rust-bytecount+runtime-dispatch-simd-devel \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-nom+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 rust-uucore+signals-devel \
 "
