# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "teckit"
PV = "2.5.12"
PR = "4.el10"
PACKAGES = " \
 teckit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/teckit-2.5.12-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9a5e358c0fa8cfbb6d0aacb211bb30ff4615e213d4d9f18c8ccca9dcf6f5456"

URI_x86_64_v2_teckit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/teckit-2.5.12-4.el10.x86_64_v2.rpm;name=x86_64_v2_teckit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_teckit}"
SRC_URI[x86_64_v2_teckit.sha256sum] = "1dcce66c272e849825b3dd95a82d25dc8b3a313e36b058fbab47b06b0cc2d402"

URI_aarch64_teckit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/teckit-2.5.12-4.el10.aarch64.rpm;name=aarch64_teckit;unpack=0"
SRC_URI:append = " ${URI_aarch64_teckit}"
SRC_URI[aarch64_teckit.sha256sum] = "5355329a93cfc1e32e48d815383e942f4a6f90c96dd858e29259020ba1b5acb8"

RDEPENDS:teckit = " \
 expat \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
