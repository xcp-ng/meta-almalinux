# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khealthcertificate"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 khealthcertificate \
 khealthcertificate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khealthcertificate-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9b2c43049691d594a1388dc59dc43ad2c7c8c6bd20f6aaa7bc0c330334ad7717"

URI_x86_64_v2_khealthcertificate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khealthcertificate}"
SRC_URI[x86_64_v2_khealthcertificate.sha256sum] = "bdfe8fd0f8d5d36287a7271a8c2625faa3d6d3911d43532e9ee27ca7c3b61e65"

URI_x86_64_v2_khealthcertificate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khealthcertificate-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khealthcertificate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khealthcertificate-devel}"
SRC_URI[x86_64_v2_khealthcertificate-devel.sha256sum] = "52b97c709f532464c2b1a8162d968847a8e5d20982cd63cfd55492f8c303cb34"

URI_aarch64_khealthcertificate = "${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_khealthcertificate;unpack=0"
SRC_URI:append = " ${URI_aarch64_khealthcertificate}"
SRC_URI[aarch64_khealthcertificate.sha256sum] = "32daadb3af099d2b683eba0cbfa2cf141e3752a34255ffe57959066271ecafa4"

URI_aarch64_khealthcertificate-devel = "${EPEL_MIRROR}/aarch64/Packages/k/khealthcertificate-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_khealthcertificate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_khealthcertificate-devel}"
SRC_URI[aarch64_khealthcertificate-devel.sha256sum] = "6626daf954dc23e9854704f50d40a2c1fde2342a9f43123ebd53f880899fea88"

RDEPENDS:khealthcertificate = " \
 glibc \
 kf6-karchive \
 kf6-kcodecs \
 kf6-ki18n \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 zlib-ng-compat \
 "
RDEPENDS:khealthcertificate-devel = " \
 cmake-filesystem \
 khealthcertificate \
 "
