# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "taglib"
PV = "1.12"
PR = "12.el10"
PACKAGES = " \
 taglib \
 taglib-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/taglib-1.12-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a023a90c7a5e727886c679d0b8ae5f2fcae2741395dc6bd146bc288ecb359883"

URI_x86_64_v2_taglib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/taglib-1.12-12.el10.x86_64_v2.rpm;name=x86_64_v2_taglib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_taglib}"
SRC_URI[x86_64_v2_taglib.sha256sum] = "bcab2799ef43e6f80993e85edfd7233689ee112cb0f0e81b7b42625d858272a6"

URI_x86_64_v2_taglib-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/taglib-devel-1.12-12.el10.x86_64_v2.rpm;name=x86_64_v2_taglib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_taglib-devel}"
SRC_URI[x86_64_v2_taglib-devel.sha256sum] = "cb31f5088cc2fb06d8b492dfd9b86badb20e5173e7c69d4b8cad45aef3f5535e"

URI_aarch64_taglib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/taglib-1.12-12.el10.aarch64.rpm;name=aarch64_taglib;unpack=0"
SRC_URI:append = " ${URI_aarch64_taglib}"
SRC_URI[aarch64_taglib.sha256sum] = "cba89f7008830ee08dad74879f1ecd93d7202b93e152fe8be0b75b5c23680d0a"

URI_aarch64_taglib-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/taglib-devel-1.12-12.el10.aarch64.rpm;name=aarch64_taglib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_taglib-devel}"
SRC_URI[aarch64_taglib-devel.sha256sum] = "f0950202d78419d80a02bfe749052d39f6c1e23d9439acf267ed6c103b58dfed"

RDEPENDS:taglib = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:taglib-devel = " \
 bash \
 pkgconf-pkg-config \
 taglib \
 taglib-devel \
 "
