# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-quote-use"
PV = "0.8.4"
PR = "2.el10_2"
PACKAGES = " \
 rust-quote-use+default-devel \
 rust-quote-use+syn-devel \
 rust-quote-use-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-quote-use-0.8.4-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2cd7d30e4675889be99cb94086e484d01d605426218ccf82b49f6b6266dbf11e"

URI_x86_64_v2_rust-quote-use+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote-use+default-devel-0.8.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote-use+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote-use+default-devel}"
SRC_URI[x86_64_v2_rust-quote-use+default-devel.sha256sum] = "edcb7c7455e3eac657f7fbd5f9d6c6ceab1eabad0b4f4e7f35d23383c83b9479"

URI_x86_64_v2_rust-quote-use+syn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote-use+syn-devel-0.8.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote-use+syn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote-use+syn-devel}"
SRC_URI[x86_64_v2_rust-quote-use+syn-devel.sha256sum] = "f67435722f92881b7f73e80b9188f853615134c19bb2f51c3af7fc38abc40ff1"

URI_x86_64_v2_rust-quote-use-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-quote-use-devel-0.8.4-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-quote-use-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-quote-use-devel}"
SRC_URI[x86_64_v2_rust-quote-use-devel.sha256sum] = "3e98a2cd07e56e737472a1d0eb7ce8a84f3222aeca0091664911e86bd9e91d96"

URI_aarch64_rust-quote-use+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote-use+default-devel-0.8.4-2.el10_2.noarch.rpm;name=aarch64_rust-quote-use+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote-use+default-devel}"
SRC_URI[aarch64_rust-quote-use+default-devel.sha256sum] = "87d50ea9f9c997679e5c3f631e900e0e23af509114c30056945bcb592d25452a"

URI_aarch64_rust-quote-use+syn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote-use+syn-devel-0.8.4-2.el10_2.noarch.rpm;name=aarch64_rust-quote-use+syn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote-use+syn-devel}"
SRC_URI[aarch64_rust-quote-use+syn-devel.sha256sum] = "aeecc526a818fdc9a5543a1a9fb5953553b032cf130a17c82c7dc16163c3a37d"

URI_aarch64_rust-quote-use-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-quote-use-devel-0.8.4-2.el10_2.noarch.rpm;name=aarch64_rust-quote-use-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-quote-use-devel}"
SRC_URI[aarch64_rust-quote-use-devel.sha256sum] = "fbe08b13f7e919a11533aa359538b5ceeb3b02188775cb3da8448d199757398e"

RDEPENDS:rust-quote-use+default-devel = " \
 cargo \
 rust-quote-use-devel \
 "
RDEPENDS:rust-quote-use+syn-devel = " \
 cargo \
 rust-quote-use-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 "
RDEPENDS:rust-quote-use-devel = " \
 cargo \
 rust-quote+default-devel \
 rust-quote-use-macros+default-devel \
 "
