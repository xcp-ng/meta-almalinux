# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-falcon"
PE = "1"
PV = "4.0.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-falcon \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-falcon-4.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad7571128ec1753a8693fb4a72a9e368f54d40682838e2b59bf471ffb9f3573a"

URI_x86_64_v2_python3-falcon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-falcon-4.0.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-falcon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-falcon}"
SRC_URI[x86_64_v2_python3-falcon.sha256sum] = "0c6def8d5cb02f702dc9a62e31bcdbb4defb789074a7a6d05b8f83122012f9e0"

URI_aarch64_python3-falcon = "${EPEL_MIRROR}/aarch64/Packages/p/python3-falcon-4.0.1-1.el10_0.aarch64.rpm;name=aarch64_python3-falcon;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-falcon}"
SRC_URI[aarch64_python3-falcon.sha256sum] = "8d818a089f98f9a6ab432016242e61ba72a0bdce2580ae9de0ae7c428d00b010"

RDEPENDS:python3-falcon = " \
 glibc \
 python3 \
 "
