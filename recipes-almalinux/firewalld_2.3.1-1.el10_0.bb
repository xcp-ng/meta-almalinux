# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "firewalld"
PV = "2.3.1"
PR = "1.el10_0"
PACKAGES = " \
 firewall-applet \
 firewall-config \
 firewalld \
 firewalld-filesystem \
 python3-firewall \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/firewalld-2.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e22a96eb793edc71fcec29ed479017ffd15a269c88c2e4f9d81e60ed86e3792d"

URI_x86_64_v2_firewall-applet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-applet-2.3.1-1.el10_0.noarch.rpm;name=x86_64_v2_firewall-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewall-applet}"
SRC_URI[x86_64_v2_firewall-applet.sha256sum] = "15dc00283281bd2cf0fbfa5b9e6b7086185c3c2daeee61dcb8d907350e679b6f"

URI_x86_64_v2_firewall-config = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/firewall-config-2.3.1-1.el10_0.noarch.rpm;name=x86_64_v2_firewall-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewall-config}"
SRC_URI[x86_64_v2_firewall-config.sha256sum] = "c684feb92c30d60d9fe51663037638b419f626ff7f9b1b2aa308bbf70f446380"

URI_x86_64_v2_firewalld = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-2.3.1-1.el10_0.noarch.rpm;name=x86_64_v2_firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewalld}"
SRC_URI[x86_64_v2_firewalld.sha256sum] = "b718b6d0bc55d2380df622add90b904fd16fb9d75e1a15febcdd382a7c6c68ef"

URI_x86_64_v2_firewalld-filesystem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/firewalld-filesystem-2.3.1-1.el10_0.noarch.rpm;name=x86_64_v2_firewalld-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_firewalld-filesystem}"
SRC_URI[x86_64_v2_firewalld-filesystem.sha256sum] = "1a4b095762c880e0ef503b7b5e6a312c9d8204769d22975f77a904e5f8dde077"

URI_x86_64_v2_python3-firewall = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-firewall-2.3.1-1.el10_0.noarch.rpm;name=x86_64_v2_python3-firewall;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-firewall}"
SRC_URI[x86_64_v2_python3-firewall.sha256sum] = "5b1ae9202f26c38d11e675ff8861879c837dd9d1e201e9fa67a259b6d99daece"

URI_aarch64_firewall-applet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-applet-2.3.1-1.el10_0.noarch.rpm;name=aarch64_firewall-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewall-applet}"
SRC_URI[aarch64_firewall-applet.sha256sum] = "15dc00283281bd2cf0fbfa5b9e6b7086185c3c2daeee61dcb8d907350e679b6f"

URI_aarch64_firewall-config = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/firewall-config-2.3.1-1.el10_0.noarch.rpm;name=aarch64_firewall-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewall-config}"
SRC_URI[aarch64_firewall-config.sha256sum] = "c684feb92c30d60d9fe51663037638b419f626ff7f9b1b2aa308bbf70f446380"

URI_aarch64_firewalld = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-2.3.1-1.el10_0.noarch.rpm;name=aarch64_firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewalld}"
SRC_URI[aarch64_firewalld.sha256sum] = "b718b6d0bc55d2380df622add90b904fd16fb9d75e1a15febcdd382a7c6c68ef"

URI_aarch64_firewalld-filesystem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/firewalld-filesystem-2.3.1-1.el10_0.noarch.rpm;name=aarch64_firewalld-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_firewalld-filesystem}"
SRC_URI[aarch64_firewalld-filesystem.sha256sum] = "1a4b095762c880e0ef503b7b5e6a312c9d8204769d22975f77a904e5f8dde077"

URI_aarch64_python3-firewall = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-firewall-2.3.1-1.el10_0.noarch.rpm;name=aarch64_python3-firewall;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-firewall}"
SRC_URI[aarch64_python3-firewall.sha256sum] = "5b1ae9202f26c38d11e675ff8861879c837dd9d1e201e9fa67a259b6d99daece"

RDEPENDS:firewall-applet = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewall-config \
 firewalld \
 hicolor-icon-theme \
 libnotify \
 python3 \
 python3-firewall \
 python3-gobject \
 python3-pyqt6-base \
 "
RDEPENDS:firewall-config = " \
 NetworkManager-libnm \
 dbus-x11 \
 firewalld \
 gtk3 \
 hicolor-icon-theme \
 python3 \
 python3-firewall \
 python3-gobject \
 "
RDEPENDS:firewalld = " \
 bash \
 firewalld-filesystem \
 python3 \
 python3-firewall \
 systemd \
 "
RDEPENDS:firewalld-filesystem = " \
 "
RDEPENDS:python3-firewall = " \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-nftables \
 "
