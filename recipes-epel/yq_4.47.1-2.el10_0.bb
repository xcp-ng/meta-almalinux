# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yq"
PV = "4.47.1"
PR = "2.el10_0"
PACKAGES = " \
 yq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yq-4.47.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ce020d92c4925fddb4afb1133604f8c6f4c70537f7f2016ca604bfc6aa1ac0b"

URI_x86_64_v2_yq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yq-4.47.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yq}"
SRC_URI[x86_64_v2_yq.sha256sum] = "0157b7f2a83832340e3828d8e4d9dbbc5e40bff6e5dd8367258107a279cc881f"

URI_aarch64_yq = "${EPEL_MIRROR}/aarch64/Packages/y/yq-4.47.1-2.el10_0.aarch64.rpm;name=aarch64_yq;unpack=0"
SRC_URI:append = " ${URI_aarch64_yq}"
SRC_URI[aarch64_yq.sha256sum] = "f77a7bfed8e823f64401246864b2ad348dab1a8ea20cbee7461b764a06c0effc"

RDEPENDS:yq = " \
 glibc \
 "
