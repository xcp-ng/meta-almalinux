# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-strictures"
PV = "2.000006"
PR = "15.el10_0"
PACKAGES = " \
 perl-strictures \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-strictures-2.000006-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "825b60fb9ecf53bd1614cc3dbb416607304093603e51ff627b30ee22fa674329"

URI_x86_64_v2_perl-strictures = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-strictures-2.000006-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-strictures;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-strictures}"
SRC_URI[x86_64_v2_perl-strictures.sha256sum] = "b768d742a92b4f8ecd395d77e6291bba6ee0dd48580c4245e35a637cd2ab9cc7"

URI_aarch64_perl-strictures = "${EPEL_MIRROR}/aarch64/Packages/p/perl-strictures-2.000006-15.el10_0.noarch.rpm;name=aarch64_perl-strictures;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-strictures}"
SRC_URI[aarch64_perl-strictures.sha256sum] = "a955fcb9e2424ce3437e8f6954a908ead232b63db8f280f06993663a53ae22c8"

RDEPENDS:perl-strictures = " \
 perl-Carp \
 perl-libs \
 "
