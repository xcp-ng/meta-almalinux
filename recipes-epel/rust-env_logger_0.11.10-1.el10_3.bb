# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger"
PV = "0.11.10"
PR = "1.el10_3"
PACKAGES = " \
 rust-env_logger+auto-color-devel \
 rust-env_logger+color-devel \
 rust-env_logger+default-devel \
 rust-env_logger+humantime-devel \
 rust-env_logger+kv-devel \
 rust-env_logger+regex-devel \
 rust-env_logger+unstable-kv-devel \
 rust-env_logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger-0.11.10-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5a5c071b8a500676c44efe29dc735391491a93a14f3d18bb137e87b9d28370da"

URI_x86_64_v2_rust-env_logger+auto-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+auto-color-devel-0.11.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+auto-color-devel}"
SRC_URI[x86_64_v2_rust-env_logger+auto-color-devel.sha256sum] = "dfec57e4dacd19be9ded2ead47906c366a2a44dd49c083fac45da6123cc7580b"

URI_x86_64_v2_rust-env_logger+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+color-devel-0.11.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+color-devel}"
SRC_URI[x86_64_v2_rust-env_logger+color-devel.sha256sum] = "f8ba97bf1c06703e71d753e1357e5e525791cadf70b11492aa81b33b7edbafa0"

URI_x86_64_v2_rust-env_logger+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+default-devel-0.11.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger+default-devel.sha256sum] = "ccbca9b5f17a1c1c01d851a3d26fcdcddeb8fee6dc5d3b859f659873ec140fe9"

URI_x86_64_v2_rust-env_logger+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+humantime-devel-0.11.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger+humantime-devel.sha256sum] = "fd5b68e4a3047a8999eaf40a0f7cc1d87da906d5e69a495946c67a2407ae6a6f"

URI_x86_64_v2_rust-env_logger+kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+kv-devel-0.11.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+kv-devel}"
SRC_URI[x86_64_v2_rust-env_logger+kv-devel.sha256sum] = "184c6c06b3fc61142ece342455ebf5715bca077ea5339cf44cafab07b6aba618"

URI_x86_64_v2_rust-env_logger+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+regex-devel-0.11.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger+regex-devel.sha256sum] = "7fdec9797ff92a27b2c48b6af7a6339ef3b924d61114a230010e45283c86040e"

URI_x86_64_v2_rust-env_logger+unstable-kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+unstable-kv-devel-0.11.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+unstable-kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+unstable-kv-devel}"
SRC_URI[x86_64_v2_rust-env_logger+unstable-kv-devel.sha256sum] = "c475bbda710c715f331f23a933dc28c629a8b08e1331cbf2b801b3d69e99a383"

URI_x86_64_v2_rust-env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger-devel-0.11.10-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger-devel}"
SRC_URI[x86_64_v2_rust-env_logger-devel.sha256sum] = "129365e5f2503d436d8876ebd26b351297923a7587b14f8240085a37e16bd80c"
RPROVIDES:rust-env_logger-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger+auto-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+auto-color-devel-0.11.10-1.el10_3.noarch.rpm;name=aarch64_rust-env_logger+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+auto-color-devel}"
SRC_URI[aarch64_rust-env_logger+auto-color-devel.sha256sum] = "88df4a5925cdaaebf72ae0b5feaba4e338a72b695131d951c0514ccf2e21e33e"

URI_aarch64_rust-env_logger+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+color-devel-0.11.10-1.el10_3.noarch.rpm;name=aarch64_rust-env_logger+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+color-devel}"
SRC_URI[aarch64_rust-env_logger+color-devel.sha256sum] = "fd15af01b1ef48cfbb72a74531d496b853f356a1c6fdc8af4b3a4883a9474503"

URI_aarch64_rust-env_logger+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+default-devel-0.11.10-1.el10_3.noarch.rpm;name=aarch64_rust-env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+default-devel}"
SRC_URI[aarch64_rust-env_logger+default-devel.sha256sum] = "94ae6586b3dffb9404e17aaa54b2433185842b86d0cd8629ccdfdedf70a55a40"

URI_aarch64_rust-env_logger+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+humantime-devel-0.11.10-1.el10_3.noarch.rpm;name=aarch64_rust-env_logger+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+humantime-devel}"
SRC_URI[aarch64_rust-env_logger+humantime-devel.sha256sum] = "4b95a2b42e1d2b8d3c1ea3f5df0b65d75a6fcdcf397d77ff46b8a6496ee2cca4"

URI_aarch64_rust-env_logger+kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+kv-devel-0.11.10-1.el10_3.noarch.rpm;name=aarch64_rust-env_logger+kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+kv-devel}"
SRC_URI[aarch64_rust-env_logger+kv-devel.sha256sum] = "55131a2b376a1cda42d534585df10d2266df4b4b16f84c46536a9108e70d8fb6"

URI_aarch64_rust-env_logger+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+regex-devel-0.11.10-1.el10_3.noarch.rpm;name=aarch64_rust-env_logger+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+regex-devel}"
SRC_URI[aarch64_rust-env_logger+regex-devel.sha256sum] = "2560c24b7fd77d5cb1f9d0e6c0aba00ce87ebd708fa491440ffb18db8e9d94e2"

URI_aarch64_rust-env_logger+unstable-kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+unstable-kv-devel-0.11.10-1.el10_3.noarch.rpm;name=aarch64_rust-env_logger+unstable-kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+unstable-kv-devel}"
SRC_URI[aarch64_rust-env_logger+unstable-kv-devel.sha256sum] = "290d4e36df4311a8ca10c712eeb0fad6b85ec0e035f69696c4c7050ff395d1ac"

URI_aarch64_rust-env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger-devel-0.11.10-1.el10_3.noarch.rpm;name=aarch64_rust-env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger-devel}"
SRC_URI[aarch64_rust-env_logger-devel.sha256sum] = "585e4511c437589f483854b76ec9d90b8ee3969150bbee93a423a4bed2917c8d"
RPROVIDES:rust-env_logger-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger+auto-color-devel = " \
 cargo \
 rust-anstream+auto-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 rust-env_logger+color-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+color-devel = " \
 cargo \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 rust-anstyle+default-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+default-devel = " \
 cargo \
 rust-env_logger+auto-color-devel \
 rust-env_logger+humantime-devel \
 rust-env_logger+regex-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+humantime-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-env_logger+kv-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-log+kv-devel \
 "
RDEPENDS:rust-env_logger+regex-devel = " \
 cargo \
 rust-env_filter+regex-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+unstable-kv-devel = " \
 cargo \
 rust-env_logger+kv-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger-devel = " \
 cargo \
 rust \
 rust-env_filter-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
