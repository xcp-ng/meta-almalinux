# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "juk"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 juk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/juk-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d97464a8e92b498ba9948b0acec3ada7cc7995f73f47b06029c25b68efd1f3b"

URI_x86_64_v2_juk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/juk-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_juk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_juk}"
SRC_URI[x86_64_v2_juk.sha256sum] = "a47544147d2a9bc3f2291d49d71786d2df48f468f862fa2d554dc66ba6b434f3"

URI_aarch64_juk = "${EPEL_MIRROR}/aarch64/Packages/j/juk-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_juk;unpack=0"
SRC_URI:append = " ${URI_aarch64_juk}"
SRC_URI[aarch64_juk.sha256sum] = "9fe781ede6fb4204253472382ec9ecee5012ae630d76e2d9d4b46224ede48652"

RDEPENDS:juk = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 taglib \
 "
