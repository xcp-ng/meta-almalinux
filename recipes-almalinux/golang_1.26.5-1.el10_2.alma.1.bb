# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang"
PV = "1.26.5"
PR = "1.el10_2.alma.1"
PACKAGES = " \
 go-toolset \
 golang \
 golang-bin \
 golang-docs \
 golang-misc \
 golang-race \
 golang-src \
 golang-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-1.26.5-1.el10_2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8af4909b5cec4fe9d17a1a7dc818d994a6f01f638c8e90e6e1d9b36441861103"

URI_x86_64_v2_go-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-toolset-1.26.5-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_go-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-toolset}"
SRC_URI[x86_64_v2_go-toolset.sha256sum] = "613da6b6cf04438a7a695c602d3f4791b89456ad9fe4e1adcdcbeca2a02197de"

URI_x86_64_v2_golang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-1.26.5-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang}"
SRC_URI[x86_64_v2_golang.sha256sum] = "e1166f3fef5f21e4d793e4662fa7b28c2cfb0946536a43bb063399e734502503"

URI_x86_64_v2_golang-bin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-bin-1.26.5-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-bin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-bin}"
SRC_URI[x86_64_v2_golang-bin.sha256sum] = "542beb74da91ed137790a16c21e393398806c6ba7ca08f0c1792cdce64bf9742"

URI_x86_64_v2_golang-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-docs-1.26.5-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_golang-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-docs}"
SRC_URI[x86_64_v2_golang-docs.sha256sum] = "e79232aca5b77e65b500df22bd8d4d8328e0c2dce6833e3fc94730d5830a9c07"

URI_x86_64_v2_golang-misc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-misc-1.26.5-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_golang-misc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-misc}"
SRC_URI[x86_64_v2_golang-misc.sha256sum] = "8b1baa3232557c008b80897b0d878d2d32cb781b8cc9b3418c2541f114ab8bd2"

URI_x86_64_v2_golang-race = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-race-1.26.5-1.el10_2.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-race;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-race}"
SRC_URI[x86_64_v2_golang-race.sha256sum] = "1cbc991bfa4a6ec99710a35e42664973cfa342027ab24531211da4d4dbadc94d"

URI_x86_64_v2_golang-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-src-1.26.5-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_golang-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-src}"
SRC_URI[x86_64_v2_golang-src.sha256sum] = "ec33bba2e56c497962b088c3e47106cc014d357d9e7a0743489c3b9f1da82635"

URI_x86_64_v2_golang-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-tests-1.26.5-1.el10_2.alma.1.noarch.rpm;name=x86_64_v2_golang-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-tests}"
SRC_URI[x86_64_v2_golang-tests.sha256sum] = "e793fc42fe1650f9a19106e8b5b7a3d9bdb7d8d0204ee5e5af2c808d2d66a9bc"
RPROVIDES:golang-tests:x86_64_v2 = "virtual/libtiffxx.so.6___64bit_"

URI_aarch64_go-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-toolset-1.26.5-1.el10_2.alma.1.aarch64.rpm;name=aarch64_go-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-toolset}"
SRC_URI[aarch64_go-toolset.sha256sum] = "11e1280db9ea847faf8ac1aa091367243d060e16254d4be9e1c9320a784ef4d1"

URI_aarch64_golang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-1.26.5-1.el10_2.alma.1.aarch64.rpm;name=aarch64_golang;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang}"
SRC_URI[aarch64_golang.sha256sum] = "58851081d6bbf0ac67b3707396e1ae7375580e86a270f9ed9842af54e385e606"

URI_aarch64_golang-bin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-bin-1.26.5-1.el10_2.alma.1.aarch64.rpm;name=aarch64_golang-bin;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-bin}"
SRC_URI[aarch64_golang-bin.sha256sum] = "db83a7a41d4ae502378dea041566968f8a11934164cfcf266d0d5feccb7d1e2e"

URI_aarch64_golang-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-docs-1.26.5-1.el10_2.alma.1.noarch.rpm;name=aarch64_golang-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-docs}"
SRC_URI[aarch64_golang-docs.sha256sum] = "e79232aca5b77e65b500df22bd8d4d8328e0c2dce6833e3fc94730d5830a9c07"

URI_aarch64_golang-misc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-misc-1.26.5-1.el10_2.alma.1.noarch.rpm;name=aarch64_golang-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-misc}"
SRC_URI[aarch64_golang-misc.sha256sum] = "8b1baa3232557c008b80897b0d878d2d32cb781b8cc9b3418c2541f114ab8bd2"

URI_aarch64_golang-race = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-race-1.26.5-1.el10_2.alma.1.aarch64.rpm;name=aarch64_golang-race;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-race}"
SRC_URI[aarch64_golang-race.sha256sum] = "b2595b3a89d36725a1a40e02f0fc44f176662e12b29737946ae976e36180433b"

URI_aarch64_golang-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-src-1.26.5-1.el10_2.alma.1.noarch.rpm;name=aarch64_golang-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-src}"
SRC_URI[aarch64_golang-src.sha256sum] = "ec33bba2e56c497962b088c3e47106cc014d357d9e7a0743489c3b9f1da82635"

URI_aarch64_golang-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-tests-1.26.5-1.el10_2.alma.1.noarch.rpm;name=aarch64_golang-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-tests}"
SRC_URI[aarch64_golang-tests.sha256sum] = "e793fc42fe1650f9a19106e8b5b7a3d9bdb7d8d0204ee5e5af2c808d2d66a9bc"
RPROVIDES:golang-tests:aarch64 = "virtual/libtiffxx.so.6___64bit_"

RDEPENDS:go-toolset = " \
 delve \
 golang \
 "
RDEPENDS:golang = " \
 golang-bin \
 golang-race \
 golang-src \
 openssl-devel \
 "
RDEPENDS:golang-bin = " \
 alternatives \
 bash \
 gcc \
 glibc \
 golang \
 "
RDEPENDS:golang-docs = " \
 golang \
 "
RDEPENDS:golang-misc = " \
 golang \
 "
RDEPENDS:golang-race = " \
 golang \
 "
RDEPENDS:golang-src = " \
 "
RDEPENDS:golang-tests = " \
 golang \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libtiffxx.so.6___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libtiffxx.so.6___64bit_"
