# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oauth2client"
PV = "4.1.3"
PR = "27.el10_0"
PACKAGES = " \
 python3-oauth2client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oauth2client-4.1.3-27.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02be26b71babbdd739324ed777fbcd80508ece3259b67b996bd9c9e86f04a23f"

URI_x86_64_v2_python3-oauth2client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oauth2client-4.1.3-27.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oauth2client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oauth2client}"
SRC_URI[x86_64_v2_python3-oauth2client.sha256sum] = "222da5737769dd9966cc39c90edd8e19bd1690231cffe84395be826d0a784cdd"

URI_aarch64_python3-oauth2client = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oauth2client-4.1.3-27.el10_0.noarch.rpm;name=aarch64_python3-oauth2client;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oauth2client}"
SRC_URI[aarch64_python3-oauth2client.sha256sum] = "def53ee3b4d3755e00939b960a993bc68404c7a061654029852ad1fc286f3242"

RDEPENDS:python3-oauth2client = " \
 python3 \
 python3-fasteners \
 python3-httplib2 \
 python3-pyOpenSSL \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-rsa \
 python3-six \
 "
