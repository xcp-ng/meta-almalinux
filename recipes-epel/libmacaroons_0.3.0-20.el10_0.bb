# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmacaroons"
PV = "0.3.0"
PR = "20.el10_0"
PACKAGES = " \
 libmacaroons \
 libmacaroons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmacaroons-0.3.0-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "144f1ce66936f1fe4c2ba5e26c35d76c8ddc0f98225a54e903368ab9f3434680"

URI_x86_64_v2_libmacaroons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmacaroons-0.3.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmacaroons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmacaroons}"
SRC_URI[x86_64_v2_libmacaroons.sha256sum] = "64bad2d07056a40eefcd22a2c82275cb566ca46dd1f2da2701f852889805d170"

URI_x86_64_v2_libmacaroons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmacaroons-devel-0.3.0-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmacaroons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmacaroons-devel}"
SRC_URI[x86_64_v2_libmacaroons-devel.sha256sum] = "fd76444795d82201dd6fdf397050693102d75eb7192da2b109a1b6bdfc3018e7"

URI_aarch64_libmacaroons = "${EPEL_MIRROR}/aarch64/Packages/l/libmacaroons-0.3.0-20.el10_0.aarch64.rpm;name=aarch64_libmacaroons;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmacaroons}"
SRC_URI[aarch64_libmacaroons.sha256sum] = "e8f382cf9d647128ff4276e9bdede538627e9052e7cf9d871635c2b95c6c6e9d"

URI_aarch64_libmacaroons-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmacaroons-devel-0.3.0-20.el10_0.aarch64.rpm;name=aarch64_libmacaroons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmacaroons-devel}"
SRC_URI[aarch64_libmacaroons-devel.sha256sum] = "040c8196ba0bdf9bd44694cb2154743b64e2f86025a676d75edccf3317d1a238"

RDEPENDS:libmacaroons = " \
 glibc \
 libsodium \
 "
RDEPENDS:libmacaroons-devel = " \
 libmacaroons \
 pkgconf-pkg-config \
 "
