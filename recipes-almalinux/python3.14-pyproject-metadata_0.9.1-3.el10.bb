# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14-pyproject-metadata"
PV = "0.9.1"
PR = "3.el10"
PACKAGES = " \
 python3.14-pyproject-metadata \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python3.14-pyproject-metadata-0.9.1-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "803ff13b4d8a2f133538d0da4c343b8a2483a686688e4b6b2d25c5bb0a40c46c"

URI_x86_64_v2_python3.14-pyproject-metadata = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-pyproject-metadata-0.9.1-3.el10.noarch.rpm;name=x86_64_v2_python3.14-pyproject-metadata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3.14-pyproject-metadata}"
SRC_URI[x86_64_v2_python3.14-pyproject-metadata.sha256sum] = "a1b39e3dd951ef1525def4da45b3f50d251cb28c436bcb547aed95ec713f1112"

URI_aarch64_python3.14-pyproject-metadata = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-pyproject-metadata-0.9.1-3.el10.noarch.rpm;name=aarch64_python3.14-pyproject-metadata;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3.14-pyproject-metadata}"
SRC_URI[aarch64_python3.14-pyproject-metadata.sha256sum] = "a1b39e3dd951ef1525def4da45b3f50d251cb28c436bcb547aed95ec713f1112"

RDEPENDS:python3.14-pyproject-metadata = " \
 python3.14 \
 python3.14-packaging \
 "
