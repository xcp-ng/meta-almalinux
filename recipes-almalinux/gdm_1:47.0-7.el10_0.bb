# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdm"
PE = "1"
PV = "47.0"
PR = "7.el10_0"
PACKAGES = " \
 gdm \
 gdm-devel \
 gdm-pam-extensions-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdm-47.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0146cd90cef83e7c61cf9d3986b4d8fb191708b0aa582e7d3d9180724bda7ac9"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - gdm: gnome-shell

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - gdm: gnome-shell

URI_x86_64_v2_gdm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdm-47.0-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm}"
SRC_URI[x86_64_v2_gdm.sha256sum] = "aa2cbfa25f02c72acbccf1f409e1dc45d178c4914982cc34e4c07e4f321885c3"

URI_x86_64_v2_gdm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-devel-47.0-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm-devel}"
SRC_URI[x86_64_v2_gdm-devel.sha256sum] = "057dc129b8ced1b643a85bff203bc432c768c8cd4fa4c0ca14422b72ca7665b8"

URI_x86_64_v2_gdm-pam-extensions-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-pam-extensions-devel-47.0-7.el10_0.x86_64_v2.rpm;name=x86_64_v2_gdm-pam-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm-pam-extensions-devel}"
SRC_URI[x86_64_v2_gdm-pam-extensions-devel.sha256sum] = "70b293147bdcd86f3c975271e5cddd0079c32d83ac160946cbab5879285b44e9"

URI_aarch64_gdm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdm-47.0-7.el10_0.aarch64.rpm;name=aarch64_gdm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm}"
SRC_URI[aarch64_gdm.sha256sum] = "62bd076fa56b2103750c6819d34a37a156562a8aa558168b0e8bc06898040e9d"

URI_aarch64_gdm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-devel-47.0-7.el10_0.aarch64.rpm;name=aarch64_gdm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm-devel}"
SRC_URI[aarch64_gdm-devel.sha256sum] = "0646ffc8fd82e2c8e7c9d1e1d4727285f5b5351878d5fd18d584562b162657a3"

URI_aarch64_gdm-pam-extensions-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-pam-extensions-devel-47.0-7.el10_0.aarch64.rpm;name=aarch64_gdm-pam-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm-pam-extensions-devel}"
SRC_URI[aarch64_gdm-pam-extensions-devel.sha256sum] = "fde1a8e283e05ed00916b7831fb11818846aad4d4e4fbead4e3091ed3f5b8858"

RDEPENDS:gdm = " \
 accountsservice \
 accountsservice-libs \
 almalinux-logos \
 audit-libs \
 bash \
 dbus-daemon \
 dconf \
 glib2 \
 glibc \
 gnome-keyring-pam \
 gnome-session \
 gnome-session-wayland-session \
 gnome-settings-daemon \
 iso-codes \
 json-glib \
 keyutils-libs \
 libXau \
 libgcc \
 libgudev \
 libselinux \
 pam \
 pam-libs \
 python3 \
 python3-pam \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 "
RDEPENDS:gdm-devel = " \
 gdm \
 gdm-pam-extensions-devel \
 glib2-devel \
 libselinux-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:gdm-pam-extensions-devel = " \
 pam-devel \
 pkgconf-pkg-config \
 "
