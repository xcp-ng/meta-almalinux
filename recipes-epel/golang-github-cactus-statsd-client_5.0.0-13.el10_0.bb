# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cactus-statsd-client"
PV = "5.0.0"
PR = "13.el10_0"
PACKAGES = " \
 compat-golang-github-cactus-statsd-client-5-devel \
 golang-github-cactus-statsd-client \
 golang-github-cactus-statsd-client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-cactus-statsd-client-5.0.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ce6b50af6c479838eccfab7d142c8140a2de8bd10b2cddbb31f192fe1ecfb56"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-cactus-statsd-client-devel: golang(github.com/jessevdk/go-flags)

URI_x86_64_v2_compat-golang-github-cactus-statsd-client-5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-cactus-statsd-client-5-devel-5.0.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-cactus-statsd-client-5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-cactus-statsd-client-5-devel}"
SRC_URI[x86_64_v2_compat-golang-github-cactus-statsd-client-5-devel.sha256sum] = "274a88ceb1ae160bb295882eb25ec3f52ed9a9d962fcd45a5e4c1b3c68eba1e8"

URI_x86_64_v2_golang-github-cactus-statsd-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-cactus-statsd-client-5.0.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-cactus-statsd-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cactus-statsd-client}"
SRC_URI[x86_64_v2_golang-github-cactus-statsd-client.sha256sum] = "236ca66ac61a035da1859a9592a8d4d1ebc6b8ab03685bfc1f470b4ad8d4688e"

URI_x86_64_v2_golang-github-cactus-statsd-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-cactus-statsd-client-devel-5.0.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-cactus-statsd-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cactus-statsd-client-devel}"
SRC_URI[x86_64_v2_golang-github-cactus-statsd-client-devel.sha256sum] = "5ff2298c86cc265b4bcb7f3940d95cc70add224080e4dfbd4b521024a8e3c7a0"

URI_aarch64_compat-golang-github-cactus-statsd-client-5-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-cactus-statsd-client-5-devel-5.0.0-13.el10_0.noarch.rpm;name=aarch64_compat-golang-github-cactus-statsd-client-5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-cactus-statsd-client-5-devel}"
SRC_URI[aarch64_compat-golang-github-cactus-statsd-client-5-devel.sha256sum] = "990aa2646ee30565d70e7b3d49da8c8ace075623e4c10f29e5288869e1d8cf85"

URI_aarch64_golang-github-cactus-statsd-client = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cactus-statsd-client-5.0.0-13.el10_0.aarch64.rpm;name=aarch64_golang-github-cactus-statsd-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cactus-statsd-client}"
SRC_URI[aarch64_golang-github-cactus-statsd-client.sha256sum] = "7b28319897cb8178706a89a9040ae2c9e03b0807b5a5de06cfeee222b02acaed"

URI_aarch64_golang-github-cactus-statsd-client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cactus-statsd-client-devel-5.0.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-cactus-statsd-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cactus-statsd-client-devel}"
SRC_URI[aarch64_golang-github-cactus-statsd-client-devel.sha256sum] = "2ad560e6de700387465170d212a2ca51fbbf07f5dc302f12db5a8a60d952dba5"

RDEPENDS:compat-golang-github-cactus-statsd-client-5-devel = " \
 go-filesystem \
 golang-github-cactus-statsd-client-devel \
 "
RDEPENDS:golang-github-cactus-statsd-client = " \
 glibc \
 "
RDEPENDS:golang-github-cactus-statsd-client-devel:x86_64_v2 = " \
 go-filesystem \
"
RDEPENDS:golang-github-cactus-statsd-client-devel:aarch64 = " \
 go-filesystem \
 golang-github-jessevdk-flags-devel \
"
