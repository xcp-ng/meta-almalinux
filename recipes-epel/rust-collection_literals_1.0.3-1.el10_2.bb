# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-collection_literals"
PV = "1.0.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-collection_literals+default-devel \
 rust-collection_literals-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-collection_literals-1.0.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b1f5a784c54f6ee4bff09a50856377ea7af01c87a2a3698a974082ac2615e319"

URI_x86_64_v2_rust-collection_literals+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-collection_literals+default-devel-1.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-collection_literals+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-collection_literals+default-devel}"
SRC_URI[x86_64_v2_rust-collection_literals+default-devel.sha256sum] = "205a14f78cb6fe9cfbf5f5ae4cf71ce42591387c64f442dc35ac3d3c2eec6b0e"

URI_x86_64_v2_rust-collection_literals-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-collection_literals-devel-1.0.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-collection_literals-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-collection_literals-devel}"
SRC_URI[x86_64_v2_rust-collection_literals-devel.sha256sum] = "31d304ae3cf625f945e0b5dd6ee4a7afcc7036c4c58356ae9d9e2e1035b2869d"

URI_aarch64_rust-collection_literals+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-collection_literals+default-devel-1.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-collection_literals+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-collection_literals+default-devel}"
SRC_URI[aarch64_rust-collection_literals+default-devel.sha256sum] = "283a1d46ff5cdde600b5957cdf1d58e5daea1f937ae1cf722cb439832174d244"

URI_aarch64_rust-collection_literals-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-collection_literals-devel-1.0.3-1.el10_2.noarch.rpm;name=aarch64_rust-collection_literals-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-collection_literals-devel}"
SRC_URI[aarch64_rust-collection_literals-devel.sha256sum] = "37e0a235c4937045a608e6056085fa66ea82136373b1e9b26c7288ee91a90aa7"

RDEPENDS:rust-collection_literals+default-devel = " \
 cargo \
 rust-collection_literals-devel \
 "
RDEPENDS:rust-collection_literals-devel = " \
 cargo \
 "
