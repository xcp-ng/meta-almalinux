# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apr"
PV = "1.7.5"
PR = "3.el10"
PACKAGES = " \
 apr \
 apr-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/apr-1.7.5-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bac04aff7643e0d069be674619b585a8a1e37eb8d7a6f76acf09c631dcaf005"

URI_x86_64_v2_apr = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-1.7.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_apr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr}"
SRC_URI[x86_64_v2_apr.sha256sum] = "42f7352c84985709bcd2873c1085b9ee73cbfeb607021901f5a990e8c257b12b"

URI_x86_64_v2_apr-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/apr-devel-1.7.5-3.el10.x86_64_v2.rpm;name=x86_64_v2_apr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apr-devel}"
SRC_URI[x86_64_v2_apr-devel.sha256sum] = "1f78633573ac48d07360142b7c3ce8ec011f8faed7a253586bc2e0a7f8223465"

URI_aarch64_apr = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-1.7.5-3.el10.aarch64.rpm;name=aarch64_apr;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr}"
SRC_URI[aarch64_apr.sha256sum] = "e0bc3d6cb26ff44ad9e044cc98e033ca3ee90f542db814dcdda358fa5a599126"

URI_aarch64_apr-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/apr-devel-1.7.5-3.el10.aarch64.rpm;name=aarch64_apr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_apr-devel}"
SRC_URI[aarch64_apr-devel.sha256sum] = "4ba67a14c6a5f6ff7874f0823a3ea8bfec8e411fba67dfd25979e17ef741148f"

RDEPENDS:apr = " \
 glibc \
 libuuid \
 libxcrypt \
 "
RDEPENDS:apr-devel = " \
 apr \
 bash \
 pkgconf-pkg-config \
 python3 \
 "
