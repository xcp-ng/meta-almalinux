# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-routinator"
PV = "0.14.2"
PR = "1.el10_1"
PACKAGES = " \
 routinator \
 rust-routinator+arbitrary-devel \
 rust-routinator+default-devel \
 rust-routinator+native-tls-devel \
 rust-routinator+rta-devel \
 rust-routinator+socks-devel \
 rust-routinator+ui-devel \
 rust-routinator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-routinator-0.14.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92de0d436d4615647d56761c155bd96a9ed3afc479ec1cb9a1f966021a3fc014"

URI_x86_64_v2_routinator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/routinator-0.14.2-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_routinator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_routinator}"
SRC_URI[x86_64_v2_routinator.sha256sum] = "a1fc9c47d39a3739d4557fd13914ecff7b4ea33ff2affe1b98ec10109c7d24a9"

URI_x86_64_v2_rust-routinator+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+arbitrary-devel-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-routinator+arbitrary-devel.sha256sum] = "23e50971808d7b23176ea3c16ab7bc0ad968d2a846856d56a02a1df9747bb49f"

URI_x86_64_v2_rust-routinator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+default-devel-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+default-devel}"
SRC_URI[x86_64_v2_rust-routinator+default-devel.sha256sum] = "d3f899e777b852c0a401702e2a440c57401fbdadee6a30a4f0a1a9308800fab9"

URI_x86_64_v2_rust-routinator+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+native-tls-devel-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+native-tls-devel}"
SRC_URI[x86_64_v2_rust-routinator+native-tls-devel.sha256sum] = "b13b1bccaaa2ebcd4ac6fd71abaf72735626c6e3cfb830838ca367ff4587db83"

URI_x86_64_v2_rust-routinator+rta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+rta-devel-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+rta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+rta-devel}"
SRC_URI[x86_64_v2_rust-routinator+rta-devel.sha256sum] = "260c4ae7724bd12ea50c285ee41400840348277e34e9b8992bfc15ec4c4265f4"

URI_x86_64_v2_rust-routinator+socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+socks-devel-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+socks-devel}"
SRC_URI[x86_64_v2_rust-routinator+socks-devel.sha256sum] = "2114a1a087c1fc7890c2e34f0e4f9b8319c73c2017487c962fe9b7486cd8d879"

URI_x86_64_v2_rust-routinator+ui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator+ui-devel-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator+ui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator+ui-devel}"
SRC_URI[x86_64_v2_rust-routinator+ui-devel.sha256sum] = "96c352af480665be99b97697592064b76cbfc4615cf2b4f83d17566150111a8f"

URI_x86_64_v2_rust-routinator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-routinator-devel-0.14.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-routinator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-routinator-devel}"
SRC_URI[x86_64_v2_rust-routinator-devel.sha256sum] = "90ead3bff13342d387416033f4f81196ec31f6b188ff2ab85089eec95fe4b5cc"

URI_aarch64_routinator = "${EPEL_MIRROR}/aarch64/Packages/r/routinator-0.14.2-1.el10_1.aarch64.rpm;name=aarch64_routinator;unpack=0"
SRC_URI:append = " ${URI_aarch64_routinator}"
SRC_URI[aarch64_routinator.sha256sum] = "da868985a87796b02e184b7138b5542341e12a1b98410da7f66510fca70bb973"

URI_aarch64_rust-routinator+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+arbitrary-devel-0.14.2-1.el10_1.noarch.rpm;name=aarch64_rust-routinator+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+arbitrary-devel}"
SRC_URI[aarch64_rust-routinator+arbitrary-devel.sha256sum] = "77862f80f63b47ac39d31b86a44aeda30bf0bfe926cb72fbe4040c7e23524415"

URI_aarch64_rust-routinator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+default-devel-0.14.2-1.el10_1.noarch.rpm;name=aarch64_rust-routinator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+default-devel}"
SRC_URI[aarch64_rust-routinator+default-devel.sha256sum] = "5f353b19d163fa2bc7081b2660b44820418c7e7cac8844158709e8af8c22e315"

URI_aarch64_rust-routinator+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+native-tls-devel-0.14.2-1.el10_1.noarch.rpm;name=aarch64_rust-routinator+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+native-tls-devel}"
SRC_URI[aarch64_rust-routinator+native-tls-devel.sha256sum] = "0824c05003fca5f85bb539132f8d43a819020db871c65600c37239bf460c1e49"

URI_aarch64_rust-routinator+rta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+rta-devel-0.14.2-1.el10_1.noarch.rpm;name=aarch64_rust-routinator+rta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+rta-devel}"
SRC_URI[aarch64_rust-routinator+rta-devel.sha256sum] = "fb10808834416003756c7b727ce846fb027c8c833bc2bdceb6ac2ba12c61da03"

URI_aarch64_rust-routinator+socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+socks-devel-0.14.2-1.el10_1.noarch.rpm;name=aarch64_rust-routinator+socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+socks-devel}"
SRC_URI[aarch64_rust-routinator+socks-devel.sha256sum] = "fb00862fdfc691159105c70be477beef257816322d809a54e4c4a00195d80609"

URI_aarch64_rust-routinator+ui-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator+ui-devel-0.14.2-1.el10_1.noarch.rpm;name=aarch64_rust-routinator+ui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator+ui-devel}"
SRC_URI[aarch64_rust-routinator+ui-devel.sha256sum] = "52acae8444fa503310be7655fe6f1619072557a881f993e7b6e989e0397baf30"

URI_aarch64_rust-routinator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-routinator-devel-0.14.2-1.el10_1.noarch.rpm;name=aarch64_rust-routinator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-routinator-devel}"
SRC_URI[aarch64_rust-routinator-devel.sha256sum] = "62c1c1fb786f93fd7159cf45b36ce070abe828a0255021619daee88cacbef81a"

RDEPENDS:routinator = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-routinator+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono+arbitrary-devel \
 rust-routinator-devel \
 rust-rpki+arbitrary-devel \
 "
RDEPENDS:rust-routinator+default-devel = " \
 cargo \
 rust-routinator+socks-devel \
 rust-routinator+ui-devel \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+native-tls-devel = " \
 cargo \
 rust-reqwest+native-tls-devel \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+rta-devel = " \
 cargo \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+socks-devel = " \
 cargo \
 rust-reqwest+socks-devel \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator+ui-devel = " \
 cargo \
 rust-routinator-devel \
 "
RDEPENDS:rust-routinator-devel = " \
 bash \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-chrono+default-devel \
 rust-clap+cargo-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 rust-clap+wrap_help-devel \
 rust-crossbeam-queue+default-devel \
 rust-dirs+default-devel \
 rust-form_urlencoded+default-devel \
 rust-futures+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+default-devel \
 rust-hyper+server-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+server-devel \
 rust-listenfd+default-devel \
 rust-log+default-devel \
 rust-nix0.27+default-devel \
 rust-nix0.27+fs-devel \
 rust-nix0.27+mman-devel \
 rust-nix0.27+net-devel \
 rust-nix0.27+process-devel \
 rust-nix0.27+socket-devel \
 rust-nix0.27+user-devel \
 rust-pin-project-lite+default-devel \
 rust-rand0.8+default-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+rustls-tls-devel \
 rust-reqwest-devel \
 rust-ring+default-devel \
 rust-rpki+default-devel \
 rust-rpki+repository-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-devel \
 rust-rpki+slurm-devel \
 rust-rustls-pemfile+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-siphasher+default-devel \
 rust-syslog+default-devel \
 rust-tempfile+default-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+sync-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 rust-toml_edit0.22+default-devel \
 rust-uuid+default-devel \
 "
