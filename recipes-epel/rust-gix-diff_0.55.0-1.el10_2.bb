# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-diff"
PV = "0.55.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-diff+blob-devel \
 rust-gix-diff+default-devel \
 rust-gix-diff+document-features-devel \
 rust-gix-diff+index-devel \
 rust-gix-diff+serde-devel \
 rust-gix-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-diff-0.55.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2d4b09835d663ecbc26af60170850c1e026a7802de2b81c7a42babff176c5e8"

URI_x86_64_v2_rust-gix-diff+blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+blob-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+blob-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+blob-devel.sha256sum] = "9032100e331e108739ad6610bf2a3588fdde16791ad7e6dc240080c3cd2c481d"

URI_x86_64_v2_rust-gix-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+default-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+default-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+default-devel.sha256sum] = "5598d5907e33cd14fcd83e031abea740d5e43e0072eabc7bb52b1f66a5b23121"

URI_x86_64_v2_rust-gix-diff+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+document-features-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+document-features-devel.sha256sum] = "ca8d48aa831ca435a161bd4c91af098069a4b30873d6d8db883559f01a875347"

URI_x86_64_v2_rust-gix-diff+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+index-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+index-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+index-devel.sha256sum] = "718eedb2846a14ba52bc29da82ca00df6a0dc2ede192bbee765b4227f161027a"

URI_x86_64_v2_rust-gix-diff+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+serde-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+serde-devel.sha256sum] = "d6646106462e31dab1f3474dd995ec3ddc5a25c170dc79cd54841cca3e84c33c"

URI_x86_64_v2_rust-gix-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff-devel-0.55.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff-devel}"
SRC_URI[x86_64_v2_rust-gix-diff-devel.sha256sum] = "9052e84088d03c5c56181b4abd8067c422b5ba26d19a823f3dfe8b9fe32aacb2"

URI_aarch64_rust-gix-diff+blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+blob-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-diff+blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+blob-devel}"
SRC_URI[aarch64_rust-gix-diff+blob-devel.sha256sum] = "e65088ca31c6d4471064f1378654b8d8cc21081477e8768b6e49fe179f9d5bfa"

URI_aarch64_rust-gix-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+default-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+default-devel}"
SRC_URI[aarch64_rust-gix-diff+default-devel.sha256sum] = "53ccdefdfbf11236330c944c00c82eb35bbd46ea7e50bdb2221f822ab77c2015"

URI_aarch64_rust-gix-diff+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+document-features-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-diff+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+document-features-devel}"
SRC_URI[aarch64_rust-gix-diff+document-features-devel.sha256sum] = "b6aa8514d48606476d4c6fe80134c34d6cbbe12aa6446401a1b91b6492386e9f"

URI_aarch64_rust-gix-diff+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+index-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-diff+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+index-devel}"
SRC_URI[aarch64_rust-gix-diff+index-devel.sha256sum] = "d19a6bd21b14aab4531f45748f6fb50d1896d155b04c5bdc4c32aa8082fb279a"

URI_aarch64_rust-gix-diff+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+serde-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-diff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+serde-devel}"
SRC_URI[aarch64_rust-gix-diff+serde-devel.sha256sum] = "9afb8e4e03122c19906ab479f7805a8d7cbe26322849031061b6a6849211271f"

URI_aarch64_rust-gix-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff-devel-0.55.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff-devel}"
SRC_URI[aarch64_rust-gix-diff-devel.sha256sum] = "12116cc36e767817a15e4245b85a61ef5434545775af1e5fb250db8f1767b1d5"

RDEPENDS:rust-gix-diff+blob-devel = " \
 cargo \
 rust-gix-command+default-devel \
 rust-gix-diff-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-path+default-devel \
 rust-gix-tempfile+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-imara-diff0.1+default-devel \
 "
RDEPENDS:rust-gix-diff+default-devel = " \
 cargo \
 rust-gix-diff+blob-devel \
 rust-gix-diff+index-devel \
 rust-gix-diff-devel \
 "
RDEPENDS:rust-gix-diff+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-diff-devel \
 "
RDEPENDS:rust-gix-diff+index-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-diff-devel \
 rust-gix-index+default-devel \
 rust-gix-pathspec+default-devel \
 "
RDEPENDS:rust-gix-diff+serde-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hash+serde-devel \
 rust-gix-index+default-devel \
 rust-gix-index+serde-devel \
 rust-gix-object+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-diff-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-thiserror+default-devel \
 "
