# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pf-bb-config"
PV = "25.11"
PR = "1.el10"
PACKAGES = " \
 pf-bb-config \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/pf-bb-config-25.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "49fd0c81847a6b1f28367d9c3c9c43710e546716df2cfd57abc90f6df1a560c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pf-bb-config-25.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_pf-bb-config;unpack=0"
SRC_URI[x86_64_v2_pf-bb-config.sha256sum] = "ac4e798dc471d92bde1e3c4d204cf5653614d5d1e7058d27dc25fa1dc39fc307"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pf-bb-config-25.11-1.el10.aarch64.rpm;name=aarch64_pf-bb-config;unpack=0"
SRC_URI[aarch64_pf-bb-config.sha256sum] = "47587ec2022082c55337cb12f6a9f4fd3b0a4da8075f3215dfaa67d0211154c2"

RDEPENDS:pf-bb-config = " \
 glibc \
 "
