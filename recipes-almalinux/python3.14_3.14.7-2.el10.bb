# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3.14"
PV = "3.14.7"
PR = "2.el10"
PACKAGES = " \
 python3.14 \
 python3.14-debug \
 python3.14-devel \
 python3.14-freethreading \
 python3.14-freethreading-debug \
 python3.14-freethreading-devel \
 python3.14-freethreading-idle \
 python3.14-freethreading-libs \
 python3.14-freethreading-test \
 python3.14-freethreading-tkinter \
 python3.14-idle \
 python3.14-libs \
 python3.14-test \
 python3.14-tkinter \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python3.14-3.14.7-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2865e1e644771c63ff9fae9291df1a3e823baaa0bbdf66a1ca1aad68d4241c58"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3.14-freethreading-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)
# - python3.14-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3.14-freethreading-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)
# - python3.14-test: (python3.14-wheel-wheel if python3.14-setuptools-wheel < 71)

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14;unpack=0"
SRC_URI[x86_64_v2_python3.14.sha256sum] = "e0acbd8a596fd794e35293de610287de5ab7be5a34784a04f48545dd79acb180"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-debug-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-debug;unpack=0"
SRC_URI[x86_64_v2_python3.14-debug.sha256sum] = "167ec1b878b86024dc3c108f5effd7b9dda90de72e1e8e75682359767e8a4de7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-devel-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-devel;unpack=0"
SRC_URI[x86_64_v2_python3.14-devel.sha256sum] = "3d0e7180a94f5892d1cd24c237a01798ef76dcacaf0171f54bb535298836d66e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading.sha256sum] = "f7e38eab4746173b6b41beb01173bd8da512a2fb57d5d48b41b42c5d561125ee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-debug-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-debug;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-debug.sha256sum] = "94aa6c3776ceaeb36b28e37ea5396227fa376702f68a13e0e8a045e290fe73d4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-devel-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-devel;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-devel.sha256sum] = "e54d54de3bbcf30f824891c19ea31e4dde3a8f79b2312e3109f05b2f681a859d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-idle-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-idle;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-idle.sha256sum] = "841066fd8635c1d10824a4acd3b2fb6a0cb9d86506b8f2c437bef363f2d1e1c4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-libs-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-libs;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-libs.sha256sum] = "efbe7c46ada6c9cdad4ce26c64caec6cbee907f0977b2f8b33a9ca0ec2275719"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-test-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-test;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-test.sha256sum] = "08ba32e056b90fd6b0d267fdb363f31e5e280e3083009a3568a4ad91b19d76aa"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-freethreading-tkinter-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-freethreading-tkinter;unpack=0"
SRC_URI[x86_64_v2_python3.14-freethreading-tkinter.sha256sum] = "71abafafdeadd7d097101c4dca506b4851c7ebf88b7dee297229afd19cd727c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-idle-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-idle;unpack=0"
SRC_URI[x86_64_v2_python3.14-idle.sha256sum] = "0228261703b1d481c09c8a30aceaa124a8070e343a6128463d892950a9b9dedd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-libs-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-libs;unpack=0"
SRC_URI[x86_64_v2_python3.14-libs.sha256sum] = "0a21dcb8676ebb65eb88676cc806d1cfffe50fc34ad065232e5469a1aa222bb5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3.14-test-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-test;unpack=0"
SRC_URI[x86_64_v2_python3.14-test.sha256sum] = "c29b86e865a11dd95b308259cbda02991f5aee3afda4653419ef8871ef4063f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3.14-tkinter-3.14.7-2.el10.x86_64_v2.rpm;name=x86_64_v2_python3.14-tkinter;unpack=0"
SRC_URI[x86_64_v2_python3.14-tkinter.sha256sum] = "12662efb90413ab3378f2bddfd0f8370d9bd6e3498ceed77dd4701c6923ddeb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14;unpack=0"
SRC_URI[aarch64_python3.14.sha256sum] = "6b19c485119d1f8f87fba6a6d1864b47d680363919b4aebea4a0861c21e94e26"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-debug-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-debug;unpack=0"
SRC_URI[aarch64_python3.14-debug.sha256sum] = "01fd8dc32d602611b5a2fb9b0975776c323dfedfb09f6b401adbab7f91e4a2f8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-devel-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-devel;unpack=0"
SRC_URI[aarch64_python3.14-devel.sha256sum] = "0b1b498a81128006fca8ecb222b2992bbb45eca6ec16a4ac683153f65dbbd6f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-freethreading;unpack=0"
SRC_URI[aarch64_python3.14-freethreading.sha256sum] = "1a70ac6dae6d0b904ad643a2d87c27f65ca4322d8d92ae4ba51bd2521da17a2d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-debug-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-debug;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-debug.sha256sum] = "8e7a301b1fb3a56e84bbd1112eff910607ebc93b4241f276df877e03cf445c3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-devel-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-devel;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-devel.sha256sum] = "79694670d7b5a486473c9745f1286c7db5d26914d4ab9e1954b1006f6e954ed4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-idle-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-idle;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-idle.sha256sum] = "27d9d7e55c763c2b6cc2271405c3d7d565c2113f0828f072c1b64d930389d7fb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-libs-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-libs;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-libs.sha256sum] = "57819b1512fab94e7a4739af6281016d1f40ae16cd52149c89a8dd53e540fbed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-test-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-test;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-test.sha256sum] = "54783f9da5f53092264ae58ee04afc400dcd692534d14b7cd2a1c6c2051d662c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-freethreading-tkinter-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-freethreading-tkinter;unpack=0"
SRC_URI[aarch64_python3.14-freethreading-tkinter.sha256sum] = "ed24faa15547086ffda9cc2f1e6f904c0f96b86043403d9db089480e6268c4f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-idle-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-idle;unpack=0"
SRC_URI[aarch64_python3.14-idle.sha256sum] = "796a2e82eb71e250b12eaebcc32bf07d7e55431c76226bc080f2259c551b2bd7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-libs-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-libs;unpack=0"
SRC_URI[aarch64_python3.14-libs.sha256sum] = "c8f7666b17124deeded75979bac744ad862a7b7eb81da98b02dbf1e3ea751f9f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3.14-test-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-test;unpack=0"
SRC_URI[aarch64_python3.14-test.sha256sum] = "eed4bc32c61c5958092eaee088b833e19cce8680b378516cfd0d42b2e296e335"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3.14-tkinter-3.14.7-2.el10.aarch64.rpm;name=aarch64_python3.14-tkinter;unpack=0"
SRC_URI[aarch64_python3.14-tkinter.sha256sum] = "fded33912461f0199649f214883dd4220ad15edf6fa84321be38a9468f18e7ed"

RDEPENDS:python3.14 = " \
 glibc \
 python3.14-libs \
 "
RDEPENDS:python3.14-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.14 \
 python3.14-devel \
 python3.14-idle \
 python3.14-libs \
 python3.14-test \
 python3.14-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-devel = " \
 bash \
 pkgconf-pkg-config \
 python-rpm-macros \
 python3-rpm-generators \
 python3-rpm-macros \
 python3.14 \
 python3.14-libs \
 "
RDEPENDS:python3.14-freethreading = " \
 glibc \
 python3.14-freethreading-libs \
 "
RDEPENDS:python3.14-freethreading-debug = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libgcc \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 pkgconf-pkg-config \
 python3.14-freethreading \
 python3.14-freethreading-devel \
 python3.14-freethreading-idle \
 python3.14-freethreading-libs \
 python3.14-freethreading-test \
 python3.14-freethreading-tkinter \
 readline \
 sqlite-libs \
 tcl \
 tk \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-freethreading-devel = " \
 bash \
 pkgconf-pkg-config \
 python3.14-freethreading \
 python3.14-freethreading-libs \
 "
RDEPENDS:python3.14-freethreading-idle = " \
 python3.14-freethreading \
 python3.14-freethreading-tkinter \
 "
RDEPENDS:python3.14-freethreading-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.14-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-freethreading-test = " \
 bash \
 glibc \
 libgcc \
 python3.14-freethreading \
 python3.14-freethreading-libs \
 python3.14-setuptools-wheel \
 "
RDEPENDS:python3.14-freethreading-tkinter = " \
 glibc \
 python3.14-freethreading \
 tcl \
 tk \
 "
RDEPENDS:python3.14-idle = " \
 python3.14 \
 python3.14-tkinter \
 "
RDEPENDS:python3.14-libs = " \
 bash \
 bzip2-libs \
 expat \
 gdbm-libs \
 glibc \
 libffi \
 libuuid \
 libzstd \
 mpdecimal \
 ncurses-libs \
 openssl-libs \
 python3.14-pip-wheel \
 readline \
 sqlite-libs \
 tzdata \
 xz-libs \
 zlib-ng-compat \
 "
RDEPENDS:python3.14-test = " \
 bash \
 glibc \
 libgcc \
 python3.14 \
 python3.14-libs \
 python3.14-setuptools-wheel \
 "
RDEPENDS:python3.14-tkinter = " \
 glibc \
 python3.14 \
 tcl \
 tk \
 "
