# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xprop"
PV = "1.2.7"
PR = "3.el10"
PACKAGES = " \
 xprop \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xprop-1.2.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "85dd471c03c6c746fcb5086140116ef5f7935a4cdd3931bc936b2100e03d33ed"

URI_x86_64_v2_xprop = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xprop-1.2.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_xprop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xprop}"
SRC_URI[x86_64_v2_xprop.sha256sum] = "7100995bfba294290ca0693cf74a049d29fb3de065908ea0af40d4a57102d16c"

URI_aarch64_xprop = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xprop-1.2.7-3.el10.aarch64.rpm;name=aarch64_xprop;unpack=0"
SRC_URI:append = " ${URI_aarch64_xprop}"
SRC_URI[aarch64_xprop.sha256sum] = "a8efeb187f92006c70b836755023dff67a4a4f87938b253db350c1f6c9c8a90f"

RDEPENDS:xprop = " \
 glibc \
 libX11 \
 "
