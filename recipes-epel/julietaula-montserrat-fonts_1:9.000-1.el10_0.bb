# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "julietaula-montserrat-fonts"
PE = "1"
PV = "9.000"
PR = "1.el10_0"
PACKAGES = " \
 julietaula-montserrat-alternates-fonts \
 julietaula-montserrat-fonts \
 julietaula-montserrat-underline-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/j/julietaula-montserrat-fonts-9.000-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "984b15edb64f7b5e9a1fc22a75896b33ff105b6f17c21ec08e68714a5d3745c4"

URI_x86_64_v2_julietaula-montserrat-alternates-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/julietaula-montserrat-alternates-fonts-9.000-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_julietaula-montserrat-alternates-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_julietaula-montserrat-alternates-fonts}"
SRC_URI[x86_64_v2_julietaula-montserrat-alternates-fonts.sha256sum] = "068f44ceda14e37be95739de59da3ab858b35fc1bc0ea50bc1dd9d61e09560a9"

URI_x86_64_v2_julietaula-montserrat-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/julietaula-montserrat-fonts-9.000-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_julietaula-montserrat-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_julietaula-montserrat-fonts}"
SRC_URI[x86_64_v2_julietaula-montserrat-fonts.sha256sum] = "a5dad3c43aa19bfeaafbd3cd9928695030d7013141f695039ebe59452cc51bf7"

URI_x86_64_v2_julietaula-montserrat-underline-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/julietaula-montserrat-underline-fonts-9.000-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_julietaula-montserrat-underline-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_julietaula-montserrat-underline-fonts}"
SRC_URI[x86_64_v2_julietaula-montserrat-underline-fonts.sha256sum] = "57536207a4c22629789fcc0a3c63d752fdb0204d0aa1445e565ac453dd63ee03"

URI_aarch64_julietaula-montserrat-alternates-fonts = "${EPEL_MIRROR}/aarch64/Packages/j/julietaula-montserrat-alternates-fonts-9.000-1.el10_0.noarch.rpm;name=aarch64_julietaula-montserrat-alternates-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_julietaula-montserrat-alternates-fonts}"
SRC_URI[aarch64_julietaula-montserrat-alternates-fonts.sha256sum] = "932cb82740d22cc3d2c3c10d2b9d211b060651b701283a96fdcbb039aeeaa85d"

URI_aarch64_julietaula-montserrat-fonts = "${EPEL_MIRROR}/aarch64/Packages/j/julietaula-montserrat-fonts-9.000-1.el10_0.noarch.rpm;name=aarch64_julietaula-montserrat-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_julietaula-montserrat-fonts}"
SRC_URI[aarch64_julietaula-montserrat-fonts.sha256sum] = "537fd41c2affd54a54ef9d47eed287d1ff4ef85062d650ad9d69d3b5396ce57a"

URI_aarch64_julietaula-montserrat-underline-fonts = "${EPEL_MIRROR}/aarch64/Packages/j/julietaula-montserrat-underline-fonts-9.000-1.el10_0.noarch.rpm;name=aarch64_julietaula-montserrat-underline-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_julietaula-montserrat-underline-fonts}"
SRC_URI[aarch64_julietaula-montserrat-underline-fonts.sha256sum] = "1c575f8fcafa57dace83aa147b136e9461395800489adfb3e0ad4740cbfb0994"

RDEPENDS:julietaula-montserrat-alternates-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:julietaula-montserrat-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:julietaula-montserrat-underline-fonts = " \
 fonts-filesystem \
 "
