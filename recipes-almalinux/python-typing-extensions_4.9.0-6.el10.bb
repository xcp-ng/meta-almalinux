# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-typing-extensions"
PV = "4.9.0"
PR = "6.el10"
PACKAGES = " \
 python3-typing-extensions \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/python-typing-extensions-4.9.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1faecb08dfe02fd5735886cd84547d1a069cfdefe0b4e040816ac80cb654a199"

URI_x86_64_v2_python3-typing-extensions = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-typing-extensions-4.9.0-6.el10.noarch.rpm;name=x86_64_v2_python3-typing-extensions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-typing-extensions}"
SRC_URI[x86_64_v2_python3-typing-extensions.sha256sum] = "b323e7e183cda698488c44cd91f8fafffc78a910bc313d2d0de1a6ea5e21e040"

URI_aarch64_python3-typing-extensions = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-typing-extensions-4.9.0-6.el10.noarch.rpm;name=aarch64_python3-typing-extensions;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-typing-extensions}"
SRC_URI[aarch64_python3-typing-extensions.sha256sum] = "b323e7e183cda698488c44cd91f8fafffc78a910bc313d2d0de1a6ea5e21e040"

RDEPENDS:python3-typing-extensions = " \
 python3 \
 "
