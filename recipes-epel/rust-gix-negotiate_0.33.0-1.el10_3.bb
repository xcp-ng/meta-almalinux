# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-negotiate"
PV = "0.33.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-negotiate+default-devel \
 rust-gix-negotiate+sha1-devel \
 rust-gix-negotiate+sha256-devel \
 rust-gix-negotiate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-negotiate-0.33.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf631450a107febe0fa558a93cc6a2b1075e3a2dfe7175992f960b5d31ebafd5"

URI_x86_64_v2_rust-gix-negotiate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate+default-devel-0.33.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate+default-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate+default-devel.sha256sum] = "35fcd1575b0e62c77f2161ef399497feebfa88caeb977907c72b1308ae8a9db3"

URI_x86_64_v2_rust-gix-negotiate+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate+sha1-devel-0.33.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate+sha1-devel.sha256sum] = "cedb598054436f0917d473e91fea978fe64edee27c50be44e9554859bc66e16c"

URI_x86_64_v2_rust-gix-negotiate+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate+sha256-devel-0.33.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate+sha256-devel.sha256sum] = "16f395f8cb3f1395b63f4a4f1d4b4c022f72dbf777cb1d4b2cc035872217cd1a"

URI_x86_64_v2_rust-gix-negotiate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-negotiate-devel-0.33.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-negotiate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-negotiate-devel}"
SRC_URI[x86_64_v2_rust-gix-negotiate-devel.sha256sum] = "a71fc91544a2938f863259b7b9a53c5bfe11ddd7746c2b82d6fa9bce092c975b"

URI_aarch64_rust-gix-negotiate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate+default-devel-0.33.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-negotiate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate+default-devel}"
SRC_URI[aarch64_rust-gix-negotiate+default-devel.sha256sum] = "ffd0cae6e7398193e0194a7b6f95ccd666b6ea10a83df5657127830b56335024"

URI_aarch64_rust-gix-negotiate+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate+sha1-devel-0.33.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-negotiate+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate+sha1-devel}"
SRC_URI[aarch64_rust-gix-negotiate+sha1-devel.sha256sum] = "0f55bd1ade34e3d87cff053db44b88c12c07081aeafd5870b11c851c1648c429"

URI_aarch64_rust-gix-negotiate+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate+sha256-devel-0.33.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-negotiate+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate+sha256-devel}"
SRC_URI[aarch64_rust-gix-negotiate+sha256-devel.sha256sum] = "989b8c2dda2e1e757bd607bb4ff32db4aea7ed1444447a209dbfbf77de1d36ae"

URI_aarch64_rust-gix-negotiate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-negotiate-devel-0.33.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-negotiate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-negotiate-devel}"
SRC_URI[aarch64_rust-gix-negotiate-devel.sha256sum] = "14407f84081e5882b5322be104efd0e96c3351eb79454839774dd1f4eefca815"

RDEPENDS:rust-gix-negotiate+default-devel = " \
 cargo \
 rust-gix-negotiate-devel \
 "
RDEPENDS:rust-gix-negotiate+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-negotiate-devel \
 "
RDEPENDS:rust-gix-negotiate+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-negotiate-devel \
 "
RDEPENDS:rust-gix-negotiate-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 "
