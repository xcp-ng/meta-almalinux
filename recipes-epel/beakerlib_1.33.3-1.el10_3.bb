# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "beakerlib"
PV = "1.33.3"
PR = "1.el10_3"
PACKAGES = " \
 beakerlib \
 beakerlib-vim-syntax \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/beakerlib-1.33.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8c4015d54257fa3c8430ad488483fe1a7200445b9964554d7ae8961f29dd49bd"

URI_x86_64_v2_beakerlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beakerlib-1.33.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_beakerlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beakerlib}"
SRC_URI[x86_64_v2_beakerlib.sha256sum] = "1d6a67379bb207de4b3aed9c1e82a20b4416176b377396a0ca5c8ee95eac5944"

URI_x86_64_v2_beakerlib-vim-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beakerlib-vim-syntax-1.33.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_beakerlib-vim-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beakerlib-vim-syntax}"
SRC_URI[x86_64_v2_beakerlib-vim-syntax.sha256sum] = "a74dbac5413b87e47d289be5968482ff7a55bc357bc5a28a00ad9b168342bc1a"

URI_aarch64_beakerlib = "${EPEL_MIRROR}/aarch64/Packages/b/beakerlib-1.33.3-1.el10_3.noarch.rpm;name=aarch64_beakerlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_beakerlib}"
SRC_URI[aarch64_beakerlib.sha256sum] = "9d2c09f6db99733c8fdefff6418822c16ca62666d165ae0c12ee7547b693b765"

URI_aarch64_beakerlib-vim-syntax = "${EPEL_MIRROR}/aarch64/Packages/b/beakerlib-vim-syntax-1.33.3-1.el10_3.noarch.rpm;name=aarch64_beakerlib-vim-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_beakerlib-vim-syntax}"
SRC_URI[aarch64_beakerlib-vim-syntax.sha256sum] = "1b09a988e89554d885d4f8412f823aacb1728c5e338973c2c3f7d1d7d6052b19"

RDEPENDS:beakerlib = " \
 bash \
 bc \
 dnf-plugins-core \
 grep \
 gzip \
 iproute \
 nfs-utils \
 python3-dnf \
 sed \
 tar \
 time \
 util-linux \
 virtual/coreutils \
 virtual/wget_or_curl \
 which \
 "
RDEPENDS:beakerlib-vim-syntax = " \
 vim-common \
 "
