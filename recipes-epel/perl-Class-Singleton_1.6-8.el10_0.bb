# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Singleton"
PV = "1.6"
PR = "8.el10_0"
PACKAGES = " \
 perl-Class-Singleton \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Singleton-1.6-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ced762ccd4aa2f249138a3ce970b87169c831688e32035c6351acdc1b096e7bd"

URI_x86_64_v2_perl-Class-Singleton = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Singleton-1.6-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Singleton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Singleton}"
SRC_URI[x86_64_v2_perl-Class-Singleton.sha256sum] = "08c0fe4ae709c266f944ee260545d1a1ee84280a5bedc879540847b0fbd643ae"

URI_aarch64_perl-Class-Singleton = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Singleton-1.6-8.el10_0.noarch.rpm;name=aarch64_perl-Class-Singleton;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Singleton}"
SRC_URI[aarch64_perl-Class-Singleton.sha256sum] = "876d3ad0bf53c53462a7f5c242443bf16fe392c84d9d97265bf2c7bb508bad8c"

RDEPENDS:perl-Class-Singleton = " \
 perl-libs \
 "
