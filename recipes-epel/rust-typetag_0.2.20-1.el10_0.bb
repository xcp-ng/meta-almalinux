# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typetag"
PV = "0.2.20"
PR = "1.el10_0"
PACKAGES = " \
 rust-typetag+default-devel \
 rust-typetag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-typetag-0.2.20-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ee6b42eb8675efb6265d88b3f7333c717e83880b36c98f5be5c16fd4e432410"

URI_x86_64_v2_rust-typetag+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag+default-devel-0.2.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag+default-devel}"
SRC_URI[x86_64_v2_rust-typetag+default-devel.sha256sum] = "8410887496c2966b1ecb24d89ed84693c9d0185014fd4c039c11302a5d5d8d59"

URI_x86_64_v2_rust-typetag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-devel-0.2.20-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-typetag-devel}"
SRC_URI[x86_64_v2_rust-typetag-devel.sha256sum] = "ec24f31e90a1d6d1481750a921d28294decbd345e5aa90abcd05e0f34e3bf97c"

URI_aarch64_rust-typetag+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag+default-devel-0.2.20-1.el10_0.noarch.rpm;name=aarch64_rust-typetag+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag+default-devel}"
SRC_URI[aarch64_rust-typetag+default-devel.sha256sum] = "4505c6de1241e13b9b85d63daa11124c55cdd32be89d17bc64fc92db440ea759"

URI_aarch64_rust-typetag-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-devel-0.2.20-1.el10_0.noarch.rpm;name=aarch64_rust-typetag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-typetag-devel}"
SRC_URI[aarch64_rust-typetag-devel.sha256sum] = "dd40f0b956d667f2d959a93319b36b851983656d29f1a2a9c830ce158c65a21e"

RDEPENDS:rust-typetag+default-devel = " \
 cargo \
 rust-typetag-devel \
 "
RDEPENDS:rust-typetag-devel = " \
 cargo \
 rust \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-inventory+default-devel \
 rust-once_cell+alloc-devel \
 rust-once_cell-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-typetag-impl+default-devel \
 "
