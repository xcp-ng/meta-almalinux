# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo_toml_edit"
PV = "0.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo_toml_edit+default-devel \
 rust-cargo_toml_edit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo_toml_edit-0.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "674865de28d2872585333c7c10e95bf44c71e30dc1601049452d671b1d934f5f"

URI_x86_64_v2_rust-cargo_toml_edit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml_edit+default-devel-0.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml_edit+default-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml_edit+default-devel.sha256sum] = "a4055e2aa5bd38d0e2afa2510810136544e9e9d7a0b071e92cd6e6547ca1ae2b"

URI_x86_64_v2_rust-cargo_toml_edit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo_toml_edit-devel-0.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo_toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo_toml_edit-devel}"
SRC_URI[x86_64_v2_rust-cargo_toml_edit-devel.sha256sum] = "433b0af3bb9ff6f10cd15f4fd17d97c2c566a6ad2ee4cff383418d81c0c1517b"

URI_aarch64_rust-cargo_toml_edit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml_edit+default-devel-0.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-cargo_toml_edit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml_edit+default-devel}"
SRC_URI[aarch64_rust-cargo_toml_edit+default-devel.sha256sum] = "e3d413d908cfd44395fb7f5420755990a11596456c3597f807b89c06acfccbda"

URI_aarch64_rust-cargo_toml_edit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo_toml_edit-devel-0.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-cargo_toml_edit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo_toml_edit-devel}"
SRC_URI[aarch64_rust-cargo_toml_edit-devel.sha256sum] = "8948ef3810920ac1b255f936a2856ffd9000bbf667edebeb47f7a7bf76641419"

RDEPENDS:rust-cargo_toml_edit+default-devel = " \
 cargo \
 rust-cargo_toml_edit-devel \
 "
RDEPENDS:rust-cargo_toml_edit-devel = " \
 cargo \
 rust \
 rust-cfg-expr+default-devel \
 rust-log+default-devel \
 rust-thiserror+default-devel \
 rust-toml_edit+default-devel \
 "
