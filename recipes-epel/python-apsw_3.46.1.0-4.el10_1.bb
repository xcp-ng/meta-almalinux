# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-apsw"
PV = "3.46.1.0"
PR = "4.el10_1"
PACKAGES = " \
 python3-apsw \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-apsw-3.46.1.0-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7a7927b3bc3901d9a96edd65b46522bd0e9d387e05b0e94ce28c7322587117b"

URI_x86_64_v2_python3-apsw = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-apsw-3.46.1.0-4.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-apsw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-apsw}"
SRC_URI[x86_64_v2_python3-apsw.sha256sum] = "bdb4284fa73ef299302997a08628b88e93c2583afc27997a6bb678dbf24e6469"

URI_aarch64_python3-apsw = "${EPEL_MIRROR}/aarch64/Packages/p/python3-apsw-3.46.1.0-4.el10_1.aarch64.rpm;name=aarch64_python3-apsw;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-apsw}"
SRC_URI[aarch64_python3-apsw.sha256sum] = "2d40f8d262e0131edd04fb08e2a78eabdadcc1217d6970e6fd9880313822686c"

RDEPENDS:python3-apsw = " \
 glibc \
 python3 \
 sqlite-libs \
 "
