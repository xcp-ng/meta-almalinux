# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clru"
PV = "0.6.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-clru+default-devel \
 rust-clru-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clru-0.6.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f364414454778ff1d51ae899e5bc2d73e56763606b1aed97f061ae91b1245514"

URI_x86_64_v2_rust-clru+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clru+default-devel-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clru+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clru+default-devel}"
SRC_URI[x86_64_v2_rust-clru+default-devel.sha256sum] = "ebc4a60f95783883dc1eab2276d387cf3ca87e3a9d936a8b6f0ad5ad4ddefae9"

URI_x86_64_v2_rust-clru-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clru-devel-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clru-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clru-devel}"
SRC_URI[x86_64_v2_rust-clru-devel.sha256sum] = "3f1825fd51f410cdbef768c61dfae32148f85aa0b11b8fdf92d601d931b4b893"

URI_aarch64_rust-clru+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clru+default-devel-0.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-clru+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clru+default-devel}"
SRC_URI[aarch64_rust-clru+default-devel.sha256sum] = "4d466bf1f2c458833ea7ad81f87f419028a17c9c3a735f9707f38cde4210cff0"

URI_aarch64_rust-clru-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clru-devel-0.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-clru-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clru-devel}"
SRC_URI[aarch64_rust-clru-devel.sha256sum] = "87c6777670ff2793b3c6429ca7d390f13522310a4a7d5d3142a8e96bd459ae06"

RDEPENDS:rust-clru+default-devel = " \
 cargo \
 rust-clru-devel \
 "
RDEPENDS:rust-clru-devel = " \
 cargo \
 "
