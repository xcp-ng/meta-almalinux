# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsepol"
PV = "3.8"
PR = "1.el10"
PACKAGES = " \
 libsepol \
 libsepol-devel \
 libsepol-static \
 libsepol-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libsepol-3.8-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9e81b420eb5455d6cbfba3fc6dd822e6dc393af3f276d353c3acb1e85974cb3"

URI_x86_64_v2_libsepol = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsepol-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol}"
SRC_URI[x86_64_v2_libsepol.sha256sum] = "fd50fedd5e8a66b03f99c608aa9eb08ba0b5e642bd0492b72f3cc212e762ba7c"

URI_x86_64_v2_libsepol-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-devel-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-devel}"
SRC_URI[x86_64_v2_libsepol-devel.sha256sum] = "a4dc3bec478ab9c84440a6805b7779d74f55f2cec6cc13d254e1ef6a3c9f163c"

URI_x86_64_v2_libsepol-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsepol-static-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-static}"
SRC_URI[x86_64_v2_libsepol-static.sha256sum] = "0ed1d4ba6b65d210c55362469e3f6ff83fd76cd6ec51137347a65b364c3a60bb"

URI_x86_64_v2_libsepol-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsepol-utils-3.8-1.el10.x86_64_v2.rpm;name=x86_64_v2_libsepol-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsepol-utils}"
SRC_URI[x86_64_v2_libsepol-utils.sha256sum] = "b2293a10b0147ea923fd9d70babb4f422f2ca30564168b8fbf688d7dd4918ad7"

URI_aarch64_libsepol = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsepol-3.8-1.el10.aarch64.rpm;name=aarch64_libsepol;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol}"
SRC_URI[aarch64_libsepol.sha256sum] = "32d58772153692e6ac295beca1a3d3dfd9eeb95e01ba1290f636016416071660"

URI_aarch64_libsepol-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-devel-3.8-1.el10.aarch64.rpm;name=aarch64_libsepol-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-devel}"
SRC_URI[aarch64_libsepol-devel.sha256sum] = "85ffa350043855ef46cfb915b6fd170b6ec218660761d2482f069f3fb7d0df5b"

URI_aarch64_libsepol-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsepol-static-3.8-1.el10.aarch64.rpm;name=aarch64_libsepol-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-static}"
SRC_URI[aarch64_libsepol-static.sha256sum] = "2a2c4c2840dfd3181be776a5a5dcefd9193cbf81dd8c828070cd4c4152259c66"

URI_aarch64_libsepol-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsepol-utils-3.8-1.el10.aarch64.rpm;name=aarch64_libsepol-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsepol-utils}"
SRC_URI[aarch64_libsepol-utils.sha256sum] = "c1b5403b3f8c5e079621995e9104e651c2c512c057a35bcbace765c0e8fec4b6"

RDEPENDS:libsepol = " \
 glibc \
 "
RDEPENDS:libsepol-devel = " \
 libsepol \
 pkgconf-pkg-config \
 "
RDEPENDS:libsepol-static = " \
 libsepol-devel \
 "
RDEPENDS:libsepol-utils = " \
 glibc \
 libsepol \
 "
