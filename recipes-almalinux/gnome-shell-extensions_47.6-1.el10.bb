# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extensions"
PV = "47.6"
PR = "1.el10"
PACKAGES = " \
 gnome-classic-session \
 gnome-shell-extension-apps-menu \
 gnome-shell-extension-auto-move-windows \
 gnome-shell-extension-classification-banner \
 gnome-shell-extension-common \
 gnome-shell-extension-custom-menu \
 gnome-shell-extension-desktop-icons \
 gnome-shell-extension-drive-menu \
 gnome-shell-extension-gesture-inhibitor \
 gnome-shell-extension-heads-up-display \
 gnome-shell-extension-launch-new-instance \
 gnome-shell-extension-light-style \
 gnome-shell-extension-native-window-placement \
 gnome-shell-extension-places-menu \
 gnome-shell-extension-screenshot-window-sizer \
 gnome-shell-extension-status-icons \
 gnome-shell-extension-system-monitor \
 gnome-shell-extension-user-theme \
 gnome-shell-extension-window-list \
 gnome-shell-extension-windowsNavigator \
 gnome-shell-extension-workspace-indicator \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-shell-extensions-47.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac66321fda7c51f04aeb1bf7abf777269390c71346bbeafe588eacb9035c499b"

URI_x86_64_v2_gnome-classic-session = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-classic-session-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-classic-session;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-classic-session}"
SRC_URI[x86_64_v2_gnome-classic-session.sha256sum] = "081ba67a1df41440ff60880b8dec05bf5ddff6f733a55e8d9d315305013661b1"

URI_x86_64_v2_gnome-shell-extension-apps-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-apps-menu-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-apps-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-apps-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-apps-menu.sha256sum] = "ca6c7c6772466c7e59fb6a808ce3efc8fff8ed729ff0c06586f49868015d1ad8"

URI_x86_64_v2_gnome-shell-extension-auto-move-windows = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-auto-move-windows-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-auto-move-windows;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-auto-move-windows}"
SRC_URI[x86_64_v2_gnome-shell-extension-auto-move-windows.sha256sum] = "8b5e285702884d34adc3b8c9ce4b95432bd8aa61efc0d88dfaaa0a6dd76d9a3e"

URI_x86_64_v2_gnome-shell-extension-classification-banner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-classification-banner-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-classification-banner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-classification-banner}"
SRC_URI[x86_64_v2_gnome-shell-extension-classification-banner.sha256sum] = "c2dd19bf72d8242938fdbb25bc7fa9ac48e84807eaa651788ac9a7b1db23d395"

URI_x86_64_v2_gnome-shell-extension-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-common-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-common}"
SRC_URI[x86_64_v2_gnome-shell-extension-common.sha256sum] = "3c73ccdd859dab6e16f3d018a449c98a850f80c7a18c80121f114ab2ee7d7c20"

URI_x86_64_v2_gnome-shell-extension-custom-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-custom-menu-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-custom-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-custom-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-custom-menu.sha256sum] = "60edad3e98a9b33436a6edf26d2c427491a8ee1644381b922c9a68c11ff05eb6"

URI_x86_64_v2_gnome-shell-extension-desktop-icons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-desktop-icons-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-desktop-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-desktop-icons}"
SRC_URI[x86_64_v2_gnome-shell-extension-desktop-icons.sha256sum] = "feeab0b7c2d77eeacb7137bb6acc67410a97a15484f1b7378bc7f29e88c0e6c8"

URI_x86_64_v2_gnome-shell-extension-drive-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-drive-menu-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-drive-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-drive-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-drive-menu.sha256sum] = "98786e89f5c6cd4fa85c6d6c7db07cb55bb184ae0bf02db9f2b16367914c4adf"

URI_x86_64_v2_gnome-shell-extension-gesture-inhibitor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-gesture-inhibitor-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-gesture-inhibitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-gesture-inhibitor}"
SRC_URI[x86_64_v2_gnome-shell-extension-gesture-inhibitor.sha256sum] = "7a7dfede79d15de64524edb0224898fd7de1434f74487e66f56c9dbf601bd740"

URI_x86_64_v2_gnome-shell-extension-heads-up-display = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-heads-up-display-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-heads-up-display;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-heads-up-display}"
SRC_URI[x86_64_v2_gnome-shell-extension-heads-up-display.sha256sum] = "cdbfdf6adad6a285832e9b30eeb276cceab64bf7cc4631221f538954d268c9e4"

URI_x86_64_v2_gnome-shell-extension-launch-new-instance = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-launch-new-instance-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-launch-new-instance;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-launch-new-instance}"
SRC_URI[x86_64_v2_gnome-shell-extension-launch-new-instance.sha256sum] = "c95ebf00544245758ddcc483f288d8815deb01d616db801e8dadf0c6e68a8e8e"

URI_x86_64_v2_gnome-shell-extension-light-style = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-light-style-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-light-style;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-light-style}"
SRC_URI[x86_64_v2_gnome-shell-extension-light-style.sha256sum] = "ab99e23cc1b45743d99c0e06fbb49370bed3daf3079370e61cac084fc73a4279"

URI_x86_64_v2_gnome-shell-extension-native-window-placement = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-native-window-placement-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-native-window-placement;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-native-window-placement}"
SRC_URI[x86_64_v2_gnome-shell-extension-native-window-placement.sha256sum] = "ac58ec36d01566223579e224fdc6e42c5b96ea613d6a94deffa5e7f70fdf5aae"

URI_x86_64_v2_gnome-shell-extension-places-menu = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-places-menu-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-places-menu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-places-menu}"
SRC_URI[x86_64_v2_gnome-shell-extension-places-menu.sha256sum] = "95aa36147a7d1e19ff672ce1080e35b9132ffdb4004fdcdb26b5ce0791c053d6"

URI_x86_64_v2_gnome-shell-extension-screenshot-window-sizer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-screenshot-window-sizer-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-screenshot-window-sizer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-screenshot-window-sizer}"
SRC_URI[x86_64_v2_gnome-shell-extension-screenshot-window-sizer.sha256sum] = "340d5304b293472f2c227c19e645c554dbd3a5dbc94898637311890a2c639528"

URI_x86_64_v2_gnome-shell-extension-status-icons = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-status-icons-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-status-icons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-status-icons}"
SRC_URI[x86_64_v2_gnome-shell-extension-status-icons.sha256sum] = "bc12e9fbb904d4cf5630e421c39ba3a561e84a44295925a2aeca025c62a8b854"

URI_x86_64_v2_gnome-shell-extension-system-monitor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-system-monitor-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-system-monitor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-system-monitor}"
SRC_URI[x86_64_v2_gnome-shell-extension-system-monitor.sha256sum] = "21912562d6eff747f0a88079197eee09b32d6030e31b911dd924444ab0880d7e"

URI_x86_64_v2_gnome-shell-extension-user-theme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-user-theme-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-user-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-user-theme}"
SRC_URI[x86_64_v2_gnome-shell-extension-user-theme.sha256sum] = "93584f59ef081f9310786d233eeed75c2671a8f9adc65779ba8e0030248e8c4e"

URI_x86_64_v2_gnome-shell-extension-window-list = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-window-list-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-window-list;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-window-list}"
SRC_URI[x86_64_v2_gnome-shell-extension-window-list.sha256sum] = "6b7c3a4ee1106ccd9734399a1db6a5882b1f6f97629a1fbc482e35cfe0f305d8"

URI_x86_64_v2_gnome-shell-extension-windowsNavigator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-windowsNavigator-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-windowsNavigator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-windowsNavigator}"
SRC_URI[x86_64_v2_gnome-shell-extension-windowsNavigator.sha256sum] = "a4edfe9005c47982cae262d6eb7ee79316b222661be5265ef98ab7f0da98c432"

URI_x86_64_v2_gnome-shell-extension-workspace-indicator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-shell-extension-workspace-indicator-47.6-1.el10.noarch.rpm;name=x86_64_v2_gnome-shell-extension-workspace-indicator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-workspace-indicator}"
SRC_URI[x86_64_v2_gnome-shell-extension-workspace-indicator.sha256sum] = "fb28facd32ae275f0f7737a8d68d7a05bae888e08e408fe3426dabdd6cf17663"

URI_aarch64_gnome-classic-session = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-classic-session-47.6-1.el10.noarch.rpm;name=aarch64_gnome-classic-session;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-classic-session}"
SRC_URI[aarch64_gnome-classic-session.sha256sum] = "081ba67a1df41440ff60880b8dec05bf5ddff6f733a55e8d9d315305013661b1"

URI_aarch64_gnome-shell-extension-apps-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-apps-menu-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-apps-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-apps-menu}"
SRC_URI[aarch64_gnome-shell-extension-apps-menu.sha256sum] = "ca6c7c6772466c7e59fb6a808ce3efc8fff8ed729ff0c06586f49868015d1ad8"

URI_aarch64_gnome-shell-extension-auto-move-windows = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-auto-move-windows-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-auto-move-windows;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-auto-move-windows}"
SRC_URI[aarch64_gnome-shell-extension-auto-move-windows.sha256sum] = "8b5e285702884d34adc3b8c9ce4b95432bd8aa61efc0d88dfaaa0a6dd76d9a3e"

URI_aarch64_gnome-shell-extension-classification-banner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-classification-banner-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-classification-banner;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-classification-banner}"
SRC_URI[aarch64_gnome-shell-extension-classification-banner.sha256sum] = "c2dd19bf72d8242938fdbb25bc7fa9ac48e84807eaa651788ac9a7b1db23d395"

URI_aarch64_gnome-shell-extension-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-common-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-common}"
SRC_URI[aarch64_gnome-shell-extension-common.sha256sum] = "3c73ccdd859dab6e16f3d018a449c98a850f80c7a18c80121f114ab2ee7d7c20"

URI_aarch64_gnome-shell-extension-custom-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-custom-menu-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-custom-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-custom-menu}"
SRC_URI[aarch64_gnome-shell-extension-custom-menu.sha256sum] = "60edad3e98a9b33436a6edf26d2c427491a8ee1644381b922c9a68c11ff05eb6"

URI_aarch64_gnome-shell-extension-desktop-icons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-desktop-icons-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-desktop-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-desktop-icons}"
SRC_URI[aarch64_gnome-shell-extension-desktop-icons.sha256sum] = "feeab0b7c2d77eeacb7137bb6acc67410a97a15484f1b7378bc7f29e88c0e6c8"

URI_aarch64_gnome-shell-extension-drive-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-drive-menu-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-drive-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-drive-menu}"
SRC_URI[aarch64_gnome-shell-extension-drive-menu.sha256sum] = "98786e89f5c6cd4fa85c6d6c7db07cb55bb184ae0bf02db9f2b16367914c4adf"

URI_aarch64_gnome-shell-extension-gesture-inhibitor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-gesture-inhibitor-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-gesture-inhibitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-gesture-inhibitor}"
SRC_URI[aarch64_gnome-shell-extension-gesture-inhibitor.sha256sum] = "7a7dfede79d15de64524edb0224898fd7de1434f74487e66f56c9dbf601bd740"

URI_aarch64_gnome-shell-extension-heads-up-display = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-heads-up-display-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-heads-up-display;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-heads-up-display}"
SRC_URI[aarch64_gnome-shell-extension-heads-up-display.sha256sum] = "cdbfdf6adad6a285832e9b30eeb276cceab64bf7cc4631221f538954d268c9e4"

URI_aarch64_gnome-shell-extension-launch-new-instance = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-launch-new-instance-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-launch-new-instance;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-launch-new-instance}"
SRC_URI[aarch64_gnome-shell-extension-launch-new-instance.sha256sum] = "c95ebf00544245758ddcc483f288d8815deb01d616db801e8dadf0c6e68a8e8e"

URI_aarch64_gnome-shell-extension-light-style = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-light-style-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-light-style;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-light-style}"
SRC_URI[aarch64_gnome-shell-extension-light-style.sha256sum] = "ab99e23cc1b45743d99c0e06fbb49370bed3daf3079370e61cac084fc73a4279"

URI_aarch64_gnome-shell-extension-native-window-placement = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-native-window-placement-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-native-window-placement;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-native-window-placement}"
SRC_URI[aarch64_gnome-shell-extension-native-window-placement.sha256sum] = "ac58ec36d01566223579e224fdc6e42c5b96ea613d6a94deffa5e7f70fdf5aae"

URI_aarch64_gnome-shell-extension-places-menu = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-places-menu-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-places-menu;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-places-menu}"
SRC_URI[aarch64_gnome-shell-extension-places-menu.sha256sum] = "95aa36147a7d1e19ff672ce1080e35b9132ffdb4004fdcdb26b5ce0791c053d6"

URI_aarch64_gnome-shell-extension-screenshot-window-sizer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-screenshot-window-sizer-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-screenshot-window-sizer;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-screenshot-window-sizer}"
SRC_URI[aarch64_gnome-shell-extension-screenshot-window-sizer.sha256sum] = "340d5304b293472f2c227c19e645c554dbd3a5dbc94898637311890a2c639528"

URI_aarch64_gnome-shell-extension-status-icons = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-status-icons-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-status-icons;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-status-icons}"
SRC_URI[aarch64_gnome-shell-extension-status-icons.sha256sum] = "bc12e9fbb904d4cf5630e421c39ba3a561e84a44295925a2aeca025c62a8b854"

URI_aarch64_gnome-shell-extension-system-monitor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-system-monitor-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-system-monitor;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-system-monitor}"
SRC_URI[aarch64_gnome-shell-extension-system-monitor.sha256sum] = "21912562d6eff747f0a88079197eee09b32d6030e31b911dd924444ab0880d7e"

URI_aarch64_gnome-shell-extension-user-theme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-user-theme-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-user-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-user-theme}"
SRC_URI[aarch64_gnome-shell-extension-user-theme.sha256sum] = "93584f59ef081f9310786d233eeed75c2671a8f9adc65779ba8e0030248e8c4e"

URI_aarch64_gnome-shell-extension-window-list = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-window-list-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-window-list;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-window-list}"
SRC_URI[aarch64_gnome-shell-extension-window-list.sha256sum] = "6b7c3a4ee1106ccd9734399a1db6a5882b1f6f97629a1fbc482e35cfe0f305d8"

URI_aarch64_gnome-shell-extension-windowsNavigator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-windowsNavigator-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-windowsNavigator;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-windowsNavigator}"
SRC_URI[aarch64_gnome-shell-extension-windowsNavigator.sha256sum] = "a4edfe9005c47982cae262d6eb7ee79316b222661be5265ef98ab7f0da98c432"

URI_aarch64_gnome-shell-extension-workspace-indicator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-shell-extension-workspace-indicator-47.6-1.el10.noarch.rpm;name=aarch64_gnome-shell-extension-workspace-indicator;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-workspace-indicator}"
SRC_URI[aarch64_gnome-shell-extension-workspace-indicator.sha256sum] = "fb28facd32ae275f0f7737a8d68d7a05bae888e08e408fe3426dabdd6cf17663"

RDEPENDS:gnome-classic-session = " \
 gnome-shell-extension-apps-menu \
 gnome-shell-extension-launch-new-instance \
 gnome-shell-extension-places-menu \
 gnome-shell-extension-window-list \
 nautilus \
 "
RDEPENDS:gnome-shell-extension-apps-menu = " \
 gnome-menus \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-auto-move-windows = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-classification-banner = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-common = " \
 gnome-shell \
 "
RDEPENDS:gnome-shell-extension-custom-menu = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-desktop-icons = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-drive-menu = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-gesture-inhibitor = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-heads-up-display = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-launch-new-instance = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-light-style = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-native-window-placement = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-places-menu = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-screenshot-window-sizer = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-status-icons = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-system-monitor = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-user-theme = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-window-list = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-windowsNavigator = " \
 gnome-shell-extension-common \
 "
RDEPENDS:gnome-shell-extension-workspace-indicator = " \
 gnome-shell-extension-common \
 "
