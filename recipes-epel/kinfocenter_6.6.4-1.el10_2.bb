# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kinfocenter"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 kinfocenter \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kinfocenter-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "222c9c0743ad38c86730bdb3a250a9b6d8d2a8f9d90f4ea3e414470ba936727b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kinfocenter-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kinfocenter;unpack=0"
SRC_URI[x86_64_v2_kinfocenter.sha256sum] = "3c7633b40d1bcb0b6050b98310685e88135ee983c2e1f0990ba48e3157554023"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kinfocenter-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_kinfocenter;unpack=0"
SRC_URI[aarch64_kinfocenter.sha256sum] = "6e52ca2e909923b02f342619afe23d844bd089e007da5e803bc60aa2c777251c"

RDEPENDS:kinfocenter = " \
 aha \
 clinfo \
 dmidecode \
 egl-utils \
 fwupd \
 glibc \
 hwdata \
 kf6-kauth \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kservice \
 kf6-solid \
 libdisplay-info-tools \
 libdrm \
 libstdc++ \
 libusb1 \
 plasma-systemsettings \
 pulseaudio-utils \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 vulkan-tools \
 wayland-utils \
 xdpyinfo \
 "
