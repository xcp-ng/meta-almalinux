# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nix"
PV = "2.31.5"
PR = "3.el10_3"
PACKAGES = " \
 nix \
 nix-core \
 nix-daemon \
 nix-devel \
 nix-doc \
 nix-filesystem \
 nix-legacy \
 nix-libs \
 nix-system \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nix-2.31.5-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "61d74a4b1150920e5afc1d1f4eba607883371a8d358d7266e803653baf54db0f"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - nix-devel: pkgconfig(libgit2) >= 1.9
# - nix-libs: libgit2.so.1.9()(64bit)

URI_x86_64_v2_nix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-2.31.5-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix}"
SRC_URI[x86_64_v2_nix.sha256sum] = "983b645582cb99e8c6d31b62166b4cfdc3219148aa7f9285e6824eaa7378662e"

URI_x86_64_v2_nix-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-core-2.31.5-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-core}"
SRC_URI[x86_64_v2_nix-core.sha256sum] = "5cd65f688ac176f837191d619171a2084f193a3760a0ef08c9d99b746cfde5ad"

URI_x86_64_v2_nix-daemon = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-daemon-2.31.5-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nix-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-daemon}"
SRC_URI[x86_64_v2_nix-daemon.sha256sum] = "0b36de2deb285c3ac457c1041082d8e2210414f7ac30d477b1ee9448db0d698d"

URI_x86_64_v2_nix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-devel-2.31.5-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-devel}"
SRC_URI[x86_64_v2_nix-devel.sha256sum] = "190e4aad4f16865e358cc68935506ef55f7217be9390691f31f9550086a09048"

URI_x86_64_v2_nix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-doc-2.31.5-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-doc}"
SRC_URI[x86_64_v2_nix-doc.sha256sum] = "733f9fea59f6bff37a743aa6b6f2edcab1d26065ccf43d314087fdf46e1577d9"

URI_x86_64_v2_nix-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-filesystem-2.31.5-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nix-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-filesystem}"
SRC_URI[x86_64_v2_nix-filesystem.sha256sum] = "3570fb0c2d7d6da2a5e0817873db9c78efe8a71221399c3ece670ceb39a6e165"

URI_x86_64_v2_nix-legacy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-legacy-2.31.5-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nix-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-legacy}"
SRC_URI[x86_64_v2_nix-legacy.sha256sum] = "837a67bee3e7b3482e8c4dbfb7441d99ba72547394fcdf6d5e6f0afdbb82565c"

URI_x86_64_v2_nix-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-libs-2.31.5-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nix-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-libs}"
SRC_URI[x86_64_v2_nix-libs.sha256sum] = "cef5f5336e81dbcccc95b5dccecc42f457f273fa513b52cd2e934f51599ce327"

URI_x86_64_v2_nix-system = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nix-system-2.31.5-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_nix-system;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nix-system}"
SRC_URI[x86_64_v2_nix-system.sha256sum] = "debae281bcf361e85545738b602b9ff5affaa8bb0f8333b1ff39d6e1b1a17c75"

URI_aarch64_nix = "${EPEL_MIRROR}/aarch64/Packages/n/nix-2.31.5-3.el10_3.aarch64.rpm;name=aarch64_nix;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix}"
SRC_URI[aarch64_nix.sha256sum] = "72e967586cc365192e4f345b6741b543469c9fbc1f312a0802ed439be52eaef4"

URI_aarch64_nix-core = "${EPEL_MIRROR}/aarch64/Packages/n/nix-core-2.31.5-3.el10_3.aarch64.rpm;name=aarch64_nix-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-core}"
SRC_URI[aarch64_nix-core.sha256sum] = "5390a1cf7a9075a19dda49a9e515f0585f80857bdec54ce519aa48693a601192"

URI_aarch64_nix-daemon = "${EPEL_MIRROR}/aarch64/Packages/n/nix-daemon-2.31.5-3.el10_3.noarch.rpm;name=aarch64_nix-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-daemon}"
SRC_URI[aarch64_nix-daemon.sha256sum] = "ba864da25fbd10fe97dbe7b95e4e6e131e2e7ec65762fd85711e0f3f9afe98d6"

URI_aarch64_nix-devel = "${EPEL_MIRROR}/aarch64/Packages/n/nix-devel-2.31.5-3.el10_3.aarch64.rpm;name=aarch64_nix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-devel}"
SRC_URI[aarch64_nix-devel.sha256sum] = "e7319eb155c1bd772ce87e50231dad331a341c8ff2d0bafdb3987822662b95ca"

URI_aarch64_nix-doc = "${EPEL_MIRROR}/aarch64/Packages/n/nix-doc-2.31.5-3.el10_3.noarch.rpm;name=aarch64_nix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-doc}"
SRC_URI[aarch64_nix-doc.sha256sum] = "366808da6da50237bd05047df70e79371adc69ce5d547ebad69fc35347fcd6a9"

URI_aarch64_nix-filesystem = "${EPEL_MIRROR}/aarch64/Packages/n/nix-filesystem-2.31.5-3.el10_3.noarch.rpm;name=aarch64_nix-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-filesystem}"
SRC_URI[aarch64_nix-filesystem.sha256sum] = "c2c2603bd2c83292dfd71d36c11117e17130c2abee9555d9f110f3fde23a25ba"

URI_aarch64_nix-legacy = "${EPEL_MIRROR}/aarch64/Packages/n/nix-legacy-2.31.5-3.el10_3.noarch.rpm;name=aarch64_nix-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-legacy}"
SRC_URI[aarch64_nix-legacy.sha256sum] = "2da94a058dce7131a63017b5635173cdf9696fdebd8be85a9d2eb913487217e6"

URI_aarch64_nix-libs = "${EPEL_MIRROR}/aarch64/Packages/n/nix-libs-2.31.5-3.el10_3.aarch64.rpm;name=aarch64_nix-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-libs}"
SRC_URI[aarch64_nix-libs.sha256sum] = "839960f73fc7a3e0eb57671f1cbea653c9dd903c27dfb08e515982b3d4f32fdd"

URI_aarch64_nix-system = "${EPEL_MIRROR}/aarch64/Packages/n/nix-system-2.31.5-3.el10_3.noarch.rpm;name=aarch64_nix-system;unpack=0"
SRC_URI:append = " ${URI_aarch64_nix-system}"
SRC_URI[aarch64_nix-system.sha256sum] = "f8f1848588f0a5bfd70d5cfdd6520d4f60980bceb6cdf6b3b50d8900dcbe35ef"

RDEPENDS:nix = " \
 nix-core \
 nix-system \
 "
RDEPENDS:nix-core = " \
 gc \
 glibc \
 libgcc \
 libstdc++ \
 nix-libs \
 "
RDEPENDS:nix-daemon = " \
 bash \
 nix-core \
 nix-system \
 systemd \
 "
RDEPENDS:nix-devel:x86_64_v2 = " \
 blake3-devel \
 brotli-devel \
 gc-devel \
 json-devel \
 libarchive-devel \
 libcpuid-devel \
 libcurl-devel \
 libseccomp-devel \
 libsodium-devel \
 lowdown-devel \
 nix-devel \
 nix-libs \
 openssl-devel \
 pkgconf-pkg-config \
 readline-devel \
 sqlite-devel \
"
RDEPENDS:nix-devel:aarch64 = " \
 blake3-devel \
 brotli-devel \
 gc-devel \
 json-devel \
 libarchive-devel \
 libcurl-devel \
 libgit2_1.9-devel \
 libseccomp-devel \
 libsodium-devel \
 lowdown-devel \
 nix-devel \
 nix-libs \
 openssl-devel \
 pkgconf-pkg-config \
 readline-devel \
 sqlite-devel \
"
RDEPENDS:nix-doc = " \
 "
RDEPENDS:nix-filesystem = " \
 "
RDEPENDS:nix-legacy = " \
 nix-core \
 "
RDEPENDS:nix-libs:x86_64_v2 = " \
 blake3 \
 boost-context \
 boost-iostreams \
 boost-url \
 gc \
 glibc \
 libarchive \
 libbrotli \
 libcpuid \
 libgcc \
 libseccomp \
 libsodium \
 libstdc++ \
 lowdown-libs \
 openssl-libs \
 readline \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:nix-libs:aarch64 = " \
 blake3 \
 boost-context \
 boost-iostreams \
 boost-url \
 gc \
 glibc \
 libarchive \
 libbrotli \
 libgcc \
 libgit2_1.9 \
 libseccomp \
 libsodium \
 libstdc++ \
 lowdown-libs \
 openssl-libs \
 readline \
 sqlite-libs \
 virtual/libcurl.so.4___64bit_ \
"
RDEPENDS:nix-system = " \
 nix-filesystem \
 "
