# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust2rpm-helper"
PV = "0.2.0"
PR = "1.el10_3"
PACKAGES = " \
 rust2rpm-helper \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust2rpm-helper-0.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28dbf2c63bff5152c0746e462e4c518be08addd35dbb2ec39651c490b005cb7e"

URI_x86_64_v2_rust2rpm-helper = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust2rpm-helper-0.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rust2rpm-helper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust2rpm-helper}"
SRC_URI[x86_64_v2_rust2rpm-helper.sha256sum] = "2be45f028544a9f5aae6b7350adb8679c49a34ec180878d34e7a3ee2f75ba241"

URI_aarch64_rust2rpm-helper = "${EPEL_MIRROR}/aarch64/Packages/r/rust2rpm-helper-0.2.0-1.el10_3.aarch64.rpm;name=aarch64_rust2rpm-helper;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust2rpm-helper}"
SRC_URI[aarch64_rust2rpm-helper.sha256sum] = "e1da523d7389999a1fe27b8d76a09007b5d15e7f1705d4af3cc0d1fccdc6336a"

RDEPENDS:rust2rpm-helper = " \
 glibc \
 libgcc \
 "
