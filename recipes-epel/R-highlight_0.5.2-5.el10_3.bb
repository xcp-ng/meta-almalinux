# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "R-highlight"
PV = "0.5.2"
PR = "5.el10_3"
PACKAGES = " \
 R-highlight \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/R-highlight-0.5.2-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "102e0aa1804b2879d8c858f2ea2c07bcac830ef7ab89d8c1e75604ce268897fa"

URI_x86_64_v2_R-highlight = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/R-highlight-0.5.2-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_R-highlight;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_R-highlight}"
SRC_URI[x86_64_v2_R-highlight.sha256sum] = "42f692782f5cae2f0f79857644fa8a424d49920cc66f8484ff07a90ba0a8b882"

URI_aarch64_R-highlight = "${EPEL_MIRROR}/aarch64/Packages/r/R-highlight-0.5.2-5.el10_3.aarch64.rpm;name=aarch64_R-highlight;unpack=0"
SRC_URI:append = " ${URI_aarch64_R-highlight}"
SRC_URI[aarch64_R-highlight.sha256sum] = "99db1108d137088a857e57423b60f3a5e59d1f8eb6e5cc2b436b8fb98b508339"

RDEPENDS:R-highlight = " \
 R-core \
 glibc \
 libgcc \
 libstdc++ \
 "
