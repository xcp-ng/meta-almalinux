# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "frei0r-plugins"
PV = "2.3.3"
PR = "4.el10_0"
PACKAGES = " \
 frei0r-devel \
 frei0r-plugins \
 frei0r-plugins-opencv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/frei0r-plugins-2.3.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68fd0d60378d85e0d46dff70fa4405135c483bbabf9ada43e9c24831779edaf5"

URI_x86_64_v2_frei0r-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/frei0r-devel-2.3.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_frei0r-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frei0r-devel}"
SRC_URI[x86_64_v2_frei0r-devel.sha256sum] = "ceb5d25854720ae72ea79c09d4f1c5e575bc64688ecb450295b59603afc9c0be"

URI_x86_64_v2_frei0r-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/frei0r-plugins-2.3.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_frei0r-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frei0r-plugins}"
SRC_URI[x86_64_v2_frei0r-plugins.sha256sum] = "9c7bac1873bb6d1df9d0ee406d29289feb2282af38f7dfccc0132f82bb556e85"

URI_x86_64_v2_frei0r-plugins-opencv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/frei0r-plugins-opencv-2.3.3-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_frei0r-plugins-opencv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_frei0r-plugins-opencv}"
SRC_URI[x86_64_v2_frei0r-plugins-opencv.sha256sum] = "23fb75fb19d9b5aa3824056b84d4902b67056e808f1b95c13fa50c87fdacdac0"

URI_aarch64_frei0r-devel = "${EPEL_MIRROR}/aarch64/Packages/f/frei0r-devel-2.3.3-4.el10_0.aarch64.rpm;name=aarch64_frei0r-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_frei0r-devel}"
SRC_URI[aarch64_frei0r-devel.sha256sum] = "ec7ac9790e008bc01ffad5908a8357066477225a1ad61edf00ca9de68700a9de"

URI_aarch64_frei0r-plugins = "${EPEL_MIRROR}/aarch64/Packages/f/frei0r-plugins-2.3.3-4.el10_0.aarch64.rpm;name=aarch64_frei0r-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_frei0r-plugins}"
SRC_URI[aarch64_frei0r-plugins.sha256sum] = "35eac2600735f3b5393d815dfb8d7bc671322b6890526ed78ebb7afb5ac1291c"

URI_aarch64_frei0r-plugins-opencv = "${EPEL_MIRROR}/aarch64/Packages/f/frei0r-plugins-opencv-2.3.3-4.el10_0.aarch64.rpm;name=aarch64_frei0r-plugins-opencv;unpack=0"
SRC_URI:append = " ${URI_aarch64_frei0r-plugins-opencv}"
SRC_URI[aarch64_frei0r-plugins-opencv.sha256sum] = "7e512902d2cc93bc184f024dea7e2f64c0005cf2be79df06dfc44da01c508466"

RDEPENDS:frei0r-devel = " \
 frei0r-plugins \
 pkgconf-pkg-config \
 "
RDEPENDS:frei0r-plugins = " \
 cairo \
 gavl \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:frei0r-plugins-opencv = " \
 frei0r-plugins \
 glibc \
 libgcc \
 libstdc++ \
 opencv-core \
 opencv-imgproc \
 opencv-objdetect \
 opencv-video \
 "
