# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpki"
PV = "0.18.6"
PR = "1.el10_0"
PACKAGES = " \
 rpki \
 rust-rpki+__windows_ci_all-devel \
 rust-rpki+arbitrary-devel \
 rust-rpki+bcder-devel \
 rust-rpki+ca-devel \
 rust-rpki+compat-devel \
 rust-rpki+crypto-devel \
 rust-rpki+default-devel \
 rust-rpki+futures-util-devel \
 rust-rpki+openssl-devel \
 rust-rpki+quick-xml-devel \
 rust-rpki+repository-devel \
 rust-rpki+ring-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-devel \
 rust-rpki+serde-support-devel \
 rust-rpki+serde_json-devel \
 rust-rpki+slurm-devel \
 rust-rpki+softkeys-devel \
 rust-rpki+tokio-devel \
 rust-rpki+untrusted-devel \
 rust-rpki+xml-devel \
 rust-rpki-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rpki-0.18.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ed6b7f8aa01df9cd0e00dc22d60ff701118631279d2e6c25310310b50d1a3ed"

URI_x86_64_v2_rpki = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpki-0.18.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpki;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpki}"
SRC_URI[x86_64_v2_rpki.sha256sum] = "cee2631d6da414e351a78dd442e152b330f9dc5821a691dfc12ade41b299f375"

URI_x86_64_v2_rust-rpki+__windows_ci_all-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+__windows_ci_all-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+__windows_ci_all-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+__windows_ci_all-devel}"
SRC_URI[x86_64_v2_rust-rpki+__windows_ci_all-devel.sha256sum] = "a3913490933ed7106c9cb238ab47cccefe1926665fd9c5e981ba9852287014dd"

URI_x86_64_v2_rust-rpki+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+arbitrary-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-rpki+arbitrary-devel.sha256sum] = "d2dc2e3f56ccdb6661d359cf76ad05d7c605c60de6d9529c777d37b83fb75c0c"

URI_x86_64_v2_rust-rpki+bcder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+bcder-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+bcder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+bcder-devel}"
SRC_URI[x86_64_v2_rust-rpki+bcder-devel.sha256sum] = "5ea883893c8208fef5feb4282b070924d58ba243d911603c2f2e32a16b1c73d5"

URI_x86_64_v2_rust-rpki+ca-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+ca-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+ca-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+ca-devel}"
SRC_URI[x86_64_v2_rust-rpki+ca-devel.sha256sum] = "b8c75970250e3ab3f14a425e0884323bb1916f66edeeaa454b51687655f34b68"

URI_x86_64_v2_rust-rpki+compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+compat-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+compat-devel}"
SRC_URI[x86_64_v2_rust-rpki+compat-devel.sha256sum] = "ea02d822ee6628ad34a1813ad40ee1352b13a79983c016dcdaba9278d2d15296"

URI_x86_64_v2_rust-rpki+crypto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+crypto-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+crypto-devel}"
SRC_URI[x86_64_v2_rust-rpki+crypto-devel.sha256sum] = "893addeaa42b32e77fb23ce021d620f9415415addc6af8c71f0e8a53e8498419"

URI_x86_64_v2_rust-rpki+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+default-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+default-devel}"
SRC_URI[x86_64_v2_rust-rpki+default-devel.sha256sum] = "a470c7fbc0abebf7f6446cfcc0d9287f2bd3fe05f0db3c0bcf2caf5edd82a67f"

URI_x86_64_v2_rust-rpki+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+futures-util-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+futures-util-devel}"
SRC_URI[x86_64_v2_rust-rpki+futures-util-devel.sha256sum] = "1db298418ea814602cc9b69ab00718e0ac35e31073cbda7d74ad8925fb9a0508"

URI_x86_64_v2_rust-rpki+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+openssl-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+openssl-devel}"
SRC_URI[x86_64_v2_rust-rpki+openssl-devel.sha256sum] = "b453bccdf41ed05bdd24e25ccbf92d875911de6da297ae71fe9f48e03007c229"

URI_x86_64_v2_rust-rpki+quick-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+quick-xml-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+quick-xml-devel}"
SRC_URI[x86_64_v2_rust-rpki+quick-xml-devel.sha256sum] = "8f657ce6b899a99d7588169e46e59126a3f13873680a4b683405d3384c08c682"

URI_x86_64_v2_rust-rpki+repository-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+repository-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+repository-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+repository-devel}"
SRC_URI[x86_64_v2_rust-rpki+repository-devel.sha256sum] = "d2479a60e9c4cb90c3791dd78657c058da084b764eb6973ef58bd4167cca40d2"

URI_x86_64_v2_rust-rpki+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+ring-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+ring-devel}"
SRC_URI[x86_64_v2_rust-rpki+ring-devel.sha256sum] = "2a7eae94ae2cbf17e52be9fbe4aa538035ce0ee4b9e237293766bae94eb4e4a6"

URI_x86_64_v2_rust-rpki+rrdp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+rrdp-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+rrdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+rrdp-devel}"
SRC_URI[x86_64_v2_rust-rpki+rrdp-devel.sha256sum] = "99540ae7fff5d9b7df51cdb28f321c6a6270c0e95cc72f0baf7d4aa64241aece"

URI_x86_64_v2_rust-rpki+rtr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+rtr-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+rtr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+rtr-devel}"
SRC_URI[x86_64_v2_rust-rpki+rtr-devel.sha256sum] = "9ee52a5dce4d27eb3592111aebf1fb24d1823e38b720c74b8babb9faf3b28369"

URI_x86_64_v2_rust-rpki+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde-devel.sha256sum] = "b2fc1815b3d2bd6d34eebef1788c8eb8f966bf252dfe28d53d70b261c2fbe70f"

URI_x86_64_v2_rust-rpki+serde-support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde-support-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde-support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde-support-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde-support-devel.sha256sum] = "dea7bfae4a2197a85c6269e1fd1442258921711f6ba4ba9e14739a55ecde83a9"

URI_x86_64_v2_rust-rpki+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+serde_json-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+serde_json-devel}"
SRC_URI[x86_64_v2_rust-rpki+serde_json-devel.sha256sum] = "7753c2dd4e953ac3467fd9a6dd65fd0598a820621c2c869d01e31889e399271e"

URI_x86_64_v2_rust-rpki+slurm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+slurm-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+slurm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+slurm-devel}"
SRC_URI[x86_64_v2_rust-rpki+slurm-devel.sha256sum] = "7b41addb3a46f567b3d0553b88f4a89549a8a9b2049caea7ac6c563686ec4fe5"

URI_x86_64_v2_rust-rpki+softkeys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+softkeys-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+softkeys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+softkeys-devel}"
SRC_URI[x86_64_v2_rust-rpki+softkeys-devel.sha256sum] = "5c37272265845e4a5184e15147cc4b5488a103cda7d7b2776efa21275481ed81"

URI_x86_64_v2_rust-rpki+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+tokio-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+tokio-devel}"
SRC_URI[x86_64_v2_rust-rpki+tokio-devel.sha256sum] = "7be3683f6bbb1d16129a66bd340e70163ab90cfa7072e2db59cca2f1f61a1200"

URI_x86_64_v2_rust-rpki+untrusted-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+untrusted-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+untrusted-devel}"
SRC_URI[x86_64_v2_rust-rpki+untrusted-devel.sha256sum] = "b949aac22e8fb32ea7ec952ff9ea8bc71e2cbd890665766589a9656412664cb1"

URI_x86_64_v2_rust-rpki+xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki+xml-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki+xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki+xml-devel}"
SRC_URI[x86_64_v2_rust-rpki+xml-devel.sha256sum] = "a647386c5ecda3bf00daf03c7a48dfd339bf37614146d4ad1fb884c6076e7c1c"

URI_x86_64_v2_rust-rpki-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rpki-devel-0.18.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rpki-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rpki-devel}"
SRC_URI[x86_64_v2_rust-rpki-devel.sha256sum] = "28c42c8a05244b9d5dfe6c5d5be7557e71a724ec585f172792b29fe02f51e834"

URI_aarch64_rpki = "${EPEL_MIRROR}/aarch64/Packages/r/rpki-0.18.6-1.el10_0.aarch64.rpm;name=aarch64_rpki;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpki}"
SRC_URI[aarch64_rpki.sha256sum] = "7871cca439d98f429d7c94315f876965dcec01d8943195a60a7daa3ddb520833"

URI_aarch64_rust-rpki+__windows_ci_all-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+__windows_ci_all-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+__windows_ci_all-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+__windows_ci_all-devel}"
SRC_URI[aarch64_rust-rpki+__windows_ci_all-devel.sha256sum] = "9b1bce53530b2d39aba3d19051c12f07ff5079d04008c4eb16f31b383b8b7f3a"

URI_aarch64_rust-rpki+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+arbitrary-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+arbitrary-devel}"
SRC_URI[aarch64_rust-rpki+arbitrary-devel.sha256sum] = "e71eba293901b029c21cb7f824e8b3406380ef95d516d27ffee2c0d991690715"

URI_aarch64_rust-rpki+bcder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+bcder-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+bcder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+bcder-devel}"
SRC_URI[aarch64_rust-rpki+bcder-devel.sha256sum] = "34bbc6b41d80ef774d9cabf504a22f9391c9aaeaf735a1de31c7455b9b77e615"

URI_aarch64_rust-rpki+ca-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+ca-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+ca-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+ca-devel}"
SRC_URI[aarch64_rust-rpki+ca-devel.sha256sum] = "5a82abc56fc074304856652c98efd12cb5ade3e80bbb3250857eefcda4684c62"

URI_aarch64_rust-rpki+compat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+compat-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+compat-devel}"
SRC_URI[aarch64_rust-rpki+compat-devel.sha256sum] = "0dedfab848daa9116a62e37dbca76bc18310bb453e36831edb3af748e8b69388"

URI_aarch64_rust-rpki+crypto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+crypto-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+crypto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+crypto-devel}"
SRC_URI[aarch64_rust-rpki+crypto-devel.sha256sum] = "452cfb18b91ce108b4810138b9f6b8beeb322ca1cbcb3ddb4e8b6869b9821316"

URI_aarch64_rust-rpki+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+default-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+default-devel}"
SRC_URI[aarch64_rust-rpki+default-devel.sha256sum] = "ddcd97cc690cec1b039714d3b724acdb3416a8b8c09b7f38108edcff28ad767f"

URI_aarch64_rust-rpki+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+futures-util-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+futures-util-devel}"
SRC_URI[aarch64_rust-rpki+futures-util-devel.sha256sum] = "09781740a041d039f7a8686a815f7d11281a53c00653e6b79489379e84e6d8dd"

URI_aarch64_rust-rpki+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+openssl-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+openssl-devel}"
SRC_URI[aarch64_rust-rpki+openssl-devel.sha256sum] = "06fe779b1f503b0959fa5c571ef1065fdc83626a5553034bf571d7f96156e15f"

URI_aarch64_rust-rpki+quick-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+quick-xml-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+quick-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+quick-xml-devel}"
SRC_URI[aarch64_rust-rpki+quick-xml-devel.sha256sum] = "5b1e2749096be844ba2f1cd4f88eac2a8f0c6d5307c00e007ea70a8c3a88ff6f"

URI_aarch64_rust-rpki+repository-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+repository-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+repository-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+repository-devel}"
SRC_URI[aarch64_rust-rpki+repository-devel.sha256sum] = "2835983a7b9ab1e5bdd33f65f9784599b6da58da40cf04649aa5559b4a549bb1"

URI_aarch64_rust-rpki+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+ring-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+ring-devel}"
SRC_URI[aarch64_rust-rpki+ring-devel.sha256sum] = "bded1035fea459c730f99146d86db51d11f63eb9ce7fea791905f799b25ce1dd"

URI_aarch64_rust-rpki+rrdp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+rrdp-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+rrdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+rrdp-devel}"
SRC_URI[aarch64_rust-rpki+rrdp-devel.sha256sum] = "9123ef468c4c9f055dcc71615d6a0f34f26a5940c9f088dfe301e3569c6224cd"

URI_aarch64_rust-rpki+rtr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+rtr-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+rtr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+rtr-devel}"
SRC_URI[aarch64_rust-rpki+rtr-devel.sha256sum] = "116465c373278a09432bc8ac7705243e590e46b397b7638ee3f648aa960fc28b"

URI_aarch64_rust-rpki+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde-devel}"
SRC_URI[aarch64_rust-rpki+serde-devel.sha256sum] = "8de049e5fdfd325f706d031bdb412ac7dfb2d2fdfeb51788bf504e8ffba03dbd"

URI_aarch64_rust-rpki+serde-support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde-support-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+serde-support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde-support-devel}"
SRC_URI[aarch64_rust-rpki+serde-support-devel.sha256sum] = "482736f6fa2977edf46419f3ee3726c2dc42c888422c5d2ae9005ffde656024d"

URI_aarch64_rust-rpki+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+serde_json-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+serde_json-devel}"
SRC_URI[aarch64_rust-rpki+serde_json-devel.sha256sum] = "4ae826fa9b6871ee4b94c59168877f11250cc5fef09dbcd86adfebe5f31f7828"

URI_aarch64_rust-rpki+slurm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+slurm-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+slurm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+slurm-devel}"
SRC_URI[aarch64_rust-rpki+slurm-devel.sha256sum] = "e65d8dfb2a3417306b12184fad66a8ccd8c345fe026296ba229e34b883fa0bdd"

URI_aarch64_rust-rpki+softkeys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+softkeys-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+softkeys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+softkeys-devel}"
SRC_URI[aarch64_rust-rpki+softkeys-devel.sha256sum] = "7e138d84cb8f5ea2eecd44338100c9e44a6addc99f55c1936cec71776efc408d"

URI_aarch64_rust-rpki+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+tokio-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+tokio-devel}"
SRC_URI[aarch64_rust-rpki+tokio-devel.sha256sum] = "b71b0b2123682c99413b755d9adeb0d7db309315e2411dc70b2b947f916f8c24"

URI_aarch64_rust-rpki+untrusted-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+untrusted-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+untrusted-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+untrusted-devel}"
SRC_URI[aarch64_rust-rpki+untrusted-devel.sha256sum] = "991ae9512a800f4b08e8d397cd902e2e79b2b2e8ff66f1425521ecff0cfea93d"

URI_aarch64_rust-rpki+xml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki+xml-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki+xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki+xml-devel}"
SRC_URI[aarch64_rust-rpki+xml-devel.sha256sum] = "638a68b777ac539649061d440291b6541b344eeae31f6477024b1fb45e29659c"

URI_aarch64_rust-rpki-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rpki-devel-0.18.6-1.el10_0.noarch.rpm;name=aarch64_rust-rpki-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rpki-devel}"
SRC_URI[aarch64_rust-rpki-devel.sha256sum] = "6c0b097e983e55f35211968cfbb91cf4a36e6afe105b5fa686608261d44c396d"

RDEPENDS:rpki = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-rpki+__windows_ci_all-devel = " \
 cargo \
 rust-rpki+ca-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+rtr-devel \
 rust-rpki+serde-support-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-chrono+arbitrary-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+bcder-devel = " \
 cargo \
 rust-bcder+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+ca-devel = " \
 cargo \
 rust-rpki+repository-devel \
 rust-rpki+rrdp-devel \
 rust-rpki+serde-support-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+compat-devel = " \
 cargo \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+crypto-devel = " \
 cargo \
 rust-rpki+bcder-devel \
 rust-rpki+ring-devel \
 rust-rpki+untrusted-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+default-devel = " \
 cargo \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+openssl-devel = " \
 cargo \
 rust-openssl+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+quick-xml-devel = " \
 cargo \
 rust-quick-xml0.31+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+repository-devel = " \
 cargo \
 rust-rpki+bcder-devel \
 rust-rpki+crypto-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+ring-devel = " \
 cargo \
 rust-ring+default-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+rrdp-devel = " \
 cargo \
 rust-rpki+ring-devel \
 rust-rpki+xml-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+rtr-devel = " \
 cargo \
 rust-rpki+futures-util-devel \
 rust-rpki+tokio-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+serde-devel = " \
 cargo \
 rust-rpki-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rpki+serde-support-devel = " \
 cargo \
 rust-rpki+serde-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+serde_json-devel = " \
 cargo \
 rust-rpki-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-rpki+slurm-devel = " \
 cargo \
 rust-rpki+rtr-devel \
 rust-rpki+serde-support-devel \
 rust-rpki+serde_json-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+softkeys-devel = " \
 cargo \
 rust-rpki+openssl-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki+tokio-devel = " \
 cargo \
 rust-rpki-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-rpki+untrusted-devel = " \
 cargo \
 rust-rpki-devel \
 rust-untrusted+default-devel \
 "
RDEPENDS:rust-rpki+xml-devel = " \
 cargo \
 rust-rpki+quick-xml-devel \
 rust-rpki-devel \
 "
RDEPENDS:rust-rpki-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-chrono+default-devel \
 rust-chrono+serde-devel \
 rust-log+default-devel \
 rust-uuid+default-devel \
 "
