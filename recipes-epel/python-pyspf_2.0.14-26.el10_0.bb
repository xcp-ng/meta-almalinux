# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyspf"
PV = "2.0.14"
PR = "26.el10_0"
PACKAGES = " \
 python3-pyspf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyspf-2.0.14-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11852a11c1250673945eb17c347020b3958cc8b9d98a7595447a2f5cb52d2df3"

URI_x86_64_v2_python3-pyspf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyspf-2.0.14-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyspf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyspf}"
SRC_URI[x86_64_v2_python3-pyspf.sha256sum] = "e89f70e7dba2180bd0aa0a9488ad53e02a71a9af61dd1e44e695d7e522e43451"

URI_aarch64_python3-pyspf = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyspf-2.0.14-26.el10_0.noarch.rpm;name=aarch64_python3-pyspf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyspf}"
SRC_URI[aarch64_python3-pyspf.sha256sum] = "94d050d4dd565976dab8d312e02608d77be3d753239f8ba95d1844d0df6b5b40"

RDEPENDS:python3-pyspf = " \
 python3 \
 python3-py3dns \
 "
