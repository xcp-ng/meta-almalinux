# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-waker-fn"
PV = "1.2.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-waker-fn+default-devel \
 rust-waker-fn+portable-atomic-devel \
 rust-waker-fn+portable-atomic-util-devel \
 rust-waker-fn-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-waker-fn-1.2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "070540e32f3d3c94f34c832b74aae474793a6c976327ac20563c9b60754af00f"

URI_x86_64_v2_rust-waker-fn+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-waker-fn+default-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-waker-fn+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-waker-fn+default-devel}"
SRC_URI[x86_64_v2_rust-waker-fn+default-devel.sha256sum] = "087bc098951d1c3404c1b191baf649a60a338b20cfcf62b2171eebd3a3259e22"

URI_x86_64_v2_rust-waker-fn+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-waker-fn+portable-atomic-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-waker-fn+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-waker-fn+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-waker-fn+portable-atomic-devel.sha256sum] = "cbe681761ee7b4c05f2f0cf2461cc3343457748102bb13730d50b20a8c55a70d"

URI_x86_64_v2_rust-waker-fn+portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-waker-fn+portable-atomic-util-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-waker-fn+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-waker-fn+portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-waker-fn+portable-atomic-util-devel.sha256sum] = "1963a293fd065f0c89e8fe032de8222ddd06c2315a848c4571de4a539a64e536"

URI_x86_64_v2_rust-waker-fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-waker-fn-devel-1.2.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-waker-fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-waker-fn-devel}"
SRC_URI[x86_64_v2_rust-waker-fn-devel.sha256sum] = "dba7b1237bef53cf6062c68e499b0bca50bcee0e4dcf0e30f735c8e818c52edd"

URI_aarch64_rust-waker-fn+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-waker-fn+default-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-waker-fn+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-waker-fn+default-devel}"
SRC_URI[aarch64_rust-waker-fn+default-devel.sha256sum] = "d2d38297399654b3453b975f5ef45cdb69ca8fe81b553821fa0cd2fd8b016ca8"

URI_aarch64_rust-waker-fn+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-waker-fn+portable-atomic-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-waker-fn+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-waker-fn+portable-atomic-devel}"
SRC_URI[aarch64_rust-waker-fn+portable-atomic-devel.sha256sum] = "51aa16c84bcd972fcfa8f4c98f25fa186c069c63361a1ec3a3fbc95c20851606"

URI_aarch64_rust-waker-fn+portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-waker-fn+portable-atomic-util-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-waker-fn+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-waker-fn+portable-atomic-util-devel}"
SRC_URI[aarch64_rust-waker-fn+portable-atomic-util-devel.sha256sum] = "c6270d91718285847cd662e562bfc9a9094e315ffe295c3d89092fd28cbca503"

URI_aarch64_rust-waker-fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-waker-fn-devel-1.2.0-1.el10_0.noarch.rpm;name=aarch64_rust-waker-fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-waker-fn-devel}"
SRC_URI[aarch64_rust-waker-fn-devel.sha256sum] = "e873b243e3fa6045957ecb090f2fc6e9e7579892acd2fe198f2e8b28320b3097"

RDEPENDS:rust-waker-fn+default-devel = " \
 cargo \
 rust-waker-fn-devel \
 "
RDEPENDS:rust-waker-fn+portable-atomic-devel = " \
 cargo \
 rust-waker-fn+portable-atomic-util-devel \
 rust-waker-fn-devel \
 "
RDEPENDS:rust-waker-fn+portable-atomic-util-devel = " \
 cargo \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util-devel \
 rust-waker-fn-devel \
 "
RDEPENDS:rust-waker-fn-devel = " \
 cargo \
 rust \
 "
