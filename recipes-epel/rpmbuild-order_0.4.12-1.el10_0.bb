# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpmbuild-order"
PV = "0.4.12"
PR = "1.el10_0"
PACKAGES = " \
 ghc-rpmbuild-order \
 ghc-rpmbuild-order-devel \
 ghc-rpmbuild-order-doc \
 ghc-rpmbuild-order-prof \
 rpmbuild-order \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rpmbuild-order-0.4.12-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5710a605d430b9166a25752d76be879959d52642d20599c24a22f6d20fc95150"

URI_x86_64_v2_ghc-rpmbuild-order = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpmbuild-order-0.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-rpmbuild-order;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpmbuild-order}"
SRC_URI[x86_64_v2_ghc-rpmbuild-order.sha256sum] = "92479c98f505db7b780fed5aa3a2da8402666a9e745fff5964411c3560a482da"

URI_x86_64_v2_ghc-rpmbuild-order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpmbuild-order-devel-0.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-rpmbuild-order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpmbuild-order-devel}"
SRC_URI[x86_64_v2_ghc-rpmbuild-order-devel.sha256sum] = "6d5977e9ee389c1a68fad16b5c28cdf4e3a79f7b3e060aee5c7172e365cd7d35"

URI_x86_64_v2_ghc-rpmbuild-order-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpmbuild-order-doc-0.4.12-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-rpmbuild-order-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpmbuild-order-doc}"
SRC_URI[x86_64_v2_ghc-rpmbuild-order-doc.sha256sum] = "4e9bcc1e30c4bc5e5b7c7473c95d63faafe062a357152cdd8bdd2dc609e19e85"

URI_x86_64_v2_ghc-rpmbuild-order-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-rpmbuild-order-prof-0.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-rpmbuild-order-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-rpmbuild-order-prof}"
SRC_URI[x86_64_v2_ghc-rpmbuild-order-prof.sha256sum] = "01d5aa36121e09ec805d2cda777aea7d80d6748e3bba0932a3504477aa2c3e5d"

URI_x86_64_v2_rpmbuild-order = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rpmbuild-order-0.4.12-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rpmbuild-order;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpmbuild-order}"
SRC_URI[x86_64_v2_rpmbuild-order.sha256sum] = "586addf08bbd7d0a5f6e916198b87c129b68808338d0cd567f53d37ba0af5ed3"

URI_aarch64_ghc-rpmbuild-order = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpmbuild-order-0.4.12-1.el10_0.aarch64.rpm;name=aarch64_ghc-rpmbuild-order;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpmbuild-order}"
SRC_URI[aarch64_ghc-rpmbuild-order.sha256sum] = "98ba4c312112dafb8adb98207066f62e4e82a7f7cb818f9bfab5ebb9e48e21bd"

URI_aarch64_ghc-rpmbuild-order-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpmbuild-order-devel-0.4.12-1.el10_0.aarch64.rpm;name=aarch64_ghc-rpmbuild-order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpmbuild-order-devel}"
SRC_URI[aarch64_ghc-rpmbuild-order-devel.sha256sum] = "72f9c69fbc7fd6f44ebac78103bc8bdab6fdf317d7fa3732c965a40442221e50"

URI_aarch64_ghc-rpmbuild-order-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpmbuild-order-doc-0.4.12-1.el10_0.noarch.rpm;name=aarch64_ghc-rpmbuild-order-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpmbuild-order-doc}"
SRC_URI[aarch64_ghc-rpmbuild-order-doc.sha256sum] = "90cbad5512df9677d84c52b711fc74ecad92863c65a5439a009660fd67a4b3be"

URI_aarch64_ghc-rpmbuild-order-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-rpmbuild-order-prof-0.4.12-1.el10_0.aarch64.rpm;name=aarch64_ghc-rpmbuild-order-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-rpmbuild-order-prof}"
SRC_URI[aarch64_ghc-rpmbuild-order-prof.sha256sum] = "1b142063a79593c74cffc7ddfd67aecbbfef6674fdc6faeb2ba1fb73dc3d5a07"

URI_aarch64_rpmbuild-order = "${EPEL_MIRROR}/aarch64/Packages/r/rpmbuild-order-0.4.12-1.el10_0.aarch64.rpm;name=aarch64_rpmbuild-order;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpmbuild-order}"
SRC_URI[aarch64_rpmbuild-order.sha256sum] = "c7ddef2476e5b0dea072904848dd64a87172ed47318bc15a0d7f699793d561b3"

RDEPENDS:ghc-rpmbuild-order = " \
 ghc-array \
 ghc-base \
 ghc-base-compat \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-clock \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-dlist \
 ghc-exceptions \
 ghc-extra \
 ghc-fgl \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-graphviz \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-parsec \
 ghc-polyparse \
 ghc-pretty \
 ghc-process \
 ghc-random \
 ghc-regex-base \
 ghc-regex-tdfa \
 ghc-simple-cmd \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-temporary \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-wl-pprint-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-rpmbuild-order-devel = " \
 ghc-base-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-extra-devel \
 ghc-fgl-devel \
 ghc-filepath-devel \
 ghc-graphviz-devel \
 ghc-regex-tdfa-devel \
 ghc-rpmbuild-order \
 ghc-simple-cmd-devel \
 "
RDEPENDS:ghc-rpmbuild-order-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-rpmbuild-order-prof = " \
 ghc-base-prof \
 ghc-case-insensitive-prof \
 ghc-directory-prof \
 ghc-extra-prof \
 ghc-fgl-prof \
 ghc-filepath-prof \
 ghc-graphviz-prof \
 ghc-regex-tdfa-prof \
 ghc-rpmbuild-order-devel \
 ghc-simple-cmd-prof \
 "
RDEPENDS:rpmbuild-order = " \
 glibc \
 gmp \
 libffi \
 rpm-build \
 "
