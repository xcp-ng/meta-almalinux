# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-v_frame"
PV = "0.3.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-v_frame+default-devel \
 rust-v_frame+serde-devel \
 rust-v_frame+serialize-devel \
 rust-v_frame-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-v_frame-0.3.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e5d653069440a384f022fea855d0a2c3762a6dfaaf80d158694510c3591db7e"

URI_x86_64_v2_rust-v_frame+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+default-devel-0.3.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+default-devel}"
SRC_URI[x86_64_v2_rust-v_frame+default-devel.sha256sum] = "7ca03df76902be86cfb14a41bae91b1c75c88ead413a9e472aa0d29e87b37657"

URI_x86_64_v2_rust-v_frame+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+serde-devel-0.3.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+serde-devel}"
SRC_URI[x86_64_v2_rust-v_frame+serde-devel.sha256sum] = "1a928c8ac865912f132c7e3efdee97b976a76fe3bf8b8f19fdd975f33076283f"

URI_x86_64_v2_rust-v_frame+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame+serialize-devel-0.3.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame+serialize-devel}"
SRC_URI[x86_64_v2_rust-v_frame+serialize-devel.sha256sum] = "bc9ddbcc9f20c6a6ec50172aa156970e934c0e40630655ecb4a2f7ec1c08bb3e"

URI_x86_64_v2_rust-v_frame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-v_frame-devel-0.3.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-v_frame-devel}"
SRC_URI[x86_64_v2_rust-v_frame-devel.sha256sum] = "9b3514046e7da18edd88a0fb254c763961b85d14647acc8d42af12132c9fe311"

URI_aarch64_rust-v_frame+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+default-devel-0.3.9-1.el10_1.noarch.rpm;name=aarch64_rust-v_frame+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+default-devel}"
SRC_URI[aarch64_rust-v_frame+default-devel.sha256sum] = "a3d918b2b0f63f7fe6f9fd88aef7cbafcae5e029a6ac5c10232bef90845596ce"

URI_aarch64_rust-v_frame+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+serde-devel-0.3.9-1.el10_1.noarch.rpm;name=aarch64_rust-v_frame+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+serde-devel}"
SRC_URI[aarch64_rust-v_frame+serde-devel.sha256sum] = "0ba7b4b93132f33a944375f09aeee7feb1f2201962a2dad08ffd33ed745aaa2a"

URI_aarch64_rust-v_frame+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame+serialize-devel-0.3.9-1.el10_1.noarch.rpm;name=aarch64_rust-v_frame+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame+serialize-devel}"
SRC_URI[aarch64_rust-v_frame+serialize-devel.sha256sum] = "de951df3a5323de53d09c201e71e4f419014413354109de1e0462aedeb30263b"

URI_aarch64_rust-v_frame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-v_frame-devel-0.3.9-1.el10_1.noarch.rpm;name=aarch64_rust-v_frame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-v_frame-devel}"
SRC_URI[aarch64_rust-v_frame-devel.sha256sum] = "2c4fda397bd93314b1bf5923e865d689e403000ee5ed3db082e9e240aa5ea948"

RDEPENDS:rust-v_frame+default-devel = " \
 cargo \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame+serialize-devel = " \
 cargo \
 rust-aligned-vec+serde-devel \
 rust-v_frame+serde-devel \
 rust-v_frame-devel \
 "
RDEPENDS:rust-v_frame-devel = " \
 cargo \
 rust \
 rust-aligned-vec+default-devel \
 rust-num-traits+default-devel \
 "
