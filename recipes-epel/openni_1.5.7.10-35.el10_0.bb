# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openni"
PV = "1.5.7.10"
PR = "35.el10_0"
PACKAGES:x86_64_v2 = " \
 openni \
 openni-devel \
 openni-doc \
 openni-examples \
 openni-java \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/o/openni-1.5.7.10-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9593930dc86a15688b225f2bf749cc5bde7e9187b11128cb0cf749bd208bc113"

URI_x86_64_v2_openni = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openni-1.5.7.10-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openni}"
SRC_URI[x86_64_v2_openni.sha256sum] = "885a53d87085358d72bd206fa925929ef30217c99081e148e5322e35c8eb502a"

URI_x86_64_v2_openni-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openni-devel-1.5.7.10-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openni-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openni-devel}"
SRC_URI[x86_64_v2_openni-devel.sha256sum] = "adb419f9e4a3f709ab706bf685c6bde91e2e5982e7639493bfa1dd2932f3fd02"

URI_x86_64_v2_openni-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openni-doc-1.5.7.10-35.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_openni-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openni-doc}"
SRC_URI[x86_64_v2_openni-doc.sha256sum] = "c947deb3b1b8cd6fa798a7288edadaafe12158d36307bcacd188775237e58176"

URI_x86_64_v2_openni-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openni-examples-1.5.7.10-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openni-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openni-examples}"
SRC_URI[x86_64_v2_openni-examples.sha256sum] = "a9947207bb38a67688b193664a1683eb07a142790a509f4975e3a2fef0ddb88c"

URI_x86_64_v2_openni-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openni-java-1.5.7.10-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openni-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openni-java}"
SRC_URI[x86_64_v2_openni-java.sha256sum] = "324f1b6b64dc3b3abbfc03215f9b23b10c1943f66fbbed71e5904666ae1b13ee"

RDEPENDS:openni = " \
 bash \
 glibc \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libusb1 \
 tinyxml \
 "
RDEPENDS:openni-devel = " \
 openni \
 pkgconf-pkg-config \
 "
RDEPENDS:openni-doc = " \
 "
RDEPENDS:openni-examples = " \
 freeglut \
 glibc \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 openni \
 "
RDEPENDS:openni-java = " \
 java-21-openjdk-headless \
 javapackages-tools \
 openni \
 "
