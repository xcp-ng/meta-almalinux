# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lagrange"
PV = "1.18.5"
PR = "1.el10_0"
PACKAGES = " \
 lagrange \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lagrange-1.18.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f318c4a587ee5fcb3501485bd8417366aa2e64e5e17e6369220328fcfe11155"

URI_x86_64_v2_lagrange = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lagrange-1.18.5-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lagrange;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lagrange}"
SRC_URI[x86_64_v2_lagrange.sha256sum] = "6411543ca514d6921b4c8f73a7b46cbcceeaade5f1d221c391dd8f555140f1e8"

URI_aarch64_lagrange = "${EPEL_MIRROR}/aarch64/Packages/l/lagrange-1.18.5-1.el10_0.aarch64.rpm;name=aarch64_lagrange;unpack=0"
SRC_URI:append = " ${URI_aarch64_lagrange}"
SRC_URI[aarch64_lagrange.sha256sum] = "24be256b5ca89c0c3927fab00d48fb328ca62b694b0c732a5c5e319cab406812"

RDEPENDS:lagrange = " \
 fribidi \
 glibc \
 harfbuzz \
 libgcc \
 libwebp \
 mpg123-libs \
 the_foundation \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
