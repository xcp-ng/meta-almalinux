# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "steam-devices"
PV = "1.0.0.101^git20260625.22ec85e"
PR = "1.el10_3"
PACKAGES = " \
 steam-devices \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/steam-devices-1.0.0.101^git20260625.22ec85e-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7d172dfb9042de5d7c9b812e7409ed2922d8fc2366b807248239868d63af5a3b"

URI_x86_64_v2_steam-devices = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/steam-devices-1.0.0.101^git20260625.22ec85e-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_steam-devices;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_steam-devices}"
SRC_URI[x86_64_v2_steam-devices.sha256sum] = "955dbb30a4e3cb6562ead528deb6b317518becfdca56b9ca5d202f2f6b75da8d"

URI_aarch64_steam-devices = "${EPEL_MIRROR}/aarch64/Packages/s/steam-devices-1.0.0.101^git20260625.22ec85e-1.el10_3.noarch.rpm;name=aarch64_steam-devices;unpack=0"
SRC_URI:append = " ${URI_aarch64_steam-devices}"
SRC_URI[aarch64_steam-devices.sha256sum] = "35f397a25f3c27f3f0c5489d12e39b541f6e5066a0b61e6aafc109fa2dca8b9c"

RDEPENDS:steam-devices = " \
 "
