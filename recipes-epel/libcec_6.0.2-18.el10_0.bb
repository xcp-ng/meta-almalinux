# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcec"
PV = "6.0.2"
PR = "18.el10_0"
PACKAGES = " \
 libcec \
 libcec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcec-6.0.2-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "892398557c3905e82502234a44a6739eb356f9d211e542c58a7421fd0013fa35"

URI_x86_64_v2_libcec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcec-6.0.2-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcec}"
SRC_URI[x86_64_v2_libcec.sha256sum] = "b8c5188847f1197cce95b0d6ca0b9f7317fe837e27721de97fb547e07674539c"

URI_x86_64_v2_libcec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcec-devel-6.0.2-18.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcec-devel}"
SRC_URI[x86_64_v2_libcec-devel.sha256sum] = "1010fe8f25cf99a200920c0905102314881490d3d6027ff4a333eaa4e2736dc8"

URI_aarch64_libcec = "${EPEL_MIRROR}/aarch64/Packages/l/libcec-6.0.2-18.el10_0.aarch64.rpm;name=aarch64_libcec;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcec}"
SRC_URI[aarch64_libcec.sha256sum] = "fed2d42dc95ad84b4e4e78546c525988b9cc30a459149339b71984ec60bf145d"

URI_aarch64_libcec-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcec-devel-6.0.2-18.el10_0.aarch64.rpm;name=aarch64_libcec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcec-devel}"
SRC_URI[aarch64_libcec-devel.sha256sum] = "a14160c03a5c9bfd31a4d9631faf4dac037da15885f1b234f3a3a4143fe0fc9a"

RDEPENDS:libcec = " \
 glibc \
 libX11 \
 libXrandr \
 libgcc \
 libstdc++ \
 ncurses-libs \
 platform \
 systemd-libs \
 "
RDEPENDS:libcec-devel = " \
 libcec \
 pkgconf-pkg-config \
 platform-devel \
 "
