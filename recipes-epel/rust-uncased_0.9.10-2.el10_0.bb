# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uncased"
PV = "0.9.10"
PR = "2.el10_0"
PACKAGES = " \
 rust-uncased+alloc-devel \
 rust-uncased+default-devel \
 rust-uncased+serde-devel \
 rust-uncased+with-serde-alloc-devel \
 rust-uncased+with-serde-devel \
 rust-uncased-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uncased-0.9.10-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "487516e0c17313909e89e3603474cbc492f260d8dce879391d40d3fb58fb5170"

URI_x86_64_v2_rust-uncased+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uncased+alloc-devel-0.9.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uncased+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uncased+alloc-devel}"
SRC_URI[x86_64_v2_rust-uncased+alloc-devel.sha256sum] = "42408547dcc0a10bff65d28ca7607f04d21d432c8180e36acf089fc006acb79b"

URI_x86_64_v2_rust-uncased+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uncased+default-devel-0.9.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uncased+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uncased+default-devel}"
SRC_URI[x86_64_v2_rust-uncased+default-devel.sha256sum] = "de4e500f780e9042c702870a9f3447a2147fb8aff385fbce91e81dbfa68fc706"

URI_x86_64_v2_rust-uncased+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uncased+serde-devel-0.9.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uncased+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uncased+serde-devel}"
SRC_URI[x86_64_v2_rust-uncased+serde-devel.sha256sum] = "b457dc06962798094da1a51d98ed298e78efba1078f95b66432cbfc61044b5f9"

URI_x86_64_v2_rust-uncased+with-serde-alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uncased+with-serde-alloc-devel-0.9.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uncased+with-serde-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uncased+with-serde-alloc-devel}"
SRC_URI[x86_64_v2_rust-uncased+with-serde-alloc-devel.sha256sum] = "8c7b52bd8d23a628f579c12f17679cc80a28c930aeb279b0d82d264846443883"

URI_x86_64_v2_rust-uncased+with-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uncased+with-serde-devel-0.9.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uncased+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uncased+with-serde-devel}"
SRC_URI[x86_64_v2_rust-uncased+with-serde-devel.sha256sum] = "49ad97e92ede0421a139647db7104e49ac2b1f521a0e28b0b976454525e25cde"

URI_x86_64_v2_rust-uncased-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uncased-devel-0.9.10-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uncased-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uncased-devel}"
SRC_URI[x86_64_v2_rust-uncased-devel.sha256sum] = "65f0ad0aeb38e6b811f9b7907cb9b449215d05572bd7b55dbbe58565c8dc4ecd"

URI_aarch64_rust-uncased+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uncased+alloc-devel-0.9.10-2.el10_0.noarch.rpm;name=aarch64_rust-uncased+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uncased+alloc-devel}"
SRC_URI[aarch64_rust-uncased+alloc-devel.sha256sum] = "85395412ce67b579c86804a1702fb8bf7612c6a63c060db65ec6e554309746b1"

URI_aarch64_rust-uncased+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uncased+default-devel-0.9.10-2.el10_0.noarch.rpm;name=aarch64_rust-uncased+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uncased+default-devel}"
SRC_URI[aarch64_rust-uncased+default-devel.sha256sum] = "1d9674f5eb57505fa85d966d1af08715c86468cc2e5e95f4898ad33e2ff69268"

URI_aarch64_rust-uncased+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uncased+serde-devel-0.9.10-2.el10_0.noarch.rpm;name=aarch64_rust-uncased+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uncased+serde-devel}"
SRC_URI[aarch64_rust-uncased+serde-devel.sha256sum] = "816236064603e95521bcac47bf615fd785cc7a119769b7407a6564eba04bbc8e"

URI_aarch64_rust-uncased+with-serde-alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uncased+with-serde-alloc-devel-0.9.10-2.el10_0.noarch.rpm;name=aarch64_rust-uncased+with-serde-alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uncased+with-serde-alloc-devel}"
SRC_URI[aarch64_rust-uncased+with-serde-alloc-devel.sha256sum] = "ba10be8b3703c1e8aa383f48b8c2fe2410e5d076a568beae6545a3127e5ce0e6"

URI_aarch64_rust-uncased+with-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uncased+with-serde-devel-0.9.10-2.el10_0.noarch.rpm;name=aarch64_rust-uncased+with-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uncased+with-serde-devel}"
SRC_URI[aarch64_rust-uncased+with-serde-devel.sha256sum] = "350195c5f188ef4736a412387d39c3a97e74d039682c37aa6b689ef80892711c"

URI_aarch64_rust-uncased-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uncased-devel-0.9.10-2.el10_0.noarch.rpm;name=aarch64_rust-uncased-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uncased-devel}"
SRC_URI[aarch64_rust-uncased-devel.sha256sum] = "9fbc2f014a3bde0c69f122bfd5b514fc3b7742f56ac89ed6a130a13dd060cf20"

RDEPENDS:rust-uncased+alloc-devel = " \
 cargo \
 rust-uncased-devel \
 "
RDEPENDS:rust-uncased+default-devel = " \
 cargo \
 rust-uncased+alloc-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-uncased+serde-devel = " \
 cargo \
 rust-serde-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-uncased+with-serde-alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-uncased+alloc-devel \
 rust-uncased+serde-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-uncased+with-serde-devel = " \
 cargo \
 rust-uncased+serde-devel \
 rust-uncased-devel \
 "
RDEPENDS:rust-uncased-devel = " \
 cargo \
 rust-version_check+default-devel \
 "
