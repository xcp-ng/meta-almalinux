# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-cryptonite"
PV = "0.30"
PR = "8.el10_0"
PACKAGES = " \
 ghc-cryptonite \
 ghc-cryptonite-devel \
 ghc-cryptonite-doc \
 ghc-cryptonite-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-cryptonite-0.30-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3769b38524ace3eef8c03453dc8f4026aea62a8a957d1b6688398f96ed8bd260"

URI_x86_64_v2_ghc-cryptonite = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptonite-0.30-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptonite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptonite}"
SRC_URI[x86_64_v2_ghc-cryptonite.sha256sum] = "79ca6eec53e96c2a28b3f5a025c24b5e0b86a9bce2acd4d1071ce9a620d55cec"

URI_x86_64_v2_ghc-cryptonite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptonite-devel-0.30-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptonite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptonite-devel}"
SRC_URI[x86_64_v2_ghc-cryptonite-devel.sha256sum] = "2933268e2e611dd20bdf7a37ee561b62f0ab85b9f6e5a4915277b422f07d5e91"

URI_x86_64_v2_ghc-cryptonite-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptonite-doc-0.30-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptonite-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptonite-doc}"
SRC_URI[x86_64_v2_ghc-cryptonite-doc.sha256sum] = "3ea02297b05518cb821a7824d13af099bd3eacacbbe257895309e632fc8de684"

URI_x86_64_v2_ghc-cryptonite-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-cryptonite-prof-0.30-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-cryptonite-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-cryptonite-prof}"
SRC_URI[x86_64_v2_ghc-cryptonite-prof.sha256sum] = "2fdafeaea41f94110b80d9f5f594b3f911c9156b1c0417ee37752896e25600de"

URI_aarch64_ghc-cryptonite = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptonite-0.30-8.el10_0.aarch64.rpm;name=aarch64_ghc-cryptonite;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptonite}"
SRC_URI[aarch64_ghc-cryptonite.sha256sum] = "cc9d693132ceaf118eee08bc47da41b0c1260927a7bf83dfdd74b8bd413c328b"

URI_aarch64_ghc-cryptonite-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptonite-devel-0.30-8.el10_0.aarch64.rpm;name=aarch64_ghc-cryptonite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptonite-devel}"
SRC_URI[aarch64_ghc-cryptonite-devel.sha256sum] = "3b029cd5398c1bf88ceec8ba4660986a53a584fe52f990b78fe4578a665e1610"

URI_aarch64_ghc-cryptonite-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptonite-doc-0.30-8.el10_0.aarch64.rpm;name=aarch64_ghc-cryptonite-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptonite-doc}"
SRC_URI[aarch64_ghc-cryptonite-doc.sha256sum] = "bdabc25e742613835a86b8e47c7563d73fc78a360271c31d4e297c78a890d24e"

URI_aarch64_ghc-cryptonite-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-cryptonite-prof-0.30-8.el10_0.aarch64.rpm;name=aarch64_ghc-cryptonite-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-cryptonite-prof}"
SRC_URI[aarch64_ghc-cryptonite-prof.sha256sum] = "f2f4c03eae7162405266d728ae3c8ac8f3cd76de673cad4a31559b7fb977f615"

RDEPENDS:ghc-cryptonite = " \
 ghc-array \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-memory \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-cryptonite-devel = " \
 ghc-base-devel \
 ghc-basement-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-cryptonite \
 ghc-deepseq-devel \
 ghc-memory-devel \
 glibc-devel \
 "
RDEPENDS:ghc-cryptonite-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-cryptonite-prof = " \
 ghc-base-prof \
 ghc-basement-prof \
 ghc-bytestring-prof \
 ghc-cryptonite-devel \
 ghc-deepseq-prof \
 ghc-memory-prof \
 "
