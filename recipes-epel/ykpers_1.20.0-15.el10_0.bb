# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ykpers"
PV = "1.20.0"
PR = "15.el10_0"
PACKAGES = " \
 ykpers \
 ykpers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/ykpers-1.20.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c30736e160664c289c651197deff28c52c53c8383206babbd33d8ae632146662"

URI_x86_64_v2_ykpers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ykpers-1.20.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ykpers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ykpers}"
SRC_URI[x86_64_v2_ykpers.sha256sum] = "d667c62049e2d07126b15c65cd8ebd146052bfeb380eb90c57ea93be2d4b316c"

URI_x86_64_v2_ykpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ykpers-devel-1.20.0-15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ykpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ykpers-devel}"
SRC_URI[x86_64_v2_ykpers-devel.sha256sum] = "ea00cc646963b34a80307d9cd85fedbdd9d62410c788c4e3b7a2968ef9b8dde1"

URI_aarch64_ykpers = "${EPEL_MIRROR}/aarch64/Packages/y/ykpers-1.20.0-15.el10_0.aarch64.rpm;name=aarch64_ykpers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ykpers}"
SRC_URI[aarch64_ykpers.sha256sum] = "45f8d3276c84fddd35bd642f73ccaf3b241e2b9f4f40dde2e27c378a5b6744ec"

URI_aarch64_ykpers-devel = "${EPEL_MIRROR}/aarch64/Packages/y/ykpers-devel-1.20.0-15.el10_0.aarch64.rpm;name=aarch64_ykpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ykpers-devel}"
SRC_URI[aarch64_ykpers-devel.sha256sum] = "5c33fedb207711797c2f2eb54e1f5b0701726fed355f0ff4e501f678700e12d8"

RDEPENDS:ykpers = " \
 glibc \
 libusb1 \
 libyubikey \
 "
RDEPENDS:ykpers-devel = " \
 pkgconf-pkg-config \
 ykpers \
 "
