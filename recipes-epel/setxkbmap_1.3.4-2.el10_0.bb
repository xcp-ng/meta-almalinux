# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setxkbmap"
PV = "1.3.4"
PR = "2.el10_0"
PACKAGES = " \
 setxkbmap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/setxkbmap-1.3.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaa84f7ce049b1b57e800aea835fe38d7eec51e7f1468d7b0e397a1c74b0c16d"

URI_x86_64_v2_setxkbmap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/setxkbmap-1.3.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_setxkbmap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setxkbmap}"
SRC_URI[x86_64_v2_setxkbmap.sha256sum] = "d39a866029310f97efe85ad40ef15b09b51b52fb0214a7560a44f79e9789bd7b"

URI_aarch64_setxkbmap = "${EPEL_MIRROR}/aarch64/Packages/s/setxkbmap-1.3.4-2.el10_0.aarch64.rpm;name=aarch64_setxkbmap;unpack=0"
SRC_URI:append = " ${URI_aarch64_setxkbmap}"
SRC_URI[aarch64_setxkbmap.sha256sum] = "691f0a231628383c8d067880c73a719fe2694ef9b63d71c8c0f0e2f138c84320"

RDEPENDS:setxkbmap = " \
 glibc \
 libX11 \
 libXrandr \
 libxkbfile \
 "
