# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-index"
PV = "0.43.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-index+default-devel \
 rust-gix-index+document-features-devel \
 rust-gix-index+serde-devel \
 rust-gix-index-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-index-0.43.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1e15ec285a5ccf6f01df8aaa1378afd6790c5aaf24eabc133065468d65cc1bf"

URI_x86_64_v2_rust-gix-index+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+default-devel-0.43.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+default-devel}"
SRC_URI[x86_64_v2_rust-gix-index+default-devel.sha256sum] = "cccbfc0ae748ee18061055c6d4a8cdc50976fcf74daf95bdd5c8ea23ba5fb7e2"

URI_x86_64_v2_rust-gix-index+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+document-features-devel-0.43.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-index+document-features-devel.sha256sum] = "005700180bccbe86f27d2f2d820f37de656e0abff0dd92feb506640095211dec"

URI_x86_64_v2_rust-gix-index+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index+serde-devel-0.43.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-index+serde-devel.sha256sum] = "d1d74da7ce47ec49277e689187c42c70040a98ca624066535416bf4647ba2784"

URI_x86_64_v2_rust-gix-index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-index-devel-0.43.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-index-devel}"
SRC_URI[x86_64_v2_rust-gix-index-devel.sha256sum] = "fae411449790c7d279c40dd19519609670f4b21bd48539d7d97b7f84a6c07a3f"

URI_aarch64_rust-gix-index+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+default-devel-0.43.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-index+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+default-devel}"
SRC_URI[aarch64_rust-gix-index+default-devel.sha256sum] = "533c688314ea5f19039f636d7f2f27ef0eb7a0119a8bbb04ae33afa93fcdaf3f"

URI_aarch64_rust-gix-index+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+document-features-devel-0.43.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-index+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+document-features-devel}"
SRC_URI[aarch64_rust-gix-index+document-features-devel.sha256sum] = "c2e97daf3b8283739ce73e9dc8d3e9f5a05a838646a24635b9249a8e822ea808"

URI_aarch64_rust-gix-index+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index+serde-devel-0.43.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-index+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index+serde-devel}"
SRC_URI[aarch64_rust-gix-index+serde-devel.sha256sum] = "dda2dba1301ddf15d6132f2f445ab0ecd5e9e4221e7e432f373a4edf783b2fa0"

URI_aarch64_rust-gix-index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-index-devel-0.43.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-index-devel}"
SRC_URI[aarch64_rust-gix-index-devel.sha256sum] = "f78019de18f4fe0abfc50055bdb1bc8d55f977f5ebbbcfe65ac1fb66d764e2fb"

RDEPENDS:rust-gix-index+default-devel = " \
 cargo \
 rust-gix-index-devel \
 "
RDEPENDS:rust-gix-index+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-index-devel \
 "
RDEPENDS:rust-gix-index+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-index-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-smallvec+serde-devel \
 "
RDEPENDS:rust-gix-index-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-bstr-devel \
 rust-filetime+default-devel \
 rust-fnv+default-devel \
 rust-gix-bitmap+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-hashbrown+default-devel \
 rust-itoa+default-devel \
 rust-libc+default-devel \
 rust-memmap2+default-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
