# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kitty"
PV = "0.47.1"
PR = "3.el10_3"
PACKAGES = " \
 kitty \
 kitty-doc \
 kitty-kitten \
 kitty-shell-integration \
 kitty-terminfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kitty-0.47.1-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bb4738b86a7029ef840a6e695ddadf3c8f8c6e86d76899559818dea1a07adbc2"

URI_x86_64_v2_kitty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-0.47.1-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty}"
SRC_URI[x86_64_v2_kitty.sha256sum] = "083a0fab91a969befd5de8a2f882b9ce5f7af55d7acbe6e7597e735b935eff0a"

URI_x86_64_v2_kitty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-doc-0.47.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kitty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty-doc}"
SRC_URI[x86_64_v2_kitty-doc.sha256sum] = "3cde5bbcb2aa33e7e754f0ce4869f2ef81072d9686103a495e00b41c52a3293b"

URI_x86_64_v2_kitty-kitten = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-kitten-0.47.1-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kitty-kitten;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty-kitten}"
SRC_URI[x86_64_v2_kitty-kitten.sha256sum] = "5914ac6dc68d1ff6128eab51a020f2695df914edb09b8d81530b6efd38b6033a"

URI_x86_64_v2_kitty-shell-integration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-shell-integration-0.47.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kitty-shell-integration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty-shell-integration}"
SRC_URI[x86_64_v2_kitty-shell-integration.sha256sum] = "51575b41b78c5bddea35e24b3d4968d6343e2a4fdf3ef5b0ce8061bed7fb1468"

URI_x86_64_v2_kitty-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kitty-terminfo-0.47.1-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kitty-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kitty-terminfo}"
SRC_URI[x86_64_v2_kitty-terminfo.sha256sum] = "ec40624ca265f62b75501c2cc66ea4162854069298907225ddc2bb73d537fca5"

URI_aarch64_kitty = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-0.47.1-3.el10_3.aarch64.rpm;name=aarch64_kitty;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty}"
SRC_URI[aarch64_kitty.sha256sum] = "a34d19a8317c6b9a06fb1176a757cc7756af13a5b7ef160c97056d1fb78811ef"

URI_aarch64_kitty-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-doc-0.47.1-3.el10_3.noarch.rpm;name=aarch64_kitty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty-doc}"
SRC_URI[aarch64_kitty-doc.sha256sum] = "02e1c7bb0b3e13a7c9553c994c5147dc021ea1dd45dc45bab8fe28358b531a00"

URI_aarch64_kitty-kitten = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-kitten-0.47.1-3.el10_3.aarch64.rpm;name=aarch64_kitty-kitten;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty-kitten}"
SRC_URI[aarch64_kitty-kitten.sha256sum] = "93d95d9152554ee37983d10fcd3ddb237fd5c98e01824141a09e67c1ecdd1c4c"

URI_aarch64_kitty-shell-integration = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-shell-integration-0.47.1-3.el10_3.noarch.rpm;name=aarch64_kitty-shell-integration;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty-shell-integration}"
SRC_URI[aarch64_kitty-shell-integration.sha256sum] = "6266faf2218d062e364e5cc1b84daa626f910373721a1bc1aed60b611a530bde"

URI_aarch64_kitty-terminfo = "${EPEL_MIRROR}/aarch64/Packages/k/kitty-terminfo-0.47.1-3.el10_3.noarch.rpm;name=aarch64_kitty-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_kitty-terminfo}"
SRC_URI[aarch64_kitty-terminfo.sha256sum] = "6baa5464d24c5994614c8f070e431dcfb5f1f4b6382dc55dd5ae273ccd635b39"

RDEPENDS:kitty = " \
 cairo \
 dbus-libs \
 freetype \
 glibc \
 harfbuzz \
 hicolor-icon-theme \
 kitty-kitten \
 kitty-shell-integration \
 kitty-terminfo \
 lcms2 \
 libX11 \
 libX11-xcb \
 libXcursor \
 libgcc \
 libpng \
 libwayland-client \
 libxkbcommon \
 libxkbcommon-x11 \
 openssl-libs \
 python3 \
 python3-libs \
 xxhash-libs \
 zlib-ng-compat \
 "
RDEPENDS:kitty-doc = " \
 "
RDEPENDS:kitty-kitten = " \
 glibc \
 "
RDEPENDS:kitty-shell-integration = " \
 bash \
 "
RDEPENDS:kitty-terminfo = " \
 ncurses-base \
 "
