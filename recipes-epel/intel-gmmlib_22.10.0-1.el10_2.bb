# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "intel-gmmlib"
PV = "22.10.0"
PR = "1.el10_2"
PACKAGES = " \
 intel-gmmlib \
 intel-gmmlib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/intel-gmmlib-22.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18842d972780fcea3bee9db8034178798716bfd3b15819e51fe8561cf9350106"

URI_x86_64_v2_intel-gmmlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-22.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gmmlib}"
SRC_URI[x86_64_v2_intel-gmmlib.sha256sum] = "bfcfd6f16d8abf07253c2d1a146362f969179ff56a2e0f65c4925501f63afc29"

URI_x86_64_v2_intel-gmmlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/intel-gmmlib-devel-22.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_intel-gmmlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_intel-gmmlib-devel}"
SRC_URI[x86_64_v2_intel-gmmlib-devel.sha256sum] = "bbd42e429d58f399f3f210350498430b46440863f5acdd226c369e6e60396f06"

URI_aarch64_intel-gmmlib = "${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-22.10.0-1.el10_2.aarch64.rpm;name=aarch64_intel-gmmlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gmmlib}"
SRC_URI[aarch64_intel-gmmlib.sha256sum] = "599e5ccf1a2c3d8146a007ee8824ffbbd92b166fe9360eece9638977ece4fd6d"

URI_aarch64_intel-gmmlib-devel = "${EPEL_MIRROR}/aarch64/Packages/i/intel-gmmlib-devel-22.10.0-1.el10_2.aarch64.rpm;name=aarch64_intel-gmmlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_intel-gmmlib-devel}"
SRC_URI[aarch64_intel-gmmlib-devel.sha256sum] = "76d49fb1904fd50d3e31fb9cfa2be70fb1d6593fdd7b003fb5a79039a02612a7"

RDEPENDS:intel-gmmlib = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:intel-gmmlib-devel = " \
 intel-gmmlib \
 pkgconf-pkg-config \
 "
