# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fixtures"
PV = "4.3.2"
PR = "1.el10_3"
PACKAGES = " \
 python3-fixtures \
 python3-fixtures+streams \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fixtures-4.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d67f422736f8722ecefc5204b90e878a529001bae94b90a890fc4bfed2d2295d"

URI_x86_64_v2_python3-fixtures = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fixtures-4.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fixtures;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fixtures}"
SRC_URI[x86_64_v2_python3-fixtures.sha256sum] = "5b6852c2b522a7449af21d5e16956282b59f571920089ba6ebfe4a5a475a7395"

URI_x86_64_v2_python3-fixtures+streams = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fixtures+streams-4.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-fixtures+streams;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fixtures+streams}"
SRC_URI[x86_64_v2_python3-fixtures+streams.sha256sum] = "b3b4cd60b37d1f51f5c61107658d901d04c25da0a54d914928cf9fd958b36f23"

URI_aarch64_python3-fixtures = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fixtures-4.3.2-1.el10_3.noarch.rpm;name=aarch64_python3-fixtures;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fixtures}"
SRC_URI[aarch64_python3-fixtures.sha256sum] = "dd0463990e0153b07ffcaff1f676c60b7e25c859090217bb685bf07079af7c74"

URI_aarch64_python3-fixtures+streams = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fixtures+streams-4.3.2-1.el10_3.noarch.rpm;name=aarch64_python3-fixtures+streams;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fixtures+streams}"
SRC_URI[aarch64_python3-fixtures+streams.sha256sum] = "d2df11b212763f72c606b592df377ef9f9e562a0320172c32cc6411e7d4a4177"

RDEPENDS:python3-fixtures = " \
 python3 \
 "
RDEPENDS:python3-fixtures+streams = " \
 python3 \
 python3-fixtures \
 python3-testtools \
 "
