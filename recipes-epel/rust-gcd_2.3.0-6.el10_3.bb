# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gcd"
PV = "2.3.0"
PR = "6.el10_3"
PACKAGES = " \
 rust-gcd+default-devel \
 rust-gcd-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-gcd-2.3.0-6.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dd734621d1d1cb3f4c74a2120cfc8a315ec0c6205304c42b33f5921da5ff166b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gcd+default-devel-2.3.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gcd+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gcd+default-devel.sha256sum] = "953c17795401997a6eeca2b7de352a37537e90d6d61b330232505dcac0020dcd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gcd-devel-2.3.0-6.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gcd-devel;unpack=0"
SRC_URI[x86_64_v2_rust-gcd-devel.sha256sum] = "4d971b753bafe9c56fb048658357f98bbff146d875198e04fb108e6964ec64cd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gcd+default-devel-2.3.0-6.el10_3.noarch.rpm;name=aarch64_rust-gcd+default-devel;unpack=0"
SRC_URI[aarch64_rust-gcd+default-devel.sha256sum] = "f6b3c959e4af6aa29c76c4f0516fe14320a2021d8d74e94176aab3c019004892"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-gcd-devel-2.3.0-6.el10_3.noarch.rpm;name=aarch64_rust-gcd-devel;unpack=0"
SRC_URI[aarch64_rust-gcd-devel.sha256sum] = "309232fa63df51f997e0bc34b24d622d4c4fc415fb9f796d6ece70dcc3f60446"

RDEPENDS:rust-gcd+default-devel = " \
 cargo \
 rust-gcd-devel \
 "
RDEPENDS:rust-gcd-devel = " \
 cargo \
 "
