# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mockall_derive"
PV = "0.11.4"
PR = "4.el10_0"
PACKAGES = " \
 rust-mockall_derive+default-devel \
 rust-mockall_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mockall_derive-0.11.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8269350789a5cc26f7b9cc379c96aa7cbb2d458d5af6b0e23e362b4660b1ae7"

URI_x86_64_v2_rust-mockall_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockall_derive+default-devel-0.11.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockall_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockall_derive+default-devel}"
SRC_URI[x86_64_v2_rust-mockall_derive+default-devel.sha256sum] = "57495393b27ee7206f3ac7bea15af383db6f8877e0132d64ffb74ce4a3d2a8ab"

URI_x86_64_v2_rust-mockall_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mockall_derive-devel-0.11.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mockall_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mockall_derive-devel}"
SRC_URI[x86_64_v2_rust-mockall_derive-devel.sha256sum] = "69f57a6664e978b37afbe2134395491e5b01bd5df9ed6362cf98bb8552e2c16d"

URI_aarch64_rust-mockall_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockall_derive+default-devel-0.11.4-4.el10_0.noarch.rpm;name=aarch64_rust-mockall_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockall_derive+default-devel}"
SRC_URI[aarch64_rust-mockall_derive+default-devel.sha256sum] = "504b6d2330a1ed5dd2eaf98c4fd65e2a372e87c0cd8513cfc055cd7be6f61ed9"

URI_aarch64_rust-mockall_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mockall_derive-devel-0.11.4-4.el10_0.noarch.rpm;name=aarch64_rust-mockall_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mockall_derive-devel}"
SRC_URI[aarch64_rust-mockall_derive-devel.sha256sum] = "b96e2809a82c7dc7424bbf4fde687d8bee6e1d4bed339e63310534c04bc2b968"

RDEPENDS:rust-mockall_derive+default-devel = " \
 cargo \
 rust-mockall_derive-devel \
 "
RDEPENDS:rust-mockall_derive-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn1+default-devel \
 rust-syn1+extra-traits-devel \
 rust-syn1+full-devel \
 "
