# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtcharts"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtcharts \
 qt5-qtcharts-devel \
 qt5-qtcharts-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtcharts-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b783b78601716f12769a3a252aa993b5a8e053ac1626270793d66decf76f96d"

URI_x86_64_v2_qt5-qtcharts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtcharts-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtcharts}"
SRC_URI[x86_64_v2_qt5-qtcharts.sha256sum] = "31925ac22d4794cc41f5ae3d38f271ff6a9259923491322e8e8388b1e39b4fff"

URI_x86_64_v2_qt5-qtcharts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtcharts-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtcharts-devel}"
SRC_URI[x86_64_v2_qt5-qtcharts-devel.sha256sum] = "0d4e890daa5098f254f704d9e6e9b09f463cdee8cd0fb1124fe1ab02aedbd76f"

URI_x86_64_v2_qt5-qtcharts-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtcharts-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtcharts-examples}"
SRC_URI[x86_64_v2_qt5-qtcharts-examples.sha256sum] = "b35ea4383d86a8e655c586e1d5ec190a9607bc6691415da7786b7bb7713d4aa9"

URI_aarch64_qt5-qtcharts = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtcharts-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtcharts}"
SRC_URI[aarch64_qt5-qtcharts.sha256sum] = "21616a9760fdaa7de570c057e7ce85f53e3628f1b6db6ea9a5b00a18d3f92498"

URI_aarch64_qt5-qtcharts-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtcharts-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtcharts-devel}"
SRC_URI[aarch64_qt5-qtcharts-devel.sha256sum] = "db252f998018b8b6a0ea186c0736f10d201277bf4dbb0fc1fcfefbcd83bd5c7c"

URI_aarch64_qt5-qtcharts-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtcharts-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtcharts-examples}"
SRC_URI[aarch64_qt5-qtcharts-examples.sha256sum] = "87a73b9d4c73d10c7982872d8153affb662575bbd439369f0cc70dc848858eca"

RDEPENDS:qt5-qtcharts = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtcharts-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtcharts \
 "
RDEPENDS:qt5-qtcharts-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtcharts \
 qt5-qtdeclarative \
 "
