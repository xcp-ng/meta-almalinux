# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch"
PV = "2.27.1"
PR = "3.el10_2"
PACKAGES = " \
 onefetch \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-2.27.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4dd780d9378d4fb63f8e365815294d14ef58cef02e0d36f957961133b493ea0a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/onefetch-2.27.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_onefetch;unpack=0"
SRC_URI[x86_64_v2_onefetch.sha256sum] = "f78259ff6ee33aec07a83cd6fe0505b41e4c5bd3c47ab512fe8bc0ae6bb12776"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/onefetch-2.27.1-3.el10_2.aarch64.rpm;name=aarch64_onefetch;unpack=0"
SRC_URI[aarch64_onefetch.sha256sum] = "0085fbcc4fe2407ae89db0d813ebffc126757929892ac8a6abb418f7eb14d0d5"

RDEPENDS:onefetch = " \
 glibc \
 libgcc \
 libzstd \
 "
