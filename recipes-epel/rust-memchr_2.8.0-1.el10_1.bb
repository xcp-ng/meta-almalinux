# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-memchr"
PV = "2.8.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-memchr+alloc-devel \
 rust-memchr+default-devel \
 rust-memchr+libc-devel \
 rust-memchr+logging-devel \
 rust-memchr+std-devel \
 rust-memchr+use_std-devel \
 rust-memchr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-memchr-2.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df3149e278d6750dd1c0ed4914a5d73b2705d1141c7ff3f50e6ef9d4b0795709"

URI_x86_64_v2_rust-memchr+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+alloc-devel-2.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+alloc-devel}"
SRC_URI[x86_64_v2_rust-memchr+alloc-devel.sha256sum] = "78274136fb48a5edf5c19afbe3ab907c010e04c1ceb6606bbc3a4f102462e762"

URI_x86_64_v2_rust-memchr+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+default-devel-2.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+default-devel}"
SRC_URI[x86_64_v2_rust-memchr+default-devel.sha256sum] = "50c61e6939db1341393a9f6b281d33a8fd4e5e03d100c1d953dc42519765505e"

URI_x86_64_v2_rust-memchr+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+libc-devel-2.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+libc-devel}"
SRC_URI[x86_64_v2_rust-memchr+libc-devel.sha256sum] = "8165a40720fffafcabe6f059eb0cc7a11643b960d1cfbbbcd549ca3fb4b0a7e8"

URI_x86_64_v2_rust-memchr+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+logging-devel-2.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+logging-devel}"
SRC_URI[x86_64_v2_rust-memchr+logging-devel.sha256sum] = "4ecd4cfed74d3206e449c8bc9df55f169b1dfa139d0c35097dc7605fc8cfede4"

URI_x86_64_v2_rust-memchr+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+std-devel-2.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+std-devel}"
SRC_URI[x86_64_v2_rust-memchr+std-devel.sha256sum] = "4984a405e2f9f45f9c937bf90b2cb32ed3d1dbf9722e68a2111f1810989ab8b7"

URI_x86_64_v2_rust-memchr+use_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr+use_std-devel-2.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr+use_std-devel}"
SRC_URI[x86_64_v2_rust-memchr+use_std-devel.sha256sum] = "662652bd3ece63a9eb978e61bb1a69045aa05e2a573bd663c53da4583a9397de"

URI_x86_64_v2_rust-memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-memchr-devel-2.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-memchr-devel}"
SRC_URI[x86_64_v2_rust-memchr-devel.sha256sum] = "71e3d86303a7545857ef907b9f2640e49a2026f3f7e7363af2f7c4ef7366c89c"

URI_aarch64_rust-memchr+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+alloc-devel-2.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-memchr+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+alloc-devel}"
SRC_URI[aarch64_rust-memchr+alloc-devel.sha256sum] = "370a467dd8c2cf631b57857adafb3bc8f017b7bbd15084c927bac081801a60f6"

URI_aarch64_rust-memchr+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+default-devel-2.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-memchr+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+default-devel}"
SRC_URI[aarch64_rust-memchr+default-devel.sha256sum] = "347e4f9b718314f21ecbcbbb1e43c2ac99e121ef6bd1a4042ed7641a86b2ac37"

URI_aarch64_rust-memchr+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+libc-devel-2.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-memchr+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+libc-devel}"
SRC_URI[aarch64_rust-memchr+libc-devel.sha256sum] = "48d06080c80bb62b7aad4a8fd3b2d17835ff749a94c2525de7ab84445c9dc1e5"

URI_aarch64_rust-memchr+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+logging-devel-2.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-memchr+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+logging-devel}"
SRC_URI[aarch64_rust-memchr+logging-devel.sha256sum] = "57892843c6ccaafce0452f51e33b9969cf66a0c4c63779f1589b017338c2b080"

URI_aarch64_rust-memchr+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+std-devel-2.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-memchr+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+std-devel}"
SRC_URI[aarch64_rust-memchr+std-devel.sha256sum] = "d2c4dc39e427393f9619b2971af2ddc1d53af1d5b9e525690bad593f407ada17"

URI_aarch64_rust-memchr+use_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr+use_std-devel-2.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-memchr+use_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr+use_std-devel}"
SRC_URI[aarch64_rust-memchr+use_std-devel.sha256sum] = "62e7ba70042d6a8e85e6a2e57b4e1d51b5732e565592709a304503fe67fe32f9"

URI_aarch64_rust-memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-memchr-devel-2.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-memchr-devel}"
SRC_URI[aarch64_rust-memchr-devel.sha256sum] = "171832e2b7744100b338ef5e6b3fd260fefea508de501d231abb6030135ed569"

RDEPENDS:rust-memchr+alloc-devel = " \
 cargo \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+default-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+libc-devel = " \
 cargo \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+logging-devel = " \
 cargo \
 rust-log+default-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+std-devel = " \
 cargo \
 rust-memchr+alloc-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr+use_std-devel = " \
 cargo \
 rust-memchr+std-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-memchr-devel = " \
 cargo \
 rust \
 "
