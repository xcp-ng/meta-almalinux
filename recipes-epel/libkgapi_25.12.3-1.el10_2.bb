# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkgapi"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 libkgapi \
 libkgapi-devel \
 libkgapi-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libkgapi-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99a81238bdbe7a509b8a65d5512a0bb39623002e6cc0e50674de318b616b85af"

URI_x86_64_v2_libkgapi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi}"
SRC_URI[x86_64_v2_libkgapi.sha256sum] = "b21549f29d984a7fc7a88f6be6fbd3c5e08454741066854394c058fe434de6b7"

URI_x86_64_v2_libkgapi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libkgapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi-devel}"
SRC_URI[x86_64_v2_libkgapi-devel.sha256sum] = "210f0de31ab43347a4371f7163450557decf47721592196bd1bc3ca4faeddbae"

URI_x86_64_v2_libkgapi-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libkgapi-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libkgapi-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkgapi-doc}"
SRC_URI[x86_64_v2_libkgapi-doc.sha256sum] = "2e1d908fb5f2fdc66f940882930415f1844d224fc1be2fd6c9175fe821143073"

URI_aarch64_libkgapi = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkgapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi}"
SRC_URI[aarch64_libkgapi.sha256sum] = "ec565100cb48ffb5de48f1a2d76ed763b508d8825c7f0676b8c15a9a0180a28e"

URI_aarch64_libkgapi-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_libkgapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi-devel}"
SRC_URI[aarch64_libkgapi-devel.sha256sum] = "4b8c45e01add8ca6d201b10822b82f60afc3e4e6dd6970158511afa458e7cf6d"

URI_aarch64_libkgapi-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libkgapi-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_libkgapi-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkgapi-doc}"
SRC_URI[aarch64_libkgapi-doc.sha256sum] = "eb8d021040a7a9b8646f301f637ca5665348d8a872b9ee887e60cbec80b477da"

RDEPENDS:libkgapi = " \
 glibc \
 kf6-kcalendarcore \
 kf6-kcontacts \
 kf6-kwallet-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libkgapi-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore-devel \
 kf6-kcontacts-devel \
 kf6-kcoreaddons-devel \
 libkgapi \
 "
RDEPENDS:libkgapi-doc = " \
 "
