# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix"
PV = "0.75.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix+async-network-client-async-std-devel \
 rust-gix+async-network-client-devel \
 rust-gix+async-std-devel \
 rust-gix+attributes-devel \
 rust-gix+basic-devel \
 rust-gix+blame-devel \
 rust-gix+blob-diff-devel \
 rust-gix+blocking-http-transport-curl-devel \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix+blocking-http-transport-reqwest-native-tls-devel \
 rust-gix+blocking-http-transport-reqwest-rust-tls-devel \
 rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel \
 rust-gix+blocking-network-client-devel \
 rust-gix+cache-efficiency-debug-devel \
 rust-gix+comfort-devel \
 rust-gix+command-devel \
 rust-gix+credentials-devel \
 rust-gix+default-devel \
 rust-gix+dirwalk-devel \
 rust-gix+document-features-devel \
 rust-gix+excludes-devel \
 rust-gix+extras-devel \
 rust-gix+gix-archive-devel \
 rust-gix+gix-status-devel \
 rust-gix+gix-worktree-stream-devel \
 rust-gix+hp-tempfile-registry-devel \
 rust-gix+index-devel \
 rust-gix+interrupt-devel \
 rust-gix+mailmap-devel \
 rust-gix+max-control-devel \
 rust-gix+max-performance-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix+merge-devel \
 rust-gix+need-more-recent-msrv-devel \
 rust-gix+pack-cache-lru-dynamic-devel \
 rust-gix+pack-cache-lru-static-devel \
 rust-gix+parallel-devel \
 rust-gix+prodash-devel \
 rust-gix+progress-tree-devel \
 rust-gix+regex-devel \
 rust-gix+revision-devel \
 rust-gix+revparse-regex-devel \
 rust-gix+serde-devel \
 rust-gix+status-devel \
 rust-gix+tracing-detail-devel \
 rust-gix+tracing-devel \
 rust-gix+tree-editor-devel \
 rust-gix+verbose-object-parsing-errors-devel \
 rust-gix+worktree-archive-devel \
 rust-gix+worktree-mutation-devel \
 rust-gix+worktree-stream-devel \
 rust-gix+zlib-ng-devel \
 rust-gix+zlib-rs-devel \
 rust-gix+zlib-stock-devel \
 rust-gix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-0.75.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "13f6c8a07a505059832c6d7dfa557626414263a5de6fea97f7d114a480872600"

URI_x86_64_v2_rust-gix+async-network-client-async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-network-client-async-std-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-network-client-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-network-client-async-std-devel}"
SRC_URI[x86_64_v2_rust-gix+async-network-client-async-std-devel.sha256sum] = "5b31bfcd8ffcca1cff1cdb28cf53baeb342e67f75602b6dbb9c055c042660eea"

URI_x86_64_v2_rust-gix+async-network-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-network-client-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-network-client-devel}"
SRC_URI[x86_64_v2_rust-gix+async-network-client-devel.sha256sum] = "1415d9f4cb33c054ab6bc9be539900cf20fcdddd3127770d7300ec1de0cd7885"

URI_x86_64_v2_rust-gix+async-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+async-std-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+async-std-devel}"
SRC_URI[x86_64_v2_rust-gix+async-std-devel.sha256sum] = "84be74685381319a26398d9d00a04a2bc1fa81672887dbbf94ab963e437be8e7"

URI_x86_64_v2_rust-gix+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+attributes-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+attributes-devel}"
SRC_URI[x86_64_v2_rust-gix+attributes-devel.sha256sum] = "012349043e1eb151754368bb4e28e6205cb5bb4b6b8421ec057370e513fd18c7"

URI_x86_64_v2_rust-gix+basic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+basic-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+basic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+basic-devel}"
SRC_URI[x86_64_v2_rust-gix+basic-devel.sha256sum] = "fdde9aa799e681fdb20188115d0d29657fc75c2ad2e98517099194a8aed5a6e9"

URI_x86_64_v2_rust-gix+blame-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blame-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blame-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blame-devel}"
SRC_URI[x86_64_v2_rust-gix+blame-devel.sha256sum] = "cb3a6f045e8a4cda13b4a4ad6b9962a98d622b5b1938e48a0052ee2b21d77b1b"

URI_x86_64_v2_rust-gix+blob-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blob-diff-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blob-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blob-diff-devel}"
SRC_URI[x86_64_v2_rust-gix+blob-diff-devel.sha256sum] = "6a79b4f7786d6dd86106911440badd21610678b8be6d1935343de8b1214d3e07"

URI_x86_64_v2_rust-gix+blocking-http-transport-curl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-curl-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-curl-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-curl-devel.sha256sum] = "3b9921e5836498d68e1aef48a1cba67d0443d4039e0f7e27f3bc5bf031f37de3"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-devel.sha256sum] = "dc2c268e0c77cf9e49f7dbbfde5ca20fbd409003b177255db506093c25192757"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-native-tls-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-native-tls-devel.sha256sum] = "d66222f9d7d63220764b2e44a155c0850ab107c54fc723a312346eb9a5f89fee"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-rust-tls-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-devel.sha256sum] = "3c62e90809a25886858e7b03253bdbf96cb0d19b027eaab2f9fef4eed0ecf9c1"

URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel.sha256sum] = "131b2440ae2e1c75f3f886ba6974c605ecc6e747a062c60b716c2b3fa3f1cd51"

URI_x86_64_v2_rust-gix+blocking-network-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+blocking-network-client-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+blocking-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+blocking-network-client-devel}"
SRC_URI[x86_64_v2_rust-gix+blocking-network-client-devel.sha256sum] = "5575d71d38402def2c723ad1c6cb5fc37bce56aa92174f2994b06e63d393677f"

URI_x86_64_v2_rust-gix+cache-efficiency-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+cache-efficiency-debug-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+cache-efficiency-debug-devel}"
SRC_URI[x86_64_v2_rust-gix+cache-efficiency-debug-devel.sha256sum] = "de5da355916ced7595f83f9a10256e0e7908fdd12d2c0def1608de3155bb462f"

URI_x86_64_v2_rust-gix+comfort-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+comfort-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+comfort-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+comfort-devel}"
SRC_URI[x86_64_v2_rust-gix+comfort-devel.sha256sum] = "0a2f20950cba69bca773de6fa09ade872cf5f0cfd713c3ea7363694dabdb345d"

URI_x86_64_v2_rust-gix+command-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+command-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+command-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+command-devel}"
SRC_URI[x86_64_v2_rust-gix+command-devel.sha256sum] = "dee005d1d35ebaf5fbb44d86a703b995c91dfb952c2ed9ff63b42c1524ea6b5b"

URI_x86_64_v2_rust-gix+credentials-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+credentials-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+credentials-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+credentials-devel}"
SRC_URI[x86_64_v2_rust-gix+credentials-devel.sha256sum] = "53f7730ac1a8114cff1ff564cf18189fedf8218d243a9f8cfa1e39473d9f9fbf"

URI_x86_64_v2_rust-gix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+default-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+default-devel}"
SRC_URI[x86_64_v2_rust-gix+default-devel.sha256sum] = "0cafab021680a02e76018c0fa085c77210b373df287c7f6775253eb3b9c306e4"

URI_x86_64_v2_rust-gix+dirwalk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+dirwalk-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+dirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+dirwalk-devel}"
SRC_URI[x86_64_v2_rust-gix+dirwalk-devel.sha256sum] = "d1e0bf583547dce54e024a2813208b43bd53183666836e5385323e5feb5da16e"

URI_x86_64_v2_rust-gix+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+document-features-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix+document-features-devel.sha256sum] = "6aa80bac0163664033b9a370456eaaab6d76b3b4646ca6d410f007588f2ddcc3"

URI_x86_64_v2_rust-gix+excludes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+excludes-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+excludes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+excludes-devel}"
SRC_URI[x86_64_v2_rust-gix+excludes-devel.sha256sum] = "9d5ed7756dffb3214688179753d58f8b2889d5d970661c58fddf4698716cb11d"

URI_x86_64_v2_rust-gix+extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+extras-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+extras-devel}"
SRC_URI[x86_64_v2_rust-gix+extras-devel.sha256sum] = "516b1a4d20f7e4286dcff8b3dd04c50c681f451585bf95cad53f595862aaa177"

URI_x86_64_v2_rust-gix+gix-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-archive-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-archive-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-archive-devel.sha256sum] = "aed872e1662d60789a042d11d6d4991f93ce891b2da60e90de1278865c58f56d"

URI_x86_64_v2_rust-gix+gix-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-status-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-status-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-status-devel.sha256sum] = "b3822afc4d51d936c22f4d3505c94454361095eb2bd5ba3dc6df3edc5284c17b"

URI_x86_64_v2_rust-gix+gix-worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+gix-worktree-stream-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+gix-worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix+gix-worktree-stream-devel.sha256sum] = "1acf9f3a0ab55363bcf0eddaf510a1ae9d9051383a81a7fcbddbc759a84a799c"

URI_x86_64_v2_rust-gix+hp-tempfile-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+hp-tempfile-registry-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+hp-tempfile-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+hp-tempfile-registry-devel}"
SRC_URI[x86_64_v2_rust-gix+hp-tempfile-registry-devel.sha256sum] = "784ba173d0d1c0142840a497a58acd8a9e346506a400065af07dcc8484136b81"

URI_x86_64_v2_rust-gix+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+index-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+index-devel}"
SRC_URI[x86_64_v2_rust-gix+index-devel.sha256sum] = "25b83d8e5a063f581111d521727ec40b409256d7644d63d843ec3b0394bf9be9"

URI_x86_64_v2_rust-gix+interrupt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+interrupt-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+interrupt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+interrupt-devel}"
SRC_URI[x86_64_v2_rust-gix+interrupt-devel.sha256sum] = "f0f48fb78ec26a0b0bb4127a11200ec4122d3c58020a98ed777f58574d458641"

URI_x86_64_v2_rust-gix+mailmap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+mailmap-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+mailmap-devel}"
SRC_URI[x86_64_v2_rust-gix+mailmap-devel.sha256sum] = "8f636200ced1e4704c9ba1918368eb287b2a4e3a67594dc67873fe09da13a996"

URI_x86_64_v2_rust-gix+max-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-control-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-control-devel}"
SRC_URI[x86_64_v2_rust-gix+max-control-devel.sha256sum] = "a19fb438cff590192e5089decbf2b383975634756167d596fdc2d2e38f309a31"

URI_x86_64_v2_rust-gix+max-performance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-performance-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-performance-devel}"
SRC_URI[x86_64_v2_rust-gix+max-performance-devel.sha256sum] = "616e0ce9d8c059afcf155ba0acec51c1ba6b9ea72e4433bdff0a8377e1486eb5"

URI_x86_64_v2_rust-gix+max-performance-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+max-performance-safe-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+max-performance-safe-devel}"
SRC_URI[x86_64_v2_rust-gix+max-performance-safe-devel.sha256sum] = "b09c19674292e79224666d3386a652f69370c19511ab1cfe3a98e1443eaec371"

URI_x86_64_v2_rust-gix+merge-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+merge-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+merge-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+merge-devel}"
SRC_URI[x86_64_v2_rust-gix+merge-devel.sha256sum] = "9176735c3e4563f1d245f0f1f57dfb45d4034de4085864dd7ff5fd1d4123c8a1"

URI_x86_64_v2_rust-gix+need-more-recent-msrv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+need-more-recent-msrv-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+need-more-recent-msrv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+need-more-recent-msrv-devel}"
SRC_URI[x86_64_v2_rust-gix+need-more-recent-msrv-devel.sha256sum] = "1436661b0a44bc25534c03181b7f0628169814c3b29de5aaa45fbd6db448ed3e"

URI_x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+pack-cache-lru-dynamic-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel}"
SRC_URI[x86_64_v2_rust-gix+pack-cache-lru-dynamic-devel.sha256sum] = "f5cedc0df775b1bd3f3d71936ddce466848b2c5125eb28bd02dcd499b67ec53f"

URI_x86_64_v2_rust-gix+pack-cache-lru-static-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+pack-cache-lru-static-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+pack-cache-lru-static-devel}"
SRC_URI[x86_64_v2_rust-gix+pack-cache-lru-static-devel.sha256sum] = "ac36ff7ce2e03b7d5661f22f9e5d2ab233c0934a2ee1bd96e0b30e40924afd9a"

URI_x86_64_v2_rust-gix+parallel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+parallel-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+parallel-devel}"
SRC_URI[x86_64_v2_rust-gix+parallel-devel.sha256sum] = "68ea03876aa7249d380747e6912cc3055530c41413fc861afe229fedbb3bee2e"

URI_x86_64_v2_rust-gix+prodash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+prodash-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+prodash-devel}"
SRC_URI[x86_64_v2_rust-gix+prodash-devel.sha256sum] = "68a72ded5640d50a79ae4223e182110d71ecf799c2623a47a84795467aa92bbe"

URI_x86_64_v2_rust-gix+progress-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+progress-tree-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+progress-tree-devel}"
SRC_URI[x86_64_v2_rust-gix+progress-tree-devel.sha256sum] = "250703e9bd42a913cb9e281cba980344d84b856e2a031ec8fd358e1df586d183"

URI_x86_64_v2_rust-gix+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+regex-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+regex-devel}"
SRC_URI[x86_64_v2_rust-gix+regex-devel.sha256sum] = "f7f0292532b11af0afd2dfa208bbced5761f5f63589a4899af0ad5e3360201fb"

URI_x86_64_v2_rust-gix+revision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+revision-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+revision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+revision-devel}"
SRC_URI[x86_64_v2_rust-gix+revision-devel.sha256sum] = "00c8e2713510ecf8eb3f6ab5ae9a32387fc860488123b4bb010e840b10239d81"

URI_x86_64_v2_rust-gix+revparse-regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+revparse-regex-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+revparse-regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+revparse-regex-devel}"
SRC_URI[x86_64_v2_rust-gix+revparse-regex-devel.sha256sum] = "335ec53b1ac5b01967eeffbb201f9e56c6b97aec025274cb2591aaa70551bfd6"

URI_x86_64_v2_rust-gix+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+serde-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+serde-devel}"
SRC_URI[x86_64_v2_rust-gix+serde-devel.sha256sum] = "41263c2300280d57744e17524077d2a6441784366f88c4b7c60c67d79b73a4b9"

URI_x86_64_v2_rust-gix+status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+status-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+status-devel}"
SRC_URI[x86_64_v2_rust-gix+status-devel.sha256sum] = "533042432c47935f31989f5aa448ff98e233c703aada43aba4d4276334eec3ee"

URI_x86_64_v2_rust-gix+tracing-detail-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tracing-detail-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tracing-detail-devel}"
SRC_URI[x86_64_v2_rust-gix+tracing-detail-devel.sha256sum] = "6601a56d7c7fed87f3878fb82e2c26efa66eeb05230af92f1d164d3939e1d6a5"

URI_x86_64_v2_rust-gix+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tracing-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tracing-devel}"
SRC_URI[x86_64_v2_rust-gix+tracing-devel.sha256sum] = "7c4a3ba7041c350575ec6bda67139b22e6715aee5aba92ee2d61300db4ccc2bd"

URI_x86_64_v2_rust-gix+tree-editor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+tree-editor-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+tree-editor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+tree-editor-devel}"
SRC_URI[x86_64_v2_rust-gix+tree-editor-devel.sha256sum] = "0a85213c4e52e1b27e6b8f35160749551fc7d3e2bc989cd661e7224dbff6d2f4"

URI_x86_64_v2_rust-gix+verbose-object-parsing-errors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+verbose-object-parsing-errors-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+verbose-object-parsing-errors-devel}"
SRC_URI[x86_64_v2_rust-gix+verbose-object-parsing-errors-devel.sha256sum] = "563b2fdfe0aa8f19baec46b494ce27dd88e7693f760319a6e64c270074a32b16"

URI_x86_64_v2_rust-gix+worktree-archive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-archive-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-archive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-archive-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-archive-devel.sha256sum] = "3182acb867cb1130276f9d16cda2b9d74c3257937765d4794b1fa0339200acc7"

URI_x86_64_v2_rust-gix+worktree-mutation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-mutation-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-mutation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-mutation-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-mutation-devel.sha256sum] = "ec5165bf029604d8ada961cddb930f4ed8c791539aab471b9f2b37c357c78818"

URI_x86_64_v2_rust-gix+worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+worktree-stream-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix+worktree-stream-devel.sha256sum] = "e578b305fe5095b712c9a6b2df2cac57bd6ba11b92c2603a2c49a5b4f1bfab69"

URI_x86_64_v2_rust-gix+zlib-ng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-ng-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-ng-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-ng-devel.sha256sum] = "5a8f3eec460658603b37ceaf6ee36532ad07995748849d935f591c2bb6b6bea0"

URI_x86_64_v2_rust-gix+zlib-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-rs-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-rs-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-rs-devel.sha256sum] = "ccfca9c90f5ea23ba0f69226af23ff2c33ea58d590aacdd428aba76909fa382b"

URI_x86_64_v2_rust-gix+zlib-stock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix+zlib-stock-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix+zlib-stock-devel}"
SRC_URI[x86_64_v2_rust-gix+zlib-stock-devel.sha256sum] = "b5b8a774d94682c8fc51476502d126fdba3f894e76555185f3f8b46f28f42646"

URI_x86_64_v2_rust-gix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-devel-0.75.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-devel}"
SRC_URI[x86_64_v2_rust-gix-devel.sha256sum] = "c58bde70f4c601c6550dbbb0ac9fda11ae966ac01681b8200cd5cf55b2e10bf0"

URI_aarch64_rust-gix+async-network-client-async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-network-client-async-std-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+async-network-client-async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-network-client-async-std-devel}"
SRC_URI[aarch64_rust-gix+async-network-client-async-std-devel.sha256sum] = "88b22b8d60f7b463b2463d33edb69e2e0c8aa15366fc40fc00bf5b2e9520ce30"

URI_aarch64_rust-gix+async-network-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-network-client-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+async-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-network-client-devel}"
SRC_URI[aarch64_rust-gix+async-network-client-devel.sha256sum] = "5b2925e216287c7921951ea91711431ad3e44fccf95b3ea9f773b1423e114c8d"

URI_aarch64_rust-gix+async-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+async-std-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+async-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+async-std-devel}"
SRC_URI[aarch64_rust-gix+async-std-devel.sha256sum] = "1878d9c1dfe66937fb9b06343843592c1c126c92bb19f3f4863d0156e11ebdb1"

URI_aarch64_rust-gix+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+attributes-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+attributes-devel}"
SRC_URI[aarch64_rust-gix+attributes-devel.sha256sum] = "02baf2c3ecc481cd7be1fa8e233cffef70af4f9d2423119cf41894ea5e3c95f6"

URI_aarch64_rust-gix+basic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+basic-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+basic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+basic-devel}"
SRC_URI[aarch64_rust-gix+basic-devel.sha256sum] = "1098659bb21a33cd4c8d4d193aa2366bd2a811bc6af7db3479f0802292c28544"

URI_aarch64_rust-gix+blame-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blame-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+blame-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blame-devel}"
SRC_URI[aarch64_rust-gix+blame-devel.sha256sum] = "0a9e57e12ab8a245bf1ea72af6613a9eb2b6026426774aa5ee6ef1b11f2755e6"

URI_aarch64_rust-gix+blob-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blob-diff-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+blob-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blob-diff-devel}"
SRC_URI[aarch64_rust-gix+blob-diff-devel.sha256sum] = "3fab96978e9a5cca57a60e2614f665d2cbfc27662d48ae5f846fb4c73b20243f"

URI_aarch64_rust-gix+blocking-http-transport-curl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-curl-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-curl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-curl-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-curl-devel.sha256sum] = "21deb979864ff651a830bca674a3010a5b4ce521509c227075ec3a398757479e"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-devel.sha256sum] = "3287368104143889065be41d7c6ba7a8dfbe972d1327818e1af61c9b12099bb9"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-native-tls-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-native-tls-devel.sha256sum] = "0468615348f923333e0cb470db1a98a54d58680f7442df1eb114ad7b74d03eed"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-rust-tls-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-devel.sha256sum] = "1057cf1c13278b6977ac929e0915fa064ab12d6f2c6fda967175a3705c861b20"

URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel}"
SRC_URI[aarch64_rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel.sha256sum] = "d5198405fd485b403724330f4f2f33d592fd773d9e914e119736dea7fe7ffcfe"

URI_aarch64_rust-gix+blocking-network-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+blocking-network-client-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+blocking-network-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+blocking-network-client-devel}"
SRC_URI[aarch64_rust-gix+blocking-network-client-devel.sha256sum] = "54146f10170be7eaf6ae60a61ceac13215cf40bf72a9b6a4f61a78a6908e26d5"

URI_aarch64_rust-gix+cache-efficiency-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+cache-efficiency-debug-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+cache-efficiency-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+cache-efficiency-debug-devel}"
SRC_URI[aarch64_rust-gix+cache-efficiency-debug-devel.sha256sum] = "74b877dc7ca4a722b51668b70726eb6dd854f34c156a675ee0cce3a7680d3c2b"

URI_aarch64_rust-gix+comfort-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+comfort-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+comfort-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+comfort-devel}"
SRC_URI[aarch64_rust-gix+comfort-devel.sha256sum] = "418a732d3280fd2244121ab2809df5be2ae6793b2c687687ff438d5a03362b6f"

URI_aarch64_rust-gix+command-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+command-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+command-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+command-devel}"
SRC_URI[aarch64_rust-gix+command-devel.sha256sum] = "60cd419636bf0d27b25e187ec6e9e523e1d90f12f775a3afb7b371a49ffcd424"

URI_aarch64_rust-gix+credentials-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+credentials-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+credentials-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+credentials-devel}"
SRC_URI[aarch64_rust-gix+credentials-devel.sha256sum] = "e886beeef325054506c0b89aa48f01db5ffe80bc7645a1bc0115229a7971ae16"

URI_aarch64_rust-gix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+default-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+default-devel}"
SRC_URI[aarch64_rust-gix+default-devel.sha256sum] = "b983a9d18ea322a2e9cf72bdd62f45942abe536967e8714b4a08590bd2748e61"

URI_aarch64_rust-gix+dirwalk-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+dirwalk-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+dirwalk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+dirwalk-devel}"
SRC_URI[aarch64_rust-gix+dirwalk-devel.sha256sum] = "422cfef627d4add1cc0a72f8b2e3a66cf2f39857c80c4b2d491bc90f1b93e4a7"

URI_aarch64_rust-gix+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+document-features-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+document-features-devel}"
SRC_URI[aarch64_rust-gix+document-features-devel.sha256sum] = "f57a09907d14cae4f23e475ac7ae034262888fb1fb1b939f98ef7bdd41850753"

URI_aarch64_rust-gix+excludes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+excludes-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+excludes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+excludes-devel}"
SRC_URI[aarch64_rust-gix+excludes-devel.sha256sum] = "b3c787721e1851475916a3311cbc2c932fc5b0035a8ef8af55dc43d2d1d4864f"

URI_aarch64_rust-gix+extras-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+extras-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+extras-devel}"
SRC_URI[aarch64_rust-gix+extras-devel.sha256sum] = "ba7b564e94ca447a785706af0661b4591270c84e1918ef908641878f2215d903"

URI_aarch64_rust-gix+gix-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-archive-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+gix-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-archive-devel}"
SRC_URI[aarch64_rust-gix+gix-archive-devel.sha256sum] = "a28aaf2f7ad41da24cbe55dec1fdc5fdedc88d96bed2fcf883a98f5c06ab5df1"

URI_aarch64_rust-gix+gix-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-status-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-status-devel}"
SRC_URI[aarch64_rust-gix+gix-status-devel.sha256sum] = "1ea1b6101aff2b292b0d293e1bc6c6f32f6dabcf3b574950bf971befa0821c3c"

URI_aarch64_rust-gix+gix-worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+gix-worktree-stream-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+gix-worktree-stream-devel}"
SRC_URI[aarch64_rust-gix+gix-worktree-stream-devel.sha256sum] = "2bb95d70733cecd8740ec4a95b1aa76c75c3317ef5ce71fdbccc7ebaa2e6bd80"

URI_aarch64_rust-gix+hp-tempfile-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+hp-tempfile-registry-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+hp-tempfile-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+hp-tempfile-registry-devel}"
SRC_URI[aarch64_rust-gix+hp-tempfile-registry-devel.sha256sum] = "8df1cd8153b2cb72d6ce4a5749aaacb9d8130827902d0ff8b05755e44d782259"

URI_aarch64_rust-gix+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+index-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+index-devel}"
SRC_URI[aarch64_rust-gix+index-devel.sha256sum] = "8849e1894e7ce8b5ba1d9aa5c12896d1981395d920f8a1537ca72bc06b4ae02d"

URI_aarch64_rust-gix+interrupt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+interrupt-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+interrupt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+interrupt-devel}"
SRC_URI[aarch64_rust-gix+interrupt-devel.sha256sum] = "37d9887825b5fa3ae6f06be56d205f8ff39bae53115ef2e56135297b44f07576"

URI_aarch64_rust-gix+mailmap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+mailmap-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+mailmap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+mailmap-devel}"
SRC_URI[aarch64_rust-gix+mailmap-devel.sha256sum] = "0117ca6cfa3d52fb8feef579ea3d075abc9721ed1c1d84588859e129dccddcab"

URI_aarch64_rust-gix+max-control-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-control-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+max-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-control-devel}"
SRC_URI[aarch64_rust-gix+max-control-devel.sha256sum] = "e596a946a30bbf702d34714d139bb6cae21f50dca8a8b1eacb10dd95eece314a"

URI_aarch64_rust-gix+max-performance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-performance-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-performance-devel}"
SRC_URI[aarch64_rust-gix+max-performance-devel.sha256sum] = "ed664ada496d3d4989dd9b8a4510a8b91ca0575f2726a6cd3c9f6abf5a923dd7"

URI_aarch64_rust-gix+max-performance-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+max-performance-safe-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+max-performance-safe-devel}"
SRC_URI[aarch64_rust-gix+max-performance-safe-devel.sha256sum] = "5dc54d412243ac01965bb9b0d2e8a566549120778e2a113b4cea7d606829647d"

URI_aarch64_rust-gix+merge-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+merge-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+merge-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+merge-devel}"
SRC_URI[aarch64_rust-gix+merge-devel.sha256sum] = "59ec11c25e179b6e37579961dd1a7bc044f413396fa37d1510bc9074c62d2444"

URI_aarch64_rust-gix+need-more-recent-msrv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+need-more-recent-msrv-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+need-more-recent-msrv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+need-more-recent-msrv-devel}"
SRC_URI[aarch64_rust-gix+need-more-recent-msrv-devel.sha256sum] = "22d8de2fa335a4aa9ffa99b45b8f32d9f9cebd46abcee6cfa668e977805a6876"

URI_aarch64_rust-gix+pack-cache-lru-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+pack-cache-lru-dynamic-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+pack-cache-lru-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+pack-cache-lru-dynamic-devel}"
SRC_URI[aarch64_rust-gix+pack-cache-lru-dynamic-devel.sha256sum] = "2f7b7aec1a9e65f98735b5e1ee8686695ef52a33d720c7d87d65d0fa8850a957"

URI_aarch64_rust-gix+pack-cache-lru-static-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+pack-cache-lru-static-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+pack-cache-lru-static-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+pack-cache-lru-static-devel}"
SRC_URI[aarch64_rust-gix+pack-cache-lru-static-devel.sha256sum] = "f0c36843654e7fb477d49b0d983795e5576fef3868bbd7a169079768fbbc17dd"

URI_aarch64_rust-gix+parallel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+parallel-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+parallel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+parallel-devel}"
SRC_URI[aarch64_rust-gix+parallel-devel.sha256sum] = "f2d34e115796374d30cef3cce34244ba74d3c5ee98d3d88ba319c389186b64ce"

URI_aarch64_rust-gix+prodash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+prodash-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+prodash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+prodash-devel}"
SRC_URI[aarch64_rust-gix+prodash-devel.sha256sum] = "76fd817fc71d2a85df026cc7b17c1e7932a532dcd14eebfdedccda696e76a63b"

URI_aarch64_rust-gix+progress-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+progress-tree-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+progress-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+progress-tree-devel}"
SRC_URI[aarch64_rust-gix+progress-tree-devel.sha256sum] = "47fd4227e9009f1142a654f439e014c96d0852e0ce9cb2e59b1eccda8e10cd6d"

URI_aarch64_rust-gix+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+regex-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+regex-devel}"
SRC_URI[aarch64_rust-gix+regex-devel.sha256sum] = "fa5917bf93504a6c5adeaf3d824f8fec0056db337666314da0a8bd98b47a96fb"

URI_aarch64_rust-gix+revision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+revision-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+revision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+revision-devel}"
SRC_URI[aarch64_rust-gix+revision-devel.sha256sum] = "376e5f3fa0389e73c632b9651be8071abea82d3e2e5f9327fdcc9423c6603c33"

URI_aarch64_rust-gix+revparse-regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+revparse-regex-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+revparse-regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+revparse-regex-devel}"
SRC_URI[aarch64_rust-gix+revparse-regex-devel.sha256sum] = "b26750c657e12b1a40da9b056a30fe75f70c052dd70cad5386f4f5ea6eb60412"

URI_aarch64_rust-gix+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+serde-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+serde-devel}"
SRC_URI[aarch64_rust-gix+serde-devel.sha256sum] = "359e33e450171f4c4392402eef3a290bd41be77422f0507dce157865c2b262cc"

URI_aarch64_rust-gix+status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+status-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+status-devel}"
SRC_URI[aarch64_rust-gix+status-devel.sha256sum] = "94bc877fae2b6b4cd796a7fc1d37b4df11b58d2997c5018eaa32885a8c605427"

URI_aarch64_rust-gix+tracing-detail-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tracing-detail-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+tracing-detail-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tracing-detail-devel}"
SRC_URI[aarch64_rust-gix+tracing-detail-devel.sha256sum] = "9f41937b3297dce608b3dc887a54ca60d76662752000c62afdb4ef714058a7fe"

URI_aarch64_rust-gix+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tracing-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tracing-devel}"
SRC_URI[aarch64_rust-gix+tracing-devel.sha256sum] = "50c5492fa62beefed1ac4cfcf480ce9fc7a34f332e468711fe259e20ddb3bfee"

URI_aarch64_rust-gix+tree-editor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+tree-editor-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+tree-editor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+tree-editor-devel}"
SRC_URI[aarch64_rust-gix+tree-editor-devel.sha256sum] = "652ee224a117146f19bce464f6fac959da43a0e1d122016b33f2906b353c4743"

URI_aarch64_rust-gix+verbose-object-parsing-errors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+verbose-object-parsing-errors-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+verbose-object-parsing-errors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+verbose-object-parsing-errors-devel}"
SRC_URI[aarch64_rust-gix+verbose-object-parsing-errors-devel.sha256sum] = "08080b6bb9a7ac07107ce9334f91c840858dfd3d2eb769728e4df9d674fc52a0"

URI_aarch64_rust-gix+worktree-archive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-archive-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+worktree-archive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-archive-devel}"
SRC_URI[aarch64_rust-gix+worktree-archive-devel.sha256sum] = "45689d9e301781778c9b16973d35f1eb42b6b5d9d4e44e0f2cf78d26b07cdb0f"

URI_aarch64_rust-gix+worktree-mutation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-mutation-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+worktree-mutation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-mutation-devel}"
SRC_URI[aarch64_rust-gix+worktree-mutation-devel.sha256sum] = "675d97f6f41183954bf7cf263ef85a17cac37218b3d68f28e10cb2b2978d8910"

URI_aarch64_rust-gix+worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+worktree-stream-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+worktree-stream-devel}"
SRC_URI[aarch64_rust-gix+worktree-stream-devel.sha256sum] = "ed93ca95a852bc804d92607987a6cb556f2bd4ed6025e96033f0e6ef8fde94a0"

URI_aarch64_rust-gix+zlib-ng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-ng-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+zlib-ng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-ng-devel}"
SRC_URI[aarch64_rust-gix+zlib-ng-devel.sha256sum] = "242919c932dc7869db6a49b6a7145e1ddc6e3926b11e6f54beb17a84e327b5c9"

URI_aarch64_rust-gix+zlib-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-rs-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+zlib-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-rs-devel}"
SRC_URI[aarch64_rust-gix+zlib-rs-devel.sha256sum] = "71c9fb11ae5d5db6a9aaea28630cf059e6c8e069e357781654e535ed59233c4d"

URI_aarch64_rust-gix+zlib-stock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix+zlib-stock-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix+zlib-stock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix+zlib-stock-devel}"
SRC_URI[aarch64_rust-gix+zlib-stock-devel.sha256sum] = "c8c7db20a67b6e7e59ade9208cd6855d2160cddf6740d1065866d16f1d9de30f"

URI_aarch64_rust-gix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-devel-0.75.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-devel}"
SRC_URI[aarch64_rust-gix-devel.sha256sum] = "dda3bf42a9c0fbbb64205dd3c29991aa2098ccf25171ee34a3ae52fc4576056e"

RDEPENDS:rust-gix+async-network-client-async-std-devel = " \
 cargo \
 rust-gix+async-network-client-devel \
 rust-gix+async-std-devel \
 rust-gix-devel \
 rust-gix-transport+async-std-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+async-network-client-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-protocol+async-client-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+async-std-devel = " \
 cargo \
 rust-async-std+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+attributes-devel = " \
 cargo \
 rust-gix+command-devel \
 rust-gix+excludes-devel \
 rust-gix-attributes+default-devel \
 rust-gix-devel \
 rust-gix-filter+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-submodule+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix+basic-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix+index-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+blame-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix-blame+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+blob-diff-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix-devel \
 rust-gix-diff+blob-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-curl-devel = " \
 cargo \
 rust-gix+blocking-network-client-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-curl-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-devel = " \
 cargo \
 rust-gix+blocking-network-client-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-native-tls-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-native-tls-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-rust-tls-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-devel \
 "
RDEPENDS:rust-gix+blocking-http-transport-reqwest-rust-tls-trust-dns-devel = " \
 cargo \
 rust-gix+blocking-http-transport-reqwest-devel \
 rust-gix-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+http-client-reqwest-rust-tls-trust-dns-devel \
 "
RDEPENDS:rust-gix+blocking-network-client-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+credentials-devel \
 rust-gix-devel \
 rust-gix-pack+streaming-input-devel \
 rust-gix-protocol+blocking-client-devel \
 rust-gix-transport+default-devel \
 "
RDEPENDS:rust-gix+cache-efficiency-debug-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+cache-efficiency-debug-devel \
 "
RDEPENDS:rust-gix+comfort-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+progress-unit-bytes-devel \
 rust-gix-features+progress-unit-human-numbers-devel \
 "
RDEPENDS:rust-gix+command-devel = " \
 cargo \
 rust-gix-command+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+credentials-devel = " \
 cargo \
 rust-gix-credentials+default-devel \
 rust-gix-devel \
 rust-gix-negotiate+default-devel \
 rust-gix-prompt+default-devel \
 "
RDEPENDS:rust-gix+default-devel = " \
 cargo \
 rust-gix+basic-devel \
 rust-gix+comfort-devel \
 rust-gix+extras-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+dirwalk-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+excludes-devel \
 rust-gix-devel \
 rust-gix-dir+default-devel \
 "
RDEPENDS:rust-gix+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+excludes-devel = " \
 cargo \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-ignore+default-devel \
 rust-gix-worktree-devel \
 "
RDEPENDS:rust-gix+extras-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+blame-devel \
 rust-gix+credentials-devel \
 rust-gix+dirwalk-devel \
 rust-gix+excludes-devel \
 rust-gix+interrupt-devel \
 rust-gix+mailmap-devel \
 rust-gix+revparse-regex-devel \
 rust-gix+status-devel \
 rust-gix+worktree-archive-devel \
 rust-gix+worktree-mutation-devel \
 rust-gix+worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+gix-archive-devel = " \
 cargo \
 rust-gix-archive-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+gix-status-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-status+default-devel \
 rust-gix-status+worktree-rewrites-devel \
 "
RDEPENDS:rust-gix+gix-worktree-stream-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-worktree-stream+default-devel \
 "
RDEPENDS:rust-gix+hp-tempfile-registry-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-tempfile+hp-hashmap-devel \
 "
RDEPENDS:rust-gix+index-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-index+default-devel \
 "
RDEPENDS:rust-gix+interrupt-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-tempfile+signals-devel \
 rust-parking_lot+default-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-gix+mailmap-devel = " \
 cargo \
 rust-gix+revision-devel \
 rust-gix-devel \
 rust-gix-mailmap+default-devel \
 "
RDEPENDS:rust-gix+max-control-devel = " \
 cargo \
 rust-gix+pack-cache-lru-dynamic-devel \
 rust-gix+pack-cache-lru-static-devel \
 rust-gix+parallel-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+max-performance-devel = " \
 cargo \
 rust-gix+max-performance-safe-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+max-performance-safe-devel = " \
 cargo \
 rust-gix+max-control-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+merge-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+blob-diff-devel \
 rust-gix+tree-editor-devel \
 rust-gix-devel \
 rust-gix-merge-devel \
 "
RDEPENDS:rust-gix+need-more-recent-msrv-devel = " \
 cargo \
 rust-gix+merge-devel \
 rust-gix+tree-editor-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+pack-cache-lru-dynamic-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-pack+pack-cache-lru-dynamic-devel \
 "
RDEPENDS:rust-gix+pack-cache-lru-static-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-pack+pack-cache-lru-static-devel \
 "
RDEPENDS:rust-gix+parallel-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+parallel-devel \
 "
RDEPENDS:rust-gix+prodash-devel = " \
 cargo \
 rust-gix-devel \
 rust-prodash+default-devel \
 rust-prodash+progress-tree-devel \
 "
RDEPENDS:rust-gix+progress-tree-devel = " \
 cargo \
 rust-gix-devel \
 rust-prodash+default-devel \
 rust-prodash+progress-tree-devel \
 "
RDEPENDS:rust-gix+regex-devel = " \
 cargo \
 rust-gix-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-gix+revision-devel = " \
 cargo \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-revision+describe-devel \
 rust-gix-revision+merge_base-devel \
 "
RDEPENDS:rust-gix+revparse-regex-devel = " \
 cargo \
 rust-gix+regex-devel \
 rust-gix+revision-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+serde-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-attributes+serde-devel \
 rust-gix-commitgraph+serde-devel \
 rust-gix-credentials+default-devel \
 rust-gix-credentials+serde-devel \
 rust-gix-devel \
 rust-gix-ignore+default-devel \
 rust-gix-ignore+serde-devel \
 rust-gix-index+default-devel \
 rust-gix-index+serde-devel \
 rust-gix-mailmap+default-devel \
 rust-gix-mailmap+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-odb+serde-devel \
 rust-gix-pack+serde-devel \
 rust-gix-protocol+serde-devel \
 rust-gix-ref+serde-devel \
 rust-gix-revision+serde-devel \
 rust-gix-transport+default-devel \
 rust-gix-transport+serde-devel \
 rust-gix-url+serde-devel \
 rust-gix-worktree+serde-devel \
 rust-gix-worktree-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix+status-devel = " \
 cargo \
 rust-gix+blob-diff-devel \
 rust-gix+dirwalk-devel \
 rust-gix+gix-status-devel \
 rust-gix+index-devel \
 rust-gix-devel \
 rust-gix-diff+index-devel \
 "
RDEPENDS:rust-gix+tracing-detail-devel = " \
 cargo \
 rust-gix+tracing-devel \
 rust-gix-devel \
 rust-gix-features+tracing-detail-devel \
 "
RDEPENDS:rust-gix+tracing-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+tracing-devel \
 "
RDEPENDS:rust-gix+tree-editor-devel = " \
 cargo \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+verbose-object-parsing-errors-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-object+verbose-object-parsing-errors-devel \
 "
RDEPENDS:rust-gix+worktree-archive-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+gix-archive-devel \
 rust-gix+worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+worktree-mutation-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix-devel \
 rust-gix-worktree-state+default-devel \
 "
RDEPENDS:rust-gix+worktree-stream-devel = " \
 cargo \
 rust-gix+attributes-devel \
 rust-gix+gix-worktree-stream-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gix+zlib-ng-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-devel \
 "
RDEPENDS:rust-gix+zlib-rs-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-devel \
 "
RDEPENDS:rust-gix+zlib-stock-devel = " \
 cargo \
 rust-gix-devel \
 rust-gix-features+zlib-devel \
 "
RDEPENDS:rust-gix-devel = " \
 bash \
 cargo \
 rust \
 rust-gix-actor+default-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-config+default-devel \
 rust-gix-date+default-devel \
 rust-gix-diff-devel \
 rust-gix-discover+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+once_cell-devel \
 rust-gix-features+progress-devel \
 rust-gix-fs+default-devel \
 rust-gix-glob+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-hashtable+default-devel \
 rust-gix-lock+default-devel \
 rust-gix-object+default-devel \
 rust-gix-odb+default-devel \
 rust-gix-pack+object-cache-dynamic-devel \
 rust-gix-pack-devel \
 rust-gix-path+default-devel \
 rust-gix-protocol+default-devel \
 rust-gix-ref+default-devel \
 rust-gix-refspec+default-devel \
 rust-gix-revision-devel \
 rust-gix-revwalk+default-devel \
 rust-gix-sec+default-devel \
 rust-gix-shallow+default-devel \
 rust-gix-tempfile-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-url+default-devel \
 rust-gix-utils+default-devel \
 rust-gix-validate+default-devel \
 rust-smallvec+default-devel \
 rust-thiserror+default-devel \
 "
