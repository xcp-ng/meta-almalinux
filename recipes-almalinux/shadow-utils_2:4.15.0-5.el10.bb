# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "shadow-utils"
PE = "2"
PV = "4.15.0"
PR = "5.el10"
PACKAGES = " \
 shadow-utils \
 shadow-utils-subid \
 shadow-utils-subid-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/shadow-utils-4.15.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a76ef5f3f05050045fddd01461c82726f3bd703c1783ebc13078e79ba0686f44"

URI_x86_64_v2_shadow-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shadow-utils-4.15.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_shadow-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shadow-utils}"
SRC_URI[x86_64_v2_shadow-utils.sha256sum] = "a5b57b3327110a28e7439d2b26d4130593426616cac8f73d34d5283760ef49d5"

URI_x86_64_v2_shadow-utils-subid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/shadow-utils-subid-4.15.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_shadow-utils-subid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shadow-utils-subid}"
SRC_URI[x86_64_v2_shadow-utils-subid.sha256sum] = "587ffafd2829db2573ec5318cde4377f44a2a8a31f65eb3c44fbd786e548ea8f"

URI_x86_64_v2_shadow-utils-subid-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/shadow-utils-subid-devel-4.15.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_shadow-utils-subid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shadow-utils-subid-devel}"
SRC_URI[x86_64_v2_shadow-utils-subid-devel.sha256sum] = "f91a0c8977d959c871fa73d787b809273176aefb47ce6a8a9569a2e652405aed"

URI_aarch64_shadow-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shadow-utils-4.15.0-5.el10.aarch64.rpm;name=aarch64_shadow-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_shadow-utils}"
SRC_URI[aarch64_shadow-utils.sha256sum] = "dad0ebbdbbcdf773c339214194c1db20aa3131d3482d932b18f6383a74c59382"

URI_aarch64_shadow-utils-subid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/shadow-utils-subid-4.15.0-5.el10.aarch64.rpm;name=aarch64_shadow-utils-subid;unpack=0"
SRC_URI:append = " ${URI_aarch64_shadow-utils-subid}"
SRC_URI[aarch64_shadow-utils-subid.sha256sum] = "fbbeb3c575d4e5a1cc3e0693eb36a389935e39892e949c91293867983e342b3f"

URI_aarch64_shadow-utils-subid-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/shadow-utils-subid-devel-4.15.0-5.el10.aarch64.rpm;name=aarch64_shadow-utils-subid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_shadow-utils-subid-devel}"
SRC_URI[aarch64_shadow-utils-subid-devel.sha256sum] = "42c00e2ca7fc31bf512063588a836a60dc203be5109a42bdda2cdcf72c045683"

RDEPENDS:shadow-utils = " \
 audit-libs \
 glibc \
 libacl \
 libattr \
 libeconf \
 libselinux \
 libsemanage \
 libxcrypt \
 pam-libs \
 setup \
 "
RDEPENDS:shadow-utils-subid = " \
 audit-libs \
 glibc \
 libacl \
 libattr \
 libeconf \
 libselinux \
 libsemanage \
 libxcrypt \
 pam-libs \
 "
RDEPENDS:shadow-utils-subid-devel = " \
 shadow-utils-subid \
 "
