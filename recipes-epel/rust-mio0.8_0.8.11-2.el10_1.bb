# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-mio0.8"
PV = "0.8.11"
PR = "2.el10_1"
PACKAGES = " \
 rust-mio0.8+default-devel \
 rust-mio0.8+log-devel \
 rust-mio0.8+net-devel \
 rust-mio0.8+os-ext-devel \
 rust-mio0.8+os-poll-devel \
 rust-mio0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-mio0.8-0.8.11-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29ae831268fe294e683997291206215a0b52e309a8b1a805e65ed5dc4c572de8"

URI_x86_64_v2_rust-mio0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+default-devel-0.8.11-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+default-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+default-devel.sha256sum] = "333f310523f6ba0ceb453855db3c1232454f5d5d9b622e2f974dfe324f3ea950"

URI_x86_64_v2_rust-mio0.8+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+log-devel-0.8.11-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+log-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+log-devel.sha256sum] = "f69b051bc745e940f7bfa668e29d474e41ed7cbe7d352a502e6c8e0c22fe2fd0"

URI_x86_64_v2_rust-mio0.8+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+net-devel-0.8.11-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+net-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+net-devel.sha256sum] = "c3453a061639727a940f7b58e29012271d38fb83f84593a5fa3e21df5cfc6ada"

URI_x86_64_v2_rust-mio0.8+os-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+os-ext-devel-0.8.11-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+os-ext-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+os-ext-devel.sha256sum] = "e2a783058350bb6d76b4b75d0dcac9bef7aa88661db1a9c17e05956dedc03123"

URI_x86_64_v2_rust-mio0.8+os-poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8+os-poll-devel-0.8.11-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8+os-poll-devel}"
SRC_URI[x86_64_v2_rust-mio0.8+os-poll-devel.sha256sum] = "0bbf198ecfb5bc047eeb7f7a0b36c9883743fa7c51c7cc81a177a108b5495697"

URI_x86_64_v2_rust-mio0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-mio0.8-devel-0.8.11-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-mio0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-mio0.8-devel}"
SRC_URI[x86_64_v2_rust-mio0.8-devel.sha256sum] = "6b4c22f6869b763853afb1121556ef9ea29b2ec35c9704c660fa7b8aa2b4ae04"

URI_aarch64_rust-mio0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+default-devel-0.8.11-2.el10_1.noarch.rpm;name=aarch64_rust-mio0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+default-devel}"
SRC_URI[aarch64_rust-mio0.8+default-devel.sha256sum] = "6ff5b7efcb24b94049b0b1bdbe61840ff7f3cf0606dcd05c93e42c0eff9fcef2"

URI_aarch64_rust-mio0.8+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+log-devel-0.8.11-2.el10_1.noarch.rpm;name=aarch64_rust-mio0.8+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+log-devel}"
SRC_URI[aarch64_rust-mio0.8+log-devel.sha256sum] = "bdc496620bbb30e6b8768031353a799330ddbf318a52cc2bb54c63846ee34374"

URI_aarch64_rust-mio0.8+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+net-devel-0.8.11-2.el10_1.noarch.rpm;name=aarch64_rust-mio0.8+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+net-devel}"
SRC_URI[aarch64_rust-mio0.8+net-devel.sha256sum] = "d1165a57f7f4307ec8bd6fd207331c0612472627ac173ea4065bda6d9ab2c04e"

URI_aarch64_rust-mio0.8+os-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+os-ext-devel-0.8.11-2.el10_1.noarch.rpm;name=aarch64_rust-mio0.8+os-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+os-ext-devel}"
SRC_URI[aarch64_rust-mio0.8+os-ext-devel.sha256sum] = "034b5b3824cf85b71c205dc3848a038ebfb2798bc2597fe04439b5dcc2550843"

URI_aarch64_rust-mio0.8+os-poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8+os-poll-devel-0.8.11-2.el10_1.noarch.rpm;name=aarch64_rust-mio0.8+os-poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8+os-poll-devel}"
SRC_URI[aarch64_rust-mio0.8+os-poll-devel.sha256sum] = "b50192f5981f3a2e31cd2328a0f4f5ed2a90f545530ec4f36a8cf9cbd0508873"

URI_aarch64_rust-mio0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-mio0.8-devel-0.8.11-2.el10_1.noarch.rpm;name=aarch64_rust-mio0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-mio0.8-devel}"
SRC_URI[aarch64_rust-mio0.8-devel.sha256sum] = "28e138fe9ec293174ca37b6cea2a752eaf912b9b003edeec0f760818a3724684"

RDEPENDS:rust-mio0.8+default-devel = " \
 cargo \
 rust-mio0.8+log-devel \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8+net-devel = " \
 cargo \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8+os-ext-devel = " \
 cargo \
 rust-mio0.8+os-poll-devel \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8+os-poll-devel = " \
 cargo \
 rust-mio0.8-devel \
 "
RDEPENDS:rust-mio0.8-devel = " \
 cargo \
 rust-libc+default-devel \
 "
