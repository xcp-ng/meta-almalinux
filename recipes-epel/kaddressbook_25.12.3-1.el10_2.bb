# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kaddressbook"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kaddressbook \
 kaddressbook-devel \
 kaddressbook-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kaddressbook-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67afa1f314343c22266a8f914bed38a36cf2ed00102161a5e037543a9c082c7b"

URI_x86_64_v2_kaddressbook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook}"
SRC_URI[x86_64_v2_kaddressbook.sha256sum] = "bf9d7a36c30fb818c1d5d556a28775346f060d3e962df5e95dbb1e863370ebb0"

URI_x86_64_v2_kaddressbook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook-devel}"
SRC_URI[x86_64_v2_kaddressbook-devel.sha256sum] = "dcd4989984f980ba322c0eea027619c3d16c138d32f5b42eee3d85ac2075a0ec"

URI_x86_64_v2_kaddressbook-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kaddressbook-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kaddressbook-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kaddressbook-libs}"
SRC_URI[x86_64_v2_kaddressbook-libs.sha256sum] = "2cdb2884974b35033f7fe9b4813bf5bf14ab2ae70569c8dee40207b337d1cf01"

URI_aarch64_kaddressbook = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kaddressbook;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook}"
SRC_URI[aarch64_kaddressbook.sha256sum] = "9ad4c57be64fc43f5f71ee5ec2bc881f2effeed1d48448fd4946e946374a6f6d"

URI_aarch64_kaddressbook-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kaddressbook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook-devel}"
SRC_URI[aarch64_kaddressbook-devel.sha256sum] = "72cd3b4088dcb71d1b49ac5db6e34303e5a709abf2d44dc0169a1383295ad032"

URI_aarch64_kaddressbook-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kaddressbook-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kaddressbook-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kaddressbook-libs}"
SRC_URI[aarch64_kaddressbook-libs.sha256sum] = "c4064c449f7e63ed10b0676ad6bfe4f07e89eeb9edb476f7136fbd92ec97f614"

RDEPENDS:kaddressbook = " \
 glibc \
 kaddressbook-libs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kontactinterface \
 libgcc \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kaddressbook-devel = " \
 cmake-filesystem \
 kaddressbook \
 kaddressbook-libs \
 "
RDEPENDS:kaddressbook-libs = " \
 akonadi-contacts \
 akonadi-search \
 akonadi-server \
 glibc \
 grantleetheme \
 kaddressbook \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kparts \
 kf6-kuserfeedback \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kldap \
 kontactinterface \
 libgcc \
 libkdepim \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
