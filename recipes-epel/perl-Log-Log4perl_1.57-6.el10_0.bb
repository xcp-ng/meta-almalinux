# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Log-Log4perl"
PV = "1.57"
PR = "6.el10_0"
PACKAGES = " \
 perl-Log-Log4perl \
 perl-Log-Log4perl-Appender-DBI \
 perl-Log-Log4perl-Appender-RRDs \
 perl-Log-Log4perl-Config-DOMConfigurator \
 perl-Log-Log4perl-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Log-Log4perl-1.57-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f976a5f9ceb3c00ed607757899eaa8ac255320cd86f49be1e7058de8655bb00f"

URI_x86_64_v2_perl-Log-Log4perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Log4perl-1.57-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Log4perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Log4perl}"
SRC_URI[x86_64_v2_perl-Log-Log4perl.sha256sum] = "7dc46fd1566c6582a4ae3d6978ef27b5ef43c288e7444ff7ebd0f6b571a3ebf9"

URI_x86_64_v2_perl-Log-Log4perl-Appender-DBI = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Log4perl-Appender-DBI-1.57-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Log4perl-Appender-DBI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Log4perl-Appender-DBI}"
SRC_URI[x86_64_v2_perl-Log-Log4perl-Appender-DBI.sha256sum] = "9431caef395756a67ce34763fedb7a1a5637197c9ea5a6c7d274478ceba5569d"

URI_x86_64_v2_perl-Log-Log4perl-Appender-RRDs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Log4perl-Appender-RRDs-1.57-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Log4perl-Appender-RRDs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Log4perl-Appender-RRDs}"
SRC_URI[x86_64_v2_perl-Log-Log4perl-Appender-RRDs.sha256sum] = "5e3b53aa56434a31bcef31d62addecb21626784681ff762d6b6311e4015af731"

URI_x86_64_v2_perl-Log-Log4perl-Config-DOMConfigurator = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Log4perl-Config-DOMConfigurator-1.57-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Log4perl-Config-DOMConfigurator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Log4perl-Config-DOMConfigurator}"
SRC_URI[x86_64_v2_perl-Log-Log4perl-Config-DOMConfigurator.sha256sum] = "4f9ffb3462339158ccb3f922d68dce8070ad4c4acfa526b8f8798ab95fde6b84"

URI_x86_64_v2_perl-Log-Log4perl-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Log4perl-tests-1.57-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Log4perl-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Log4perl-tests}"
SRC_URI[x86_64_v2_perl-Log-Log4perl-tests.sha256sum] = "d760a82ba220d8aae54e288261c68cd5019dfdd856d161d5ce98d37df3706704"

URI_aarch64_perl-Log-Log4perl = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Log4perl-1.57-6.el10_0.noarch.rpm;name=aarch64_perl-Log-Log4perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Log4perl}"
SRC_URI[aarch64_perl-Log-Log4perl.sha256sum] = "2caccb6ffbfefc1d0bce261f5437c3a57033eb38e7584166e3ab2731b1b800ba"

URI_aarch64_perl-Log-Log4perl-Appender-DBI = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Log4perl-Appender-DBI-1.57-6.el10_0.noarch.rpm;name=aarch64_perl-Log-Log4perl-Appender-DBI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Log4perl-Appender-DBI}"
SRC_URI[aarch64_perl-Log-Log4perl-Appender-DBI.sha256sum] = "6dd1e1a1c410dd2ce87d8dbed7cb220eb2d69a091d2a4d387d8e58b54c052230"

URI_aarch64_perl-Log-Log4perl-Appender-RRDs = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Log4perl-Appender-RRDs-1.57-6.el10_0.noarch.rpm;name=aarch64_perl-Log-Log4perl-Appender-RRDs;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Log4perl-Appender-RRDs}"
SRC_URI[aarch64_perl-Log-Log4perl-Appender-RRDs.sha256sum] = "a8b5a3a598842378069f00c5d1763785b50873e65372f71ddd1d49a0895da79c"

URI_aarch64_perl-Log-Log4perl-Config-DOMConfigurator = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Log4perl-Config-DOMConfigurator-1.57-6.el10_0.noarch.rpm;name=aarch64_perl-Log-Log4perl-Config-DOMConfigurator;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Log4perl-Config-DOMConfigurator}"
SRC_URI[aarch64_perl-Log-Log4perl-Config-DOMConfigurator.sha256sum] = "a5c2d7793f9a5e6574d5106a7712610aaead7f1c46641b61ec0ae820a7d26849"

URI_aarch64_perl-Log-Log4perl-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Log4perl-tests-1.57-6.el10_0.noarch.rpm;name=aarch64_perl-Log-Log4perl-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Log4perl-tests}"
SRC_URI[aarch64_perl-Log-Log4perl-tests.sha256sum] = "355cb1cc0fdb2f4ea38dc9650e713937ede2a55c420df0ef6f98bbc790517f1c"

RDEPENDS:perl-Log-Log4perl = " \
 perl-Carp \
 perl-Encode \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-File-Temp \
 perl-IO \
 perl-IPC-SysV \
 perl-LDAP \
 perl-Log-Dispatch \
 perl-Log-Dispatch-FileRotate \
 perl-Log-Log4perl \
 perl-POSIX \
 perl-PathTools \
 perl-Safe \
 perl-Storable \
 perl-Sys-Hostname \
 perl-Term-ANSIColor \
 perl-Time-HiRes \
 perl-base \
 perl-constant \
 perl-if \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Log-Log4perl-Appender-DBI = " \
 perl-Carp \
 perl-DBI \
 perl-Log-Log4perl \
 perl-libs \
 "
RDEPENDS:perl-Log-Log4perl-Appender-RRDs = " \
 perl-Log-Log4perl \
 perl-libs \
 rrdtool-perl \
 "
RDEPENDS:perl-Log-Log4perl-Config-DOMConfigurator = " \
 perl-Log-Log4perl \
 perl-XML-DOM \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Log-Log4perl-tests = " \
 bash \
 perl-Benchmark \
 perl-Carp \
 perl-Class-Prototyped \
 perl-DBI \
 perl-Data-Dumper \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Temp \
 perl-Filter \
 perl-FindBin \
 perl-IO \
 perl-Log-Dispatch \
 perl-Log-Log4perl \
 perl-PathTools \
 perl-Sysadm-Install \
 perl-Test \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-YAML \
 perl-base \
 perl-constant \
 perl-fields \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-vars \
 rrdtool-perl \
 "
