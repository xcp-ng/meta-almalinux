# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapd"
PV = "2.72"
PR = "1.el10_2"
PACKAGES = " \
 snap-confine \
 snapd \
 snapd-devel \
 snapd-selinux \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapd-2.72-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d4fc9ca42a67f832981da22fc3e3e3be21c45355ee1cdc47075961286bf1e94"

URI_x86_64_v2_snap-confine = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snap-confine-2.72-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snap-confine;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snap-confine}"
SRC_URI[x86_64_v2_snap-confine.sha256sum] = "b7c652893229444ab1bacd03992065226dccadd0ce8a817ed34b8f1a8f434e25"

URI_x86_64_v2_snapd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-2.72-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd}"
SRC_URI[x86_64_v2_snapd.sha256sum] = "46bf05742f42f527ab810bb6d75c9f2acf6d6e547bc372b95563390a77fc622b"

URI_x86_64_v2_snapd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-devel-2.72-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_snapd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-devel}"
SRC_URI[x86_64_v2_snapd-devel.sha256sum] = "b1c19320f37d1d92c572d5c2079c606ef52c2982b59d1e1246cb81ff7e8fcfd4"

URI_x86_64_v2_snapd-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapd-selinux-2.72-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_snapd-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapd-selinux}"
SRC_URI[x86_64_v2_snapd-selinux.sha256sum] = "7649c03cd9e18b0aab11780426649b8f33015082ffc0056f65206b3b422e11de"

URI_aarch64_snap-confine = "${EPEL_MIRROR}/aarch64/Packages/s/snap-confine-2.72-1.el10_2.aarch64.rpm;name=aarch64_snap-confine;unpack=0"
SRC_URI:append = " ${URI_aarch64_snap-confine}"
SRC_URI[aarch64_snap-confine.sha256sum] = "aa1519895c4a4f7012d4e8244d9fb86a8ef88c487439cfe24dea85030b177cd0"

URI_aarch64_snapd = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-2.72-1.el10_2.aarch64.rpm;name=aarch64_snapd;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd}"
SRC_URI[aarch64_snapd.sha256sum] = "563c41eb4ea62ba0163a60ca0620d76e35f6183094c2c1adb19a73c88161df92"

URI_aarch64_snapd-devel = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-devel-2.72-1.el10_2.noarch.rpm;name=aarch64_snapd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-devel}"
SRC_URI[aarch64_snapd-devel.sha256sum] = "23806e79a4da342ff69a1b5218c27e77fb261ec45db3fe03c1fd5f88b6058736"

URI_aarch64_snapd-selinux = "${EPEL_MIRROR}/aarch64/Packages/s/snapd-selinux-2.72-1.el10_2.noarch.rpm;name=aarch64_snapd-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapd-selinux}"
SRC_URI[aarch64_snapd-selinux.sha256sum] = "0faa8d61af2dddcb5491773d0c4fcffb6a950c7912a221cb536c7e11bbd9e309"

RDEPENDS:snap-confine = " \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 systemd-libs \
 "
RDEPENDS:snapd = " \
 bash \
 bash-completion \
 glibc \
 snap-confine \
 snapd-selinux \
 squashfs-tools \
 systemd \
 virtual/_squashfuse_and_fuse__or_kmod_squashfs.ko_ \
 xdelta \
 "
RDEPENDS:snapd-devel = " \
 "
RDEPENDS:snapd-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 "
