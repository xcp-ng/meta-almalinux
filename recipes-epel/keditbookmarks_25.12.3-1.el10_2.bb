# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keditbookmarks"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 keditbookmarks \
 keditbookmarks-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keditbookmarks-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0398a8009a9529fb5c05a472973f4c5df892bf773677b10636d9813150b3bef6"

URI_x86_64_v2_keditbookmarks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keditbookmarks-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keditbookmarks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keditbookmarks}"
SRC_URI[x86_64_v2_keditbookmarks.sha256sum] = "3dbd99792f4ef3a7f1881cc0da568b17cd0d2a6c247b577bc3c4324a5a1e0395"

URI_x86_64_v2_keditbookmarks-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keditbookmarks-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keditbookmarks-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keditbookmarks-libs}"
SRC_URI[x86_64_v2_keditbookmarks-libs.sha256sum] = "423fc3d28c9d1fac593b13652c453dcc37623432440e58b5cfc2d7ffb6d2bc58"

URI_aarch64_keditbookmarks = "${EPEL_MIRROR}/aarch64/Packages/k/keditbookmarks-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_keditbookmarks;unpack=0"
SRC_URI:append = " ${URI_aarch64_keditbookmarks}"
SRC_URI[aarch64_keditbookmarks.sha256sum] = "480a6501325ede14aabdd39634c2db5aba8236f603245a01fc9ff344536ac244"

URI_aarch64_keditbookmarks-libs = "${EPEL_MIRROR}/aarch64/Packages/k/keditbookmarks-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_keditbookmarks-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_keditbookmarks-libs}"
SRC_URI[aarch64_keditbookmarks-libs.sha256sum] = "8a2f3ff8b2fdc23b76c700ff4f85d04b473a465c32461b872b30dd2b110f2ff6"

RDEPENDS:keditbookmarks = " \
 glibc \
 keditbookmarks-libs \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:keditbookmarks-libs = " \
 glibc \
 keditbookmarks \
 kf6-kbookmarks \
 kf6-kconfigwidgets \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
