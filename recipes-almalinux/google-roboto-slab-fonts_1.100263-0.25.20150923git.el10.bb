# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "google-roboto-slab-fonts"
PV = "1.100263"
PR = "0.25.20150923git.el10"
PACKAGES = " \
 google-roboto-slab-fonts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/google-roboto-slab-fonts-1.100263-0.25.20150923git.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ebcb404d724fab096dad240d42b5013286918462a2f4eedff2c52844a16658e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/google-roboto-slab-fonts-1.100263-0.25.20150923git.el10.noarch.rpm;name=x86_64_v2_google-roboto-slab-fonts;unpack=0"
SRC_URI[x86_64_v2_google-roboto-slab-fonts.sha256sum] = "95217ce712783fbe09ebc493be39f2f032ad705c4585be4802fe6aa3cc782a09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/google-roboto-slab-fonts-1.100263-0.25.20150923git.el10.noarch.rpm;name=aarch64_google-roboto-slab-fonts;unpack=0"
SRC_URI[aarch64_google-roboto-slab-fonts.sha256sum] = "95217ce712783fbe09ebc493be39f2f032ad705c4585be4802fe6aa3cc782a09"

RDEPENDS:google-roboto-slab-fonts = " \
 fonts-filesystem \
 "
