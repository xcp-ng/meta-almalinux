# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "imagej"
PV = "1.54r"
PR = "1.el10_1"
PACKAGES = " \
 imagej \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/imagej-1.54r-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cdd4fa44dac1ed0d49339306419bed27e3db8a17b90a1622afd20d437eb312ed"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imagej-1.54r-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_imagej;unpack=0"
SRC_URI[x86_64_v2_imagej.sha256sum] = "52ccaa4fc5add904af355cbd13e2235bc79ce5fd007f619b85667dcd188572dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/imagej-1.54r-1.el10_1.noarch.rpm;name=aarch64_imagej;unpack=0"
SRC_URI[aarch64_imagej.sha256sum] = "0834d9d0bad497fc5358d998a9175b9a7c8f3a63129f0b8219a47cf5a3f49d7e"

RDEPENDS:imagej = " \
 bash \
 java-21-openjdk-devel \
 javapackages-tools \
 "
