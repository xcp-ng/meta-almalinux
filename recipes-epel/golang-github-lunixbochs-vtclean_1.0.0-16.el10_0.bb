# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-lunixbochs-vtclean"
PV = "1.0.0"
PR = "16.el10_0"
PACKAGES = " \
 golang-github-lunixbochs-vtclean \
 golang-github-lunixbochs-vtclean-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-lunixbochs-vtclean-1.0.0-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31b5cadf219ed2f8022e770bed57202fea1766acdda1f410e4c3744d59ed724e"

URI_x86_64_v2_golang-github-lunixbochs-vtclean = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-lunixbochs-vtclean-1.0.0-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-lunixbochs-vtclean;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-lunixbochs-vtclean}"
SRC_URI[x86_64_v2_golang-github-lunixbochs-vtclean.sha256sum] = "9c4916e98041d1a154f7cf39125bb20fb5e6c29c331815abc14dd47e345293bd"

URI_x86_64_v2_golang-github-lunixbochs-vtclean-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-lunixbochs-vtclean-devel-1.0.0-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-lunixbochs-vtclean-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-lunixbochs-vtclean-devel}"
SRC_URI[x86_64_v2_golang-github-lunixbochs-vtclean-devel.sha256sum] = "7946bbbc6f1c40d9a0066497e1526a08f5cf98cdb2bf92c8a85c912c582bbd3c"

URI_aarch64_golang-github-lunixbochs-vtclean = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-lunixbochs-vtclean-1.0.0-16.el10_0.aarch64.rpm;name=aarch64_golang-github-lunixbochs-vtclean;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-lunixbochs-vtclean}"
SRC_URI[aarch64_golang-github-lunixbochs-vtclean.sha256sum] = "1784bc59a3a3afaf36c640123cba9b3ea2bcc5d17710a489010665fabb669502"

URI_aarch64_golang-github-lunixbochs-vtclean-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-lunixbochs-vtclean-devel-1.0.0-16.el10_0.noarch.rpm;name=aarch64_golang-github-lunixbochs-vtclean-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-lunixbochs-vtclean-devel}"
SRC_URI[aarch64_golang-github-lunixbochs-vtclean-devel.sha256sum] = "225adedcd3e78124d414d693b5e8fe062879972520d6f7364a5256fc4c6d0abc"

RDEPENDS:golang-github-lunixbochs-vtclean = " \
 glibc \
 "
RDEPENDS:golang-github-lunixbochs-vtclean-devel = " \
 go-filesystem \
 "
