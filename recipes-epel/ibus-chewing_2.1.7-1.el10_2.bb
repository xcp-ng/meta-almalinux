# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ibus-chewing"
PV = "2.1.7"
PR = "1.el10_2"
PACKAGES = " \
 ibus-chewing \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ibus-chewing-2.1.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bc2e0156f433bc1245702af1608cf08b5433d59194b3addf4131fbcde33f0ae"

URI_x86_64_v2_ibus-chewing = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ibus-chewing-2.1.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ibus-chewing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ibus-chewing}"
SRC_URI[x86_64_v2_ibus-chewing.sha256sum] = "b1b75c05f14e94fd37cfe3464bc656ba0741f1353361f32e139dcc90161bb872"

URI_aarch64_ibus-chewing = "${EPEL_MIRROR}/aarch64/Packages/i/ibus-chewing-2.1.7-1.el10_2.aarch64.rpm;name=aarch64_ibus-chewing;unpack=0"
SRC_URI:append = " ${URI_aarch64_ibus-chewing}"
SRC_URI[aarch64_ibus-chewing.sha256sum] = "1fba238611a74caf905bfa1cc965e1ac5aaca875cc3ee222e67f65f6ebfd3a3c"

RDEPENDS:ibus-chewing = " \
 glib2 \
 glibc \
 gtk4 \
 ibus-libs \
 libadwaita \
 libchewing \
 libgcc \
 "
