# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mrack"
PV = "1.27.0"
PR = "1.el10_3"
PACKAGES = " \
 mrack \
 mrack-cli \
 python3-mrack-aws \
 python3-mrack-beaker \
 python3-mrack-openstack \
 python3-mrack-podman \
 python3-mrack-virt \
 python3-mracklib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mrack-1.27.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39d99f1f934459e423a0c29131ed241768fe28b1777ef5b9172e7f4999f15a90"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-mracklib: sshpass

URI_x86_64_v2_mrack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mrack-1.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mrack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrack}"
SRC_URI[x86_64_v2_mrack.sha256sum] = "1832e0067addfe477b71d3b2fce465775eef50b4f4592bfbf7417ddf4fe4a872"

URI_x86_64_v2_mrack-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mrack-cli-1.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_mrack-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mrack-cli}"
SRC_URI[x86_64_v2_mrack-cli.sha256sum] = "5595925a6319f7a72a87160ae6bcdb7828e3bc01c7cc911c4906f2d502cd625d"

URI_x86_64_v2_python3-mrack-aws = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-aws-1.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-aws;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-aws}"
SRC_URI[x86_64_v2_python3-mrack-aws.sha256sum] = "47b6fd6b9c9ebcde339488a45afe01e0d7059cddf57e885eb950e0e90f7cd564"

URI_x86_64_v2_python3-mrack-beaker = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-beaker-1.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-beaker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-beaker}"
SRC_URI[x86_64_v2_python3-mrack-beaker.sha256sum] = "d2a2160f845db6416ec811bd8812d6d4ca5d2689d8d71c7d8e4af9a84678d4cc"

URI_x86_64_v2_python3-mrack-openstack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-openstack-1.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-openstack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-openstack}"
SRC_URI[x86_64_v2_python3-mrack-openstack.sha256sum] = "fd90bd1882776a0eca2bf39eb87a878589a57cedcadd65640d73176a9bfdf52c"

URI_x86_64_v2_python3-mrack-podman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-podman-1.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-podman}"
SRC_URI[x86_64_v2_python3-mrack-podman.sha256sum] = "8d13c817f50b64458a522dbebca6c12126fc52341d5940f7692be5783c4b549c"

URI_x86_64_v2_python3-mrack-virt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mrack-virt-1.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mrack-virt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mrack-virt}"
SRC_URI[x86_64_v2_python3-mrack-virt.sha256sum] = "7e3d3c3429d3bf99b058273c565977a73828b3adb4e7b20c9c43631f73a4f7eb"

URI_x86_64_v2_python3-mracklib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mracklib-1.27.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mracklib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mracklib}"
SRC_URI[x86_64_v2_python3-mracklib.sha256sum] = "f4f8291625f79c44aeb794a70bd5afdc4c712f2ab787198d387e90feabf4db6e"

URI_aarch64_mrack = "${EPEL_MIRROR}/aarch64/Packages/m/mrack-1.27.0-1.el10_3.noarch.rpm;name=aarch64_mrack;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrack}"
SRC_URI[aarch64_mrack.sha256sum] = "721686999342bc4835d8fbc9ae603df69024d2026aa9ecb06f4e4b5e04a446f0"

URI_aarch64_mrack-cli = "${EPEL_MIRROR}/aarch64/Packages/m/mrack-cli-1.27.0-1.el10_3.noarch.rpm;name=aarch64_mrack-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_mrack-cli}"
SRC_URI[aarch64_mrack-cli.sha256sum] = "7bdc8f83652030a50bb2113ed2eae5beef2588fb7ec37bd8f65e9f605fa28d4c"

URI_aarch64_python3-mrack-aws = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-aws-1.27.0-1.el10_3.noarch.rpm;name=aarch64_python3-mrack-aws;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-aws}"
SRC_URI[aarch64_python3-mrack-aws.sha256sum] = "13cc4b21c444c2e335fa41d2dfd999db3108f8e59bbf5f06cd3834538090d443"

URI_aarch64_python3-mrack-beaker = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-beaker-1.27.0-1.el10_3.noarch.rpm;name=aarch64_python3-mrack-beaker;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-beaker}"
SRC_URI[aarch64_python3-mrack-beaker.sha256sum] = "90351bb5886f373f7960dc28c9b1c1aaf4f23c7957cbae27cd4ce3c639554cdb"

URI_aarch64_python3-mrack-openstack = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-openstack-1.27.0-1.el10_3.noarch.rpm;name=aarch64_python3-mrack-openstack;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-openstack}"
SRC_URI[aarch64_python3-mrack-openstack.sha256sum] = "34994c323f91b4ae712fd1bbab129934ae745399afdeeffb177aca243d15e16b"

URI_aarch64_python3-mrack-podman = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-podman-1.27.0-1.el10_3.noarch.rpm;name=aarch64_python3-mrack-podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-podman}"
SRC_URI[aarch64_python3-mrack-podman.sha256sum] = "48ece5bab539c32ae063f9d53f54e3100a277e2a1dbcffece8c6ca5369511104"

URI_aarch64_python3-mrack-virt = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mrack-virt-1.27.0-1.el10_3.noarch.rpm;name=aarch64_python3-mrack-virt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mrack-virt}"
SRC_URI[aarch64_python3-mrack-virt.sha256sum] = "c5c9326e0c72ab19b7c8123c7d8c4812260fb65188ff89ee85d3adbf48f6d55f"

URI_aarch64_python3-mracklib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mracklib-1.27.0-1.el10_3.noarch.rpm;name=aarch64_python3-mracklib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mracklib}"
SRC_URI[aarch64_python3-mracklib.sha256sum] = "b99b98d47f2ad53d5ab7084fa30b13e953a0d81871af2a665691e14d71de068d"

RDEPENDS:mrack = " \
 mrack-cli \
 python3-mrack-aws \
 python3-mrack-beaker \
 python3-mrack-openstack \
 python3-mrack-podman \
 python3-mrack-virt \
 python3-mracklib \
 "
RDEPENDS:mrack-cli = " \
 python3 \
 python3-click \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-aws = " \
 python3 \
 python3-boto3 \
 python3-botocore \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-beaker = " \
 beaker-client \
 python3 \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-openstack = " \
 python3 \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-podman = " \
 podman \
 python3 \
 python3-mracklib \
 "
RDEPENDS:python3-mrack-virt = " \
 python3 \
 python3-mracklib \
 testcloud \
 "
RDEPENDS:python3-mracklib:x86_64_v2 = " \
 python3 \
 python3-pyyaml \
"
RDEPENDS:python3-mracklib:aarch64 = " \
 python3 \
 python3-pyyaml \
 sshpass \
"
