# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libxml++"
PV = "2.42.3"
PR = "7.el10_2"
PACKAGES = " \
 libxml++ \
 libxml++-devel \
 libxml++-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libxml++-2.42.3-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8684f5813f4cb87a7ff19f091ff744a5b995869973b79410d79ead79cfd8ac8c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxml++-2.42.3-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxml++;unpack=0"
SRC_URI[x86_64_v2_libxml++.sha256sum] = "5e01b7df4920cdf485c581faced575226ed18546f2f1f6335d9b2d1dc1c46a36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxml++-devel-2.42.3-7.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libxml++-devel;unpack=0"
SRC_URI[x86_64_v2_libxml++-devel.sha256sum] = "dfec25f18f84e297438cd8c7065c44c7100140b6358ffb1b68679ce16a51f99f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libxml++-doc-2.42.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_libxml++-doc;unpack=0"
SRC_URI[x86_64_v2_libxml++-doc.sha256sum] = "32593975bce7bef09a9c43db90bfb1b0640797e64224129ef9006f6c0bec4283"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxml++-2.42.3-7.el10_2.aarch64.rpm;name=aarch64_libxml++;unpack=0"
SRC_URI[aarch64_libxml++.sha256sum] = "31e21980ab527ad5ad84fa87ddb318fe281deef08603f28b9ec6fa61f9a8595d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxml++-devel-2.42.3-7.el10_2.aarch64.rpm;name=aarch64_libxml++-devel;unpack=0"
SRC_URI[aarch64_libxml++-devel.sha256sum] = "c6ed72ce3531f72e9cfdf38f7e1878b9e13feb4e2b1d6a21c20359cfbe690dd4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libxml++-doc-2.42.3-7.el10_2.noarch.rpm;name=aarch64_libxml++-doc;unpack=0"
SRC_URI[aarch64_libxml++-doc.sha256sum] = "3b9971f311625cc1ecd738975310ecdd0afdcbce8478749fb718f08d09c1584c"

RDEPENDS:libxml++ = " \
 glibc \
 glibmm2.4 \
 libgcc \
 libstdc++ \
 libxml2 \
 "
RDEPENDS:libxml++-devel = " \
 glibmm2.4-devel \
 libxml++ \
 libxml2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libxml++-doc = " \
 glibmm2.4-doc \
 libxml++ \
 "
