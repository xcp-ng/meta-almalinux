# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sblim-sfcb"
PV = "1.4.9"
PR = "36.el10"
PACKAGES = " \
 sblim-sfcb \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sblim-sfcb-1.4.9-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b296aae759e672e108b4b0fd83047d9650f617f22e8e6a1e7d90cd2aaaf1fad4"

URI_x86_64_v2_sblim-sfcb = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sblim-sfcb-1.4.9-36.el10.x86_64_v2.rpm;name=x86_64_v2_sblim-sfcb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sblim-sfcb}"
SRC_URI[x86_64_v2_sblim-sfcb.sha256sum] = "0864ac215a1af270950790d514018dcc775627cb3e9efca7f2df157a1a1b4a82"

URI_aarch64_sblim-sfcb = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sblim-sfcb-1.4.9-36.el10.aarch64.rpm;name=aarch64_sblim-sfcb;unpack=0"
SRC_URI:append = " ${URI_aarch64_sblim-sfcb}"
SRC_URI[aarch64_sblim-sfcb.sha256sum] = "28bb3363632d64d307d1ad6cb3d381d71927a064cf91e556ff2301d2506257f4"

RDEPENDS:sblim-sfcb = " \
 bash \
 cim-schema \
 glibc \
 openslp \
 openssl-libs \
 pam-libs \
 perl-Getopt-Long \
 perl-URI \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 sblim-sfcCommon \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 zlib-ng-compat \
 "
