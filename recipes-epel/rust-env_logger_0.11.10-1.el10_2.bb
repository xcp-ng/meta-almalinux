# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_logger"
PV = "0.11.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-env_logger+auto-color-devel \
 rust-env_logger+color-devel \
 rust-env_logger+default-devel \
 rust-env_logger+humantime-devel \
 rust-env_logger+kv-devel \
 rust-env_logger+regex-devel \
 rust-env_logger+unstable-kv-devel \
 rust-env_logger-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_logger-0.11.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "409ee7e366e911f4a7d2ca5564dcfd228f0b807dcdd12013d7e47b700cb95303"

URI_x86_64_v2_rust-env_logger+auto-color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+auto-color-devel-0.11.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+auto-color-devel}"
SRC_URI[x86_64_v2_rust-env_logger+auto-color-devel.sha256sum] = "e10a733896f2876621bd65e8aaf1fea69e5b0fb0e738639d2907ade317facea5"

URI_x86_64_v2_rust-env_logger+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+color-devel-0.11.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+color-devel}"
SRC_URI[x86_64_v2_rust-env_logger+color-devel.sha256sum] = "a3164307f38461694cbe534d2aa26b3e130c05a01fdcee9b690c5c73ef6158f7"

URI_x86_64_v2_rust-env_logger+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+default-devel-0.11.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+default-devel}"
SRC_URI[x86_64_v2_rust-env_logger+default-devel.sha256sum] = "8c237de711122d8d50ca0b9d7419e6d0b8073ba4da905938cd3fe28da86dc938"

URI_x86_64_v2_rust-env_logger+humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+humantime-devel-0.11.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+humantime-devel}"
SRC_URI[x86_64_v2_rust-env_logger+humantime-devel.sha256sum] = "acf3f696e3d348c7b6a0d206c849855a4ddc5dfb409b3c0ae7cf532f87c148c5"

URI_x86_64_v2_rust-env_logger+kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+kv-devel-0.11.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+kv-devel}"
SRC_URI[x86_64_v2_rust-env_logger+kv-devel.sha256sum] = "d2c4a546614fd52b79bc6760986156c03729efbefc66bf3e4d31caad9b938d43"

URI_x86_64_v2_rust-env_logger+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+regex-devel-0.11.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+regex-devel}"
SRC_URI[x86_64_v2_rust-env_logger+regex-devel.sha256sum] = "7a1fff82476748759b420fa26c5433fd1683745485c891bc51d2393088750d8d"

URI_x86_64_v2_rust-env_logger+unstable-kv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger+unstable-kv-devel-0.11.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger+unstable-kv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger+unstable-kv-devel}"
SRC_URI[x86_64_v2_rust-env_logger+unstable-kv-devel.sha256sum] = "05b68fddba7da16684600f5e0a600aea30c529ff5745c14aa88eb3b74a231251"

URI_x86_64_v2_rust-env_logger-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_logger-devel-0.11.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_logger-devel}"
SRC_URI[x86_64_v2_rust-env_logger-devel.sha256sum] = "ad57cfc7e6a009d5e427f79a78137b8276427eb643d67b4d929126317be23cd9"
RPROVIDES:rust-env_logger-devel:x86_64_v2 = "virtual/crate_env_logger__ge_0.6.1"

URI_aarch64_rust-env_logger+auto-color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+auto-color-devel-0.11.10-1.el10_2.noarch.rpm;name=aarch64_rust-env_logger+auto-color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+auto-color-devel}"
SRC_URI[aarch64_rust-env_logger+auto-color-devel.sha256sum] = "4b3886c559db59e88efa29bdf233c65f2d856d10e956b5e6c02b16277fd7e2b0"

URI_aarch64_rust-env_logger+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+color-devel-0.11.10-1.el10_2.noarch.rpm;name=aarch64_rust-env_logger+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+color-devel}"
SRC_URI[aarch64_rust-env_logger+color-devel.sha256sum] = "579159529599f15c31e3fd12f556e79b2b8479978d3fae655a3790c49d107be1"

URI_aarch64_rust-env_logger+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+default-devel-0.11.10-1.el10_2.noarch.rpm;name=aarch64_rust-env_logger+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+default-devel}"
SRC_URI[aarch64_rust-env_logger+default-devel.sha256sum] = "3b875639dc485163d905da1e37b7bd96d7399898f9a7b81a091866807f3a0c50"

URI_aarch64_rust-env_logger+humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+humantime-devel-0.11.10-1.el10_2.noarch.rpm;name=aarch64_rust-env_logger+humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+humantime-devel}"
SRC_URI[aarch64_rust-env_logger+humantime-devel.sha256sum] = "44824504e2afe90467d98389512521e8a5c708ff1c4ca4b51fe13a1c34efc392"

URI_aarch64_rust-env_logger+kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+kv-devel-0.11.10-1.el10_2.noarch.rpm;name=aarch64_rust-env_logger+kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+kv-devel}"
SRC_URI[aarch64_rust-env_logger+kv-devel.sha256sum] = "7560f4c078d15e06ba7ff6fa663e584bf356bc7d72cb8d536ac69615deba08d0"

URI_aarch64_rust-env_logger+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+regex-devel-0.11.10-1.el10_2.noarch.rpm;name=aarch64_rust-env_logger+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+regex-devel}"
SRC_URI[aarch64_rust-env_logger+regex-devel.sha256sum] = "4c2519c92d0ebab853c32f11098aadf4512ddfb7c13e63a250973b73290187bb"

URI_aarch64_rust-env_logger+unstable-kv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger+unstable-kv-devel-0.11.10-1.el10_2.noarch.rpm;name=aarch64_rust-env_logger+unstable-kv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger+unstable-kv-devel}"
SRC_URI[aarch64_rust-env_logger+unstable-kv-devel.sha256sum] = "9bb31ec43c0b2e6cd415c4c2e014e9aab1046b688f9e024142e657da570eb521"

URI_aarch64_rust-env_logger-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_logger-devel-0.11.10-1.el10_2.noarch.rpm;name=aarch64_rust-env_logger-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_logger-devel}"
SRC_URI[aarch64_rust-env_logger-devel.sha256sum] = "9d378b3cb7303e2513bbb68404239cbd5fe9088f889e87314fa74bf2eed39ede"
RPROVIDES:rust-env_logger-devel:aarch64 = "virtual/crate_env_logger__ge_0.6.1"

RDEPENDS:rust-env_logger+auto-color-devel = " \
 cargo \
 rust-anstream+auto-devel \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 rust-env_logger+color-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+color-devel = " \
 cargo \
 rust-anstream+wincon-devel \
 rust-anstream-devel \
 rust-anstyle+default-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+default-devel = " \
 cargo \
 rust-env_logger+auto-color-devel \
 rust-env_logger+humantime-devel \
 rust-env_logger+regex-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+humantime-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-jiff+std-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-env_logger+kv-devel = " \
 cargo \
 rust-env_logger-devel \
 rust-log+kv-devel \
 "
RDEPENDS:rust-env_logger+regex-devel = " \
 cargo \
 rust-env_filter+regex-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger+unstable-kv-devel = " \
 cargo \
 rust-env_logger+kv-devel \
 rust-env_logger-devel \
 "
RDEPENDS:rust-env_logger-devel = " \
 cargo \
 rust \
 rust-env_filter-devel \
 rust-log+default-devel \
 rust-log+std-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_env_logger__ge_0.6.1"

PROVIDES:append:aarch64 = " rpm/virtual/crate_env_logger__ge_0.6.1"
