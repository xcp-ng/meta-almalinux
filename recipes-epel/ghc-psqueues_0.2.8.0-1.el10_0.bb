# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-psqueues"
PV = "0.2.8.0"
PR = "1.el10_0"
PACKAGES = " \
 ghc-psqueues \
 ghc-psqueues-devel \
 ghc-psqueues-doc \
 ghc-psqueues-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-psqueues-0.2.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "288f568f14e3624244f4f576d5d39b2dc0d2bf35c518340c0757805ae4e005f6"

URI_x86_64_v2_ghc-psqueues = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-psqueues-0.2.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-psqueues;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-psqueues}"
SRC_URI[x86_64_v2_ghc-psqueues.sha256sum] = "f32429684ef7b8f0a958f57f845081bd6d1bd7ec09645805683ae067b624fa5d"

URI_x86_64_v2_ghc-psqueues-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-psqueues-devel-0.2.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-psqueues-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-psqueues-devel}"
SRC_URI[x86_64_v2_ghc-psqueues-devel.sha256sum] = "93aa095f6e6f9b49247a713e768a67e012b4d4815944ee112265d12c72751ee1"

URI_x86_64_v2_ghc-psqueues-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-psqueues-doc-0.2.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-psqueues-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-psqueues-doc}"
SRC_URI[x86_64_v2_ghc-psqueues-doc.sha256sum] = "d2e162abfe5daf9bc9cec4f7480f896a1fa0c7081c89b5e09135c130e4b3ff1d"

URI_x86_64_v2_ghc-psqueues-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-psqueues-prof-0.2.8.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-psqueues-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-psqueues-prof}"
SRC_URI[x86_64_v2_ghc-psqueues-prof.sha256sum] = "91530fc7cb1291a812fadb13f9071e017f85f3a3a51af236da173ee7521dfa9b"

URI_aarch64_ghc-psqueues = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-psqueues-0.2.8.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-psqueues;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-psqueues}"
SRC_URI[aarch64_ghc-psqueues.sha256sum] = "39536a6e2d6c4453c5cb6dbf73fa0222f159fc43eaedabde2d643066e95da77f"

URI_aarch64_ghc-psqueues-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-psqueues-devel-0.2.8.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-psqueues-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-psqueues-devel}"
SRC_URI[aarch64_ghc-psqueues-devel.sha256sum] = "b3835cbe15182450ba32488d1760701f639d501ce6b347ffec37f6dc0fc1a6ff"

URI_aarch64_ghc-psqueues-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-psqueues-doc-0.2.8.0-1.el10_0.noarch.rpm;name=aarch64_ghc-psqueues-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-psqueues-doc}"
SRC_URI[aarch64_ghc-psqueues-doc.sha256sum] = "dde6a2f9a951547beed99867dff240554b9e142c16a95666e05f1dba357b4ed0"

URI_aarch64_ghc-psqueues-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-psqueues-prof-0.2.8.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-psqueues-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-psqueues-prof}"
SRC_URI[aarch64_ghc-psqueues-prof.sha256sum] = "8bd739d4ea3e8439087a5735d278b147055343328f8d9deb06f4f5304cbf465a"

RDEPENDS:ghc-psqueues = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-os-string \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-psqueues-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 ghc-hashable-devel \
 ghc-psqueues \
 "
RDEPENDS:ghc-psqueues-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-psqueues-prof = " \
 ghc-base-prof \
 ghc-deepseq-prof \
 ghc-hashable-prof \
 ghc-psqueues-devel \
 "
