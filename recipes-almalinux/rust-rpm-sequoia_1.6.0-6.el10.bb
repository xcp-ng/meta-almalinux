# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rpm-sequoia"
PV = "1.6.0"
PR = "6.el10"
PACKAGES = " \
 rpm-sequoia \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rust-rpm-sequoia-1.6.0-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "78382b150d6d91ddb23e8bf1efe17125e4b1063836c5a90a3ce54a9d1fff81d7"

URI_x86_64_v2_rpm-sequoia = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rpm-sequoia-1.6.0-6.el10.x86_64_v2.rpm;name=x86_64_v2_rpm-sequoia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rpm-sequoia}"
SRC_URI[x86_64_v2_rpm-sequoia.sha256sum] = "c164162ae0cba140f0c7bb6bea13843deb8762e57f997d4d5db1b3eb40671b7e"

URI_aarch64_rpm-sequoia = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rpm-sequoia-1.6.0-6.el10.aarch64.rpm;name=aarch64_rpm-sequoia;unpack=0"
SRC_URI:append = " ${URI_aarch64_rpm-sequoia}"
SRC_URI[aarch64_rpm-sequoia.sha256sum] = "4d48a47bd04d167608ab86ee6bb7219926e6092dc5a22822ec1b12399e943def"

RDEPENDS:rpm-sequoia = " \
 glibc \
 libgcc \
 openssl-libs \
 "
