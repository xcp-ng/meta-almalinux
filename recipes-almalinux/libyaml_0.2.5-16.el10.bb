# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libyaml"
PV = "0.2.5"
PR = "16.el10"
PACKAGES = " \
 libyaml \
 libyaml-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libyaml-0.2.5-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6617b40da7022d5cfcca7b2f3061690c808d4fdb6e0f3a39929e7f2faf54b37"

URI_x86_64_v2_libyaml = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libyaml-0.2.5-16.el10.x86_64_v2.rpm;name=x86_64_v2_libyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libyaml}"
SRC_URI[x86_64_v2_libyaml.sha256sum] = "f28dbfcf7c545d29e434f06c493fc01010787c8a506fef05c79bb93d855809f4"

URI_x86_64_v2_libyaml-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libyaml-devel-0.2.5-16.el10.x86_64_v2.rpm;name=x86_64_v2_libyaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libyaml-devel}"
SRC_URI[x86_64_v2_libyaml-devel.sha256sum] = "29e863eab177fa6568301f93930248d8675961696c46775872f693294c88f189"

URI_aarch64_libyaml = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libyaml-0.2.5-16.el10.aarch64.rpm;name=aarch64_libyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_libyaml}"
SRC_URI[aarch64_libyaml.sha256sum] = "5b435f7a651f21853a06eb2f6f1f2be44305b3cf3bb5f7067ff15d49a0e918a9"

URI_aarch64_libyaml-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libyaml-devel-0.2.5-16.el10.aarch64.rpm;name=aarch64_libyaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libyaml-devel}"
SRC_URI[aarch64_libyaml-devel.sha256sum] = "c5334dc51a30a4307ddb78646d90245fa3038cac97717a5133c0521ad051563e"

RDEPENDS:libyaml = " \
 glibc \
 "
RDEPENDS:libyaml-devel = " \
 libyaml \
 pkgconf-pkg-config \
 "
