# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtcoap"
PV = "6.10.1"
PR = "1.el10_2"
PACKAGES = " \
 qt6-qtcoap \
 qt6-qtcoap-devel \
 qt6-qtcoap-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtcoap-6.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0e900d32e2a87d13c652170e46ecafa4a09da387102174bcf9f207720dc4c2f"

URI_x86_64_v2_qt6-qtcoap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtcoap-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcoap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcoap}"
SRC_URI[x86_64_v2_qt6-qtcoap.sha256sum] = "39e2aec959f8368092bd1f0b4f2e60dee6f4858b1798bdce4cd090e542b95ef8"

URI_x86_64_v2_qt6-qtcoap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtcoap-devel-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcoap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcoap-devel}"
SRC_URI[x86_64_v2_qt6-qtcoap-devel.sha256sum] = "767b7672b7550c927602dcd02431efc51884a290afca041ce791263b3c95dccd"

URI_x86_64_v2_qt6-qtcoap-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtcoap-examples-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcoap-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcoap-examples}"
SRC_URI[x86_64_v2_qt6-qtcoap-examples.sha256sum] = "8d2379ac5484313948bbcd76cba5d4ff2cb870ca3ba4518aa1cefb5482df8165"

URI_aarch64_qt6-qtcoap = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtcoap-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtcoap;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcoap}"
SRC_URI[aarch64_qt6-qtcoap.sha256sum] = "e1782d4008fc6486877b3498dc8e197f4e14baf3a0667858afbee20eb7ceb1e7"

URI_aarch64_qt6-qtcoap-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtcoap-devel-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtcoap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcoap-devel}"
SRC_URI[aarch64_qt6-qtcoap-devel.sha256sum] = "5413d8f4af8481b98a8cf14dd6892ab3b9044a2eb0ed644d195c27d20948f36f"

URI_aarch64_qt6-qtcoap-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtcoap-examples-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtcoap-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcoap-examples}"
SRC_URI[aarch64_qt6-qtcoap-examples.sha256sum] = "b0fbdea92e2b98b47162b9545366baa4b1e03944b1622603688b895c3406f776"

RDEPENDS:qt6-qtcoap = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtcoap-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtcoap \
 "
RDEPENDS:qt6-qtcoap-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcoap \
 qt6-qtcoap-devel \
 qt6-qtdeclarative \
 "
