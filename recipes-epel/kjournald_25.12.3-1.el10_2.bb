# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjournald"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kjournald \
 kjournald-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kjournald-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b54000cf03441448c2bf504d8344b562e79da9c17a66a67ce991b01e4af3076"

URI_x86_64_v2_kjournald = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjournald}"
SRC_URI[x86_64_v2_kjournald.sha256sum] = "12c93ea8a36376642f55eb7008d5e0f042f627df2e8914e80f769d5a9d0bee93"

URI_x86_64_v2_kjournald-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjournald-libs-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjournald-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kjournald-libs}"
SRC_URI[x86_64_v2_kjournald-libs.sha256sum] = "9add6b70b17c590e1a5ad0078a26c681c47c7cfd5f6ec21472dfdd881b1bb709"

URI_aarch64_kjournald = "${EPEL_MIRROR}/aarch64/Packages/k/kjournald-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kjournald;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjournald}"
SRC_URI[aarch64_kjournald.sha256sum] = "1c8d4e9df5fa7c7bec5947b3eca0786ab324ef05f4112073677e9cc2e76a1825"

URI_aarch64_kjournald-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kjournald-libs-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kjournald-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kjournald-libs}"
SRC_URI[aarch64_kjournald-libs.sha256sum] = "d60e66e16107e981789156d0eb7dd3a1e27d190889fdb05bad8fd55638619175"

RDEPENDS:kjournald = " \
 glibc \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kjournald-libs \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kjournald-libs = " \
 glibc \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 systemd-libs \
 "
