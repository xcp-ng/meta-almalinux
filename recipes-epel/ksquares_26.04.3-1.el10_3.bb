# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksquares"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ksquares \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksquares-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c760c2c36cdfe126d0239fccdc003b0c3431a885f9b928e5511152da29c3beb"

URI_x86_64_v2_ksquares = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksquares-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksquares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksquares}"
SRC_URI[x86_64_v2_ksquares.sha256sum] = "3f53bf52eab6c19e135954890da734c847daaaf117e1992c8383d9e6f26532f2"

URI_aarch64_ksquares = "${EPEL_MIRROR}/aarch64/Packages/k/ksquares-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ksquares;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksquares}"
SRC_URI[aarch64_ksquares.sha256sum] = "c357a9f307550056a31c799b86713df4ec24b5b0b55f4274820600c8fbe7fe8d"

RDEPENDS:ksquares = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
