# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pynacl"
PV = "1.5.0"
PR = "10.el10_0"
PACKAGES = " \
 python3-pynacl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pynacl-1.5.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "603733e468d059101120ae80bc37bd47070455c538f00742b2abd597d6d2d43c"

URI_x86_64_v2_python3-pynacl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pynacl-1.5.0-10.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pynacl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pynacl}"
SRC_URI[x86_64_v2_python3-pynacl.sha256sum] = "724d34308ee6eceac2fc15adf0d88c3819e29a6f28804a736b8e3769206cc79c"

URI_aarch64_python3-pynacl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pynacl-1.5.0-10.el10_0.aarch64.rpm;name=aarch64_python3-pynacl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pynacl}"
SRC_URI[aarch64_python3-pynacl.sha256sum] = "4a6622b7237745b45e7bb2a517559460d22d3dd1da279742c0782f724177083c"

RDEPENDS:python3-pynacl = " \
 glibc \
 libsodium \
 python3 \
 python3-cffi \
 "
