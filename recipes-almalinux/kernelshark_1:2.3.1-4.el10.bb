# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kernelshark"
PE = "1"
PV = "2.3.1"
PR = "4.el10"
PACKAGES = " \
 kernelshark \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/kernelshark-2.3.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb7b2a782349da2511e75c8767f730ffe540c9cb29fe39cfff4178bb62edf35d"

URI_x86_64_v2_kernelshark = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/kernelshark-2.3.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_kernelshark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kernelshark}"
SRC_URI[x86_64_v2_kernelshark.sha256sum] = "c9fff3e93a589487d4321ef61a79b63352a10bc71c17582e1e8e43b235cb364a"

URI_aarch64_kernelshark = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/kernelshark-2.3.1-4.el10.aarch64.rpm;name=aarch64_kernelshark;unpack=0"
SRC_URI:append = " ${URI_aarch64_kernelshark}"
SRC_URI[aarch64_kernelshark.sha256sum] = "bbcbf58fa6a07c8eadedef39524417b1a9d15486e2160cf6a66e5e78c44b6556"

RDEPENDS:kernelshark = " \
 bash \
 freeglut \
 glibc \
 json-c \
 json-c-devel \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 libtracecmd \
 libtracecmd-devel \
 libtraceevent \
 libtracefs \
 mesa-libGLU \
 pkgconf-pkg-config \
 polkit \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtscxml \
 virtual/font_notosans_ \
 "
