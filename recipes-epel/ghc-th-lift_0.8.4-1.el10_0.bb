# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-th-lift"
PV = "0.8.4"
PR = "1.el10_0"
PACKAGES = " \
 ghc-th-lift \
 ghc-th-lift-devel \
 ghc-th-lift-doc \
 ghc-th-lift-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-th-lift-0.8.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27da8d6fc07379a937c9e3ed518f3aaba764c2f757f6a77475614c6b136661de"

URI_x86_64_v2_ghc-th-lift = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-lift-0.8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-lift;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-lift}"
SRC_URI[x86_64_v2_ghc-th-lift.sha256sum] = "4f84d7a0dd1222d997386da76902d2e4da020c81980334e587bcf94382c036e2"

URI_x86_64_v2_ghc-th-lift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-lift-devel-0.8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-lift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-lift-devel}"
SRC_URI[x86_64_v2_ghc-th-lift-devel.sha256sum] = "30e9f07f029e8f889dcbef8596ab9e9905e9b6e4dbcb4f981af5a6b3b500d572"

URI_x86_64_v2_ghc-th-lift-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-lift-doc-0.8.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-th-lift-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-lift-doc}"
SRC_URI[x86_64_v2_ghc-th-lift-doc.sha256sum] = "732b1c02db814f720395b397934ad92d150f2260c22e8058eba8bbfe2336aa64"

URI_x86_64_v2_ghc-th-lift-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-th-lift-prof-0.8.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-th-lift-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-th-lift-prof}"
SRC_URI[x86_64_v2_ghc-th-lift-prof.sha256sum] = "52603dedf6dc2048e380720843f42b502f31a0a9fe0e23f4592810a59e696cca"

URI_aarch64_ghc-th-lift = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-lift-0.8.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-th-lift;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-lift}"
SRC_URI[aarch64_ghc-th-lift.sha256sum] = "93f78df2ed4a337f661ba4410c9a12b1dc5ea6a0b0ec72ba46dfc3bbee37b9a4"

URI_aarch64_ghc-th-lift-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-lift-devel-0.8.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-th-lift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-lift-devel}"
SRC_URI[aarch64_ghc-th-lift-devel.sha256sum] = "785e80ba4457bef56680ca84cb72b766d3480f96386e098acf4430bbaae944de"

URI_aarch64_ghc-th-lift-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-lift-doc-0.8.4-1.el10_0.noarch.rpm;name=aarch64_ghc-th-lift-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-lift-doc}"
SRC_URI[aarch64_ghc-th-lift-doc.sha256sum] = "4c1f40f783657da351287d466856edfa5f965173b9159085748429f689ff9c84"

URI_aarch64_ghc-th-lift-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-th-lift-prof-0.8.4-1.el10_0.aarch64.rpm;name=aarch64_ghc-th-lift-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-th-lift-prof}"
SRC_URI[aarch64_ghc-th-lift-prof.sha256sum] = "b85e5f4221e2afbd1016653c6c7df498a29aa63a815633b03669a638c2aa14b1"

RDEPENDS:ghc-th-lift = " \
 ghc-array \
 ghc-base \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-th-abstraction \
 glibc \
 gmp \
 "
RDEPENDS:ghc-th-lift-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-template-haskell-devel \
 ghc-th-abstraction-devel \
 ghc-th-lift \
 "
RDEPENDS:ghc-th-lift-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-th-lift-prof = " \
 ghc-base-prof \
 ghc-template-haskell-prof \
 ghc-th-abstraction-prof \
 ghc-th-lift-devel \
 "
