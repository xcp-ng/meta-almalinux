# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ed25519-dalek"
PV = "2.2.0"
PR = "4.el10_2"
PACKAGES = " \
 rust-ed25519-dalek+alloc-devel \
 rust-ed25519-dalek+asm-devel \
 rust-ed25519-dalek+default-devel \
 rust-ed25519-dalek+digest-devel \
 rust-ed25519-dalek+fast-devel \
 rust-ed25519-dalek+hazmat-devel \
 rust-ed25519-dalek+legacy_compatibility-devel \
 rust-ed25519-dalek+pem-devel \
 rust-ed25519-dalek+pkcs8-devel \
 rust-ed25519-dalek+rand_core-devel \
 rust-ed25519-dalek+serde-devel \
 rust-ed25519-dalek+signature-devel \
 rust-ed25519-dalek+std-devel \
 rust-ed25519-dalek+zeroize-devel \
 rust-ed25519-dalek-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ed25519-dalek-2.2.0-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80b7a9eea388a7d2db77acaddab263ceaf0b000c972e2f5c47ab58d504e368f1"

URI_x86_64_v2_rust-ed25519-dalek+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+alloc-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+alloc-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+alloc-devel.sha256sum] = "164d578afc282a976d22156b4f51b9567436b4c967cb6075dde379df67d29403"

URI_x86_64_v2_rust-ed25519-dalek+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+asm-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+asm-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+asm-devel.sha256sum] = "be7233851f3215a42ae46843c391f411aafe491ee9e91503fad90a14b4e733ad"

URI_x86_64_v2_rust-ed25519-dalek+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+default-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+default-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+default-devel.sha256sum] = "ee1292d5d109b77e541670e5a4f9da9ea554ea61e01ad5f640b7570b196080e5"

URI_x86_64_v2_rust-ed25519-dalek+digest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+digest-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+digest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+digest-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+digest-devel.sha256sum] = "631fa5e2a904c087ff9c03115588efc87fa7c521c59e881a0a084b10fea5c048"

URI_x86_64_v2_rust-ed25519-dalek+fast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+fast-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+fast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+fast-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+fast-devel.sha256sum] = "5818533e5c6635fe3cc1c6b010d3e20690404d484d8ff98186ba21cc9f004f81"

URI_x86_64_v2_rust-ed25519-dalek+hazmat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+hazmat-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+hazmat-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+hazmat-devel.sha256sum] = "1653b8737ec3a215d9e35ce070bd05d292ea04f810b5af6746b838b18a968d63"

URI_x86_64_v2_rust-ed25519-dalek+legacy_compatibility-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+legacy_compatibility-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+legacy_compatibility-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+legacy_compatibility-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+legacy_compatibility-devel.sha256sum] = "5bedfaed3570db1dcbacb2b53fe3a9ea753d949d474153d0139995e9c7d3f324"

URI_x86_64_v2_rust-ed25519-dalek+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+pem-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+pem-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+pem-devel.sha256sum] = "e1bb193b5ea96fdd08c6e35b1f22469ba21644489212bda4e334b70669c6904c"

URI_x86_64_v2_rust-ed25519-dalek+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+pkcs8-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+pkcs8-devel.sha256sum] = "d55829a2364c6ab5b48d6909e73d5b96e44c17042789e5faf56db64417b62013"

URI_x86_64_v2_rust-ed25519-dalek+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+rand_core-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+rand_core-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+rand_core-devel.sha256sum] = "421e6f4b4d55af637551f9d5b64aab59dc57c245ed077a3e4ee5ccb9ec270ec9"

URI_x86_64_v2_rust-ed25519-dalek+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+serde-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+serde-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+serde-devel.sha256sum] = "8f50dfd26bc24cfb0c91405db9425c496aeff7428995e68e9dc0c2818eb4859b"

URI_x86_64_v2_rust-ed25519-dalek+signature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+signature-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+signature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+signature-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+signature-devel.sha256sum] = "262b5b920522e073bfcf6bc091e19457c6a93bb44e8b90cb5f39013cd84633e9"

URI_x86_64_v2_rust-ed25519-dalek+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+std-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+std-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+std-devel.sha256sum] = "5f4433e2bbeef7ad78bf020a42cb50211538e8c47c22d210d2dbd91032927eb9"

URI_x86_64_v2_rust-ed25519-dalek+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek+zeroize-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek+zeroize-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek+zeroize-devel.sha256sum] = "82107d21e642380ee5b70eb49346dba8de76143fc14340e19ca8ec94195eebb2"

URI_x86_64_v2_rust-ed25519-dalek-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ed25519-dalek-devel-2.2.0-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ed25519-dalek-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ed25519-dalek-devel}"
SRC_URI[x86_64_v2_rust-ed25519-dalek-devel.sha256sum] = "71d2d157645a849fdc54cd1ecb470f756bda2d9d590504587f13f93bfce9c9f0"

URI_aarch64_rust-ed25519-dalek+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+alloc-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+alloc-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+alloc-devel.sha256sum] = "8aaa33e1b3ac32451b12fda441b30d74145b98c9306e862b35d736f0a4fedb28"

URI_aarch64_rust-ed25519-dalek+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+asm-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+asm-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+asm-devel.sha256sum] = "fdecce069bbc4a5418f415c99ff7cdff7731e1f8052cd2c1bc484a4e922ef6af"

URI_aarch64_rust-ed25519-dalek+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+default-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+default-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+default-devel.sha256sum] = "7219e654a5ed856f2fb96923fe56a53ce00569a71a44a1efd2720b07f3ae3c2f"

URI_aarch64_rust-ed25519-dalek+digest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+digest-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+digest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+digest-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+digest-devel.sha256sum] = "95010c0bf28e4f7b6738d6480689f257730a8100670ab1722d8dd2418fd230fa"

URI_aarch64_rust-ed25519-dalek+fast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+fast-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+fast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+fast-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+fast-devel.sha256sum] = "f85cbe7de6c91a90695e88543a31229c10cd52a694bbb0f84e27dc2e549e2001"

URI_aarch64_rust-ed25519-dalek+hazmat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+hazmat-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+hazmat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+hazmat-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+hazmat-devel.sha256sum] = "ec694c665220b067cb0322f89f0ec53903154fe2d4730ebda04ca8266f0c484c"

URI_aarch64_rust-ed25519-dalek+legacy_compatibility-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+legacy_compatibility-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+legacy_compatibility-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+legacy_compatibility-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+legacy_compatibility-devel.sha256sum] = "9dd38677a0354474c752740856a47ab4022c99f237b0ce1b062e8f03456211d8"

URI_aarch64_rust-ed25519-dalek+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+pem-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+pem-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+pem-devel.sha256sum] = "1ee8378d731d50b760f5f561ba624e55e1ba3748993430d0e9f359ddcac24daf"

URI_aarch64_rust-ed25519-dalek+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+pkcs8-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+pkcs8-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+pkcs8-devel.sha256sum] = "d07c5d5f0975317ff0862a5a8711e9bb6226d289aff5fb3d157aa880c60f1746"

URI_aarch64_rust-ed25519-dalek+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+rand_core-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+rand_core-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+rand_core-devel.sha256sum] = "aecdfca7bffac71170e078f1444ea92299e7b51cf3c0bb01dd7564cd38d12ecc"

URI_aarch64_rust-ed25519-dalek+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+serde-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+serde-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+serde-devel.sha256sum] = "2df24df652045100330eee5bf073ed83e987865a86344cd3c6d2a86e01514b66"

URI_aarch64_rust-ed25519-dalek+signature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+signature-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+signature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+signature-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+signature-devel.sha256sum] = "b34f7ec82f6b510afa1a8317a00a7fe67b2728dcc1bb5b9dc1920619c6d14c33"

URI_aarch64_rust-ed25519-dalek+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+std-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+std-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+std-devel.sha256sum] = "039ec581c2bc0d5f8a418cb79d7afe8dc71b86780b9cb0bb2d7e4e3c7b672312"

URI_aarch64_rust-ed25519-dalek+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek+zeroize-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek+zeroize-devel}"
SRC_URI[aarch64_rust-ed25519-dalek+zeroize-devel.sha256sum] = "2f99dbffde3c3d7c8fcab2bc6b57bd09eefdb5021ebb947b55ecefc581dfc68a"

URI_aarch64_rust-ed25519-dalek-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ed25519-dalek-devel-2.2.0-4.el10_2.noarch.rpm;name=aarch64_rust-ed25519-dalek-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ed25519-dalek-devel}"
SRC_URI[aarch64_rust-ed25519-dalek-devel.sha256sum] = "e997fb7243faf101c7948112a75fa49806673917a3aa25da96ed1a86a12ca82f"

RDEPENDS:rust-ed25519-dalek+alloc-devel = " \
 cargo \
 rust-curve25519-dalek+alloc-devel \
 rust-ed25519+alloc-devel \
 rust-ed25519-dalek-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-zeroize+alloc-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-ed25519-dalek+asm-devel = " \
 cargo \
 rust-ed25519-dalek-devel \
 rust-sha2+asm-devel \
 "
RDEPENDS:rust-ed25519-dalek+default-devel = " \
 cargo \
 rust-ed25519-dalek+fast-devel \
 rust-ed25519-dalek+std-devel \
 rust-ed25519-dalek+zeroize-devel \
 rust-ed25519-dalek-devel \
 "
RDEPENDS:rust-ed25519-dalek+digest-devel = " \
 cargo \
 rust-ed25519-dalek-devel \
 rust-signature+digest-devel \
 rust-signature-devel \
 "
RDEPENDS:rust-ed25519-dalek+fast-devel = " \
 cargo \
 rust-curve25519-dalek+precomputed-tables-devel \
 rust-ed25519-dalek-devel \
 "
RDEPENDS:rust-ed25519-dalek+hazmat-devel = " \
 cargo \
 rust-ed25519-dalek-devel \
 "
RDEPENDS:rust-ed25519-dalek+legacy_compatibility-devel = " \
 cargo \
 rust-curve25519-dalek+legacy_compatibility-devel \
 rust-ed25519-dalek-devel \
 "
RDEPENDS:rust-ed25519-dalek+pem-devel = " \
 cargo \
 rust-ed25519+pem-devel \
 rust-ed25519-dalek+alloc-devel \
 rust-ed25519-dalek+pkcs8-devel \
 rust-ed25519-dalek-devel \
 "
RDEPENDS:rust-ed25519-dalek+pkcs8-devel = " \
 cargo \
 rust-ed25519+pkcs8-devel \
 rust-ed25519-dalek-devel \
 "
RDEPENDS:rust-ed25519-dalek+rand_core-devel = " \
 cargo \
 rust-ed25519-dalek-devel \
 rust-rand_core0.6-devel \
 "
RDEPENDS:rust-ed25519-dalek+serde-devel = " \
 cargo \
 rust-ed25519+serde-devel \
 rust-ed25519-dalek-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ed25519-dalek+signature-devel = " \
 cargo \
 rust-ed25519-dalek-devel \
 rust-signature-devel \
 "
RDEPENDS:rust-ed25519-dalek+std-devel = " \
 cargo \
 rust-ed25519+std-devel \
 rust-ed25519-dalek+alloc-devel \
 rust-ed25519-dalek-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 rust-sha2+std-devel \
 "
RDEPENDS:rust-ed25519-dalek+zeroize-devel = " \
 cargo \
 rust-curve25519-dalek+zeroize-devel \
 rust-ed25519-dalek-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-ed25519-dalek-devel = " \
 cargo \
 rust \
 rust-curve25519-dalek+digest-devel \
 rust-curve25519-dalek-devel \
 rust-ed25519-devel \
 rust-sha2-devel \
 rust-subtle-devel \
 "
