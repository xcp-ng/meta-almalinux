# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lsfrom"
PV = "2.0"
PR = "1.el10_0"
PACKAGES = " \
 lsfrom \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lsfrom-2.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58e863ccc8fa50cb99426e8ba5310a21e6738a8f9b676ecc0a0ef862214be3f2"

URI_x86_64_v2_lsfrom = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lsfrom-2.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lsfrom;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lsfrom}"
SRC_URI[x86_64_v2_lsfrom.sha256sum] = "e9d02fae7f4df32d7fd9886e538f17238254866be7f646c4d42e726319735751"

URI_aarch64_lsfrom = "${EPEL_MIRROR}/aarch64/Packages/l/lsfrom-2.0-1.el10_0.aarch64.rpm;name=aarch64_lsfrom;unpack=0"
SRC_URI:append = " ${URI_aarch64_lsfrom}"
SRC_URI[aarch64_lsfrom.sha256sum] = "45d959763fbe35c24dc205faeeebc739925e97a042f51328c051491735078b83"

RDEPENDS:lsfrom = " \
 glibc \
 gmp \
 libffi \
 "
