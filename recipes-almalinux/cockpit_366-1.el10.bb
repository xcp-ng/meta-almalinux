# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit"
PV = "366"
PR = "1.el10"
PACKAGES = " \
 cockpit \
 cockpit-bridge \
 cockpit-doc \
 cockpit-packagekit \
 cockpit-storaged \
 cockpit-system \
 cockpit-ws \
 cockpit-ws-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cockpit-366-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3f2f3c9ccc65bee07312b6ae69352b082bc5b0a983c756c41dbb9d3c8aacbfac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-366-1.el10.x86_64_v2.rpm;name=x86_64_v2_cockpit;unpack=0"
SRC_URI[x86_64_v2_cockpit.sha256sum] = "c2739689b48efc7d64be5fa56e2428ad6d71a90e58e5015654d702299ff7458a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-bridge-366-1.el10.noarch.rpm;name=x86_64_v2_cockpit-bridge;unpack=0"
SRC_URI[x86_64_v2_cockpit-bridge.sha256sum] = "255ffbfe370d0290475cc9cf418df0b2186013c72e0db85d8869b99a445d467d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-doc-366-1.el10.noarch.rpm;name=x86_64_v2_cockpit-doc;unpack=0"
SRC_URI[x86_64_v2_cockpit-doc.sha256sum] = "1b255500baf20abe5a08756fe8c580f208d706230189f265f2215a6f4b29994d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-packagekit-366-1.el10.noarch.rpm;name=x86_64_v2_cockpit-packagekit;unpack=0"
SRC_URI[x86_64_v2_cockpit-packagekit.sha256sum] = "b0612d3c0eac106083553cea86a57752e6ac10553066be40d989055705a46266"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-storaged-366-1.el10.noarch.rpm;name=x86_64_v2_cockpit-storaged;unpack=0"
SRC_URI[x86_64_v2_cockpit-storaged.sha256sum] = "af501c4c560a1abfdce9a072dea3c2c5d7ee4df6a0dae295ea220012306fa02b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-system-366-1.el10.noarch.rpm;name=x86_64_v2_cockpit-system;unpack=0"
SRC_URI[x86_64_v2_cockpit-system.sha256sum] = "772ee9dbc6e83830d924c2031e4948220ea1ac2a7634ea286353bf313a801e91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-366-1.el10.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws;unpack=0"
SRC_URI[x86_64_v2_cockpit-ws.sha256sum] = "00a0e59372aa5e8b7140483b39f2327544998db69c7629f145fa011cac35cfb2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cockpit-ws-selinux-366-1.el10.x86_64_v2.rpm;name=x86_64_v2_cockpit-ws-selinux;unpack=0"
SRC_URI[x86_64_v2_cockpit-ws-selinux.sha256sum] = "5eff763cc510d48c86722512c3e92e24742dc5983fadf21acd62e07f15f0f029"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-366-1.el10.aarch64.rpm;name=aarch64_cockpit;unpack=0"
SRC_URI[aarch64_cockpit.sha256sum] = "4caa33b79358b131a77c5c299ef4309c5e785677a90688d355cd6a709d9d3ba4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-bridge-366-1.el10.noarch.rpm;name=aarch64_cockpit-bridge;unpack=0"
SRC_URI[aarch64_cockpit-bridge.sha256sum] = "255ffbfe370d0290475cc9cf418df0b2186013c72e0db85d8869b99a445d467d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-doc-366-1.el10.noarch.rpm;name=aarch64_cockpit-doc;unpack=0"
SRC_URI[aarch64_cockpit-doc.sha256sum] = "1b255500baf20abe5a08756fe8c580f208d706230189f265f2215a6f4b29994d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-packagekit-366-1.el10.noarch.rpm;name=aarch64_cockpit-packagekit;unpack=0"
SRC_URI[aarch64_cockpit-packagekit.sha256sum] = "b0612d3c0eac106083553cea86a57752e6ac10553066be40d989055705a46266"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-storaged-366-1.el10.noarch.rpm;name=aarch64_cockpit-storaged;unpack=0"
SRC_URI[aarch64_cockpit-storaged.sha256sum] = "af501c4c560a1abfdce9a072dea3c2c5d7ee4df6a0dae295ea220012306fa02b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-system-366-1.el10.noarch.rpm;name=aarch64_cockpit-system;unpack=0"
SRC_URI[aarch64_cockpit-system.sha256sum] = "772ee9dbc6e83830d924c2031e4948220ea1ac2a7634ea286353bf313a801e91"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-366-1.el10.aarch64.rpm;name=aarch64_cockpit-ws;unpack=0"
SRC_URI[aarch64_cockpit-ws.sha256sum] = "01bc3cb016ec7edadb55bd9ecb75e22926d9edd7cb3f7ec43f9ce990d02b6c36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cockpit-ws-selinux-366-1.el10.aarch64.rpm;name=aarch64_cockpit-ws-selinux;unpack=0"
SRC_URI[aarch64_cockpit-ws-selinux.sha256sum] = "3d76fcd654886bf8cd41c5847d36f50a0195951d77ec00b39b436d91dc73d77a"

RDEPENDS:cockpit = " \
 cockpit-bridge \
 cockpit-system \
 cockpit-ws \
 "
RDEPENDS:cockpit-bridge = " \
 python3 \
 "
RDEPENDS:cockpit-doc = " \
 "
RDEPENDS:cockpit-packagekit = " \
 PackageKit \
 cockpit-bridge \
 polkit \
 "
RDEPENDS:cockpit-storaged = " \
 bash \
 cockpit-system \
 python3 \
 python3-dbus \
 udisks2 \
 "
RDEPENDS:cockpit-system = " \
 NetworkManager \
 cockpit-bridge \
 grep \
 libpwquality \
 shadow-utils \
 sos \
 sudo \
 virtual//usr/bin/date \
 "
RDEPENDS:cockpit-ws = " \
 bash \
 cockpit-ws-selinux \
 glib2 \
 glibc \
 gnutls \
 json-glib \
 krb5-libs \
 libgcc \
 openssl \
 pam-libs \
 systemd-libs \
 "
RDEPENDS:cockpit-ws-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 selinux-policy-targeted \
 "
