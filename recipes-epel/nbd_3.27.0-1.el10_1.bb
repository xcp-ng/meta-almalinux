# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nbd"
PV = "3.27.0"
PR = "1.el10_1"
PACKAGES = " \
 nbd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nbd-3.27.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "da79a43078a370e396d39cdeff1d709b7cc320e8d50030b59abba699ea214366"

URI_x86_64_v2_nbd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nbd-3.27.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nbd}"
SRC_URI[x86_64_v2_nbd.sha256sum] = "59c78a90b45251732f5dfc135e62aad637b8daa7b317bbefd1c1621c0ae3bb1b"

URI_aarch64_nbd = "${EPEL_MIRROR}/aarch64/Packages/n/nbd-3.27.0-1.el10_1.aarch64.rpm;name=aarch64_nbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nbd}"
SRC_URI[aarch64_nbd.sha256sum] = "584fe8486e6e4973ec250b506581f4fb47ffcc0ab3577d7cf8be2a33d753092d"

RDEPENDS:nbd = " \
 bash \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libnl3 \
 systemd \
 "
