# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Try-Tiny"
PV = "0.31"
PR = "12.el10"
PACKAGES = " \
 perl-Try-Tiny \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Try-Tiny-0.31-12.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "068b003857ca03caf680264a7b57e33b069d9bdf51172df7943d48c3aecb1fa6"

URI_x86_64_v2_perl-Try-Tiny = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Try-Tiny-0.31-12.el10.noarch.rpm;name=x86_64_v2_perl-Try-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Try-Tiny}"
SRC_URI[x86_64_v2_perl-Try-Tiny.sha256sum] = "8ab071ef81c3f4815ec28d6572ac357f03176dd4b1bd32a70ed50de9d5bf3c9d"

URI_aarch64_perl-Try-Tiny = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Try-Tiny-0.31-12.el10.noarch.rpm;name=aarch64_perl-Try-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Try-Tiny}"
SRC_URI[aarch64_perl-Try-Tiny.sha256sum] = "8ab071ef81c3f4815ec28d6572ac357f03176dd4b1bd32a70ed50de9d5bf3c9d"

RDEPENDS:perl-Try-Tiny = " \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 "
