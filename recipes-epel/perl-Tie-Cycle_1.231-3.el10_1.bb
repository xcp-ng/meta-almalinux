# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tie-Cycle"
PV = "1.231"
PR = "3.el10_1"
PACKAGES = " \
 perl-Tie-Cycle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tie-Cycle-1.231-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "604b7d0ecdf4460a9d4980cde6070b1fc312cc512b62fc7af370e5da99916a60"

URI_x86_64_v2_perl-Tie-Cycle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Cycle-1.231-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Cycle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Cycle}"
SRC_URI[x86_64_v2_perl-Tie-Cycle.sha256sum] = "779a8e8bd5962d90b295eed3f056b500a5ca35c56baa4e862094f7c3d1da5b9d"

URI_aarch64_perl-Tie-Cycle = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Cycle-1.231-3.el10_1.noarch.rpm;name=aarch64_perl-Tie-Cycle;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Cycle}"
SRC_URI[aarch64_perl-Tie-Cycle.sha256sum] = "26700c8ba1d285b7702b4ac88e482c8de71bd8928312595eb067b49c50748067"

RDEPENDS:perl-Tie-Cycle = " \
 perl-Carp \
 perl-constant \
 perl-libs \
 "
