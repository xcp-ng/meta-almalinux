# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kblocks"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kblocks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kblocks-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c482e3143600bd72176212023ee3399e3470cad701f22058321a14908dd2cbf7"

URI_x86_64_v2_kblocks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kblocks-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kblocks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kblocks}"
SRC_URI[x86_64_v2_kblocks.sha256sum] = "4ac293b7a35c1df01ff1e1cb2630a0f0898e5a550de3f70cb9e480b8ea1e9de1"

URI_aarch64_kblocks = "${EPEL_MIRROR}/aarch64/Packages/k/kblocks-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kblocks;unpack=0"
SRC_URI:append = " ${URI_aarch64_kblocks}"
SRC_URI[aarch64_kblocks.sha256sum] = "87f1575c8246f972320b2e5c8481eac483cbae5e641e64d89bb8e99320987bec"

RDEPENDS:kblocks = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
