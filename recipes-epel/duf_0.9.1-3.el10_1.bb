# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "duf"
PV = "0.9.1"
PR = "3.el10_1"
PACKAGES = " \
 duf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/duf-0.9.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "151065261f08c0331b93234738c3f9c80ceb5747313ab95b9055264cc8120970"

URI_x86_64_v2_duf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/duf-0.9.1-3.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_duf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_duf}"
SRC_URI[x86_64_v2_duf.sha256sum] = "e994a3298fb65d19e8e19d02937ed80f903f9177e51a753b29b02474dab04764"

URI_aarch64_duf = "${EPEL_MIRROR}/aarch64/Packages/d/duf-0.9.1-3.el10_1.aarch64.rpm;name=aarch64_duf;unpack=0"
SRC_URI:append = " ${URI_aarch64_duf}"
SRC_URI[aarch64_duf.sha256sum] = "74bd070a8d4a0ca9d4b162bbdb7dd8507567c299a260262c267d2452e35f2d9d"

RDEPENDS:duf = " \
 glibc \
 "
