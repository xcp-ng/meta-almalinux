# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glab"
PV = "1.102.0"
PR = "1.el10_3"
PACKAGES = " \
 glab \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/glab-1.102.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cb1a362f98cf1af01e66181a6af27faf9371bc2da9c95f390eeb9079a8bb8ee7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glab-1.102.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glab;unpack=0"
SRC_URI[x86_64_v2_glab.sha256sum] = "c754b60af4258c86667f8afe1b9471341028592c0250d9f5f25fe553d1c9b660"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/glab-1.102.0-1.el10_3.aarch64.rpm;name=aarch64_glab;unpack=0"
SRC_URI[aarch64_glab.sha256sum] = "16f57e70cf2f1a773c2c11baa6db4d226cf86d726fd6ac172c537119002ee677"

RDEPENDS:glab = " \
 git-core \
 glibc \
 "
