# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_isaac"
PV = "0.5.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_isaac+default-devel \
 rust-rand_isaac-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rand_isaac-0.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4b9059ac29b15e5803cc3dc8f51d8dcd4baa5f3bf11f9a3a1b3ce59704e9bd9a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac+default-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand_isaac+default-devel.sha256sum] = "c50becb77eef0831db0b315d8ae7e0ad8752a2da35d48d94754b0f075164b802"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac-devel-0.5.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand_isaac-devel.sha256sum] = "45d46e573b2fa5fd0dd86bc85d8c2b9eeef6edbaa4602b11f91aa4a4281267d0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac+default-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac+default-devel;unpack=0"
SRC_URI[aarch64_rust-rand_isaac+default-devel.sha256sum] = "e563f9b2b0fe291ccb07f37ef398f3ed60d5bafc5f4112e2a185f5766c6b87c0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac-devel-0.5.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac-devel;unpack=0"
SRC_URI[aarch64_rust-rand_isaac-devel.sha256sum] = "77b7f50f99ed3231cba1c57d80d36474ff636d12c5935d6f4387a4dbb879f552"

RDEPENDS:rust-rand_isaac+default-devel = " \
 cargo \
 rust-rand_isaac-devel \
 "
RDEPENDS:rust-rand_isaac-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
