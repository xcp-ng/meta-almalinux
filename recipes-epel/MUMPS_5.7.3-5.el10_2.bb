# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "MUMPS"
PV = "5.7.3"
PR = "5.el10_2"
PACKAGES = " \
 MUMPS \
 MUMPS-common \
 MUMPS-devel \
 MUMPS-examples \
 MUMPS-mpich \
 MUMPS-mpich-devel \
 MUMPS-mpich-examples \
 MUMPS-openmpi \
 MUMPS-openmpi-devel \
 MUMPS-openmpi-examples \
 MUMPS-srpm-macros \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/MUMPS-5.7.3-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d64a66fcbad5939e29b85bd294d9cfc0981c5bd1f9da6f1817a62932059e30e4"

URI_x86_64_v2_MUMPS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-5.7.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_MUMPS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS}"
SRC_URI[x86_64_v2_MUMPS.sha256sum] = "3b45675887eec9ed05f60c0eac098903493531ad68d7b8ea072a86b8c40b4ad3"

URI_x86_64_v2_MUMPS-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-common-5.7.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_MUMPS-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-common}"
SRC_URI[x86_64_v2_MUMPS-common.sha256sum] = "58549cca065471594b60495c8f2aff27d7f25a2a942562a167e5809adb8caa83"

URI_x86_64_v2_MUMPS-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-devel-5.7.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_MUMPS-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-devel}"
SRC_URI[x86_64_v2_MUMPS-devel.sha256sum] = "da5f4df76726ab58f11d1c6de07bbe530e60e15d9fd1a61ab46ef83d08afabda"

URI_x86_64_v2_MUMPS-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-examples-5.7.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_MUMPS-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-examples}"
SRC_URI[x86_64_v2_MUMPS-examples.sha256sum] = "8431d2a4fbf01326e3da09828ece96620749f1c6f7cf12eb54c650062bf6f8d2"

URI_x86_64_v2_MUMPS-mpich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-mpich-5.7.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_MUMPS-mpich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-mpich}"
SRC_URI[x86_64_v2_MUMPS-mpich.sha256sum] = "3f1257dcdc87c2fcdd1be70b3c75fd39ad097e0b9ff28c977de455248aa5c874"

URI_x86_64_v2_MUMPS-mpich-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-mpich-devel-5.7.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_MUMPS-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-mpich-devel}"
SRC_URI[x86_64_v2_MUMPS-mpich-devel.sha256sum] = "62056a7310b832d46feb419f206de2a029409c69134603816cdcb0a044eb6595"

URI_x86_64_v2_MUMPS-mpich-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-mpich-examples-5.7.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_MUMPS-mpich-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-mpich-examples}"
SRC_URI[x86_64_v2_MUMPS-mpich-examples.sha256sum] = "fb032df857fb6072ac5e37c14fd7343c498de009421aca502428cf75046cfc28"

URI_x86_64_v2_MUMPS-openmpi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-openmpi-5.7.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_MUMPS-openmpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-openmpi}"
SRC_URI[x86_64_v2_MUMPS-openmpi.sha256sum] = "23a974533fd003ad6a337bbbc4dd1460684f6ec120cb50dceb8841474fde6004"

URI_x86_64_v2_MUMPS-openmpi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-openmpi-devel-5.7.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_MUMPS-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-openmpi-devel}"
SRC_URI[x86_64_v2_MUMPS-openmpi-devel.sha256sum] = "67c26711b879d81bf2f2637f8898c9e05b547612635620b8b78c4d78ab2cd891"

URI_x86_64_v2_MUMPS-openmpi-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-openmpi-examples-5.7.3-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_MUMPS-openmpi-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-openmpi-examples}"
SRC_URI[x86_64_v2_MUMPS-openmpi-examples.sha256sum] = "e8f9770c356b42afcffa9304cb0d7ee5eac45b2b03fd05233b0a0a0106805a8c"

URI_x86_64_v2_MUMPS-srpm-macros = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/MUMPS-srpm-macros-5.7.3-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_MUMPS-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_MUMPS-srpm-macros}"
SRC_URI[x86_64_v2_MUMPS-srpm-macros.sha256sum] = "4ffb63edebff9e683c956e72db124382fac6febf8742e02fbda997e8d8528b89"

URI_aarch64_MUMPS = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-5.7.3-5.el10_2.aarch64.rpm;name=aarch64_MUMPS;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS}"
SRC_URI[aarch64_MUMPS.sha256sum] = "407cb1a309657c10ec3cee90cd00125e8187ee72f5477e1a4d45e82185435da8"

URI_aarch64_MUMPS-common = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-common-5.7.3-5.el10_2.noarch.rpm;name=aarch64_MUMPS-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-common}"
SRC_URI[aarch64_MUMPS-common.sha256sum] = "530afe6246a0c864658ddd419cfc6883e86b4ea64ce5ca52e62bcc356763c1cf"

URI_aarch64_MUMPS-devel = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-devel-5.7.3-5.el10_2.aarch64.rpm;name=aarch64_MUMPS-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-devel}"
SRC_URI[aarch64_MUMPS-devel.sha256sum] = "bb8f9acc8c12f10bd190faf692db4308bcde73963bd880793df1d82689382e74"

URI_aarch64_MUMPS-examples = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-examples-5.7.3-5.el10_2.aarch64.rpm;name=aarch64_MUMPS-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-examples}"
SRC_URI[aarch64_MUMPS-examples.sha256sum] = "f0cefd5c4f09f9499425f87afea1c135270d76a4277bb57df1d750dddf8bcb53"

URI_aarch64_MUMPS-mpich = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-mpich-5.7.3-5.el10_2.aarch64.rpm;name=aarch64_MUMPS-mpich;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-mpich}"
SRC_URI[aarch64_MUMPS-mpich.sha256sum] = "90a713f93e32ddbe6dd78048c79faab583213c5abd7721928407fe110745c8e9"

URI_aarch64_MUMPS-mpich-devel = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-mpich-devel-5.7.3-5.el10_2.aarch64.rpm;name=aarch64_MUMPS-mpich-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-mpich-devel}"
SRC_URI[aarch64_MUMPS-mpich-devel.sha256sum] = "3a7c3a70318b34c8dee44ea978473bc62edcb758b7406042de2a1e58cc7dfe1e"

URI_aarch64_MUMPS-mpich-examples = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-mpich-examples-5.7.3-5.el10_2.aarch64.rpm;name=aarch64_MUMPS-mpich-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-mpich-examples}"
SRC_URI[aarch64_MUMPS-mpich-examples.sha256sum] = "5bf2eb917cd67aa5222fa15295bfddd385fd4ec0556895b93a06ea708140563d"

URI_aarch64_MUMPS-openmpi = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-openmpi-5.7.3-5.el10_2.aarch64.rpm;name=aarch64_MUMPS-openmpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-openmpi}"
SRC_URI[aarch64_MUMPS-openmpi.sha256sum] = "9a6b78f438175be44eac7eb78f88d4ed10801ff6a55f873e2cfbfc4a35ecafd4"

URI_aarch64_MUMPS-openmpi-devel = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-openmpi-devel-5.7.3-5.el10_2.aarch64.rpm;name=aarch64_MUMPS-openmpi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-openmpi-devel}"
SRC_URI[aarch64_MUMPS-openmpi-devel.sha256sum] = "08c6ba58394537f100769e3ac54dea8c73c21fb5f744e3db618a38019487a263"

URI_aarch64_MUMPS-openmpi-examples = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-openmpi-examples-5.7.3-5.el10_2.aarch64.rpm;name=aarch64_MUMPS-openmpi-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-openmpi-examples}"
SRC_URI[aarch64_MUMPS-openmpi-examples.sha256sum] = "39492a8292b7e8483c5f5ee1ee0f0f07df679b2d2a7298e77627bf18ba29fada"

URI_aarch64_MUMPS-srpm-macros = "${EPEL_MIRROR}/aarch64/Packages/m/MUMPS-srpm-macros-5.7.3-5.el10_2.noarch.rpm;name=aarch64_MUMPS-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_MUMPS-srpm-macros}"
SRC_URI[aarch64_MUMPS-srpm-macros.sha256sum] = "06ebaf538bc5fc33e32ac98c6c2ffa689fdfa82398a00e1cd0bcaa0cccf38230"

RDEPENDS:MUMPS = " \
 MUMPS-common \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 metis \
 scotch \
 "
RDEPENDS:MUMPS-common = " \
 "
RDEPENDS:MUMPS-devel = " \
 MUMPS \
 MUMPS-srpm-macros \
 gcc-gfortran \
 "
RDEPENDS:MUMPS-examples = " \
 MUMPS \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 metis \
 scotch \
 "
RDEPENDS:MUMPS-mpich = " \
 MUMPS-common \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 metis \
 mpich \
 ptscotch-mpich \
 scalapack-mpich \
 "
RDEPENDS:MUMPS-mpich-devel = " \
 MUMPS-mpich \
 MUMPS-srpm-macros \
 "
RDEPENDS:MUMPS-mpich-examples = " \
 MUMPS-mpich \
 flexiblas-netlib \
 gcc-gfortran \
 glibc \
 libgcc \
 libgfortran \
 metis \
 mpich \
 ptscotch-mpich \
 scalapack-mpich \
 "
RDEPENDS:MUMPS-openmpi = " \
 MUMPS-common \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 metis \
 openmpi \
 ptscotch-openmpi \
 scalapack-openmpi \
 "
RDEPENDS:MUMPS-openmpi-devel = " \
 MUMPS-openmpi \
 MUMPS-srpm-macros \
 gcc-gfortran \
 "
RDEPENDS:MUMPS-openmpi-examples = " \
 MUMPS-openmpi \
 flexiblas-netlib \
 glibc \
 libgcc \
 libgfortran \
 metis \
 openmpi \
 ptscotch-openmpi \
 scalapack-openmpi \
 "
RDEPENDS:MUMPS-srpm-macros = " \
 "
