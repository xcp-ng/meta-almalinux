# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-breeze"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 breeze-cursor-theme \
 plasma-breeze \
 plasma-breeze-common \
 plasma-breeze-qt6 \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-breeze-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fca9973a2a850da77cef2df55a80dbb92f91cd83828b26601cce0a5e499756f0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/breeze-cursor-theme-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_breeze-cursor-theme;unpack=0"
SRC_URI[x86_64_v2_breeze-cursor-theme.sha256sum] = "7383c3fcc28a5a4b0ed97db6347791f42a5fd5f06fdbf64d132467e2d23b4ce6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze;unpack=0"
SRC_URI[x86_64_v2_plasma-breeze.sha256sum] = "5ae4ae54286b5d2df58e8ed590179c3d9a180e17ced69ae23c18c5153782577c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-common-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-breeze-common;unpack=0"
SRC_URI[x86_64_v2_plasma-breeze-common.sha256sum] = "80028dcea2909b165fa6053999f187d27a9cf9ce2645fcbb32bb312c474e3bef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-breeze-qt6-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-breeze-qt6;unpack=0"
SRC_URI[x86_64_v2_plasma-breeze-qt6.sha256sum] = "1a55dd78c73b8e5f804d38c6e0a7c448ca864789013d88ab9c0dcf7cc12e41f1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/breeze-cursor-theme-6.7.5-1.el10_3.noarch.rpm;name=aarch64_breeze-cursor-theme;unpack=0"
SRC_URI[aarch64_breeze-cursor-theme.sha256sum] = "9172c65d42e0bf3aabd8e85bc00ff8bcc57c0aac918b306d8a96f1b989643792"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-breeze;unpack=0"
SRC_URI[aarch64_plasma-breeze.sha256sum] = "e7cdc95474d931a770053d20403018c52b498983aab0f87b9e51dcf4b13eec7a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-common-6.7.5-1.el10_3.noarch.rpm;name=aarch64_plasma-breeze-common;unpack=0"
SRC_URI[aarch64_plasma-breeze-common.sha256sum] = "780b9309821d3de668df61bc701f049556314b5e3662b2f4463928d381c63990"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-breeze-qt6-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-breeze-qt6;unpack=0"
SRC_URI[aarch64_plasma-breeze-qt6.sha256sum] = "7bafcb20fb177028c4dedbbbf4395735ab36e088ed11d58cd90acfab543f1245"

RDEPENDS:breeze-cursor-theme = " \
 "
RDEPENDS:plasma-breeze = " \
 cmake-filesystem \
 glibc \
 kdecoration \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 libstdc++ \
 plasma-breeze-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
RDEPENDS:plasma-breeze-common = " \
 "
RDEPENDS:plasma-breeze-qt6 = " \
 glibc \
 kf6-frameworkintegration-libs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kguiaddons \
 kf6-kiconthemes \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-breeze-common \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
