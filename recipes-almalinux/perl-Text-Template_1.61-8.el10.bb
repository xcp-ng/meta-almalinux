# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Template"
PV = "1.61"
PR = "8.el10"
PACKAGES = " \
 perl-Text-Template \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Text-Template-1.61-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9e9e19fd20ac16f2615ebdb88420cad8b872071b1d853db3ce19760a77be9154"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Text-Template-1.61-8.el10.noarch.rpm;name=x86_64_v2_perl-Text-Template;unpack=0"
SRC_URI[x86_64_v2_perl-Text-Template.sha256sum] = "6c777da05ff3a242770e64e19d09508de4eb157e33cd58f9f98c5c9ca6ecaa71"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Text-Template-1.61-8.el10.noarch.rpm;name=aarch64_perl-Text-Template;unpack=0"
SRC_URI[aarch64_perl-Text-Template.sha256sum] = "6c777da05ff3a242770e64e19d09508de4eb157e33cd58f9f98c5c9ca6ecaa71"

RDEPENDS:perl-Text-Template = " \
 perl-Carp \
 perl-Exporter \
 perl-Text-Template \
 perl-base \
 perl-libs \
 "
