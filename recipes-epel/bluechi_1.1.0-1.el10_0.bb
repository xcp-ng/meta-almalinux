# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bluechi"
PV = "1.1.0"
PR = "1.el10_0"
PACKAGES = " \
 bluechi-agent \
 bluechi-controller \
 bluechi-ctl \
 bluechi-is-online \
 bluechi-selinux \
 python3-bluechi \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bluechi-1.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a531a2b4798df531a0fbe1e046d5c8013034597147ad3142a3143f7cb3e8a9b3"

URI_x86_64_v2_bluechi-agent = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-agent-1.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-agent;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-agent}"
SRC_URI[x86_64_v2_bluechi-agent.sha256sum] = "383d2635247f52696e333d8972b6cce020d9867d776e68b75f5be41c3f6ef473"

URI_x86_64_v2_bluechi-controller = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-controller-1.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-controller;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-controller}"
SRC_URI[x86_64_v2_bluechi-controller.sha256sum] = "45476867f9f10d4f2389fd993e12e025bc0a3723ae168ef9d854a228393e24d5"

URI_x86_64_v2_bluechi-ctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-ctl-1.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-ctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-ctl}"
SRC_URI[x86_64_v2_bluechi-ctl.sha256sum] = "ad347dc562ad8c4da9bcba95296cbd006d6701be7ab333c4b2f4ed583c1a4709"

URI_x86_64_v2_bluechi-is-online = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-is-online-1.1.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bluechi-is-online;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-is-online}"
SRC_URI[x86_64_v2_bluechi-is-online.sha256sum] = "01a006ca63db2a7426fdf0bcc4d67e5e989f51a12e02edfbf997d5f1342b94ea"

URI_x86_64_v2_bluechi-selinux = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bluechi-selinux-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_bluechi-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bluechi-selinux}"
SRC_URI[x86_64_v2_bluechi-selinux.sha256sum] = "4e287afd0945ab3b39c82cb22d575def4fe5dd92711482ef2b89066122f0ad91"

URI_x86_64_v2_python3-bluechi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-bluechi-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-bluechi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-bluechi}"
SRC_URI[x86_64_v2_python3-bluechi.sha256sum] = "9bc05198b741f98805a1d9ac60a5d087de2dfdad96ddf0f087e1f6a1738497e3"

URI_aarch64_bluechi-agent = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-agent-1.1.0-1.el10_0.aarch64.rpm;name=aarch64_bluechi-agent;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-agent}"
SRC_URI[aarch64_bluechi-agent.sha256sum] = "8e708fcd190cc9ded8ae4175e83c75d4ba634031ed23148bc10a84c821e7f6b5"

URI_aarch64_bluechi-controller = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-controller-1.1.0-1.el10_0.aarch64.rpm;name=aarch64_bluechi-controller;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-controller}"
SRC_URI[aarch64_bluechi-controller.sha256sum] = "16df45ca49a7b533d99da580fe0c87d9c7e6dd16e84bf87a4db732aa19ca9a02"

URI_aarch64_bluechi-ctl = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-ctl-1.1.0-1.el10_0.aarch64.rpm;name=aarch64_bluechi-ctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-ctl}"
SRC_URI[aarch64_bluechi-ctl.sha256sum] = "8114262f261086f622cfeacf1fede2795404df64e658adbd6c8dae3409dd1e14"

URI_aarch64_bluechi-is-online = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-is-online-1.1.0-1.el10_0.aarch64.rpm;name=aarch64_bluechi-is-online;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-is-online}"
SRC_URI[aarch64_bluechi-is-online.sha256sum] = "8bc3949e27926ed5b8afdf8040f19ae0ab2fc6a47fdd28a4e42f596e786a06ff"

URI_aarch64_bluechi-selinux = "${EPEL_MIRROR}/aarch64/Packages/b/bluechi-selinux-1.1.0-1.el10_0.noarch.rpm;name=aarch64_bluechi-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_bluechi-selinux}"
SRC_URI[aarch64_bluechi-selinux.sha256sum] = "ed94ffc17c4a5f2d36be82049410da4d89772a38d5a72e55e0dbd082cc66f8bc"

URI_aarch64_python3-bluechi = "${EPEL_MIRROR}/aarch64/Packages/p/python3-bluechi-1.1.0-1.el10_0.noarch.rpm;name=aarch64_python3-bluechi;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-bluechi}"
SRC_URI[aarch64_python3-bluechi.sha256sum] = "92cd0dad536e397e4626002cba39068ac599312b1176e76e04e06069b04e9b7e"

RDEPENDS:bluechi-agent = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-controller = " \
 bash \
 glibc \
 libgcc \
 libselinux \
 systemd \
 systemd-libs \
 "
RDEPENDS:bluechi-ctl = " \
 bluechi-controller \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-is-online = " \
 glibc \
 libgcc \
 systemd-libs \
 "
RDEPENDS:bluechi-selinux = " \
 bash \
 policycoreutils \
 selinux-policy \
 virtual/selinux-policy-any_ge_40.13.26 \
 "
RDEPENDS:python3-bluechi = " \
 python3 \
 python3-dasbus \
 "
