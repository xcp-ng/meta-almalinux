# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cpuguy83-md2man"
PV = "2.0.3"
PR = "8.el10"
PACKAGES = " \
 golang-github-cpuguy83-md2man \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/golang-github-cpuguy83-md2man-2.0.3-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0d5df030de8910b474f50a54959d023d22281e19e636f0fb6cf473591775f1e"

URI_x86_64_v2_golang-github-cpuguy83-md2man = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/golang-github-cpuguy83-md2man-2.0.3-8.el10.x86_64_v2.rpm;name=x86_64_v2_golang-github-cpuguy83-md2man;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cpuguy83-md2man}"
SRC_URI[x86_64_v2_golang-github-cpuguy83-md2man.sha256sum] = "b2d95a1b8deb7dd2ad9b3b74e744c200648120a26fde559b133ed5296f2cca69"

URI_aarch64_golang-github-cpuguy83-md2man = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/golang-github-cpuguy83-md2man-2.0.3-8.el10.aarch64.rpm;name=aarch64_golang-github-cpuguy83-md2man;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cpuguy83-md2man}"
SRC_URI[aarch64_golang-github-cpuguy83-md2man.sha256sum] = "80545f1feaab7e6c90f764eced06d5a9d4060485d3887c16b6fed0175570b70d"

RDEPENDS:golang-github-cpuguy83-md2man = " \
 glibc \
 "
