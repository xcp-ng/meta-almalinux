# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-runtime-format"
PV = "0.1.3"
PR = "4.el10_3"
PACKAGES = " \
 rust-runtime-format+default-devel \
 rust-runtime-format+std-devel \
 rust-runtime-format+tinyvec-devel \
 rust-runtime-format-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-runtime-format-0.1.3-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "624db9c5e45772406b017c8b355e57bd37754d1acde98974b7ee0ef6d44b1bae"

URI_x86_64_v2_rust-runtime-format+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-runtime-format+default-devel-0.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-runtime-format+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-runtime-format+default-devel}"
SRC_URI[x86_64_v2_rust-runtime-format+default-devel.sha256sum] = "8dce272757d916a484bd14bb826bd37b9da39601e22d74dd426a3a37fb7378ec"

URI_x86_64_v2_rust-runtime-format+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-runtime-format+std-devel-0.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-runtime-format+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-runtime-format+std-devel}"
SRC_URI[x86_64_v2_rust-runtime-format+std-devel.sha256sum] = "c43afca9a6c8fff7066ded9507a95cfb7046540c8883f940dea3145d3b79ec01"

URI_x86_64_v2_rust-runtime-format+tinyvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-runtime-format+tinyvec-devel-0.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-runtime-format+tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-runtime-format+tinyvec-devel}"
SRC_URI[x86_64_v2_rust-runtime-format+tinyvec-devel.sha256sum] = "5eb46cb61ac21195a79a172991bffe54cdf5324c480a44c8ffec29aba18cdd69"

URI_x86_64_v2_rust-runtime-format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-runtime-format-devel-0.1.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-runtime-format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-runtime-format-devel}"
SRC_URI[x86_64_v2_rust-runtime-format-devel.sha256sum] = "458801f1afef08e127e663993be324876bc7f9b12c0ae76608bb7105a68b7f3f"

URI_aarch64_rust-runtime-format+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-runtime-format+default-devel-0.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-runtime-format+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-runtime-format+default-devel}"
SRC_URI[aarch64_rust-runtime-format+default-devel.sha256sum] = "ba18e499753d5a41d41208ebbe896321588dd08bfb4641edc150e3108f824acb"

URI_aarch64_rust-runtime-format+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-runtime-format+std-devel-0.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-runtime-format+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-runtime-format+std-devel}"
SRC_URI[aarch64_rust-runtime-format+std-devel.sha256sum] = "d28a160ed57d7b4ad9e3f1444438365f228fd3084746a04008080aea7656b84b"

URI_aarch64_rust-runtime-format+tinyvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-runtime-format+tinyvec-devel-0.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-runtime-format+tinyvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-runtime-format+tinyvec-devel}"
SRC_URI[aarch64_rust-runtime-format+tinyvec-devel.sha256sum] = "b8db481512043242b1ed47c9cbd78d11b215bcdeff4fd65fd67f8f1f02aca2a8"

URI_aarch64_rust-runtime-format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-runtime-format-devel-0.1.3-4.el10_3.noarch.rpm;name=aarch64_rust-runtime-format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-runtime-format-devel}"
SRC_URI[aarch64_rust-runtime-format-devel.sha256sum] = "5b7ef19884930a653ccf3c02846a1748e3d208d11cd143fc4b459c57e3776aa8"

RDEPENDS:rust-runtime-format+default-devel = " \
 cargo \
 rust-runtime-format+std-devel \
 rust-runtime-format-devel \
 "
RDEPENDS:rust-runtime-format+std-devel = " \
 cargo \
 rust-runtime-format-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 "
RDEPENDS:rust-runtime-format+tinyvec-devel = " \
 cargo \
 rust-runtime-format-devel \
 rust-tinyvec+default-devel \
 "
RDEPENDS:rust-runtime-format-devel = " \
 cargo \
 "
