# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "testssl"
PV = "3.2.1"
PR = "1.el10_0"
PACKAGES = " \
 testssl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/testssl-3.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2efcfb9e4ba30677145b0ac61fb3844ff898d52794d67bd8a0e7fa82f8a31ae7"

URI_x86_64_v2_testssl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/testssl-3.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_testssl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_testssl}"
SRC_URI[x86_64_v2_testssl.sha256sum] = "800452f8dde50d9a6347b6133d507361697822147e8524f3d35c68a084e5ab79"

URI_aarch64_testssl = "${EPEL_MIRROR}/aarch64/Packages/t/testssl-3.2.1-1.el10_0.noarch.rpm;name=aarch64_testssl;unpack=0"
SRC_URI:append = " ${URI_aarch64_testssl}"
SRC_URI[aarch64_testssl.sha256sum] = "eeea3fa665a0bff08251946bb85fb9a913d4da15dad49788e82b45a2bd6f0b19"

RDEPENDS:testssl = " \
 bash \
 bind-utils \
 ca-certificates \
 gawk \
 glibc-common \
 grep \
 hostname \
 ncurses \
 openssl \
 procps-ng \
 sed \
 util-linux \
 virtual/coreutils \
 "
