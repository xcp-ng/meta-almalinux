# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-equator"
PV = "0.6.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-equator+default-devel \
 rust-equator-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-equator-0.6.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e08f789f6043b1b4f7ab6807a81cdc4311497bd9f027a5ba1dcbdd873e08a84"

URI_x86_64_v2_rust-equator+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator+default-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator+default-devel}"
SRC_URI[x86_64_v2_rust-equator+default-devel.sha256sum] = "f7b5fd8d6fc7d8f96ca6c4d3fe9b3d8232adb231a1b599917f8db34850cb4683"

URI_x86_64_v2_rust-equator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-equator-devel-0.6.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-equator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-equator-devel}"
SRC_URI[x86_64_v2_rust-equator-devel.sha256sum] = "a8f767cd12a8b453fad197ffc5a98a80c39c372f9f085da02ae3f3f3d171d657"

URI_aarch64_rust-equator+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator+default-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-equator+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator+default-devel}"
SRC_URI[aarch64_rust-equator+default-devel.sha256sum] = "7ce0fee46b5d14a32d33fd5f08e8ae99b96d415eaef240851765eca235a30244"

URI_aarch64_rust-equator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-equator-devel-0.6.0-1.el10_2.noarch.rpm;name=aarch64_rust-equator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-equator-devel}"
SRC_URI[aarch64_rust-equator-devel.sha256sum] = "ddf95ba8387761ac7cac09ab95cde9a6eca884fa811fa20172a1648d28945ce8"

RDEPENDS:rust-equator+default-devel = " \
 cargo \
 rust-equator-devel \
 "
RDEPENDS:rust-equator-devel = " \
 cargo \
 rust-equator-macro+default-devel \
 "
