# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poxml"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 poxml \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/poxml-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5528a9ac02b7ac66740fe1b647ec45bdfa9cbdd50ec230943b9c8605a8ef800a"

URI_x86_64_v2_poxml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/poxml-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_poxml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_poxml}"
SRC_URI[x86_64_v2_poxml.sha256sum] = "c90b33e5078769b0d1c2da1034fe102bc73298a2930a0effd20a1c18d087538a"

URI_aarch64_poxml = "${EPEL_MIRROR}/aarch64/Packages/p/poxml-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_poxml;unpack=0"
SRC_URI:append = " ${URI_aarch64_poxml}"
SRC_URI[aarch64_poxml.sha256sum] = "2788058b9c8faeb6b69a3b21b3987670f2b60cedd58322dc1978d40e0fb58a49"

RDEPENDS:poxml = " \
 gettext-libs \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
