# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_basenc"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_basenc+default-devel \
 rust-uu_basenc-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_basenc-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "627375ca73a0a6baca0adf07e87dfaac105f1629e2859d038f4f7a5b59c58905"

URI_x86_64_v2_rust-uu_basenc+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_basenc+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_basenc+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_basenc+default-devel}"
SRC_URI[x86_64_v2_rust-uu_basenc+default-devel.sha256sum] = "cbd69784d180aeb143bb46a49baa5263e6f8239187c09a3c6ae51c2afa066ad9"

URI_x86_64_v2_rust-uu_basenc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_basenc-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_basenc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_basenc-devel}"
SRC_URI[x86_64_v2_rust-uu_basenc-devel.sha256sum] = "2eb486a84ebe5bd642cf29297ffff60eb24c298bfb996170b81b72c6703bb08c"

URI_aarch64_rust-uu_basenc+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_basenc+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_basenc+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_basenc+default-devel}"
SRC_URI[aarch64_rust-uu_basenc+default-devel.sha256sum] = "d2b6d90811546d208fc8d8c1f1a760f8d935d384c8f29c3e4151ce61e48ad6d9"

URI_aarch64_rust-uu_basenc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_basenc-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_basenc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_basenc-devel}"
SRC_URI[aarch64_rust-uu_basenc-devel.sha256sum] = "0b8df15a0ae6f3d4dfed49535f9b9efb7d80983e263374071e3c6daf6c5c86fb"

RDEPENDS:rust-uu_basenc+default-devel = " \
 cargo \
 rust-uu_basenc-devel \
 "
RDEPENDS:rust-uu_basenc-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uu_base32+default-devel \
 rust-uucore+default-devel \
 rust-uucore+encoding-devel \
 "
