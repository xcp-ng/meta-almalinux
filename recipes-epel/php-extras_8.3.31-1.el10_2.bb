# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-extras"
PV = "8.3.31"
PR = "1.el10_2"
PACKAGES = " \
 php-pdo-dblib \
 php-pdo-firebird \
 php-pspell \
 php-sodium \
 php-tidy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-extras-8.3.31-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cd504e46f9a4d065e6158a97ce3ccbd3cc9f61707d813eb27c9c734ad1e23c1"

URI_x86_64_v2_php-pdo-dblib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pdo-dblib-8.3.31-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo-dblib}"
SRC_URI[x86_64_v2_php-pdo-dblib.sha256sum] = "6aeaf124291b5196d6dc1543cd8965a1e49e28cb91345b05f447815feaaf7015"

URI_x86_64_v2_php-pdo-firebird = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pdo-firebird-8.3.31-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pdo-firebird;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo-firebird}"
SRC_URI[x86_64_v2_php-pdo-firebird.sha256sum] = "607e379c882b6b7098d5bb2eb00e2aba7b1017aaffac21df56788bb9554e01d6"

URI_x86_64_v2_php-pspell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pspell-8.3.31-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pspell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pspell}"
SRC_URI[x86_64_v2_php-pspell.sha256sum] = "27770a560d5adf4f0c176750010ada7a0ea614528b49394c0b6841db24af0878"

URI_x86_64_v2_php-sodium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-sodium-8.3.31-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-sodium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-sodium}"
SRC_URI[x86_64_v2_php-sodium.sha256sum] = "5536a20655137045c338c0a4c0fa21e53d706b6342bfdf2d0097d5fa25a212bc"
RPROVIDES:php-sodium:x86_64_v2 = "virtual/php-sodium"

URI_x86_64_v2_php-tidy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-tidy-8.3.31-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-tidy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-tidy}"
SRC_URI[x86_64_v2_php-tidy.sha256sum] = "e31f885d56e4ffc571ca7961d7aabe8609a4650179f367f178e69c343677396e"

URI_aarch64_php-pdo-dblib = "${EPEL_MIRROR}/aarch64/Packages/p/php-pdo-dblib-8.3.31-1.el10_2.aarch64.rpm;name=aarch64_php-pdo-dblib;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo-dblib}"
SRC_URI[aarch64_php-pdo-dblib.sha256sum] = "301b5f8358705c1317ed38e10283f774ed9ca68ca2f3e59a08157572875df4b1"

URI_aarch64_php-pdo-firebird = "${EPEL_MIRROR}/aarch64/Packages/p/php-pdo-firebird-8.3.31-1.el10_2.aarch64.rpm;name=aarch64_php-pdo-firebird;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo-firebird}"
SRC_URI[aarch64_php-pdo-firebird.sha256sum] = "c4d646dd851f05ae0bfd99199c420a246e3093df147b31f123fcca0bc666b40b"

URI_aarch64_php-pspell = "${EPEL_MIRROR}/aarch64/Packages/p/php-pspell-8.3.31-1.el10_2.aarch64.rpm;name=aarch64_php-pspell;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pspell}"
SRC_URI[aarch64_php-pspell.sha256sum] = "28b8680b75639e452ab382962c42249c884af70cfb731f2f6a103bdbc4fe70a4"

URI_aarch64_php-sodium = "${EPEL_MIRROR}/aarch64/Packages/p/php-sodium-8.3.31-1.el10_2.aarch64.rpm;name=aarch64_php-sodium;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-sodium}"
SRC_URI[aarch64_php-sodium.sha256sum] = "3a7c3e7a2d81aeb942361fc827cde777c50c2575905427302778921bb50ec065"
RPROVIDES:php-sodium:aarch64 = "virtual/php-sodium"

URI_aarch64_php-tidy = "${EPEL_MIRROR}/aarch64/Packages/p/php-tidy-8.3.31-1.el10_2.aarch64.rpm;name=aarch64_php-tidy;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-tidy}"
SRC_URI[aarch64_php-tidy.sha256sum] = "002a5ade5f8d137c85f2ff294a2b0ca90fdb0443e1284cb6862cb9440e8e2f69"

RDEPENDS:php-pdo-dblib = " \
 freetds-libs \
 glibc \
 php-common \
 php-pdo \
 "
RDEPENDS:php-pdo-firebird = " \
 glibc \
 libfbclient2 \
 php-common \
 php-pdo \
 "
RDEPENDS:php-pspell = " \
 aspell \
 glibc \
 php-common \
 "
RDEPENDS:php-sodium = " \
 glibc \
 libsodium \
 php-common \
 "
RDEPENDS:php-tidy = " \
 glibc \
 libtidy \
 php-common \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/php-sodium"

PROVIDES:append:aarch64 = " rpm/virtual/php-sodium"
