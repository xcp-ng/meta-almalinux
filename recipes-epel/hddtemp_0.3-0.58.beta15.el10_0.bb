# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hddtemp"
PV = "0.3"
PR = "0.58.beta15.el10_0"
PACKAGES = " \
 hddtemp \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/hddtemp-0.3-0.58.beta15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48efe8bd883851f8b90333c6513183e0874d7d685e6a236816468db3823f66f0"

URI_x86_64_v2_hddtemp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hddtemp-0.3-0.58.beta15.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hddtemp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hddtemp}"
SRC_URI[x86_64_v2_hddtemp.sha256sum] = "e1efb846cccdcbdb429dbf77f5cac18bd6f66c245e9a7ac09b6642b75edd0e54"

URI_aarch64_hddtemp = "${EPEL_MIRROR}/aarch64/Packages/h/hddtemp-0.3-0.58.beta15.el10_0.aarch64.rpm;name=aarch64_hddtemp;unpack=0"
SRC_URI:append = " ${URI_aarch64_hddtemp}"
SRC_URI[aarch64_hddtemp.sha256sum] = "2a12116a70ee3b7c19b7166d64141281aefbfc7cafa65c704ad568cecf5be268"

RDEPENDS:hddtemp = " \
 bash \
 glibc \
 usermode \
 "
