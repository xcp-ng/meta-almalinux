# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konversation"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 konversation \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/konversation-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4a9b5e1fb20e7d77ae21f635f713f16e97afa0563e1a139b75912d99f296c3d3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konversation-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konversation;unpack=0"
SRC_URI[x86_64_v2_konversation.sha256sum] = "d92794c441aa4d8d6106077482350c44bcac4aded2fdad8b58280310eca2e935"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/konversation-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_konversation;unpack=0"
SRC_URI[aarch64_konversation.sha256sum] = "6fb22c67dd5d0f6c2a69343d1406354776a65d56e646031f0c593d1e4db997a1"

RDEPENDS:konversation = " \
 bash \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-ktextwidgets \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 libstdc++ \
 perl-interpreter \
 python3 \
 qca-qt6 \
 qca-qt6-ossl \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
