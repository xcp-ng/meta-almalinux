# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-maybe-rayon"
PV = "0.1.1"
PR = "4.el10_0"
PACKAGES = " \
 rust-maybe-rayon+default-devel \
 rust-maybe-rayon+rayon-devel \
 rust-maybe-rayon+threads-devel \
 rust-maybe-rayon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-maybe-rayon-0.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b2abbd78878f499b79c1197ac264d6d4ea67926c698da8cc6e7d0b7e84c2c5d5"

URI_x86_64_v2_rust-maybe-rayon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-rayon+default-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-rayon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-rayon+default-devel}"
SRC_URI[x86_64_v2_rust-maybe-rayon+default-devel.sha256sum] = "93f9298857ebb6c9bc486d2d9f68c0a2389fdb2bc45d251155419d369b691b9a"

URI_x86_64_v2_rust-maybe-rayon+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-rayon+rayon-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-rayon+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-rayon+rayon-devel}"
SRC_URI[x86_64_v2_rust-maybe-rayon+rayon-devel.sha256sum] = "a331cc131c01022b7ad794a2fdb808f520d8a9b733beb4ea30a39c76bb6998dc"

URI_x86_64_v2_rust-maybe-rayon+threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-rayon+threads-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-rayon+threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-rayon+threads-devel}"
SRC_URI[x86_64_v2_rust-maybe-rayon+threads-devel.sha256sum] = "1b4ee729c69c19b1324e9c658d414624ecf50bcc182933fade5e125ce1405a83"

URI_x86_64_v2_rust-maybe-rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-maybe-rayon-devel-0.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-maybe-rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-maybe-rayon-devel}"
SRC_URI[x86_64_v2_rust-maybe-rayon-devel.sha256sum] = "39d0fbd75104450abd49d6ab8bfaea0fbc0393e0d74d8e735047e3ad15d6887b"

URI_aarch64_rust-maybe-rayon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-rayon+default-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-maybe-rayon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-rayon+default-devel}"
SRC_URI[aarch64_rust-maybe-rayon+default-devel.sha256sum] = "101901a2ca2d8ae7ede4f0ee0a9f3c8c3849678ba264cc71d75c63962985747b"

URI_aarch64_rust-maybe-rayon+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-rayon+rayon-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-maybe-rayon+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-rayon+rayon-devel}"
SRC_URI[aarch64_rust-maybe-rayon+rayon-devel.sha256sum] = "35153622171c3255885172c3b40d6372248ac65a10087c6ffda724bbd74065c8"

URI_aarch64_rust-maybe-rayon+threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-rayon+threads-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-maybe-rayon+threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-rayon+threads-devel}"
SRC_URI[aarch64_rust-maybe-rayon+threads-devel.sha256sum] = "f367c6566e71404c9a0686f834dfb980edbe4e295f875bf6e0a2d9cac5b5e313"

URI_aarch64_rust-maybe-rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-maybe-rayon-devel-0.1.1-4.el10_0.noarch.rpm;name=aarch64_rust-maybe-rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-maybe-rayon-devel}"
SRC_URI[aarch64_rust-maybe-rayon-devel.sha256sum] = "1821cb23b8546f6e3ecb445cc78f435ebb006b60953e39dd87b65e83e2c6053b"

RDEPENDS:rust-maybe-rayon+default-devel = " \
 cargo \
 rust-maybe-rayon+threads-devel \
 rust-maybe-rayon-devel \
 "
RDEPENDS:rust-maybe-rayon+rayon-devel = " \
 cargo \
 rust-maybe-rayon-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-maybe-rayon+threads-devel = " \
 cargo \
 rust-maybe-rayon+rayon-devel \
 rust-maybe-rayon-devel \
 "
RDEPENDS:rust-maybe-rayon-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 "
