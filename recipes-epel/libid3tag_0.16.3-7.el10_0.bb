# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libid3tag"
PV = "0.16.3"
PR = "7.el10_0"
PACKAGES = " \
 libid3tag \
 libid3tag-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libid3tag-0.16.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "969e917c0d35e76ce7c88488961e086e4e728ea9878e46805f3eb52cede79477"

URI_x86_64_v2_libid3tag = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libid3tag-0.16.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libid3tag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libid3tag}"
SRC_URI[x86_64_v2_libid3tag.sha256sum] = "6ebcae51a5e0a9ce3b273eb386dd8cac8cad15e91dff61c1e0e8e78902b96d68"

URI_x86_64_v2_libid3tag-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libid3tag-devel-0.16.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libid3tag-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libid3tag-devel}"
SRC_URI[x86_64_v2_libid3tag-devel.sha256sum] = "c607f0a81aff7cbe4e8623cf5ba9a0e7ce72257c06731d48f5a1863cb5b4af4c"

URI_aarch64_libid3tag = "${EPEL_MIRROR}/aarch64/Packages/l/libid3tag-0.16.3-7.el10_0.aarch64.rpm;name=aarch64_libid3tag;unpack=0"
SRC_URI:append = " ${URI_aarch64_libid3tag}"
SRC_URI[aarch64_libid3tag.sha256sum] = "1203c3631fbc0f5366dc6c077ae0851d174f406f389b310c5bfe59f408bd30a9"

URI_aarch64_libid3tag-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libid3tag-devel-0.16.3-7.el10_0.aarch64.rpm;name=aarch64_libid3tag-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libid3tag-devel}"
SRC_URI[aarch64_libid3tag-devel.sha256sum] = "ef95fbfa157dbe03c1e7c373421ac2e21a3f365eaed032f1d72d82d9169297bd"

RDEPENDS:libid3tag = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:libid3tag-devel = " \
 cmake-filesystem \
 libid3tag \
 pkgconf-pkg-config \
 "
