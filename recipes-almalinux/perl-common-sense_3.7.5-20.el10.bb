# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-common-sense"
PV = "3.7.5"
PR = "20.el10"
PACKAGES = " \
 perl-common-sense \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-common-sense-3.7.5-20.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "711da0a1b0162da3b1fa4562c1546b788a411da859d68afd82addcda66c0b829"

URI_x86_64_v2_perl-common-sense = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-common-sense-3.7.5-20.el10.x86_64_v2.rpm;name=x86_64_v2_perl-common-sense;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-common-sense}"
SRC_URI[x86_64_v2_perl-common-sense.sha256sum] = "2ff023d19e2f0c859f7afaf77c9e9d65c1217659a18ae149325d4c4df078dae8"

URI_aarch64_perl-common-sense = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-common-sense-3.7.5-20.el10.aarch64.rpm;name=aarch64_perl-common-sense;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-common-sense}"
SRC_URI[aarch64_perl-common-sense.sha256sum] = "9e8d5afeccba3202d299dd7424000912f5f1c832f772e059f8452e4aaf520c02"

RDEPENDS:perl-common-sense = " \
 perl-libs \
 "
