# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-shell-extension-forge"
PV = "89"
PR = "1.el10_2"
PACKAGES = " \
 gnome-shell-extension-forge \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-shell-extension-forge-89-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b986397dda0e5d32c320164aa3a1694313964556862ffabfca03c739d22c5f4d"

URI_x86_64_v2_gnome-shell-extension-forge = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-shell-extension-forge-89-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-shell-extension-forge;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-shell-extension-forge}"
SRC_URI[x86_64_v2_gnome-shell-extension-forge.sha256sum] = "2a889491c396c8b0a898b32a2b9fb30aef3e6e587a293cba2e42b11b21da8b33"

URI_aarch64_gnome-shell-extension-forge = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-shell-extension-forge-89-1.el10_2.noarch.rpm;name=aarch64_gnome-shell-extension-forge;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-shell-extension-forge}"
SRC_URI[aarch64_gnome-shell-extension-forge.sha256sum] = "e030c774bfca07c5aef4443d78e1f54d323fd2148f6e602417a240a85a0b750d"

RDEPENDS:gnome-shell-extension-forge = " \
 gnome-shell \
 "
