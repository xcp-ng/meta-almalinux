# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Text-Password-Pronounceable"
PV = "0.30"
PR = "41.el10_2"
PACKAGES = " \
 perl-Text-Password-Pronounceable \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Text-Password-Pronounceable-0.30-41.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2af1886f8c91f4762dc608fa185744995bec1965f83538a82197a6f5ed082a2e"

URI_x86_64_v2_perl-Text-Password-Pronounceable = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Text-Password-Pronounceable-0.30-41.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Text-Password-Pronounceable;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Text-Password-Pronounceable}"
SRC_URI[x86_64_v2_perl-Text-Password-Pronounceable.sha256sum] = "2970aa8374a653fac257354d4fb7549e3fb2ea49f8794d66f58f0be71f229953"

URI_aarch64_perl-Text-Password-Pronounceable = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Text-Password-Pronounceable-0.30-41.el10_2.noarch.rpm;name=aarch64_perl-Text-Password-Pronounceable;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Text-Password-Pronounceable}"
SRC_URI[aarch64_perl-Text-Password-Pronounceable.sha256sum] = "b5600c03d3cd81fc292c4f574bef611c0d198e7f38face3f2116c4acabe9f3f5"

RDEPENDS:perl-Text-Password-Pronounceable = " \
 perl-Carp \
 perl-libs \
 "
