# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mimedefang"
PV = "3.7.1"
PR = "1.el10_2"
PACKAGES = " \
 mimedefang \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mimedefang-3.7.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a8ea76ea77f5f7ca74660033bfc8ed5745d834386ea253639d9ffe698ab5393b"

URI_x86_64_v2_mimedefang = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mimedefang-3.7.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mimedefang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mimedefang}"
SRC_URI[x86_64_v2_mimedefang.sha256sum] = "6a142f347691b61c12d2b7291c7cfe3b7d8f78ccb0bbf694e5172deb9462863e"

URI_aarch64_mimedefang = "${EPEL_MIRROR}/aarch64/Packages/m/mimedefang-3.7.1-1.el10_2.aarch64.rpm;name=aarch64_mimedefang;unpack=0"
SRC_URI:append = " ${URI_aarch64_mimedefang}"
SRC_URI[aarch64_mimedefang.sha256sum] = "f1c712cd57cc33a291e1653a2fdbe60edb68acbf736630eb65e3a704a501d861"

RDEPENDS:mimedefang = " \
 bash \
 glibc \
 mimedefang \
 perl-Carp \
 perl-Data-Dumper \
 perl-Digest-SHA \
 perl-Errno \
 perl-Exporter \
 perl-File-Temp \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IO \
 perl-IO-Socket-SSL \
 perl-MIME-tools \
 perl-Mail-DKIM \
 perl-Mail-SPF \
 perl-Net-DNS \
 perl-PathTools \
 perl-Pod-Usage \
 perl-Socket \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-constant \
 perl-interpreter \
 perl-lib \
 perl-libs \
 sendmail-milter \
 shadow-utils \
 systemd \
 "
