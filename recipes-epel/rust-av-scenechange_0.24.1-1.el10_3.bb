# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av-scenechange"
PV = "0.24.1"
PR = "1.el10_3"
PACKAGES = " \
 av-scenechange \
 rust-av-scenechange+asm-devel \
 rust-av-scenechange+binary-devel \
 rust-av-scenechange+cc-devel \
 rust-av-scenechange+clap-devel \
 rust-av-scenechange+console-devel \
 rust-av-scenechange+default-devel \
 rust-av-scenechange+devel-devel \
 rust-av-scenechange+fern-devel \
 rust-av-scenechange+libc-devel \
 rust-av-scenechange+nasm-rs-devel \
 rust-av-scenechange+serde-devel \
 rust-av-scenechange+serde_json-devel \
 rust-av-scenechange+serialize-devel \
 rust-av-scenechange+static_simd-devel \
 rust-av-scenechange+threading-devel \
 rust-av-scenechange+tracing-subscriber-devel \
 rust-av-scenechange-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av-scenechange-0.24.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d1881603f7068a6a6224ebb7436185fcbc6948b909cab0061d0b6edcb454aca"

URI_x86_64_v2_av-scenechange = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/av-scenechange-0.24.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_av-scenechange;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_av-scenechange}"
SRC_URI[x86_64_v2_av-scenechange.sha256sum] = "d47e11474a7b229deab5091a91b6bc0c3fd1bcbe1e2a84e42d35ff9f2586e437"

URI_x86_64_v2_rust-av-scenechange+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+asm-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+asm-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+asm-devel.sha256sum] = "e7ca1f9ddf75bce4f2d34db2fb9c404eb32250aaf5affdb754b45314d6acb69a"

URI_x86_64_v2_rust-av-scenechange+binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+binary-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+binary-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+binary-devel.sha256sum] = "bb6f6fde281cc823cb668a3591ec133f12f9caac7a3722fbaff95c6f55ae21dd"

URI_x86_64_v2_rust-av-scenechange+cc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+cc-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+cc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+cc-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+cc-devel.sha256sum] = "f308e8612117fbd14fd62e1ba889b459e948b8c196245bb7f985308b59e94c5b"

URI_x86_64_v2_rust-av-scenechange+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+clap-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+clap-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+clap-devel.sha256sum] = "966b503d7a779d74ea6df39f27c9dd761cc8750edb82341f2ed6497e94010ef8"

URI_x86_64_v2_rust-av-scenechange+console-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+console-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+console-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+console-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+console-devel.sha256sum] = "b4cbf6f2b36399ddbe58579ff760a7abff4eb2fb13456b9104b974c75cf3ffe7"

URI_x86_64_v2_rust-av-scenechange+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+default-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+default-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+default-devel.sha256sum] = "a2fccf4a5a7bff21edad48e6641801ee65bc18cc05fc1ebb7745e5f9ca7924e9"

URI_x86_64_v2_rust-av-scenechange+devel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+devel-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+devel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+devel-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+devel-devel.sha256sum] = "32b1108fdf1952f68a39828c41e4e2ba9848a75abde8ee33dd645d31df596d02"

URI_x86_64_v2_rust-av-scenechange+fern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+fern-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+fern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+fern-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+fern-devel.sha256sum] = "4f4ab9b4971b8f4d1d0528ec74d712194bcd2ad7933fb36727c5a5f58dfde503"

URI_x86_64_v2_rust-av-scenechange+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+libc-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+libc-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+libc-devel.sha256sum] = "ba762ee8476b1f6f0f509b6cb1a8d06060ef5d6f765237a8167eff994fa71502"

URI_x86_64_v2_rust-av-scenechange+nasm-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+nasm-rs-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+nasm-rs-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+nasm-rs-devel.sha256sum] = "fce35d8eb778549150eed833b05b4de23c04b98a052710f66559908964e2f0ee"

URI_x86_64_v2_rust-av-scenechange+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+serde-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+serde-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+serde-devel.sha256sum] = "6c118c2f96b293da2ef805cf554e1867fa8e3244ad27e5ba9f2c7ac3a9ab6a3a"

URI_x86_64_v2_rust-av-scenechange+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+serde_json-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+serde_json-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+serde_json-devel.sha256sum] = "dc7e9281efc29fa958c767212274fa56344fbe87fefbe0609bd15969f52ac574"

URI_x86_64_v2_rust-av-scenechange+serialize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+serialize-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+serialize-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+serialize-devel.sha256sum] = "e61e90df4088c526c9c06f51146461e37af9b72f9518027d463f13a37dbc38f4"

URI_x86_64_v2_rust-av-scenechange+static_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+static_simd-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+static_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+static_simd-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+static_simd-devel.sha256sum] = "d5f0c065180d99061e969cc3cb60e175e759822f0c0c033bcdf8424b36ff1ff6"

URI_x86_64_v2_rust-av-scenechange+threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+threading-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+threading-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+threading-devel.sha256sum] = "62e1fc977496db59c5b521f92355feb4af30b32d8d62ce904f5174377ee78918"

URI_x86_64_v2_rust-av-scenechange+tracing-subscriber-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange+tracing-subscriber-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange+tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange+tracing-subscriber-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange+tracing-subscriber-devel.sha256sum] = "68118d03aa98f961b5a6a68a33c51fca778aca3b2a758ed728cbb7b02c2eca12"

URI_x86_64_v2_rust-av-scenechange-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-scenechange-devel-0.24.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-scenechange-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-scenechange-devel}"
SRC_URI[x86_64_v2_rust-av-scenechange-devel.sha256sum] = "f6e705d36f9e9f2f563ddcea6d2756f537e527cacf878c9c71209debb1d79711"

URI_aarch64_av-scenechange = "${EPEL_MIRROR}/aarch64/Packages/a/av-scenechange-0.24.1-1.el10_3.aarch64.rpm;name=aarch64_av-scenechange;unpack=0"
SRC_URI:append = " ${URI_aarch64_av-scenechange}"
SRC_URI[aarch64_av-scenechange.sha256sum] = "8600e493f22a3bef3a01d73ae96e27952f0ac988700794e315648ce2d43fb611"

URI_aarch64_rust-av-scenechange+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+asm-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+asm-devel}"
SRC_URI[aarch64_rust-av-scenechange+asm-devel.sha256sum] = "2a316b999769ea788a1d87b0783a61f665aed30a21745f27546be1a5a5c16d19"

URI_aarch64_rust-av-scenechange+binary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+binary-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+binary-devel}"
SRC_URI[aarch64_rust-av-scenechange+binary-devel.sha256sum] = "9a71dd1f2bbd3c332b325a4d2e10e96382e479fa555920da97addb1f5d47bd02"

URI_aarch64_rust-av-scenechange+cc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+cc-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+cc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+cc-devel}"
SRC_URI[aarch64_rust-av-scenechange+cc-devel.sha256sum] = "9a50e31716b1f7a502e115637f5b833a5b6fc4b5cd1d114ba66b4589ba391672"

URI_aarch64_rust-av-scenechange+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+clap-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+clap-devel}"
SRC_URI[aarch64_rust-av-scenechange+clap-devel.sha256sum] = "85b11402125119e0988d7b3a3d34665510df4f5356091c2cb855938734bbb03b"

URI_aarch64_rust-av-scenechange+console-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+console-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+console-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+console-devel}"
SRC_URI[aarch64_rust-av-scenechange+console-devel.sha256sum] = "5259477d6eaf9b70d8a909bb44b59cdbb5be439326f7e0eed657bccfda0021b2"

URI_aarch64_rust-av-scenechange+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+default-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+default-devel}"
SRC_URI[aarch64_rust-av-scenechange+default-devel.sha256sum] = "abf79c046928b5821449e4137d052d686d22ff40c330e80d91c9d09b9c93ac75"

URI_aarch64_rust-av-scenechange+devel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+devel-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+devel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+devel-devel}"
SRC_URI[aarch64_rust-av-scenechange+devel-devel.sha256sum] = "dc01db8756a5098afb84a3d3a10431496d0a5d8ebdfce5b193a53a49d5b7d211"

URI_aarch64_rust-av-scenechange+fern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+fern-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+fern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+fern-devel}"
SRC_URI[aarch64_rust-av-scenechange+fern-devel.sha256sum] = "7c902865b1da3b912da78a1357adbcbc06921ad090d7c59aec7fc46ed7891c2e"

URI_aarch64_rust-av-scenechange+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+libc-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+libc-devel}"
SRC_URI[aarch64_rust-av-scenechange+libc-devel.sha256sum] = "8e156d6e7640ac9816c36c9f874ca1dc89d0277057a4d1134156e3530ba7b33f"

URI_aarch64_rust-av-scenechange+nasm-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+nasm-rs-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+nasm-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+nasm-rs-devel}"
SRC_URI[aarch64_rust-av-scenechange+nasm-rs-devel.sha256sum] = "0306075962eb0bd40202188e07759888045ff354671cafb66b651a599fe0ac7d"

URI_aarch64_rust-av-scenechange+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+serde-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+serde-devel}"
SRC_URI[aarch64_rust-av-scenechange+serde-devel.sha256sum] = "f950735f3ecf7eec78ebc2cebeedc9c3ad6efa00ff0fdcc8e464625b1f1a4622"

URI_aarch64_rust-av-scenechange+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+serde_json-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+serde_json-devel}"
SRC_URI[aarch64_rust-av-scenechange+serde_json-devel.sha256sum] = "01f847618de1fcddfbe3c9adbb6cc4205317a2fc901109a5a142377587908d5e"

URI_aarch64_rust-av-scenechange+serialize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+serialize-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+serialize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+serialize-devel}"
SRC_URI[aarch64_rust-av-scenechange+serialize-devel.sha256sum] = "98c3e89d3aaf78782b60ec09ffc87777b6d58b65578da050e13bd0ec8d2d17fe"

URI_aarch64_rust-av-scenechange+static_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+static_simd-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+static_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+static_simd-devel}"
SRC_URI[aarch64_rust-av-scenechange+static_simd-devel.sha256sum] = "162419b9cda6f5e88ac1e9a2f13aefc26b4461b3f9076cf964a7807830282ccf"

URI_aarch64_rust-av-scenechange+threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+threading-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+threading-devel}"
SRC_URI[aarch64_rust-av-scenechange+threading-devel.sha256sum] = "dbd976747101eaa0eb0cfdd9f4df76e5efdaac76711732348203368f3b577956"

URI_aarch64_rust-av-scenechange+tracing-subscriber-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange+tracing-subscriber-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange+tracing-subscriber-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange+tracing-subscriber-devel}"
SRC_URI[aarch64_rust-av-scenechange+tracing-subscriber-devel.sha256sum] = "601ed64a1fe925ff628dc0a0319f445476bf89a8d032f9eae6b5b787a88f653e"

URI_aarch64_rust-av-scenechange-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-scenechange-devel-0.24.1-1.el10_3.noarch.rpm;name=aarch64_rust-av-scenechange-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-scenechange-devel}"
SRC_URI[aarch64_rust-av-scenechange-devel.sha256sum] = "b42d57f2623c2c13da31c66c7855e15434f0aa172e4d49f1f5b58af5146421e9"

RDEPENDS:av-scenechange = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-av-scenechange+asm-devel = " \
 cargo \
 rust-av-scenechange+cc-devel \
 rust-av-scenechange+libc-devel \
 rust-av-scenechange+nasm-rs-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+binary-devel = " \
 cargo \
 rust-av-scenechange+clap-devel \
 rust-av-scenechange+serialize-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+cc-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 "
RDEPENDS:rust-av-scenechange+clap-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-clap+default-devel \
 rust-clap+derive-devel \
 "
RDEPENDS:rust-av-scenechange+console-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-console+default-devel \
 "
RDEPENDS:rust-av-scenechange+default-devel = " \
 cargo \
 rust-av-scenechange+asm-devel \
 rust-av-scenechange+binary-devel \
 rust-av-scenechange+threading-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+devel-devel = " \
 cargo \
 rust-av-scenechange+console-devel \
 rust-av-scenechange+fern-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+fern-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-fern+default-devel \
 "
RDEPENDS:rust-av-scenechange+libc-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-av-scenechange+nasm-rs-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-nasm-rs+default-devel \
 rust-nasm-rs+parallel-devel \
 "
RDEPENDS:rust-av-scenechange+serde-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-av-scenechange+serde_json-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-av-scenechange+serialize-devel = " \
 cargo \
 rust-av-scenechange+serde-devel \
 rust-av-scenechange+serde_json-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+static_simd-devel = " \
 cargo \
 rust-av-scenechange+asm-devel \
 rust-av-scenechange-devel \
 "
RDEPENDS:rust-av-scenechange+threading-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-maybe-rayon+threads-devel \
 "
RDEPENDS:rust-av-scenechange+tracing-subscriber-devel = " \
 cargo \
 rust-av-scenechange-devel \
 rust-tracing-subscriber+default-devel \
 "
RDEPENDS:rust-av-scenechange-devel = " \
 cargo \
 rust \
 rust-aligned+default-devel \
 rust-anyhow+default-devel \
 rust-arrayvec+default-devel \
 rust-av-decoders+default-devel \
 rust-cfg-if+default-devel \
 rust-cpufeatures+default-devel \
 rust-log+default-devel \
 rust-maybe-rayon-devel \
 rust-num-rational-devel \
 rust-num-traits+default-devel \
 rust-v_frame+default-devel \
 rust-v_frame+padding_api-devel \
 rust-y4m+default-devel \
 "
