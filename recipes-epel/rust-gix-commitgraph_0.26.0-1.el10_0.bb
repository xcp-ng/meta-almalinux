# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-commitgraph"
PV = "0.26.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-gix-commitgraph+default-devel \
 rust-gix-commitgraph+document-features-devel \
 rust-gix-commitgraph+serde-devel \
 rust-gix-commitgraph-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-commitgraph-0.26.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "21574dcf8e4cec066cc0405798939222fb41716a24a09761400fe5d4fb6d5354"

URI_x86_64_v2_rust-gix-commitgraph+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+default-devel-0.26.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+default-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+default-devel.sha256sum] = "4ba5a8551e4d0071c9e9363332439890e00063473e187c547ea89e6bd2fcac65"

URI_x86_64_v2_rust-gix-commitgraph+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+document-features-devel-0.26.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+document-features-devel.sha256sum] = "dd46d9277cf0760018bb33c5300360c5a94bffb9bfae62bfbea08bd1d72d6cd5"

URI_x86_64_v2_rust-gix-commitgraph+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph+serde-devel-0.26.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph+serde-devel.sha256sum] = "add7355d45d180ccaa9f5c6136b9afeb18c9ed220db8768590e0e8c3349942d4"

URI_x86_64_v2_rust-gix-commitgraph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-commitgraph-devel-0.26.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-commitgraph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-commitgraph-devel}"
SRC_URI[x86_64_v2_rust-gix-commitgraph-devel.sha256sum] = "3ef01d909078b673cf91de4f754aac81fc28a51ebec56eeb31faa9321f13b8d1"

URI_aarch64_rust-gix-commitgraph+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+default-devel-0.26.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-commitgraph+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+default-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+default-devel.sha256sum] = "5a9ae5a53bc6e8291f9dc4e4007fc1c7a697f295526c154228a49ddab1a8e724"

URI_aarch64_rust-gix-commitgraph+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+document-features-devel-0.26.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-commitgraph+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+document-features-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+document-features-devel.sha256sum] = "b93c9bb8ba3bae2d1d98e2d8a572bc51aa0cb3b29d6b660dd2a8bc55bfa28ba3"

URI_aarch64_rust-gix-commitgraph+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph+serde-devel-0.26.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-commitgraph+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph+serde-devel}"
SRC_URI[aarch64_rust-gix-commitgraph+serde-devel.sha256sum] = "0ed371128154e421f6b39c1f1fcdbdfb44f2face462df65f193ccad63626f6a6"

URI_aarch64_rust-gix-commitgraph-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-commitgraph-devel-0.26.0-1.el10_0.noarch.rpm;name=aarch64_rust-gix-commitgraph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-commitgraph-devel}"
SRC_URI[aarch64_rust-gix-commitgraph-devel.sha256sum] = "2b71ccba6490cc004dfe2fc9baad592cf760e9fd0105f91ab2396d7c14c03f85"

RDEPENDS:rust-gix-commitgraph+default-devel = " \
 cargo \
 rust-gix-commitgraph-devel \
 "
RDEPENDS:rust-gix-commitgraph+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-commitgraph-devel \
 "
RDEPENDS:rust-gix-commitgraph+serde-devel = " \
 cargo \
 rust-bstr+serde-devel \
 rust-gix-commitgraph-devel \
 rust-gix-hash+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-commitgraph-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-chunk+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+rustsha1-devel \
 rust-gix-hash+default-devel \
 rust-memmap2+default-devel \
 rust-thiserror+default-devel \
 "
