# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-primal-check"
PV = "0.3.4"
PR = "3.el10_0"
PACKAGES = " \
 rust-primal-check+default-devel \
 rust-primal-check+unstable-devel \
 rust-primal-check-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-primal-check-0.3.4-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af68d6e3a339bee326eea871e52e11f7ac6be08b54e668957d49b6761ce0f29e"

URI_x86_64_v2_rust-primal-check+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primal-check+default-devel-0.3.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primal-check+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primal-check+default-devel}"
SRC_URI[x86_64_v2_rust-primal-check+default-devel.sha256sum] = "a9d6bcf786ac9384544704e01b57ab2be65eabefba24d9c9b13c45be5ffc02d3"

URI_x86_64_v2_rust-primal-check+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primal-check+unstable-devel-0.3.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primal-check+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primal-check+unstable-devel}"
SRC_URI[x86_64_v2_rust-primal-check+unstable-devel.sha256sum] = "caef56a80b064151f28164e1450abff682aaf9bccae001e7b4f0e55dca1dbb48"

URI_x86_64_v2_rust-primal-check-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-primal-check-devel-0.3.4-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-primal-check-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-primal-check-devel}"
SRC_URI[x86_64_v2_rust-primal-check-devel.sha256sum] = "1c978b4b4e25fd95d73d66cf3cf39930ead682a0e9fbf4033f54cb8151316e5f"

URI_aarch64_rust-primal-check+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primal-check+default-devel-0.3.4-3.el10_0.noarch.rpm;name=aarch64_rust-primal-check+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primal-check+default-devel}"
SRC_URI[aarch64_rust-primal-check+default-devel.sha256sum] = "2a13eeda3313e14079ca8184d02643bce9adf23a791ada87ee6e64da10a59a26"

URI_aarch64_rust-primal-check+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primal-check+unstable-devel-0.3.4-3.el10_0.noarch.rpm;name=aarch64_rust-primal-check+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primal-check+unstable-devel}"
SRC_URI[aarch64_rust-primal-check+unstable-devel.sha256sum] = "7f31c7e184dec42275bd9ad4b819c0e5b18c553bd95f280d896b2e1f7953d800"

URI_aarch64_rust-primal-check-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-primal-check-devel-0.3.4-3.el10_0.noarch.rpm;name=aarch64_rust-primal-check-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-primal-check-devel}"
SRC_URI[aarch64_rust-primal-check-devel.sha256sum] = "61d62c8310eadef94327b850bbeeceda4995b1ea3793489c781dc2b33140165a"

RDEPENDS:rust-primal-check+default-devel = " \
 cargo \
 rust-primal-check-devel \
 "
RDEPENDS:rust-primal-check+unstable-devel = " \
 cargo \
 rust-primal-check-devel \
 "
RDEPENDS:rust-primal-check-devel = " \
 cargo \
 rust-num-integer+default-devel \
 "
