# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rich"
PV = "13.9.4"
PR = "1.el10_0"
PACKAGES = " \
 python3-rich \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rich-13.9.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6863b4e3412ec2b6aefff67f21e95b874da3683d4fe179c0b24d9ea85003d744"

URI_x86_64_v2_python3-rich = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rich-13.9.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rich;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rich}"
SRC_URI[x86_64_v2_python3-rich.sha256sum] = "582435bf050d5e29708821b219b0bd3a9da668477c3729c0c26a1fbcf731ca6f"

URI_aarch64_python3-rich = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rich-13.9.4-1.el10_0.noarch.rpm;name=aarch64_python3-rich;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rich}"
SRC_URI[aarch64_python3-rich.sha256sum] = "e2cd003ec67e2d49b8f1571f2eb90699ba40f1f85724649bbd59269912b9bd96"

RDEPENDS:python3-rich = " \
 python3 \
 python3-markdown-it-py \
 python3-pygments \
 "
