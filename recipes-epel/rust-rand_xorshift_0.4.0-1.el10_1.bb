# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xorshift"
PV = "0.4.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-rand_xorshift+default-devel \
 rust-rand_xorshift+serde-devel \
 rust-rand_xorshift-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xorshift-0.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9e7f120043612ff7d755e1ba2306ea1088d53b6a868661fc1db13089a61998ef"

URI_x86_64_v2_rust-rand_xorshift+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift+default-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift+default-devel.sha256sum] = "0734fb3c0223365002197e6cb3cb69c3f79366c32647f7b093afd6ecf41f84cf"

URI_x86_64_v2_rust-rand_xorshift+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift+serde-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift+serde-devel.sha256sum] = "c3cb4a6588cbf4ca9e93f7a0e246f02cc5d04196f19af893791854eae2548ab3"

URI_x86_64_v2_rust-rand_xorshift-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xorshift-devel-0.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xorshift-devel}"
SRC_URI[x86_64_v2_rust-rand_xorshift-devel.sha256sum] = "8345240296f433d2289491a1db71c53bc58a56fe5b8ce9ad21e35a0b7fec1ae3"

URI_aarch64_rust-rand_xorshift+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift+default-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-rand_xorshift+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift+default-devel}"
SRC_URI[aarch64_rust-rand_xorshift+default-devel.sha256sum] = "27a9b3db450a0b0c67cc5226e4fb3155dcae02b3b9368d32152c8fb99011cdbe"

URI_aarch64_rust-rand_xorshift+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift+serde-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-rand_xorshift+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift+serde-devel}"
SRC_URI[aarch64_rust-rand_xorshift+serde-devel.sha256sum] = "a0095732e288d80c11134ec99313c270d2b681c1bea68ebfde90c2fe6b8ba2b5"

URI_aarch64_rust-rand_xorshift-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xorshift-devel-0.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-rand_xorshift-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xorshift-devel}"
SRC_URI[aarch64_rust-rand_xorshift-devel.sha256sum] = "c6db9156a3f691a156eded36a62a5181b3dafbb9235ccb64d93a273d5db6971b"

RDEPENDS:rust-rand_xorshift+default-devel = " \
 cargo \
 rust-rand_xorshift-devel \
 "
RDEPENDS:rust-rand_xorshift+serde-devel = " \
 cargo \
 rust-rand_xorshift-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-rand_xorshift-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
