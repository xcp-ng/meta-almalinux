# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kokkos"
PV = "5.1.1"
PR = "1.el10_3"
PACKAGES = " \
 kokkos \
 kokkos-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kokkos-5.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b3fa45fd9518e56835956fba1f3e044fc127483274d3cb50459cc3f072e15e9e"

URI_x86_64_v2_kokkos = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kokkos-5.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kokkos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kokkos}"
SRC_URI[x86_64_v2_kokkos.sha256sum] = "1e492d4e68b48991c297b616b768a56371134b44bcb0617e434b392c0ab72673"

URI_x86_64_v2_kokkos-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kokkos-devel-5.1.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kokkos-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kokkos-devel}"
SRC_URI[x86_64_v2_kokkos-devel.sha256sum] = "1aa4c07e2d4c6420eb889a3bf148f3fee4bc19ab9e7deaad91c8694bf2a003b5"

URI_aarch64_kokkos = "${EPEL_MIRROR}/aarch64/Packages/k/kokkos-5.1.1-1.el10_3.aarch64.rpm;name=aarch64_kokkos;unpack=0"
SRC_URI:append = " ${URI_aarch64_kokkos}"
SRC_URI[aarch64_kokkos.sha256sum] = "def1f0127cdb0c855e0b2dee99122dd0fa8e9506f08662a32422c59af3a5f4d1"

URI_aarch64_kokkos-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kokkos-devel-5.1.1-1.el10_3.aarch64.rpm;name=aarch64_kokkos-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kokkos-devel}"
SRC_URI[aarch64_kokkos-devel.sha256sum] = "48410ff99b3b784adf7735688906fc5c6903a3a5edfe542eff4a886d80ed6ee1"

RDEPENDS:kokkos = " \
 glibc \
 hwloc-libs \
 libgcc \
 libgomp \
 libstdc++ \
 "
RDEPENDS:kokkos-devel = " \
 bash \
 cmake-filesystem \
 hwloc-devel \
 kokkos \
 "
