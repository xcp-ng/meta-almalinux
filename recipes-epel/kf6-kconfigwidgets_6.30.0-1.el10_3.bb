# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kconfigwidgets"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kconfigwidgets \
 kf6-kconfigwidgets-devel \
 kf6-kconfigwidgets-doc \
 kf6-kconfigwidgets-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kconfigwidgets-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "41d576638ea837e028adae75486957a1e3839c6e71a80f5cb4b7e0ea818d8b09"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets;unpack=0"
SRC_URI[x86_64_v2_kf6-kconfigwidgets.sha256sum] = "4891c22e179ace5536389e4f614abd5f3386fd96fd295d2878ad793b77053a7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-devel.sha256sum] = "f363b34f43986cb0496baaac45ff88a6d247d396978765e9a8f5e9be7642fcfb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-doc.sha256sum] = "c0ebadaacf4419ca047ff13d7305ff4f183e48b9fbd0cb0c86bc81780d51f8d2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kconfigwidgets-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kconfigwidgets-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kconfigwidgets-html.sha256sum] = "5de317eb10c69f90a7850d8703f6d3ee06af7ef34d4c82ae94f025a8f1a78074"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kconfigwidgets;unpack=0"
SRC_URI[aarch64_kf6-kconfigwidgets.sha256sum] = "4faa615d24b0eed96f2b9576876f6cfe4af2adc908920ad5e10d0505fb85db11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kconfigwidgets-devel;unpack=0"
SRC_URI[aarch64_kf6-kconfigwidgets-devel.sha256sum] = "6f52cab6ad017f51dde28ea5032a0c0eb7bd674a345b98f7d982d2266d3dc7e6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kconfigwidgets-doc;unpack=0"
SRC_URI[aarch64_kf6-kconfigwidgets-doc.sha256sum] = "e4f169882a1a6d161edb93db901c92aeda7cdcebb5eadd38517d8f69d05fc30b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kconfigwidgets-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kconfigwidgets-html;unpack=0"
SRC_URI[aarch64_kf6-kconfigwidgets-html.sha256sum] = "48610faf6a07a405f2721250255b37696f2fe2f6bbeb7043edcb64f1130d159c"

RDEPENDS:kf6-kconfigwidgets = " \
 glibc \
 kf6-filesystem \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kauth-devel \
 kf6-kcodecs-devel \
 kf6-kcolorscheme-devel \
 kf6-kconfig-devel \
 kf6-kconfigwidgets \
 kf6-kwidgetsaddons-devel \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kconfigwidgets-doc = " \
 "
RDEPENDS:kf6-kconfigwidgets-html = " \
 "
