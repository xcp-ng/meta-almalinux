# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-watchfiles"
PV = "1.2.0"
PR = "3.el10_3"
PACKAGES = " \
 python3-watchfiles \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-watchfiles-1.2.0-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "756c66ff7bde8eb85e8d214c0bdf960ea084a9cd1e239353b3a9bddcb9dc833c"

URI_x86_64_v2_python3-watchfiles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-watchfiles-1.2.0-3.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-watchfiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-watchfiles}"
SRC_URI[x86_64_v2_python3-watchfiles.sha256sum] = "2a26576e5b0f36cacaa6ac395fd9b7b3c45a3c1f2ed9be8d7c68ed4fbc90c966"

URI_aarch64_python3-watchfiles = "${EPEL_MIRROR}/aarch64/Packages/p/python3-watchfiles-1.2.0-3.el10_3.aarch64.rpm;name=aarch64_python3-watchfiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-watchfiles}"
SRC_URI[aarch64_python3-watchfiles.sha256sum] = "2a50f702f42be870b7a098cb78ca263f751dde84251758b873076fac92afe4a6"

RDEPENDS:python3-watchfiles = " \
 glibc \
 libgcc \
 python3 \
 python3-anyio \
 "
