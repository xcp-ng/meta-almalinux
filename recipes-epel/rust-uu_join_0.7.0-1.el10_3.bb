# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_join"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_join+default-devel \
 rust-uu_join-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_join-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb7bbcc6536cc695275f56f6a8d2006eaf060812828a05c4ce569a35b761ce18"

URI_x86_64_v2_rust-uu_join+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_join+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_join+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_join+default-devel}"
SRC_URI[x86_64_v2_rust-uu_join+default-devel.sha256sum] = "1af684ce3498e580c794497c80126ea95cfdabf72fd21ba1919bc190f55f493d"

URI_x86_64_v2_rust-uu_join-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_join-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_join-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_join-devel}"
SRC_URI[x86_64_v2_rust-uu_join-devel.sha256sum] = "d14bf06e0c703db6634b9f17eceadd46f385759dfe359f91c0e5b5e266f3402b"

URI_aarch64_rust-uu_join+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_join+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_join+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_join+default-devel}"
SRC_URI[aarch64_rust-uu_join+default-devel.sha256sum] = "bdc72457e8bbc41755be622c15638f5d0f69df7b3aa39accfa0a0d3afaafcc5a"

URI_aarch64_rust-uu_join-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_join-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_join-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_join-devel}"
SRC_URI[aarch64_rust-uu_join-devel.sha256sum] = "267e375e728cd2915b874b7812ccb44c94854eb7e848d36309ff01f3179d192a"

RDEPENDS:rust-uu_join+default-devel = " \
 cargo \
 rust-uu_join-devel \
 "
RDEPENDS:rust-uu_join-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-memchr+default-devel \
 rust-thiserror+default-devel \
 rust-uucore+default-devel \
 rust-uucore+i18n-collator-devel \
 "
