# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nu-ansi-term"
PV = "0.50.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-nu-ansi-term+default-devel \
 rust-nu-ansi-term+derive_serde_style-devel \
 rust-nu-ansi-term+gnu_legacy-devel \
 rust-nu-ansi-term+serde-devel \
 rust-nu-ansi-term+std-devel \
 rust-nu-ansi-term-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-nu-ansi-term-0.50.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dfcb9b8fe1c5f01d9540bf569e88cea96edddd2d6bd94c85b4f5f5790c0b7ec5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+default-devel-0.50.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-nu-ansi-term+default-devel.sha256sum] = "605294f594911a12f5421aee5bd5e1324c3c169983716346ad2f581eabca00eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+derive_serde_style-devel-0.50.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel;unpack=0"
SRC_URI[x86_64_v2_rust-nu-ansi-term+derive_serde_style-devel.sha256sum] = "1e9cd6ef2e72c519822ded2cacef7deecf86cc6af92369b1461f938501a57e1e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+gnu_legacy-devel-0.50.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel;unpack=0"
SRC_URI[x86_64_v2_rust-nu-ansi-term+gnu_legacy-devel.sha256sum] = "39ce2f4915f08adc398624aa42d4afe273857ec0bfa18f31e915f9d9ebbc2ce1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+serde-devel-0.50.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-nu-ansi-term+serde-devel.sha256sum] = "4979faafe25361fb94883c6453a1e5385685e92ba4136ad9c1afd67dcf531e5a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term+std-devel-0.50.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-nu-ansi-term+std-devel.sha256sum] = "467f6f4721e62ed4887fa2b46cf7161f11ecb5e360ca54c455187571dd3147e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nu-ansi-term-devel-0.50.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nu-ansi-term-devel;unpack=0"
SRC_URI[x86_64_v2_rust-nu-ansi-term-devel.sha256sum] = "060f43eeb447ee1700f9801b43102bc79f9b66f5eaa5263edbc35cfca46f718d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+default-devel-0.50.3-1.el10_3.noarch.rpm;name=aarch64_rust-nu-ansi-term+default-devel;unpack=0"
SRC_URI[aarch64_rust-nu-ansi-term+default-devel.sha256sum] = "9727b384056583de8493732c00c94a6078f3882834dda3ba6a4745622ecc9672"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+derive_serde_style-devel-0.50.3-1.el10_3.noarch.rpm;name=aarch64_rust-nu-ansi-term+derive_serde_style-devel;unpack=0"
SRC_URI[aarch64_rust-nu-ansi-term+derive_serde_style-devel.sha256sum] = "b59222b973b1ce9d33438018e147a1b02429b253a4754930d6b776af111619a6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+gnu_legacy-devel-0.50.3-1.el10_3.noarch.rpm;name=aarch64_rust-nu-ansi-term+gnu_legacy-devel;unpack=0"
SRC_URI[aarch64_rust-nu-ansi-term+gnu_legacy-devel.sha256sum] = "f536db221a97340ecc7f9f420c41dc206e1397b7505e0e92126dce2d855ec865"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+serde-devel-0.50.3-1.el10_3.noarch.rpm;name=aarch64_rust-nu-ansi-term+serde-devel;unpack=0"
SRC_URI[aarch64_rust-nu-ansi-term+serde-devel.sha256sum] = "8fcf921e370bb7586e7d89cf9f7e9ab448027979aef461036e9c25e6a904160d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term+std-devel-0.50.3-1.el10_3.noarch.rpm;name=aarch64_rust-nu-ansi-term+std-devel;unpack=0"
SRC_URI[aarch64_rust-nu-ansi-term+std-devel.sha256sum] = "90c5031b4b7ac990936a21e15e3ab1d514388f86d6fb2aeab6d764324837e1b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-nu-ansi-term-devel-0.50.3-1.el10_3.noarch.rpm;name=aarch64_rust-nu-ansi-term-devel;unpack=0"
SRC_URI[aarch64_rust-nu-ansi-term-devel.sha256sum] = "fdd8b98c196727cf1e8b3ebc249b814e4cd0c80fb7425597ac7c237e43285d16"

RDEPENDS:rust-nu-ansi-term+default-devel = " \
 cargo \
 rust-nu-ansi-term+std-devel \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term+derive_serde_style-devel = " \
 cargo \
 rust-nu-ansi-term+serde-devel \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term+gnu_legacy-devel = " \
 cargo \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term+serde-devel = " \
 cargo \
 rust-nu-ansi-term-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-nu-ansi-term+std-devel = " \
 cargo \
 rust-nu-ansi-term-devel \
 "
RDEPENDS:rust-nu-ansi-term-devel = " \
 cargo \
 rust \
 "
