# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-zmq"
PV = "27.2.0"
PR = "1.el10_3"
PACKAGES = " \
 python3-pyzmq \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-zmq-27.2.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3e65e23eadc870504742a70433a4f461fec583803989fcbab4c27f9fdadb905e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyzmq-27.2.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyzmq;unpack=0"
SRC_URI[x86_64_v2_python3-pyzmq.sha256sum] = "1652eb003ee24785ef109919723b149e7403e9995c6ecbe2e79730b5dfeecf81"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pyzmq-27.2.0-1.el10_3.aarch64.rpm;name=aarch64_python3-pyzmq;unpack=0"
SRC_URI[aarch64_python3-pyzmq.sha256sum] = "b1d4e81284392d17c4c06d2a2990979bf5faf50898b08e7db69b7977885dd92e"

RDEPENDS:python3-pyzmq = " \
 glibc \
 python3 \
 zeromq \
 "
