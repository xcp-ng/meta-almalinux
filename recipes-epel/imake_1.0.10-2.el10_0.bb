# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "imake"
PV = "1.0.10"
PR = "2.el10_0"
PACKAGES = " \
 imake \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/imake-1.0.10-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f2b07943572dde9d9d26598f5e6cfd6cab366f10891a6029756df38764fbb436"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/imake-1.0.10-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_imake;unpack=0"
SRC_URI[x86_64_v2_imake.sha256sum] = "e2d95a07a4ec7afa0977a9d5a3317ee1e500ca57cb0b364432bd8886740d6154"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/imake-1.0.10-2.el10_0.aarch64.rpm;name=aarch64_imake;unpack=0"
SRC_URI[aarch64_imake.sha256sum] = "31dcd6502255a594634dad4a3eeedce391b84f0609c47ded03a3de5e5d2a32b3"

RDEPENDS:imake = " \
 bash \
 gcc \
 glibc \
 perl-interpreter \
 "
