# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXISF"
PV = "0.2.12"
PR = "2.el10_0"
PACKAGES = " \
 libXISF \
 libXISF-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libXISF-0.2.12-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5ac9311e0fa57ad9c65cd5ed11ea6f4c4e6da150f38b697e0d8b093280ad517d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXISF-0.2.12-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXISF;unpack=0"
SRC_URI[x86_64_v2_libXISF.sha256sum] = "c47676c44b0d669bc183befe0f6fba1ee8de2b1821ef77360902cdef05a4d72e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libXISF-devel-0.2.12-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libXISF-devel;unpack=0"
SRC_URI[x86_64_v2_libXISF-devel.sha256sum] = "6e7d0c34e6a4def2c133724ec8c801d5caca977e0a2a87e6ab888e733a593449"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libXISF-0.2.12-2.el10_0.aarch64.rpm;name=aarch64_libXISF;unpack=0"
SRC_URI[aarch64_libXISF.sha256sum] = "2a0c0673d537fb42945adda666d2460003de6ab3395dc26125ed0d029b2af33c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libXISF-devel-0.2.12-2.el10_0.aarch64.rpm;name=aarch64_libXISF-devel;unpack=0"
SRC_URI[aarch64_libXISF-devel.sha256sum] = "f5d2a552d3997a1df61811674fbc5c306ba0f12b080ac050f4ff4e39af64be38"

RDEPENDS:libXISF = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 pugixml \
 zlib-ng-compat \
 "
RDEPENDS:libXISF-devel = " \
 libXISF \
 lz4-devel \
 pkgconf-pkg-config \
 pugixml-devel \
 zlib-ng-compat-devel \
 "
