# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-ieee754"
PV = "0.8.0"
PR = "32.el10_0"
PACKAGES = " \
 ghc-ieee754 \
 ghc-ieee754-devel \
 ghc-ieee754-doc \
 ghc-ieee754-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-ieee754-0.8.0-32.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0a09e6e330cc06ed353b69638eec9f953228b0decafd422f47fed37f30d70e4"

URI_x86_64_v2_ghc-ieee754 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ieee754-0.8.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ieee754;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ieee754}"
SRC_URI[x86_64_v2_ghc-ieee754.sha256sum] = "fd42d1fdf492ec43ed288d4a338f872696ce88e8b916ccd9465f076300dc9bbb"

URI_x86_64_v2_ghc-ieee754-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ieee754-devel-0.8.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ieee754-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ieee754-devel}"
SRC_URI[x86_64_v2_ghc-ieee754-devel.sha256sum] = "97443c9e205a4951da78dee0252b4e3784135dd5b4f5ed1d168055d7ab98d557"

URI_x86_64_v2_ghc-ieee754-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ieee754-doc-0.8.0-32.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ieee754-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ieee754-doc}"
SRC_URI[x86_64_v2_ghc-ieee754-doc.sha256sum] = "675d5484bcc4d33c66d447aff86f15d3a25f2a29297316b40d64bf001c96b494"

URI_x86_64_v2_ghc-ieee754-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ieee754-prof-0.8.0-32.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ieee754-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-ieee754-prof}"
SRC_URI[x86_64_v2_ghc-ieee754-prof.sha256sum] = "830c94144b7c071f3c8f6093657786f809cbffa7dd9dd27e5c355e6f243b918c"

URI_aarch64_ghc-ieee754 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ieee754-0.8.0-32.el10_0.aarch64.rpm;name=aarch64_ghc-ieee754;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ieee754}"
SRC_URI[aarch64_ghc-ieee754.sha256sum] = "1eb11559243cee1ee152021337e558af7ac870e9cf5d4a9b9d4ee513763f9766"

URI_aarch64_ghc-ieee754-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ieee754-devel-0.8.0-32.el10_0.aarch64.rpm;name=aarch64_ghc-ieee754-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ieee754-devel}"
SRC_URI[aarch64_ghc-ieee754-devel.sha256sum] = "d6a730123e409666b8a8c1493cb36812306e19b652af2883d373a7cb7b28d2f0"

URI_aarch64_ghc-ieee754-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ieee754-doc-0.8.0-32.el10_0.noarch.rpm;name=aarch64_ghc-ieee754-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ieee754-doc}"
SRC_URI[aarch64_ghc-ieee754-doc.sha256sum] = "5e92a593b723542931d8521500ab541a5d19e756b436bbf1e81bb092dd28660e"

URI_aarch64_ghc-ieee754-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-ieee754-prof-0.8.0-32.el10_0.aarch64.rpm;name=aarch64_ghc-ieee754-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-ieee754-prof}"
SRC_URI[aarch64_ghc-ieee754-prof.sha256sum] = "6b5674219f0425d989142d9e1809811b8c7053678a4b3bb1e47090999e86d686"

RDEPENDS:ghc-ieee754 = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ieee754-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-ieee754 \
 "
RDEPENDS:ghc-ieee754-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ieee754-prof = " \
 ghc-base-prof \
 ghc-ieee754-devel \
 "
