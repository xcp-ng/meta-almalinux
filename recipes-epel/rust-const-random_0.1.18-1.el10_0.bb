# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-const-random"
PV = "0.1.18"
PR = "1.el10_0"
PACKAGES = " \
 rust-const-random+default-devel \
 rust-const-random-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-const-random-0.1.18-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "073d05e581dd4b2e13e9ad1c0a7d2411ff23d9c921f31a5a587229ea6cfa0dc4"

URI_x86_64_v2_rust-const-random+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-random+default-devel-0.1.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-random+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-random+default-devel}"
SRC_URI[x86_64_v2_rust-const-random+default-devel.sha256sum] = "155ef1da2119a602fb05e14550536a25c472b6d98f67ac7e46ad6493af6ba703"

URI_x86_64_v2_rust-const-random-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-random-devel-0.1.18-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-random-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-random-devel}"
SRC_URI[x86_64_v2_rust-const-random-devel.sha256sum] = "80d6bc45c17b83fd412347d0173beaab7eebe711eb0f4b2d41220defa616e37e"

URI_aarch64_rust-const-random+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-random+default-devel-0.1.18-1.el10_0.noarch.rpm;name=aarch64_rust-const-random+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-random+default-devel}"
SRC_URI[aarch64_rust-const-random+default-devel.sha256sum] = "453b55638c7e1b98b1ffc071f97d0f0c1e19894db57cf41727d9b710da4d4943"

URI_aarch64_rust-const-random-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-random-devel-0.1.18-1.el10_0.noarch.rpm;name=aarch64_rust-const-random-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-random-devel}"
SRC_URI[aarch64_rust-const-random-devel.sha256sum] = "847bc97aec72879daf083adeb97cc785f5f0f58e345e0772e7221b0f2065b269"

RDEPENDS:rust-const-random+default-devel = " \
 cargo \
 rust-const-random-devel \
 "
RDEPENDS:rust-const-random-devel = " \
 cargo \
 rust-const-random-macro+default-devel \
 "
