# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua-socket"
PV = "3.1.0"
PR = "6.el10_0"
PACKAGES = " \
 lua-socket \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lua-socket-3.1.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fbff3206bc7609a4a82a367d98da88e124bb8323652a476ea0d554a24c21204"

URI_x86_64_v2_lua-socket = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lua-socket-3.1.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lua-socket;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-socket}"
SRC_URI[x86_64_v2_lua-socket.sha256sum] = "bb9d587ebff18281b27c205e6ca90bfd062275c581680a723c356a7c5005b667"

URI_aarch64_lua-socket = "${EPEL_MIRROR}/aarch64/Packages/l/lua-socket-3.1.0-6.el10_0.aarch64.rpm;name=aarch64_lua-socket;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-socket}"
SRC_URI[aarch64_lua-socket.sha256sum] = "516f118dda3c39b5ec2c4b7bd27b3284f888d7a1e60b00a413cc20f081e15d5e"

RDEPENDS:lua-socket = " \
 glibc \
 lua-libs \
 "
