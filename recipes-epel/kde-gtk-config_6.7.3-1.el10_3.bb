# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-gtk-config"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 kde-gtk-config \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-gtk-config-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9cfd3c219e20b87562572846536534b3cbb23348adb3b686baaf265d314e930"

URI_x86_64_v2_kde-gtk-config = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-gtk-config-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-gtk-config;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-gtk-config}"
SRC_URI[x86_64_v2_kde-gtk-config.sha256sum] = "d3b66dcbb0528c53d6bcb3431c1b82c07cf42e0756c47be1976b59b724826f2d"

URI_aarch64_kde-gtk-config = "${EPEL_MIRROR}/aarch64/Packages/k/kde-gtk-config-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_kde-gtk-config;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-gtk-config}"
SRC_URI[aarch64_kde-gtk-config.sha256sum] = "acccaae3deea71c425847cce6b59574412cdb043a067ffa2152854c9a1d3d19c"

RDEPENDS:kde-gtk-config = " \
 bash \
 breeze-gtk-common \
 glib2 \
 glibc \
 gtk3 \
 kde-cli-tools \
 kdecoration \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
