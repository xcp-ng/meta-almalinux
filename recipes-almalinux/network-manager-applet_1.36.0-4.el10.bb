# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "network-manager-applet"
PV = "1.36.0"
PR = "4.el10"
PACKAGES = " \
 network-manager-applet \
 nm-connection-editor \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/network-manager-applet-1.36.0-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f7c3b7618745b5a56aca836b86288f7c19cb6ae60851d0e56842650b627c06c0"

URI_x86_64_v2_network-manager-applet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/network-manager-applet-1.36.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_network-manager-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_network-manager-applet}"
SRC_URI[x86_64_v2_network-manager-applet.sha256sum] = "c64fbd1ead7a486135164026859c9cf793e3f3ceac8f68f286d26083961d72fe"

URI_x86_64_v2_nm-connection-editor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nm-connection-editor-1.36.0-4.el10.x86_64_v2.rpm;name=x86_64_v2_nm-connection-editor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nm-connection-editor}"
SRC_URI[x86_64_v2_nm-connection-editor.sha256sum] = "c12bad29e3f8d1cb560a70af8d94db6c155cb9cbc283cff5129c037b6c25da0d"

URI_aarch64_network-manager-applet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/network-manager-applet-1.36.0-4.el10.aarch64.rpm;name=aarch64_network-manager-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_network-manager-applet}"
SRC_URI[aarch64_network-manager-applet.sha256sum] = "e6fcf6008bf960b19e42cd10e0d3a14f815fb734367d5a18e0f10fc3b0883ea6"

URI_aarch64_nm-connection-editor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nm-connection-editor-1.36.0-4.el10.aarch64.rpm;name=aarch64_nm-connection-editor;unpack=0"
SRC_URI:append = " ${URI_aarch64_nm-connection-editor}"
SRC_URI[aarch64_nm-connection-editor.sha256sum] = "cd7beb66ecb2e57c9a683bc20c7f429106512a055f4aa830bcf9227ebbcc9933"

RDEPENDS:network-manager-applet = " \
 NetworkManager \
 libnma \
 nm-connection-editor \
 "
RDEPENDS:nm-connection-editor = " \
 NetworkManager-libnm \
 glib2 \
 glibc \
 gtk3 \
 jansson \
 libgcc \
 libnma \
 libselinux \
 "
