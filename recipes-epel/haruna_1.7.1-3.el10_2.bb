# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "haruna"
PV = "1.7.1"
PR = "3.el10_2"
PACKAGES = " \
 haruna \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/haruna-1.7.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "317e95868cc71a5333d994300c14d30dd76f8b1b441eae2d7826e4817b5f4f61"

URI_x86_64_v2_haruna = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/haruna-1.7.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_haruna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_haruna}"
SRC_URI[x86_64_v2_haruna.sha256sum] = "0d5e136ea8b201eec0db12f1e85feb74b9a0aad9627bd6e1a5471982c53846ab"

URI_aarch64_haruna = "${EPEL_MIRROR}/aarch64/Packages/h/haruna-1.7.1-3.el10_2.aarch64.rpm;name=aarch64_haruna;unpack=0"
SRC_URI:append = " ${URI_aarch64_haruna}"
SRC_URI[aarch64_haruna.sha256sum] = "ecd5f15630cef417af2b4bdf6a1789d892deeeac6ed5e364ede372387c72baaf"

RDEPENDS:haruna = " \
 glibc \
 hicolor-icon-theme \
 kde-filesystem \
 kdsingleapplication-qt6 \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kitemmodels \
 kf6-kservice \
 kf6-kwindowsystem \
 kf6-qqc2-desktop-style \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libstdc++ \
 libswscale-free \
 mpvqt \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
