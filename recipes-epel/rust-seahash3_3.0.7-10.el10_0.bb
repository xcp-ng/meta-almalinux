# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-seahash3"
PV = "3.0.7"
PR = "10.el10_0"
PACKAGES = " \
 rust-seahash3+default-devel \
 rust-seahash3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-seahash3-3.0.7-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b97681cdc4c05b11e8f5bdbe7ddbb21694c0950830f19424442715b567a7e70c"

URI_x86_64_v2_rust-seahash3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-seahash3+default-devel-3.0.7-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-seahash3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-seahash3+default-devel}"
SRC_URI[x86_64_v2_rust-seahash3+default-devel.sha256sum] = "99202e3b0ef41a121ced0e36ffebce0410037abc0aee83d809e7cf840226d19f"

URI_x86_64_v2_rust-seahash3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-seahash3-devel-3.0.7-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-seahash3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-seahash3-devel}"
SRC_URI[x86_64_v2_rust-seahash3-devel.sha256sum] = "1c009a2e6891f5d19c605e214bd3c2bbe62b73200ddf88b4a0ef33704911205f"

URI_aarch64_rust-seahash3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-seahash3+default-devel-3.0.7-10.el10_0.noarch.rpm;name=aarch64_rust-seahash3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-seahash3+default-devel}"
SRC_URI[aarch64_rust-seahash3+default-devel.sha256sum] = "7b50e528edd8903051ee1c0aaf257192085f8050646e8561371fa178d5b46ca4"

URI_aarch64_rust-seahash3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-seahash3-devel-3.0.7-10.el10_0.noarch.rpm;name=aarch64_rust-seahash3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-seahash3-devel}"
SRC_URI[aarch64_rust-seahash3-devel.sha256sum] = "e12948cc464b4254d7391ba40ee6220f070e26a555a29864071b6f4ff326f6b8"

RDEPENDS:rust-seahash3+default-devel = " \
 cargo \
 rust-seahash3-devel \
 "
RDEPENDS:rust-seahash3-devel = " \
 cargo \
 "
