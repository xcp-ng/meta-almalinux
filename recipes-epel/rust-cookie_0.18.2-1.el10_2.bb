# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cookie"
PV = "0.18.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-cookie+aes-gcm-devel \
 rust-cookie+base64-devel \
 rust-cookie+default-devel \
 rust-cookie+hkdf-devel \
 rust-cookie+hmac-devel \
 rust-cookie+key-expansion-devel \
 rust-cookie+percent-encode-devel \
 rust-cookie+percent-encoding-devel \
 rust-cookie+private-devel \
 rust-cookie+rand-devel \
 rust-cookie+secure-devel \
 rust-cookie+sha2-devel \
 rust-cookie+signed-devel \
 rust-cookie+subtle-devel \
 rust-cookie-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cookie-0.18.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "42e4a77dbc2020b120ace84b8020296072cdea4d29dd8cf0e0ff6f4fac91e393"

URI_x86_64_v2_rust-cookie+aes-gcm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+aes-gcm-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+aes-gcm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+aes-gcm-devel}"
SRC_URI[x86_64_v2_rust-cookie+aes-gcm-devel.sha256sum] = "e907d133d514f56a73423f631542e3922d10fc7b987c886d8db19031f3cff950"

URI_x86_64_v2_rust-cookie+base64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+base64-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+base64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+base64-devel}"
SRC_URI[x86_64_v2_rust-cookie+base64-devel.sha256sum] = "7d2ccd2e44386ef85975e2ef66e874a58a8b57bbe23968f8ae83f5346ca2cdf9"

URI_x86_64_v2_rust-cookie+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+default-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+default-devel}"
SRC_URI[x86_64_v2_rust-cookie+default-devel.sha256sum] = "a2342a601b6d4f7f75d70cdd54c4c8b21e732ce413e48246dfdbc92330b370c1"

URI_x86_64_v2_rust-cookie+hkdf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+hkdf-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+hkdf-devel}"
SRC_URI[x86_64_v2_rust-cookie+hkdf-devel.sha256sum] = "67182deddd8db2c247bfcf4877e10b84bbb292d9b0a5cc172e0292fb54e44c54"

URI_x86_64_v2_rust-cookie+hmac-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+hmac-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+hmac-devel}"
SRC_URI[x86_64_v2_rust-cookie+hmac-devel.sha256sum] = "31b10a1fd6b5774b42288ce5aed0eb02090b9e7ffe24574d8db9d4d24c669598"

URI_x86_64_v2_rust-cookie+key-expansion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+key-expansion-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+key-expansion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+key-expansion-devel}"
SRC_URI[x86_64_v2_rust-cookie+key-expansion-devel.sha256sum] = "dd47f818d14f839142c881f914fe62085fea14f2e841709d746ef079a1b757b2"

URI_x86_64_v2_rust-cookie+percent-encode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+percent-encode-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+percent-encode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+percent-encode-devel}"
SRC_URI[x86_64_v2_rust-cookie+percent-encode-devel.sha256sum] = "503ac9b49029b01aa24d2bd250de1e4e855c092c1d15a0c06005d9e134338748"

URI_x86_64_v2_rust-cookie+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+percent-encoding-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-cookie+percent-encoding-devel.sha256sum] = "8894f6a7d97b71469704f3a47de42e9e4b39acecf12bff1d5c95e75799ae7cd1"

URI_x86_64_v2_rust-cookie+private-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+private-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+private-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+private-devel}"
SRC_URI[x86_64_v2_rust-cookie+private-devel.sha256sum] = "8c76df93fa6d90ea25ab41a5d15333b0020ee88e93e08fa24bceadb3780eea4e"

URI_x86_64_v2_rust-cookie+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+rand-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+rand-devel}"
SRC_URI[x86_64_v2_rust-cookie+rand-devel.sha256sum] = "14a973d277ae00fd3347219182bae6cbe4469a6ca5333a757a4e6269c4abd1f0"

URI_x86_64_v2_rust-cookie+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+secure-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+secure-devel}"
SRC_URI[x86_64_v2_rust-cookie+secure-devel.sha256sum] = "abe9dab872aa7c757718637e34da7970e55534ed5e0c07ff3de72812c1b295a6"

URI_x86_64_v2_rust-cookie+sha2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+sha2-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+sha2-devel}"
SRC_URI[x86_64_v2_rust-cookie+sha2-devel.sha256sum] = "5b8e5f2947a2edaaebfaa9ac545833a1b719f75c1bb454edf6b910ff63627a41"

URI_x86_64_v2_rust-cookie+signed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+signed-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+signed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+signed-devel}"
SRC_URI[x86_64_v2_rust-cookie+signed-devel.sha256sum] = "06bbd66ca772329a9ece068809e69228625dd6833b8a2fef8e5d86ac3fdd6dd3"

URI_x86_64_v2_rust-cookie+subtle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie+subtle-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie+subtle-devel}"
SRC_URI[x86_64_v2_rust-cookie+subtle-devel.sha256sum] = "06e126ebb437d9e5aaa0d4d5692983cb28e9d0015977a4216a22736570c3687b"

URI_x86_64_v2_rust-cookie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cookie-devel-0.18.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cookie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cookie-devel}"
SRC_URI[x86_64_v2_rust-cookie-devel.sha256sum] = "7242701de26999b76731df4bfc1fc176c911a82976145e30748e296d97d166fa"

URI_aarch64_rust-cookie+aes-gcm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+aes-gcm-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+aes-gcm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+aes-gcm-devel}"
SRC_URI[aarch64_rust-cookie+aes-gcm-devel.sha256sum] = "3a9b1e6a387573ef3df4fb64d23783c1068e94388f961be812045abd5196b2e5"

URI_aarch64_rust-cookie+base64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+base64-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+base64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+base64-devel}"
SRC_URI[aarch64_rust-cookie+base64-devel.sha256sum] = "39dbbf4c78ef3008b7f60ac9bfad974860993065c9dd285a9dc368795d22fcfe"

URI_aarch64_rust-cookie+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+default-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+default-devel}"
SRC_URI[aarch64_rust-cookie+default-devel.sha256sum] = "4fd1fbedade47aa98f1d8ae6c4212e65331025da9d9e10e0f72969b8fb5e0a1f"

URI_aarch64_rust-cookie+hkdf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+hkdf-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+hkdf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+hkdf-devel}"
SRC_URI[aarch64_rust-cookie+hkdf-devel.sha256sum] = "0fb019b4138af595a245c1b060d6a0edad9bdcf5d0837ae573b490bd6e83d62a"

URI_aarch64_rust-cookie+hmac-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+hmac-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+hmac-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+hmac-devel}"
SRC_URI[aarch64_rust-cookie+hmac-devel.sha256sum] = "edd6d1e64cec6961625bf811fb8bc6e20fb7ea95f70a34831c6c88407b129ef8"

URI_aarch64_rust-cookie+key-expansion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+key-expansion-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+key-expansion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+key-expansion-devel}"
SRC_URI[aarch64_rust-cookie+key-expansion-devel.sha256sum] = "e055f3d8cf63b56944097a7516892bb6204bf7ff30751610801e1480891b6705"

URI_aarch64_rust-cookie+percent-encode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+percent-encode-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+percent-encode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+percent-encode-devel}"
SRC_URI[aarch64_rust-cookie+percent-encode-devel.sha256sum] = "a6bd1bf846d0535198dac638667030c5438ebc0d6a1f290d3624c10a78f55cc0"

URI_aarch64_rust-cookie+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+percent-encoding-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+percent-encoding-devel}"
SRC_URI[aarch64_rust-cookie+percent-encoding-devel.sha256sum] = "7f8eb1becc86877b546fa80bb6f336ede9e25032d3b1a579e3853e661f1999aa"

URI_aarch64_rust-cookie+private-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+private-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+private-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+private-devel}"
SRC_URI[aarch64_rust-cookie+private-devel.sha256sum] = "211248f2aa5c7ecf40c7234f041a8e140c7d37e29225b7be6a35833bba945fe7"

URI_aarch64_rust-cookie+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+rand-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+rand-devel}"
SRC_URI[aarch64_rust-cookie+rand-devel.sha256sum] = "30e5654fee80d56f6a8e857295fb1c902e4c7b471a8b5dcbc669c8346ab2cd40"

URI_aarch64_rust-cookie+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+secure-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+secure-devel}"
SRC_URI[aarch64_rust-cookie+secure-devel.sha256sum] = "ec1c665d778fd0fb0b1adb370ed0c0d7e659143f024daa6d4a551cf6fd42eaaf"

URI_aarch64_rust-cookie+sha2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+sha2-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+sha2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+sha2-devel}"
SRC_URI[aarch64_rust-cookie+sha2-devel.sha256sum] = "d25ee8e01b8935271c74284ea5044661823bc3f655a8c15c337213a031f63723"

URI_aarch64_rust-cookie+signed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+signed-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+signed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+signed-devel}"
SRC_URI[aarch64_rust-cookie+signed-devel.sha256sum] = "bc83072817b7fbfc5cb394c1f28c9d6710446113226785ce975e02e212456044"

URI_aarch64_rust-cookie+subtle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie+subtle-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie+subtle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie+subtle-devel}"
SRC_URI[aarch64_rust-cookie+subtle-devel.sha256sum] = "2114176dd4a074cbae8aa40afdcb86489e5524501bf35683e2cf90c28d9170e2"

URI_aarch64_rust-cookie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cookie-devel-0.18.2-1.el10_2.noarch.rpm;name=aarch64_rust-cookie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cookie-devel}"
SRC_URI[aarch64_rust-cookie-devel.sha256sum] = "6b961cd3e1b1b3e55a9c850e11f526412ea9101be14a99b60ff2c669d45e95c9"

RDEPENDS:rust-cookie+aes-gcm-devel = " \
 cargo \
 rust-aes-gcm+default-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+base64-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+default-devel = " \
 cargo \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+hkdf-devel = " \
 cargo \
 rust-cookie-devel \
 rust-hkdf+default-devel \
 "
RDEPENDS:rust-cookie+hmac-devel = " \
 cargo \
 rust-cookie-devel \
 rust-hmac+default-devel \
 "
RDEPENDS:rust-cookie+key-expansion-devel = " \
 cargo \
 rust-cookie+hkdf-devel \
 rust-cookie+sha2-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+percent-encode-devel = " \
 cargo \
 rust-cookie+percent-encoding-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+percent-encoding-devel = " \
 cargo \
 rust-cookie-devel \
 rust-percent-encoding+default-devel \
 "
RDEPENDS:rust-cookie+private-devel = " \
 cargo \
 rust-cookie+aes-gcm-devel \
 rust-cookie+base64-devel \
 rust-cookie+rand-devel \
 rust-cookie+subtle-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+rand-devel = " \
 cargo \
 rust-cookie-devel \
 rust-rand0.8+default-devel \
 "
RDEPENDS:rust-cookie+secure-devel = " \
 cargo \
 rust-cookie+key-expansion-devel \
 rust-cookie+private-devel \
 rust-cookie+signed-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+sha2-devel = " \
 cargo \
 rust-cookie-devel \
 rust-sha2+default-devel \
 "
RDEPENDS:rust-cookie+signed-devel = " \
 cargo \
 rust-cookie+base64-devel \
 rust-cookie+hmac-devel \
 rust-cookie+rand-devel \
 rust-cookie+sha2-devel \
 rust-cookie+subtle-devel \
 rust-cookie-devel \
 "
RDEPENDS:rust-cookie+subtle-devel = " \
 cargo \
 rust-cookie-devel \
 rust-subtle+default-devel \
 "
RDEPENDS:rust-cookie-devel = " \
 bash \
 cargo \
 rust \
 rust-time+formatting-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 rust-time+std-devel \
 rust-time-devel \
 rust-version_check+default-devel \
 "
