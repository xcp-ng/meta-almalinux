# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-human_format"
PV = "1.1.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-human_format+default-devel \
 rust-human_format-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-human_format-1.1.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d75ad39725a1a3c51b5f379b2c3d0145e78053f1a05df4000643255d7f041a33"

URI_x86_64_v2_rust-human_format+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human_format+default-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human_format+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human_format+default-devel}"
SRC_URI[x86_64_v2_rust-human_format+default-devel.sha256sum] = "67ee3b44538fbd36ede6f8b2e500d48323e1a2753cf8a273f95d0fff32d67f2f"

URI_x86_64_v2_rust-human_format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-human_format-devel-1.1.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-human_format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-human_format-devel}"
SRC_URI[x86_64_v2_rust-human_format-devel.sha256sum] = "6fe929541a9e2b944b812bc4c739d7a810937518618adfc0c43e0ea550141021"

URI_aarch64_rust-human_format+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human_format+default-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-human_format+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human_format+default-devel}"
SRC_URI[aarch64_rust-human_format+default-devel.sha256sum] = "a75b86daf8af57ac13b94a173f9fcb6dbbbbbb9eda5c258a88e859dbcf1f6ea4"

URI_aarch64_rust-human_format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-human_format-devel-1.1.0-1.el10_0.noarch.rpm;name=aarch64_rust-human_format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-human_format-devel}"
SRC_URI[aarch64_rust-human_format-devel.sha256sum] = "4d1dc18d696edd8292c1c88b303ab86d93379d085c1eefc0a701501b3d3f0a74"

RDEPENDS:rust-human_format+default-devel = " \
 cargo \
 rust-human_format-devel \
 "
RDEPENDS:rust-human_format-devel = " \
 cargo \
 "
