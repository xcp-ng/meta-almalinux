# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4cxx"
PV = "1.5.0"
PR = "1.el10_2"
PACKAGES = " \
 log4cxx \
 log4cxx-devel \
 log4cxx-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/log4cxx-1.5.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "121be64cd212a6428726a464b532abeb702a567fb80b634a9dbab2f472c9c960"

URI_x86_64_v2_log4cxx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-1.5.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cxx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cxx}"
SRC_URI[x86_64_v2_log4cxx.sha256sum] = "940f13e4017a16681a9a06df1b3f1cb621a1b73595cb5416dacd534cd25a0788"

URI_x86_64_v2_log4cxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-devel-1.5.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cxx-devel}"
SRC_URI[x86_64_v2_log4cxx-devel.sha256sum] = "c326cdfd60dbcdb3f656cca1513049f12330dbceb258124ce44ae195de8bdf44"

URI_x86_64_v2_log4cxx-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-doc-1.5.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_log4cxx-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cxx-doc}"
SRC_URI[x86_64_v2_log4cxx-doc.sha256sum] = "6e1efb14a547909de6d8697064629d5b43c195dabef1ecf8a94154dda9f16de9"

URI_aarch64_log4cxx = "${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-1.5.0-1.el10_2.aarch64.rpm;name=aarch64_log4cxx;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cxx}"
SRC_URI[aarch64_log4cxx.sha256sum] = "0fcb15d700ccd8db5a727c4efb4f594d8e9d74efffd3f8a94630dece80966562"

URI_aarch64_log4cxx-devel = "${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-devel-1.5.0-1.el10_2.aarch64.rpm;name=aarch64_log4cxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cxx-devel}"
SRC_URI[aarch64_log4cxx-devel.sha256sum] = "4cbf80f5aab4c2e1600439892642b589897bb64cc1d6acf9023fb1d02edc83dd"

URI_aarch64_log4cxx-doc = "${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-doc-1.5.0-1.el10_2.noarch.rpm;name=aarch64_log4cxx-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cxx-doc}"
SRC_URI[aarch64_log4cxx-doc.sha256sum] = "93c87d28cbc11fbaf375845c4015ea2b4ccd6b9bf9debc66679268c4ec728030"

RDEPENDS:log4cxx = " \
 apr \
 apr-util \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:log4cxx-devel = " \
 apr-devel \
 apr-util-devel \
 cmake-filesystem \
 log4cxx \
 pkgconf-pkg-config \
 "
RDEPENDS:log4cxx-doc = " \
 "
