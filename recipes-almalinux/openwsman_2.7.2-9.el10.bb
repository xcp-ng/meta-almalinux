# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openwsman"
PV = "2.7.2"
PR = "9.el10"
PACKAGES = " \
 libwsman-devel \
 libwsman1 \
 openwsman-client \
 openwsman-python3 \
 openwsman-selinux \
 openwsman-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openwsman-2.7.2-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c62bf3f045216b9d3da899fd72ad8ca741ef6a22d7a0f5db32195d35584c0458"

URI_x86_64_v2_libwsman-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwsman-devel-2.7.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_libwsman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwsman-devel}"
SRC_URI[x86_64_v2_libwsman-devel.sha256sum] = "b55911c579319d9f9de4f2072e785cc86d7343883a9e3e50b4e6e09531c5663a"

URI_x86_64_v2_libwsman1 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwsman1-2.7.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_libwsman1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwsman1}"
SRC_URI[x86_64_v2_libwsman1.sha256sum] = "9152950a849f5784612de83d9dfa14c1926491a8d81994203ca7c0cf12344b94"

URI_x86_64_v2_openwsman-client = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openwsman-client-2.7.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_openwsman-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openwsman-client}"
SRC_URI[x86_64_v2_openwsman-client.sha256sum] = "9c7990b2c32b8705513ef2592836ce977ad6b551973920e64f594a6cf24a56fd"

URI_x86_64_v2_openwsman-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openwsman-python3-2.7.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_openwsman-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openwsman-python3}"
SRC_URI[x86_64_v2_openwsman-python3.sha256sum] = "f3105899eeb293dbbff93121fa899352acd2b91df95a15b1f640e910c7d3cd19"

URI_x86_64_v2_openwsman-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openwsman-selinux-2.7.2-9.el10.noarch.rpm;name=x86_64_v2_openwsman-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openwsman-selinux}"
SRC_URI[x86_64_v2_openwsman-selinux.sha256sum] = "7a97009a0c48090f2e274535e82238700e4dd516a7f58b399ad86fe516b09edd"

URI_x86_64_v2_openwsman-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openwsman-server-2.7.2-9.el10.x86_64_v2.rpm;name=x86_64_v2_openwsman-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openwsman-server}"
SRC_URI[x86_64_v2_openwsman-server.sha256sum] = "14f43fe47de1c0e9ead308ce983063cd17fc93cfbf965535a3839c165d42c268"

URI_aarch64_libwsman-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwsman-devel-2.7.2-9.el10.aarch64.rpm;name=aarch64_libwsman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwsman-devel}"
SRC_URI[aarch64_libwsman-devel.sha256sum] = "deb68423ad7fccdabf1ed188ee9d8fdd1bf39f64cc671d6ff5ce81542025701e"

URI_aarch64_libwsman1 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwsman1-2.7.2-9.el10.aarch64.rpm;name=aarch64_libwsman1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwsman1}"
SRC_URI[aarch64_libwsman1.sha256sum] = "bb770ef1000ebbf55b2b2fef872367b295b4030b5668c52aa9007f8b2502d3a3"

URI_aarch64_openwsman-client = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openwsman-client-2.7.2-9.el10.aarch64.rpm;name=aarch64_openwsman-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_openwsman-client}"
SRC_URI[aarch64_openwsman-client.sha256sum] = "4b5edea53142c48d9d5f2e628193380ee4ebae78e77e36acd29461b757aac891"

URI_aarch64_openwsman-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openwsman-python3-2.7.2-9.el10.aarch64.rpm;name=aarch64_openwsman-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_openwsman-python3}"
SRC_URI[aarch64_openwsman-python3.sha256sum] = "ea6cc694d7b965f0f49189abde9e1dec0d4ca2eab8a8ac2350c5790428a17c15"

URI_aarch64_openwsman-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openwsman-selinux-2.7.2-9.el10.noarch.rpm;name=aarch64_openwsman-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_openwsman-selinux}"
SRC_URI[aarch64_openwsman-selinux.sha256sum] = "7a97009a0c48090f2e274535e82238700e4dd516a7f58b399ad86fe516b09edd"

URI_aarch64_openwsman-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openwsman-server-2.7.2-9.el10.aarch64.rpm;name=aarch64_openwsman-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_openwsman-server}"
SRC_URI[aarch64_openwsman-server.sha256sum] = "43d943a8151561b3982e8924ac7afa8411f0453fc147cf1757fa488924524c6c"

RDEPENDS:libwsman-devel = " \
 libcurl-devel \
 libwsman1 \
 libxml2-devel \
 openwsman-client \
 openwsman-server \
 pam-devel \
 pkgconf-pkg-config \
 sblim-sfcc-devel \
 "
RDEPENDS:libwsman1 = " \
 glibc \
 libxml2 \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:openwsman-client = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:openwsman-python3 = " \
 glibc \
 libwsman1 \
 python3 \
 "
RDEPENDS:openwsman-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:openwsman-server = " \
 bash \
 glibc \
 libwsman1 \
 libxcrypt \
 openssl-libs \
 openwsman-selinux \
 pam-libs \
 ruby-libs \
 sblim-sfcc \
 "
