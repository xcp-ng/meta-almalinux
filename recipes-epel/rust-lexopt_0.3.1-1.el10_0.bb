# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-lexopt"
PV = "0.3.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-lexopt+default-devel \
 rust-lexopt-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-lexopt-0.3.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f375232f2c0bb36e7fb25d311b0b8ee472c21861acc0c3121e2d2559f3a607cb"

URI_x86_64_v2_rust-lexopt+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexopt+default-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexopt+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexopt+default-devel}"
SRC_URI[x86_64_v2_rust-lexopt+default-devel.sha256sum] = "3c6533c33cac721233571a63d2924d803832d9f40a3733048b7a8a78f28c1b57"

URI_x86_64_v2_rust-lexopt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-lexopt-devel-0.3.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-lexopt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-lexopt-devel}"
SRC_URI[x86_64_v2_rust-lexopt-devel.sha256sum] = "d79fa04c8a923a8338aca37ac641f49a3c00be99bdab780b10f06348d8b234b4"

URI_aarch64_rust-lexopt+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexopt+default-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-lexopt+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexopt+default-devel}"
SRC_URI[aarch64_rust-lexopt+default-devel.sha256sum] = "4c763c934156f5c879441697c034de186b0ba3db2a1d99fa8523dbd249e68427"

URI_aarch64_rust-lexopt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-lexopt-devel-0.3.1-1.el10_0.noarch.rpm;name=aarch64_rust-lexopt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-lexopt-devel}"
SRC_URI[aarch64_rust-lexopt-devel.sha256sum] = "19cfa66336460f13b54c1e693f68451e63bf9378588212491ab1f861000139b1"

RDEPENDS:rust-lexopt+default-devel = " \
 cargo \
 rust-lexopt-devel \
 "
RDEPENDS:rust-lexopt-devel = " \
 cargo \
 "
