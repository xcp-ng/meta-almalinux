# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtcharts"
PV = "6.8.1"
PR = "2.el10"
PACKAGES = " \
 qt6-qtcharts \
 qt6-qtcharts-devel \
 qt6-qtcharts-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtcharts-6.8.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45b310170c356e7197337de76662cfdee7e3ef404ae9a4261827da4cbf9bf6a5"

URI_x86_64_v2_qt6-qtcharts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtcharts-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcharts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcharts}"
SRC_URI[x86_64_v2_qt6-qtcharts.sha256sum] = "0cc469a117f8767c72c6a096264e6382d665d9da26baa91b42f32b4057900603"

URI_x86_64_v2_qt6-qtcharts-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtcharts-devel-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcharts-devel}"
SRC_URI[x86_64_v2_qt6-qtcharts-devel.sha256sum] = "a041689947e45b9f08ea2c42c8cd1b4c36f42808c2068e1b113cac5c0157e7e5"

URI_x86_64_v2_qt6-qtcharts-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtcharts-examples-6.8.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtcharts-examples}"
SRC_URI[x86_64_v2_qt6-qtcharts-examples.sha256sum] = "5fd2760b226bec2286aae42ddeb7022b6cac3e73b9efb3cfe6ec5100810703b0"

URI_aarch64_qt6-qtcharts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtcharts-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtcharts;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcharts}"
SRC_URI[aarch64_qt6-qtcharts.sha256sum] = "a1c9f46a471b98a7a75e661e9018ed4e395d3a2c9cf9512ad2e7341b02e0751e"

URI_aarch64_qt6-qtcharts-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtcharts-devel-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtcharts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcharts-devel}"
SRC_URI[aarch64_qt6-qtcharts-devel.sha256sum] = "2055f844bc91f9bb9d98ef4403b257d0c665560d460dec9efa3efec2af63e851"

URI_aarch64_qt6-qtcharts-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtcharts-examples-6.8.1-2.el10.aarch64.rpm;name=aarch64_qt6-qtcharts-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtcharts-examples}"
SRC_URI[aarch64_qt6-qtcharts-examples.sha256sum] = "5832a521bcea76b4795cae2360c8f3ea6ef875daed5b99edd32b74da4f0bf79c"

RDEPENDS:qt6-qtcharts = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:qt6-qtcharts-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtcharts \
 qt6-qtcharts-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:qt6-qtcharts-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 "
