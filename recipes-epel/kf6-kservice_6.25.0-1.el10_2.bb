# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kservice"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kservice \
 kf6-kservice-devel \
 kf6-kservice-doc \
 kf6-kservice-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kservice-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f760b39f5be32c6edeb8ddc8fc12b833768af367370f66ef60f98dd10ff1e860"

URI_x86_64_v2_kf6-kservice = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice}"
SRC_URI[x86_64_v2_kf6-kservice.sha256sum] = "d0bfb4be354226a91b2cecc0c5fcd348f6d9458b6a86d1a62a9f652c6afaafc5"

URI_x86_64_v2_kf6-kservice-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kservice-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-devel}"
SRC_URI[x86_64_v2_kf6-kservice-devel.sha256sum] = "7a75a65c325f9a673a548f801687a1c0f027a05bdebb35bb70777f0955da0070"

URI_x86_64_v2_kf6-kservice-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kservice-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-doc}"
SRC_URI[x86_64_v2_kf6-kservice-doc.sha256sum] = "775583e67961ebd864b5f8fc2357f7b8197824f88bc3efcd979504aabae73636"

URI_x86_64_v2_kf6-kservice-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kservice-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kservice-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kservice-html}"
SRC_URI[x86_64_v2_kf6-kservice-html.sha256sum] = "48b49391c82743a21a11fa04ef1922f29838289df1485ba40d74c4867d2559c3"

URI_aarch64_kf6-kservice = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kservice;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice}"
SRC_URI[aarch64_kf6-kservice.sha256sum] = "661c2d4e69cb1e6e5186c21da7d93eadf950364d55f58088355c7406af9daf85"

URI_aarch64_kf6-kservice-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kservice-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-devel}"
SRC_URI[aarch64_kf6-kservice-devel.sha256sum] = "fa04fb63e7c708e0509e70913f47a31e9ceaf23239dfe14c63def904e1cf4765"

URI_aarch64_kf6-kservice-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kservice-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-doc}"
SRC_URI[aarch64_kf6-kservice-doc.sha256sum] = "c691d519fa075cf3510059a7577002d2928fa3e69981060524bd12d537c2fbc2"

URI_aarch64_kf6-kservice-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kservice-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kservice-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kservice-html}"
SRC_URI[aarch64_kf6-kservice-html.sha256sum] = "93a327d0bdeb4d8b82aac0a03b0eecb8bbcf7b1e5444ed38d010a91a6f83c28d"

RDEPENDS:kf6-kservice = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kservice-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-kcoreaddons-devel \
 kf6-kservice \
 "
RDEPENDS:kf6-kservice-doc = " \
 "
RDEPENDS:kf6-kservice-html = " \
 "
