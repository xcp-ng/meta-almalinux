# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Redis-Fast"
PV = "0.37"
PR = "5.el10_2"
PACKAGES = " \
 perl-Redis-Fast \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Redis-Fast-0.37-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3eaafb05194c89c6feb48cfa7669d53539a8fa6c8412e4639377b227a1fafd0"

URI_x86_64_v2_perl-Redis-Fast = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Redis-Fast-0.37-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Redis-Fast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Redis-Fast}"
SRC_URI[x86_64_v2_perl-Redis-Fast.sha256sum] = "d03bd91c62137ce87322785ce3c8b58e2e12336a99b952ebdd9e798f5abc5aad"

URI_aarch64_perl-Redis-Fast = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Redis-Fast-0.37-5.el10_2.aarch64.rpm;name=aarch64_perl-Redis-Fast;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Redis-Fast}"
SRC_URI[aarch64_perl-Redis-Fast.sha256sum] = "5ad2cc72ba2bc1d1c5b1540bc989aceb9e01e372caa28902db8bea84fb4dee78"

RDEPENDS:perl-Redis-Fast = " \
 glibc \
 hiredis \
 perl-Carp \
 perl-Encode \
 perl-Redis-Fast \
 perl-Scalar-List-Utils \
 perl-Tie \
 perl-Try-Tiny \
 perl-base \
 perl-constant \
 perl-libs \
 "
