# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-enum-primitive-derive"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-enum-primitive-derive+default-devel \
 rust-enum-primitive-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-enum-primitive-derive-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68bc3fb04755146b947a8185f22895dde048e5552a0b1393b7ac2287f2740f94"

URI_x86_64_v2_rust-enum-primitive-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-primitive-derive+default-devel-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-primitive-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-primitive-derive+default-devel}"
SRC_URI[x86_64_v2_rust-enum-primitive-derive+default-devel.sha256sum] = "e3c9c41408c23a4d7639d904ef072b30044a9228979bf44cf3f07ddf9efee30d"

URI_x86_64_v2_rust-enum-primitive-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-enum-primitive-derive-devel-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-enum-primitive-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-enum-primitive-derive-devel}"
SRC_URI[x86_64_v2_rust-enum-primitive-derive-devel.sha256sum] = "8a8b3b71a2562cff2d1b7f0ec8f6603d1b49206505a438f007ee57c0b167688c"

URI_aarch64_rust-enum-primitive-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-primitive-derive+default-devel-0.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-enum-primitive-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-primitive-derive+default-devel}"
SRC_URI[aarch64_rust-enum-primitive-derive+default-devel.sha256sum] = "3004b8f715bd84ce95fa07aa89d4ac8549d1e470add99388ffc4ad733abb5ca2"

URI_aarch64_rust-enum-primitive-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-enum-primitive-derive-devel-0.3.0-1.el10_0.noarch.rpm;name=aarch64_rust-enum-primitive-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-enum-primitive-derive-devel}"
SRC_URI[aarch64_rust-enum-primitive-derive-devel.sha256sum] = "673899268f16451d8c10c2b9f2c671443e2294959937f424a5031717188f71cd"

RDEPENDS:rust-enum-primitive-derive+default-devel = " \
 cargo \
 rust-enum-primitive-derive-devel \
 "
RDEPENDS:rust-enum-primitive-derive-devel = " \
 cargo \
 rust \
 rust-num-traits-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
