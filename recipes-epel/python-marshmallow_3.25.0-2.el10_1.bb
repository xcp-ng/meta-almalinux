# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-marshmallow"
PV = "3.25.0"
PR = "2.el10_1"
PACKAGES = " \
 python-marshmallow-doc \
 python3-marshmallow \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-marshmallow-3.25.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f939080d87bb1bd3fc574f2d539041a6d337202f9a4a56571f5511fa20dac358"

URI_x86_64_v2_python-marshmallow-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-marshmallow-doc-3.25.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-marshmallow-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-marshmallow-doc}"
SRC_URI[x86_64_v2_python-marshmallow-doc.sha256sum] = "b05a93e6ea60a42153dbabcdc548516cd05da13cba4100dd3b9cd1de74bbed60"

URI_x86_64_v2_python3-marshmallow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-marshmallow-3.25.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-marshmallow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-marshmallow}"
SRC_URI[x86_64_v2_python3-marshmallow.sha256sum] = "a138d53fefa858a6c80480f541db644b1895b55a6738d98bc2aa4e938a4a1035"

URI_aarch64_python-marshmallow-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-marshmallow-doc-3.25.0-2.el10_1.noarch.rpm;name=aarch64_python-marshmallow-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-marshmallow-doc}"
SRC_URI[aarch64_python-marshmallow-doc.sha256sum] = "742d53770d2654ce55868537fd7cb9d22a83be2cd0f645b9b67c73db391b1649"

URI_aarch64_python3-marshmallow = "${EPEL_MIRROR}/aarch64/Packages/p/python3-marshmallow-3.25.0-2.el10_1.noarch.rpm;name=aarch64_python3-marshmallow;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-marshmallow}"
SRC_URI[aarch64_python3-marshmallow.sha256sum] = "82ea96a1b1b610da9a0d75c5e23d388b9fba8824286ece3483d5baa293be3880"

RDEPENDS:python-marshmallow-doc = " \
 "
RDEPENDS:python3-marshmallow = " \
 python3 \
 python3-ordered-set \
 python3-packaging \
 "
