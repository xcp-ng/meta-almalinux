# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "corosync"
PV = "3.1.9"
PR = "2.el10_1.1"
PACKAGES = " \
 corosync-vqsim \
 corosynclib \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/corosync-3.1.9-2.el10_1.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f26d902c7ab7dc97f4cbb12f7090c3e7114e57bd8251b23ea3f0c874fa94c91"

URI_x86_64_v2_corosync-vqsim = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/corosync-vqsim-3.1.9-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_corosync-vqsim;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_corosync-vqsim}"
SRC_URI[x86_64_v2_corosync-vqsim.sha256sum] = "0bb1fa48597fbdaaa7e221507c58e7191c7f1c4653af9c38b602282a0b5dad48"

URI_x86_64_v2_corosynclib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/corosynclib-3.1.9-2.el10_1.1.x86_64_v2.rpm;name=x86_64_v2_corosynclib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_corosynclib}"
SRC_URI[x86_64_v2_corosynclib.sha256sum] = "ab3ac83f711763ab3d441636d03b24d4ee2190345accddc3e3a59e1c201bb058"

URI_aarch64_corosync-vqsim = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/corosync-vqsim-3.1.9-2.el10_1.1.aarch64.rpm;name=aarch64_corosync-vqsim;unpack=0"
SRC_URI:append = " ${URI_aarch64_corosync-vqsim}"
SRC_URI[aarch64_corosync-vqsim.sha256sum] = "ee3b82c71531f0a5fd8ceb8ac657483eeb17fa872e8c8e191db4d232ba581230"

URI_aarch64_corosynclib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/corosynclib-3.1.9-2.el10_1.1.aarch64.rpm;name=aarch64_corosynclib;unpack=0"
SRC_URI:append = " ${URI_aarch64_corosynclib}"
SRC_URI[aarch64_corosynclib.sha256sum] = "8af843324fea435fb7f2d8af204f49dde2833fdf14e240a9217622278a08183e"

RDEPENDS:corosync-vqsim = " \
 corosynclib \
 glibc \
 libknet1 \
 libqb \
 pkgconf-pkg-config \
 readline \
 "
RDEPENDS:corosynclib = " \
 glibc \
 libqb \
 "
