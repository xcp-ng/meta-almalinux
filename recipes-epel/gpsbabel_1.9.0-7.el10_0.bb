# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gpsbabel"
PV = "1.9.0"
PR = "7.el10_0"
PACKAGES = " \
 gpsbabel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gpsbabel-1.9.0-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "882a3e7bd9e7e0bd8abf40bd50526b8281ffdb0a370dac417cf11a8ebf3dd212"

URI_x86_64_v2_gpsbabel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gpsbabel-1.9.0-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gpsbabel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gpsbabel}"
SRC_URI[x86_64_v2_gpsbabel.sha256sum] = "9506fe76d6d37342fc4dc51158cfaf7fa6a63ffd494d456dd54a6d49a5d4abc0"

URI_aarch64_gpsbabel = "${EPEL_MIRROR}/aarch64/Packages/g/gpsbabel-1.9.0-7.el10_0.aarch64.rpm;name=aarch64_gpsbabel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gpsbabel}"
SRC_URI[aarch64_gpsbabel.sha256sum] = "5f91dc4225dd55547bc29d369692774460e26128c12b7bc06975696eaff31c30"

RDEPENDS:gpsbabel = " \
 glibc \
 libgcc \
 libstdc++ \
 libusb1 \
 qt5-qtbase \
 shapelib \
 zlib-ng-compat \
 "
