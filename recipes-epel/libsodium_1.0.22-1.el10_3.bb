# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libsodium"
PV = "1.0.22"
PR = "1.el10_3"
PACKAGES = " \
 libsodium \
 libsodium-devel \
 libsodium-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libsodium-1.0.22-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2d42186793242a6b63dfe43a88136987e07570be2202716df4921935520121f4"

URI_x86_64_v2_libsodium = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-1.0.22-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsodium}"
SRC_URI[x86_64_v2_libsodium.sha256sum] = "0f0f0bc0be63009dd6f90006302a250b735b854be71a7b9725dd7276c7daa001"

URI_x86_64_v2_libsodium-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-devel-1.0.22-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsodium-devel}"
SRC_URI[x86_64_v2_libsodium-devel.sha256sum] = "aebca50201990aac1f2d70637c3fbce8c13a7882c4778eeabbe33f979623881a"

URI_x86_64_v2_libsodium-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libsodium-static-1.0.22-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libsodium-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsodium-static}"
SRC_URI[x86_64_v2_libsodium-static.sha256sum] = "4d04b919c57c1970f94303f3f2fe17dcbde651dc57a0ccd79ea96370be15de77"

URI_aarch64_libsodium = "${EPEL_MIRROR}/aarch64/Packages/l/libsodium-1.0.22-1.el10_3.aarch64.rpm;name=aarch64_libsodium;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsodium}"
SRC_URI[aarch64_libsodium.sha256sum] = "a3590581c0f9327200b049715df2fc018cd4b5ce0e7c5ab218c4d12a39414524"

URI_aarch64_libsodium-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libsodium-devel-1.0.22-1.el10_3.aarch64.rpm;name=aarch64_libsodium-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsodium-devel}"
SRC_URI[aarch64_libsodium-devel.sha256sum] = "31b1f9ce1baa7e8d8ecec1a7282e3eb1d9b83465c6cc666204fb5e000e4d5c03"

URI_aarch64_libsodium-static = "${EPEL_MIRROR}/aarch64/Packages/l/libsodium-static-1.0.22-1.el10_3.aarch64.rpm;name=aarch64_libsodium-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsodium-static}"
SRC_URI[aarch64_libsodium-static.sha256sum] = "20553f85bba766d9adc5fd2bc2158f4168d7759f5ae96712e3d3f8c3dddf9961"

RDEPENDS:libsodium = " \
 glibc \
 "
RDEPENDS:libsodium-devel = " \
 libsodium \
 pkgconf-pkg-config \
 "
RDEPENDS:libsodium-static = " \
 libsodium-devel \
 "
