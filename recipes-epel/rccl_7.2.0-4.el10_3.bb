# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rccl"
PV = "7.2.0"
PR = "4.el10_3"
PACKAGES:x86_64_v2 = " \
 rccl \
 rccl-data \
 rccl-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/r/rccl-7.2.0-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c054fde09fad0f0b29e0efdc650c00ba59e458354f01c65aa657ab6aef770b74"

URI_x86_64_v2_rccl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rccl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl}"
SRC_URI[x86_64_v2_rccl.sha256sum] = "4ab36057eeab7ef6c4884474596fcd7e7a5b9e6e5a8dad27b6d1c3210712d2ab"

URI_x86_64_v2_rccl-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-data-7.2.0-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rccl-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl-data}"
SRC_URI[x86_64_v2_rccl-data.sha256sum] = "320066ac5c02c5714b9c85f98d11aa48fd32ee3b814891176255e0f7ea963620"

URI_x86_64_v2_rccl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rccl-devel-7.2.0-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rccl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rccl-devel}"
SRC_URI[x86_64_v2_rccl-devel.sha256sum] = "7960f877441e2ffe38804d35179ce170fadf4e40eca472b4c48806225b8f03bd"

RDEPENDS:rccl = " \
 glibc \
 libgcc \
 libstdc++ \
 rccl-data \
 rocm-hip \
 rocm-smi \
 "
RDEPENDS:rccl-data = " \
 "
RDEPENDS:rccl-devel = " \
 cmake-filesystem \
 rccl \
 "
