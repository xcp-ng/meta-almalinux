# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "skopeo"
PE = "2"
PV = "1.23.0"
PR = "1.el10"
PACKAGES = " \
 skopeo \
 skopeo-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/skopeo-1.23.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "470d7d0d6c469b6a07ba2b391c26b4025a79415e1980d7c7d12e2a1c6130d56b"

URI_x86_64_v2_skopeo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-1.23.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_skopeo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skopeo}"
SRC_URI[x86_64_v2_skopeo.sha256sum] = "b6cf255d4ad0f8026a7e48993b2a6fc124f653e4d7f1c930163f9fe87af3d633"

URI_x86_64_v2_skopeo-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/skopeo-tests-1.23.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_skopeo-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_skopeo-tests}"
SRC_URI[x86_64_v2_skopeo-tests.sha256sum] = "538e7af36b4d2ea21398fcaa35cfc3a6aa95112bc38134a20c84f7f8be7e0412"

URI_aarch64_skopeo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-1.23.0-1.el10.aarch64.rpm;name=aarch64_skopeo;unpack=0"
SRC_URI:append = " ${URI_aarch64_skopeo}"
SRC_URI[aarch64_skopeo.sha256sum] = "a495cc075a8a4df1f197f269471b14ca12aba933ebcf8bb0d1e3eeeeddaf34ff"

URI_aarch64_skopeo-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/skopeo-tests-1.23.0-1.el10.aarch64.rpm;name=aarch64_skopeo-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_skopeo-tests}"
SRC_URI[aarch64_skopeo-tests.sha256sum] = "aaee7c25acef0846ad7b1c42fe6522f57fe123787e546370a03dbe4fffd1b128"

RDEPENDS:skopeo = " \
 containers-common \
 glibc \
 gpgme \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:skopeo-tests = " \
 bash \
 crun \
 gnupg2 \
 golang \
 httpd-tools \
 jq \
 openssl \
 podman \
 skopeo \
 squashfs-tools \
 virtual//usr/bin/env \
 "
