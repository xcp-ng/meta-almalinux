# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-darling_macro"
PV = "0.20.11"
PR = "1.el10_1"
PACKAGES = " \
 rust-darling_macro+default-devel \
 rust-darling_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-darling_macro-0.20.11-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f1d68bd000b49e233b80b0381985bc338a7ea96c5a1a1ef3e14bf02472f2361"

URI_x86_64_v2_rust-darling_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_macro+default-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_macro+default-devel}"
SRC_URI[x86_64_v2_rust-darling_macro+default-devel.sha256sum] = "93c39c96bbcd2ed4f3ffaef311aee2166221d470a9740e6580d4e0c88874d295"

URI_x86_64_v2_rust-darling_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-darling_macro-devel-0.20.11-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-darling_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-darling_macro-devel}"
SRC_URI[x86_64_v2_rust-darling_macro-devel.sha256sum] = "64c168606454d8f50bf23272b01e6a7a6a1ce8f076edccaaa874c1a38ca65ddf"

URI_aarch64_rust-darling_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_macro+default-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_macro+default-devel}"
SRC_URI[aarch64_rust-darling_macro+default-devel.sha256sum] = "f09a856a1735abf09e1a405943021ddfe1ed207959d2d207d567dadb2ab69fe8"

URI_aarch64_rust-darling_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-darling_macro-devel-0.20.11-1.el10_1.noarch.rpm;name=aarch64_rust-darling_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-darling_macro-devel}"
SRC_URI[aarch64_rust-darling_macro-devel.sha256sum] = "8d0176c3cb3342b10b5fc725259d48578c4e44a78a288d173d2682b374557ed0"

RDEPENDS:rust-darling_macro+default-devel = " \
 cargo \
 rust-darling_macro-devel \
 "
RDEPENDS:rust-darling_macro-devel = " \
 cargo \
 rust \
 rust-darling_core+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
