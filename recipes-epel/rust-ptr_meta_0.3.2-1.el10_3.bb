# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ptr_meta"
PV = "0.3.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-ptr_meta+default-devel \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta+ptr_meta_derive-devel \
 rust-ptr_meta+std-devel \
 rust-ptr_meta-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ptr_meta-0.3.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e15722af2f85ca67864a36b4579a40eb47769d04310136133cd528bbc028017"

URI_x86_64_v2_rust-ptr_meta+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+default-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+default-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+default-devel.sha256sum] = "c5b554c8ad94a97340a53f62bd4b496d31e0e15d9ff80a5db17d33eaf855267d"

URI_x86_64_v2_rust-ptr_meta+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+derive-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+derive-devel.sha256sum] = "1881a6d9b49771b83a0c3d0ae2a3e59f3916224dc6f07633d0ab65f37dcb16d5"

URI_x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+ptr_meta_derive-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+ptr_meta_derive-devel.sha256sum] = "6ca5b876a31aafeacb7f8f88e8f8155b9463714b777360c0eb3533cb709e0307"

URI_x86_64_v2_rust-ptr_meta+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta+std-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta+std-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta+std-devel.sha256sum] = "69d30268306e43099cce2f128e172d7621fda2596dd00d858b8039c5123e59d3"

URI_x86_64_v2_rust-ptr_meta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ptr_meta-devel-0.3.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ptr_meta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ptr_meta-devel}"
SRC_URI[x86_64_v2_rust-ptr_meta-devel.sha256sum] = "dc5eed6fba3c22fecba79729d130e662d2779d3f8e5a00b8e7ea7ebec879fc49"

URI_aarch64_rust-ptr_meta+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+default-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-ptr_meta+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+default-devel}"
SRC_URI[aarch64_rust-ptr_meta+default-devel.sha256sum] = "f993273dc67134ec9114a92a2b76e8b6d4fa7f16c5043e94f0e9709583f5f80d"

URI_aarch64_rust-ptr_meta+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+derive-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-ptr_meta+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+derive-devel}"
SRC_URI[aarch64_rust-ptr_meta+derive-devel.sha256sum] = "52b3a8dfd136d30cf12acec2ec26603ee68e901bcf635845262c6e7746e699fb"

URI_aarch64_rust-ptr_meta+ptr_meta_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+ptr_meta_derive-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-ptr_meta+ptr_meta_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+ptr_meta_derive-devel}"
SRC_URI[aarch64_rust-ptr_meta+ptr_meta_derive-devel.sha256sum] = "32970514f063829cbe77a7c64c0b653c3fea824f3751fae73d69cb2692c34ecb"

URI_aarch64_rust-ptr_meta+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta+std-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-ptr_meta+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta+std-devel}"
SRC_URI[aarch64_rust-ptr_meta+std-devel.sha256sum] = "79f3bd2cbe51a928c0729dcbb09aebc068a84a07aa07f134e28fbf607f97f4b2"

URI_aarch64_rust-ptr_meta-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ptr_meta-devel-0.3.2-1.el10_3.noarch.rpm;name=aarch64_rust-ptr_meta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ptr_meta-devel}"
SRC_URI[aarch64_rust-ptr_meta-devel.sha256sum] = "d1083145568197510866771e007c683b0114cdef21827a553fdbb6aad5e8c601"

RDEPENDS:rust-ptr_meta+default-devel = " \
 cargo \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta+std-devel \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta+derive-devel = " \
 cargo \
 rust-ptr_meta+ptr_meta_derive-devel \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta+ptr_meta_derive-devel = " \
 cargo \
 rust-ptr_meta-devel \
 rust-ptr_meta_derive-devel \
 "
RDEPENDS:rust-ptr_meta+std-devel = " \
 cargo \
 rust-ptr_meta-devel \
 "
RDEPENDS:rust-ptr_meta-devel = " \
 cargo \
 rust \
 "
