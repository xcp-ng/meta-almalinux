# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "recoll"
PV = "1.44.2"
PR = "1.el10_2"
PACKAGES = " \
 recoll \
 recoll-devel \
 recoll-gssp \
 recoll-helpers \
 recoll-kio \
 recoll-krunner \
 recoll-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/recoll-1.44.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9d03e274c1f1ebdcee4df1427bbf8f1986053033238b32d8fb8c617e9fdfc9a9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-1.44.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll;unpack=0"
SRC_URI[x86_64_v2_recoll.sha256sum] = "c0e05fb39e6526ec9147a8ed15790f300bef5f32a977d3a0ea974a84029f0f21"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-devel-1.44.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-devel;unpack=0"
SRC_URI[x86_64_v2_recoll-devel.sha256sum] = "9f8364e78b6b24977adef02d0e3261a6db1d8dfe303bd98b743c7ff52fc4694f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-gssp-1.44.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-gssp;unpack=0"
SRC_URI[x86_64_v2_recoll-gssp.sha256sum] = "d01602633c371446ec39a1994dd629faf9ca6bd0962a3cbc70115ad661ec3508"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-helpers-1.44.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-helpers;unpack=0"
SRC_URI[x86_64_v2_recoll-helpers.sha256sum] = "24674527c914c2fccda4e0d6d8ca349956e4361584d579999528ccd51cd7fd7b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-kio-1.44.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-kio;unpack=0"
SRC_URI[x86_64_v2_recoll-kio.sha256sum] = "4f8f409a59130220f7510828e556ebb2910917cdad656ff681416ec7aef69f3c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-krunner-1.44.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-krunner;unpack=0"
SRC_URI[x86_64_v2_recoll-krunner.sha256sum] = "e9b03d776d2059d8c2eda16f5091c963be17edc3122db7daa8225de5c015b0fa"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/recoll-libs-1.44.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_recoll-libs;unpack=0"
SRC_URI[x86_64_v2_recoll-libs.sha256sum] = "4ac70271f077ea2f182444cea8d1864013e4f3ebfc41e3c1fbcfd4c246ee623c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-1.44.2-1.el10_2.aarch64.rpm;name=aarch64_recoll;unpack=0"
SRC_URI[aarch64_recoll.sha256sum] = "44de79de4c03c99887798961cabaf06556fb01a31e8511bfcea0a85d65dc9a34"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-devel-1.44.2-1.el10_2.aarch64.rpm;name=aarch64_recoll-devel;unpack=0"
SRC_URI[aarch64_recoll-devel.sha256sum] = "50f8ab7f9c239955553a89447b1985b58808816b920b69a6474343df0e2e548a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-gssp-1.44.2-1.el10_2.aarch64.rpm;name=aarch64_recoll-gssp;unpack=0"
SRC_URI[aarch64_recoll-gssp.sha256sum] = "91b79823eaac8c627fc285fff5863742b4ce07e2e6317cc2facff9ce8d4ca0c2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-helpers-1.44.2-1.el10_2.aarch64.rpm;name=aarch64_recoll-helpers;unpack=0"
SRC_URI[aarch64_recoll-helpers.sha256sum] = "417ebf57d17a06f672ec759320c09371405997b1e0d10b3d3be5be94f93ab71f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-kio-1.44.2-1.el10_2.aarch64.rpm;name=aarch64_recoll-kio;unpack=0"
SRC_URI[aarch64_recoll-kio.sha256sum] = "3d356d3b536915ff9669f4d44ff5efec5bcd9655497dbd8d2b266899b75244dc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-krunner-1.44.2-1.el10_2.aarch64.rpm;name=aarch64_recoll-krunner;unpack=0"
SRC_URI[aarch64_recoll-krunner.sha256sum] = "50170fbfce72e07d8315d48e479659f9942c6c63426c8a0e1c186ffda2edff39"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/recoll-libs-1.44.2-1.el10_2.aarch64.rpm;name=aarch64_recoll-libs;unpack=0"
SRC_URI[aarch64_recoll-libs.sha256sum] = "6629c4774a4fdec9b3c17c410c38c04bbf16d81afb164055e67d92dc14ab3c21"

RDEPENDS:recoll = " \
 aspell \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 perl-interpreter \
 python3 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 recoll-libs \
 xdg-utils \
 "
RDEPENDS:recoll-devel = " \
 recoll-libs \
 "
RDEPENDS:recoll-gssp = " \
 gnome-shell \
 python3 \
 python3-gobject-base \
 recoll \
 "
RDEPENDS:recoll-helpers = " \
 recoll \
 "
RDEPENDS:recoll-kio = " \
 glibc \
 kf6-kio-core-libs \
 libstdc++ \
 qt6-qtbase \
 recoll \
 recoll-libs \
 "
RDEPENDS:recoll-krunner = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-krunner \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 recoll \
 recoll-libs \
 "
RDEPENDS:recoll-libs = " \
 file-libs \
 glibc \
 jsoncpp \
 libX11 \
 libgcc \
 libstdc++ \
 libxml2 \
 libxslt \
 xapian-core-libs \
 zlib-ng-compat \
 "
