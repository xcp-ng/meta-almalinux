# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-py3dns"
PV = "4.0.0"
PR = "11.el10_1"
PACKAGES = " \
 python3-py3dns \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-py3dns-4.0.0-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abff41c98d1b2432a7ae28b7463877de68f1bfbe639f2f339983b83dedb30813"

URI_x86_64_v2_python3-py3dns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-py3dns-4.0.0-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-py3dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-py3dns}"
SRC_URI[x86_64_v2_python3-py3dns.sha256sum] = "0ef6a175553dc530aea4947dc6c6a23f55d98874ea2f542e817cc94f96d958e4"

URI_aarch64_python3-py3dns = "${EPEL_MIRROR}/aarch64/Packages/p/python3-py3dns-4.0.0-11.el10_1.noarch.rpm;name=aarch64_python3-py3dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-py3dns}"
SRC_URI[aarch64_python3-py3dns.sha256sum] = "d4a661acc3008beeaae56d36e4e1c1be6ea22381d96b055104b71d5c3c7b5163"

RDEPENDS:python3-py3dns = " \
 python3 \
 "
