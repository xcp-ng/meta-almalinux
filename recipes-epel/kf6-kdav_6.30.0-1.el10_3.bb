# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdav"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kdav \
 kf6-kdav-devel \
 kf6-kdav-doc \
 kf6-kdav-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kdav-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6821f1bd3428a029b0635fb3cfb0971ce6c9759f2203b7826904ebe3ba8aed23"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav;unpack=0"
SRC_URI[x86_64_v2_kf6-kdav.sha256sum] = "27b7799657f9d2cabe590630f3b22ae628519239c4cb26bd0a4b03a9f6ef48cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdav-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kdav-devel.sha256sum] = "306e16e65e4f5923e260e10d7990506a2b5662aa5012473695e3993cb65f0d49"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdav-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kdav-doc.sha256sum] = "af8a3ac4bf0b7492fc407bd3890e36fb924d2fe62127fc95d094bd2337d39f0d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdav-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdav-html;unpack=0"
SRC_URI[x86_64_v2_kf6-kdav-html.sha256sum] = "3601939fe85f2bba46beed811bb07150b40fcd427269a2047e57ce1cc35a4f7d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdav;unpack=0"
SRC_URI[aarch64_kf6-kdav.sha256sum] = "6254abb06ffbc180698454e4a46965e6ae8e8e783cfe357df47bd33089c6a6f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kdav-devel;unpack=0"
SRC_URI[aarch64_kf6-kdav-devel.sha256sum] = "bf8023cfedd0f24a60833c70b44c3a6fb5a8e73914de00c663976d0143e74eee"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdav-doc;unpack=0"
SRC_URI[aarch64_kf6-kdav-doc.sha256sum] = "e384426812cdb542adcea480926916a1575fa083633fe3810aee90560f55db29"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdav-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kdav-html;unpack=0"
SRC_URI[aarch64_kf6-kdav-html.sha256sum] = "50b20b351775da07bb2e130c3609c03f629709791e9cc198f62e2eb08089a0b3"

RDEPENDS:kf6-kdav = " \
 glibc \
 kf6-filesystem \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kdav-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-kdav \
 "
RDEPENDS:kf6-kdav-doc = " \
 "
RDEPENDS:kf6-kdav-html = " \
 "
