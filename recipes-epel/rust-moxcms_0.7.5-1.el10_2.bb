# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-moxcms"
PV = "0.7.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-moxcms+avx-devel \
 rust-moxcms+default-devel \
 rust-moxcms+neon-devel \
 rust-moxcms+options-devel \
 rust-moxcms+sse-devel \
 rust-moxcms-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-moxcms-0.7.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eeb79cdcc485f4cea1792eb78f62c6d3a8d2a5871b943d543cf9575c87739d4f"

URI_x86_64_v2_rust-moxcms+avx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+avx-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+avx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+avx-devel}"
SRC_URI[x86_64_v2_rust-moxcms+avx-devel.sha256sum] = "8eb8fe1a924c7ff8c2a8928c9d9e3677e9e66aecc42294c4d2716da07d988798"

URI_x86_64_v2_rust-moxcms+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+default-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+default-devel}"
SRC_URI[x86_64_v2_rust-moxcms+default-devel.sha256sum] = "ec1b53327efa65a13baf7d6e36c00c8430f0d66275c64320380c745119fab32f"

URI_x86_64_v2_rust-moxcms+neon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+neon-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+neon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+neon-devel}"
SRC_URI[x86_64_v2_rust-moxcms+neon-devel.sha256sum] = "247d9632b7734ef4d9deb22a6e5f1eb07c616ab26ecdacef02b37ce03fbd094a"

URI_x86_64_v2_rust-moxcms+options-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+options-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+options-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+options-devel}"
SRC_URI[x86_64_v2_rust-moxcms+options-devel.sha256sum] = "231f058e7f0fe0a5c2faaacefc5026f31b663adb9e31cd57f515b4da7c8c9588"

URI_x86_64_v2_rust-moxcms+sse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms+sse-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms+sse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms+sse-devel}"
SRC_URI[x86_64_v2_rust-moxcms+sse-devel.sha256sum] = "a996ce088db9abca54e1dce666273c8a1ac172f116ac32eb82ee738118c4ea02"

URI_x86_64_v2_rust-moxcms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-moxcms-devel-0.7.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-moxcms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-moxcms-devel}"
SRC_URI[x86_64_v2_rust-moxcms-devel.sha256sum] = "c52027cc01f839ff38dbc40895ef110f9bdf7f726a30bdd498df3991998a9612"

URI_aarch64_rust-moxcms+avx-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+avx-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-moxcms+avx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+avx-devel}"
SRC_URI[aarch64_rust-moxcms+avx-devel.sha256sum] = "c1fcd246bbe22cfeabea364b311c6330f7bd0dcc2ff1854b0292daf97950cb9c"

URI_aarch64_rust-moxcms+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+default-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-moxcms+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+default-devel}"
SRC_URI[aarch64_rust-moxcms+default-devel.sha256sum] = "152b278b42ae8602daa996f24081b621ae54f58d4773481d02b6a1b84b6eb0d7"

URI_aarch64_rust-moxcms+neon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+neon-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-moxcms+neon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+neon-devel}"
SRC_URI[aarch64_rust-moxcms+neon-devel.sha256sum] = "83010ce80ba9f41ca1f2001618b3e8adff5de3be6932d0905b599be66dac4ab7"

URI_aarch64_rust-moxcms+options-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+options-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-moxcms+options-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+options-devel}"
SRC_URI[aarch64_rust-moxcms+options-devel.sha256sum] = "6f13336517e2b79659481c57459be4c6671d3fe296e0c319c996a3842fda83aa"

URI_aarch64_rust-moxcms+sse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms+sse-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-moxcms+sse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms+sse-devel}"
SRC_URI[aarch64_rust-moxcms+sse-devel.sha256sum] = "cb48bbeecae917327baccbe338072c419c46c87f53da013bd472c079fb2297f7"

URI_aarch64_rust-moxcms-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-moxcms-devel-0.7.5-1.el10_2.noarch.rpm;name=aarch64_rust-moxcms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-moxcms-devel}"
SRC_URI[aarch64_rust-moxcms-devel.sha256sum] = "df0a16fc43d74d3052a8b1d2d0bca981383610e5e0a8ffc956f180f6960b6803"

RDEPENDS:rust-moxcms+avx-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+default-devel = " \
 cargo \
 rust-moxcms+avx-devel \
 rust-moxcms+neon-devel \
 rust-moxcms+sse-devel \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+neon-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+options-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms+sse-devel = " \
 cargo \
 rust-moxcms-devel \
 "
RDEPENDS:rust-moxcms-devel = " \
 cargo \
 rust \
 rust-num-traits+default-devel \
 rust-pxfm+default-devel \
 "
