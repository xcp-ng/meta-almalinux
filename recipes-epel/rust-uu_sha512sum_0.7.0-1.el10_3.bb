# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_sha512sum"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_sha512sum+default-devel \
 rust-uu_sha512sum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_sha512sum-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36dc09b23e278a4ad961f3229e947ef850c04d5af351046ab4f2622db1a31ec6"

URI_x86_64_v2_rust-uu_sha512sum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha512sum+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha512sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha512sum+default-devel}"
SRC_URI[x86_64_v2_rust-uu_sha512sum+default-devel.sha256sum] = "e38b4e380adf532085d2cf92c7c50445a104157bca61857ad09c075c5a5f3df3"

URI_x86_64_v2_rust-uu_sha512sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha512sum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha512sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha512sum-devel}"
SRC_URI[x86_64_v2_rust-uu_sha512sum-devel.sha256sum] = "e6fb9b1950bcb518db80ed230b0526bd48e1461b3e72207a0a64c92ba43247f2"

URI_aarch64_rust-uu_sha512sum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha512sum+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha512sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha512sum+default-devel}"
SRC_URI[aarch64_rust-uu_sha512sum+default-devel.sha256sum] = "469c0eac31bd282e1361caa98cb667c33b7cd4108494d7a0c64a9539a797597b"

URI_aarch64_rust-uu_sha512sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha512sum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha512sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha512sum-devel}"
SRC_URI[aarch64_rust-uu_sha512sum-devel.sha256sum] = "fb5b3c7effbccc3df0c0ce2a51000fb5bde764c62ebccc9546fee889979f517c"

RDEPENDS:rust-uu_sha512sum+default-devel = " \
 cargo \
 rust-uu_sha512sum-devel \
 "
RDEPENDS:rust-uu_sha512sum-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uu_checksum_common+default-devel \
 rust-uucore+checksum-devel \
 rust-uucore+default-devel \
 rust-uucore+encoding-devel \
 rust-uucore+hardware-devel \
 rust-uucore+sum-devel \
 "
