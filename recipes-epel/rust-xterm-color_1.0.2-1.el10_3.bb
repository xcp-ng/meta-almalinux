# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xterm-color"
PV = "1.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-xterm-color+default-devel \
 rust-xterm-color-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-xterm-color-1.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6010bdea3febd0fcbb80b44030556b1a421c86e27933b856c5f2dde435a07caf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xterm-color+default-devel-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xterm-color+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xterm-color+default-devel.sha256sum] = "440856779213c766d3977ab8287b39697a4d4189c269c09f20192953ee71d006"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xterm-color-devel-1.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xterm-color-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xterm-color-devel.sha256sum] = "600cc433cec3eb74be96da4f32ca7b1266bf09644f6599c184aa19e5c697e001"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xterm-color+default-devel-1.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-xterm-color+default-devel;unpack=0"
SRC_URI[aarch64_rust-xterm-color+default-devel.sha256sum] = "222423a61d2cb5333bd083de4c27c223679f10d866c3ebd20f9978ee7893f1ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xterm-color-devel-1.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-xterm-color-devel;unpack=0"
SRC_URI[aarch64_rust-xterm-color-devel.sha256sum] = "ac01306e6c24421212be0d7d18108320c76a18cf573da868fdbb61360bc173b4"

RDEPENDS:rust-xterm-color+default-devel = " \
 cargo \
 rust-xterm-color-devel \
 "
RDEPENDS:rust-xterm-color-devel = " \
 cargo \
 rust \
 "
