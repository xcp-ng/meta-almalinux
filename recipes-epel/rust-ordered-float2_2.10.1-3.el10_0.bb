# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ordered-float2"
PV = "2.10.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-ordered-float2+arbitrary-devel \
 rust-ordered-float2+default-devel \
 rust-ordered-float2+proptest-devel \
 rust-ordered-float2+rand-devel \
 rust-ordered-float2+randtest-devel \
 rust-ordered-float2+rkyv-devel \
 rust-ordered-float2+serde-devel \
 rust-ordered-float2+std-devel \
 rust-ordered-float2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ordered-float2-2.10.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b99055bc4b4ef5abbd854675774f7ce53c60ff5208897a914cb197b7ca2b62c"

URI_x86_64_v2_rust-ordered-float2+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float2+arbitrary-devel-2.10.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float2+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float2+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-ordered-float2+arbitrary-devel.sha256sum] = "ebfea71bee53ee2bea9c3c50acb9147d95756b534d9fdc42543312a5fefcbaf6"

URI_x86_64_v2_rust-ordered-float2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float2+default-devel-2.10.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float2+default-devel}"
SRC_URI[x86_64_v2_rust-ordered-float2+default-devel.sha256sum] = "5784f9da50339d05e2971a41de228491f463c6ab6a799bda19cdacbf3622041a"

URI_x86_64_v2_rust-ordered-float2+proptest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float2+proptest-devel-2.10.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float2+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float2+proptest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float2+proptest-devel.sha256sum] = "9d3a32f00c3c8c0c9c7fb93d747317ebb23f568c4e36612cba1943eca5488016"

URI_x86_64_v2_rust-ordered-float2+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float2+rand-devel-2.10.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float2+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float2+rand-devel}"
SRC_URI[x86_64_v2_rust-ordered-float2+rand-devel.sha256sum] = "31c21241300baf9727964c7d4e6d469e454c8fd4ed7bad85c9e7b8c1202e5773"

URI_x86_64_v2_rust-ordered-float2+randtest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float2+randtest-devel-2.10.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float2+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float2+randtest-devel}"
SRC_URI[x86_64_v2_rust-ordered-float2+randtest-devel.sha256sum] = "42a03078ffd9f54ccf84532e60895e1b2585fec2495ed6cd36933a85b09d7199"

URI_x86_64_v2_rust-ordered-float2+rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float2+rkyv-devel-2.10.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float2+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float2+rkyv-devel}"
SRC_URI[x86_64_v2_rust-ordered-float2+rkyv-devel.sha256sum] = "5de2fcb01819df99e9dca60555384e105688408a0e91b882fa1d21f16b4e5294"

URI_x86_64_v2_rust-ordered-float2+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float2+serde-devel-2.10.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float2+serde-devel}"
SRC_URI[x86_64_v2_rust-ordered-float2+serde-devel.sha256sum] = "32d3eb550370bacec0a9750468415651ba572a5bba47d98fa9af825103751eeb"

URI_x86_64_v2_rust-ordered-float2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float2+std-devel-2.10.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float2+std-devel}"
SRC_URI[x86_64_v2_rust-ordered-float2+std-devel.sha256sum] = "49f7805030840056cda4ccee3229151471ae46f05222f23c397b5d7a1d7ac40a"

URI_x86_64_v2_rust-ordered-float2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ordered-float2-devel-2.10.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ordered-float2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ordered-float2-devel}"
SRC_URI[x86_64_v2_rust-ordered-float2-devel.sha256sum] = "84e85b685d5c9b744ff59d6d82bf7c578f92d75b66a474c73dd8620d4727ec0c"

URI_aarch64_rust-ordered-float2+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float2+arbitrary-devel-2.10.1-3.el10_0.noarch.rpm;name=aarch64_rust-ordered-float2+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float2+arbitrary-devel}"
SRC_URI[aarch64_rust-ordered-float2+arbitrary-devel.sha256sum] = "834de90219be2c166f5d2b6f4bdb74ceb7926fc9eff45ad20055439ab35eaa2e"

URI_aarch64_rust-ordered-float2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float2+default-devel-2.10.1-3.el10_0.noarch.rpm;name=aarch64_rust-ordered-float2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float2+default-devel}"
SRC_URI[aarch64_rust-ordered-float2+default-devel.sha256sum] = "e381dc9cf5d5c33a548f117b01076ca0395699d508cab225fcfcc14cd4e3342b"

URI_aarch64_rust-ordered-float2+proptest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float2+proptest-devel-2.10.1-3.el10_0.noarch.rpm;name=aarch64_rust-ordered-float2+proptest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float2+proptest-devel}"
SRC_URI[aarch64_rust-ordered-float2+proptest-devel.sha256sum] = "e36e5d0cb0c57361fdb0f4e41231f6b0154ed916a7a782533cb64b9a4da7656d"

URI_aarch64_rust-ordered-float2+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float2+rand-devel-2.10.1-3.el10_0.noarch.rpm;name=aarch64_rust-ordered-float2+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float2+rand-devel}"
SRC_URI[aarch64_rust-ordered-float2+rand-devel.sha256sum] = "9e2b0a1a6aa3794baa72bfbc1cae4fba86b81f26cd73bbe21212b5723dae4d5e"

URI_aarch64_rust-ordered-float2+randtest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float2+randtest-devel-2.10.1-3.el10_0.noarch.rpm;name=aarch64_rust-ordered-float2+randtest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float2+randtest-devel}"
SRC_URI[aarch64_rust-ordered-float2+randtest-devel.sha256sum] = "494087470323c7e785ebb62f588c95d0046679dc5f2dbcf0b45a695f0b3121a0"

URI_aarch64_rust-ordered-float2+rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float2+rkyv-devel-2.10.1-3.el10_0.noarch.rpm;name=aarch64_rust-ordered-float2+rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float2+rkyv-devel}"
SRC_URI[aarch64_rust-ordered-float2+rkyv-devel.sha256sum] = "69a33ff9d8e03b600dc2ef2b97fc5ddfe1a3a0aede258b2f7f50e0ee589c7731"

URI_aarch64_rust-ordered-float2+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float2+serde-devel-2.10.1-3.el10_0.noarch.rpm;name=aarch64_rust-ordered-float2+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float2+serde-devel}"
SRC_URI[aarch64_rust-ordered-float2+serde-devel.sha256sum] = "30cb97fcff78b20ee9002d6f0e30d7f53d023c7dae98e0315bb01381e9a1fd96"

URI_aarch64_rust-ordered-float2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float2+std-devel-2.10.1-3.el10_0.noarch.rpm;name=aarch64_rust-ordered-float2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float2+std-devel}"
SRC_URI[aarch64_rust-ordered-float2+std-devel.sha256sum] = "30a81f14c9d24a189f8b6cb9f2eba486181fb0b311ed4940ecca03c1d7a918df"

URI_aarch64_rust-ordered-float2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ordered-float2-devel-2.10.1-3.el10_0.noarch.rpm;name=aarch64_rust-ordered-float2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ordered-float2-devel}"
SRC_URI[aarch64_rust-ordered-float2-devel.sha256sum] = "d7f471edf38f6b823472858c041f87cd9fd907844ddc57aad93d63d19253c09b"

RDEPENDS:rust-ordered-float2+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-ordered-float2-devel \
 "
RDEPENDS:rust-ordered-float2+default-devel = " \
 cargo \
 rust-ordered-float2+std-devel \
 rust-ordered-float2-devel \
 "
RDEPENDS:rust-ordered-float2+proptest-devel = " \
 cargo \
 rust-ordered-float2-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-ordered-float2+rand-devel = " \
 cargo \
 rust-ordered-float2-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float2+randtest-devel = " \
 cargo \
 rust-ordered-float2-devel \
 rust-rand0.8+std-devel \
 rust-rand0.8+std_rng-devel \
 rust-rand0.8-devel \
 "
RDEPENDS:rust-ordered-float2+rkyv-devel = " \
 cargo \
 rust-ordered-float2-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-ordered-float2+serde-devel = " \
 cargo \
 rust-ordered-float2-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-ordered-float2+std-devel = " \
 cargo \
 rust-num-traits+std-devel \
 rust-ordered-float2-devel \
 "
RDEPENDS:rust-ordered-float2-devel = " \
 cargo \
 rust-num-traits-devel \
 "
