# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http-content-range"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-http-content-range+default-devel \
 rust-http-content-range-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-content-range-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a7deeb2fdce997717c0c5f6d2d7711addcc82256f16befd074bf9b76bd78d5e"

URI_x86_64_v2_rust-http-content-range+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-content-range+default-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-content-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-content-range+default-devel}"
SRC_URI[x86_64_v2_rust-http-content-range+default-devel.sha256sum] = "79c3b24692f6bab37c522109f0c70f4495bdb25fb2b6f458b88291e8f99c433f"

URI_x86_64_v2_rust-http-content-range-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-content-range-devel-0.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-content-range-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-content-range-devel}"
SRC_URI[x86_64_v2_rust-http-content-range-devel.sha256sum] = "e41ad5afec66e0df49480fb376d0e5f2a7da92b18e178f7a3ccae65b982fe17c"

URI_aarch64_rust-http-content-range+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-content-range+default-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-http-content-range+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-content-range+default-devel}"
SRC_URI[aarch64_rust-http-content-range+default-devel.sha256sum] = "0f6c6f0212df2f5b8a4d514a431096dbffb6d4c1b914d60b46e828a71ca6ca61"

URI_aarch64_rust-http-content-range-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-content-range-devel-0.2.4-1.el10_0.noarch.rpm;name=aarch64_rust-http-content-range-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-content-range-devel}"
SRC_URI[aarch64_rust-http-content-range-devel.sha256sum] = "4c090c9d392ed61a54187088aa69f73ff08fe539b890a3dd9ca17b5ac845bb3d"

RDEPENDS:rust-http-content-range+default-devel = " \
 cargo \
 rust-http-content-range-devel \
 "
RDEPENDS:rust-http-content-range-devel = " \
 cargo \
 rust \
 "
