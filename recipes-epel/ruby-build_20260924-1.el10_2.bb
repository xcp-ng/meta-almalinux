# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ruby-build"
PV = "20260924"
PR = "1.el10_2"
PACKAGES = " \
 ruby-build \
 ruby-build-all \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-rbenv \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/ruby-build-20260924-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8d702402b3d92c61188b24ea4690c6e0c65a677e668ee8d601024e49d432e1ae"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build;unpack=0"
SRC_URI[x86_64_v2_ruby-build.sha256sum] = "db0e4498602fbe457a4ce0be04107247be8f43ad4f79c0558135d5cffd7a0b4f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-all-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-all;unpack=0"
SRC_URI[x86_64_v2_ruby-build-all.sha256sum] = "c4ebf4fe79830d07d49c268556bb49e9764b12fc58340f25c185b832334a290c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-core-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-core;unpack=0"
SRC_URI[x86_64_v2_ruby-build-core.sha256sum] = "2e2b6facb867339cb73d9ec4e621802b12dcd3c1a2f7f02f4c1c26f27f091e9e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-jruby-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-jruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-jruby.sha256sum] = "d7923f54e3f460bf495a1e7c9d392070d97f21daca4054800a769bcb7ca5bf8d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-mruby-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-mruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-mruby.sha256sum] = "2d71b9e4e2a112519b23fe63697d2d35f39e045ea9aec2aa60e3b6f8c105cc40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-others-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-others;unpack=0"
SRC_URI[x86_64_v2_ruby-build-others.sha256sum] = "207290f6db66ef17b2159ae2c1ed417a52cfac821acac3e877eb3c38aba9d584"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-picoruby-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-picoruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-picoruby.sha256sum] = "eb8bcc83b2526f2d9c19d590053ff0ae1b223a4e07dcb80fe0173bbd43dcd23d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-rbenv-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-rbenv;unpack=0"
SRC_URI[x86_64_v2_ruby-build-rbenv.sha256sum] = "de9b012d895e99231491d4ec3f43eeca5610df0ad28881730a5625d28cf8759f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-ruby-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-ruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-ruby.sha256sum] = "c8a7d0d50e40d8e81eedf3c950580ec0c25a447b3b7bd268c8843681a9a00a0b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ruby-build-truffleruby-20260924-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ruby-build-truffleruby;unpack=0"
SRC_URI[x86_64_v2_ruby-build-truffleruby.sha256sum] = "768c2a6f3d9ae8f022fe0e121b54a0a9bdd3e5bc52dbe2f75d5d171586b736c3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build;unpack=0"
SRC_URI[aarch64_ruby-build.sha256sum] = "8149426bc05e991109cd72d8d3207726e7776fdae80075edc90452b8ff22c07f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-all-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build-all;unpack=0"
SRC_URI[aarch64_ruby-build-all.sha256sum] = "6829da4836132d939e84dfe7478937767c443d1c3be2fc556ec41862c29bb066"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-core-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build-core;unpack=0"
SRC_URI[aarch64_ruby-build-core.sha256sum] = "73eed9fececcbebb055a5bd29154d99ffea509968f3d48f5e9502c0d822ab446"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-jruby-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build-jruby;unpack=0"
SRC_URI[aarch64_ruby-build-jruby.sha256sum] = "a7ee2ef8a95d1271882c0af299430a73cd2883e29a7a8a3ec0d1d8414cbfde20"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-mruby-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build-mruby;unpack=0"
SRC_URI[aarch64_ruby-build-mruby.sha256sum] = "cf00949bbdd45b0aa2e3f56423046caf48eb40fba51b2dc678c4ca50ee624450"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-others-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build-others;unpack=0"
SRC_URI[aarch64_ruby-build-others.sha256sum] = "daa5287d481f137f54a5664c15c6e8f460b7b78f2ec14a038e1ebbda45cf2ea9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-picoruby-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build-picoruby;unpack=0"
SRC_URI[aarch64_ruby-build-picoruby.sha256sum] = "9da9097038afe6f906f4d52245e5ea7f1074797cd094bcdc0bcc896ce94c5dda"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-rbenv-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build-rbenv;unpack=0"
SRC_URI[aarch64_ruby-build-rbenv.sha256sum] = "efa95585b6a5a582e80149c4286949a4098c754a3e798662a084fe5777fe8973"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-ruby-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build-ruby;unpack=0"
SRC_URI[aarch64_ruby-build-ruby.sha256sum] = "122dd5a2134c23412ba0e32d87d209984bb4c5a3a460295bf3d1c28d6199b797"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/ruby-build-truffleruby-20260924-1.el10_2.noarch.rpm;name=aarch64_ruby-build-truffleruby;unpack=0"
SRC_URI[aarch64_ruby-build-truffleruby.sha256sum] = "6586f56adced10f169c7b3b78a1aec34ad32573e4472a9a6dde8c01d320ab54c"

RDEPENDS:ruby-build = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-all = " \
 ruby-build \
 ruby-build-core \
 ruby-build-jruby \
 ruby-build-mruby \
 ruby-build-others \
 ruby-build-picoruby \
 ruby-build-ruby \
 ruby-build-truffleruby \
 "
RDEPENDS:ruby-build-core = " \
 bash \
 "
RDEPENDS:ruby-build-jruby = " \
 gcc-c++ \
 java-latest-openjdk-headless \
 make \
 ruby-build-core \
 "
RDEPENDS:ruby-build-mruby = " \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-others = " \
 ruby-build-core \
 "
RDEPENDS:ruby-build-picoruby = " \
 gcc \
 git-core \
 ruby \
 ruby-build-core \
 rubygem-rake \
 "
RDEPENDS:ruby-build-rbenv = " \
 bash \
 rbenv \
 ruby-build \
 "
RDEPENDS:ruby-build-ruby = " \
 gcc \
 libffi-devel \
 libyaml-devel \
 perl-File-Compare \
 perl-File-Copy \
 perl-FindBin \
 perl-IPC-Cmd \
 perl-Time-Piece \
 perl-interpreter \
 perl-lib \
 ruby-build-core \
 zlib-ng-compat-devel \
 "
RDEPENDS:ruby-build-truffleruby = " \
 gcc \
 libyaml-devel \
 ruby-build-core \
 "
