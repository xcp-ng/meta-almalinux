# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glibc"
PV = "2.39"
PR = "58.el10_1.7.alma.1"
PACKAGES = " \
 glibc \
 glibc-all-langpacks \
 glibc-benchtests \
 glibc-common \
 glibc-devel \
 glibc-doc \
 glibc-gconv-extra \
 glibc-langpack-aa \
 glibc-langpack-af \
 glibc-langpack-agr \
 glibc-langpack-ak \
 glibc-langpack-am \
 glibc-langpack-an \
 glibc-langpack-anp \
 glibc-langpack-ar \
 glibc-langpack-as \
 glibc-langpack-ast \
 glibc-langpack-ayc \
 glibc-langpack-az \
 glibc-langpack-be \
 glibc-langpack-bem \
 glibc-langpack-ber \
 glibc-langpack-bg \
 glibc-langpack-bhb \
 glibc-langpack-bho \
 glibc-langpack-bi \
 glibc-langpack-bn \
 glibc-langpack-bo \
 glibc-langpack-br \
 glibc-langpack-brx \
 glibc-langpack-bs \
 glibc-langpack-byn \
 glibc-langpack-ca \
 glibc-langpack-ce \
 glibc-langpack-chr \
 glibc-langpack-ckb \
 glibc-langpack-cmn \
 glibc-langpack-crh \
 glibc-langpack-cs \
 glibc-langpack-csb \
 glibc-langpack-cv \
 glibc-langpack-cy \
 glibc-langpack-da \
 glibc-langpack-de \
 glibc-langpack-doi \
 glibc-langpack-dsb \
 glibc-langpack-dv \
 glibc-langpack-dz \
 glibc-langpack-el \
 glibc-langpack-en \
 glibc-langpack-eo \
 glibc-langpack-es \
 glibc-langpack-et \
 glibc-langpack-eu \
 glibc-langpack-fa \
 glibc-langpack-ff \
 glibc-langpack-fi \
 glibc-langpack-fil \
 glibc-langpack-fo \
 glibc-langpack-fr \
 glibc-langpack-fur \
 glibc-langpack-fy \
 glibc-langpack-ga \
 glibc-langpack-gbm \
 glibc-langpack-gd \
 glibc-langpack-gez \
 glibc-langpack-gl \
 glibc-langpack-gu \
 glibc-langpack-gv \
 glibc-langpack-ha \
 glibc-langpack-hak \
 glibc-langpack-he \
 glibc-langpack-hi \
 glibc-langpack-hif \
 glibc-langpack-hne \
 glibc-langpack-hr \
 glibc-langpack-hsb \
 glibc-langpack-ht \
 glibc-langpack-hu \
 glibc-langpack-hy \
 glibc-langpack-ia \
 glibc-langpack-id \
 glibc-langpack-ig \
 glibc-langpack-ik \
 glibc-langpack-is \
 glibc-langpack-it \
 glibc-langpack-iu \
 glibc-langpack-ja \
 glibc-langpack-ka \
 glibc-langpack-kab \
 glibc-langpack-kk \
 glibc-langpack-kl \
 glibc-langpack-km \
 glibc-langpack-kn \
 glibc-langpack-ko \
 glibc-langpack-kok \
 glibc-langpack-ks \
 glibc-langpack-ku \
 glibc-langpack-kv \
 glibc-langpack-kw \
 glibc-langpack-ky \
 glibc-langpack-lb \
 glibc-langpack-lg \
 glibc-langpack-li \
 glibc-langpack-lij \
 glibc-langpack-ln \
 glibc-langpack-lo \
 glibc-langpack-lt \
 glibc-langpack-lv \
 glibc-langpack-lzh \
 glibc-langpack-mag \
 glibc-langpack-mai \
 glibc-langpack-mfe \
 glibc-langpack-mg \
 glibc-langpack-mhr \
 glibc-langpack-mi \
 glibc-langpack-miq \
 glibc-langpack-mjw \
 glibc-langpack-mk \
 glibc-langpack-ml \
 glibc-langpack-mn \
 glibc-langpack-mni \
 glibc-langpack-mnw \
 glibc-langpack-mr \
 glibc-langpack-ms \
 glibc-langpack-mt \
 glibc-langpack-my \
 glibc-langpack-nan \
 glibc-langpack-nb \
 glibc-langpack-nds \
 glibc-langpack-ne \
 glibc-langpack-nhn \
 glibc-langpack-niu \
 glibc-langpack-nl \
 glibc-langpack-nn \
 glibc-langpack-nr \
 glibc-langpack-nso \
 glibc-langpack-oc \
 glibc-langpack-om \
 glibc-langpack-or \
 glibc-langpack-os \
 glibc-langpack-pa \
 glibc-langpack-pap \
 glibc-langpack-pl \
 glibc-langpack-ps \
 glibc-langpack-pt \
 glibc-langpack-quz \
 glibc-langpack-raj \
 glibc-langpack-rif \
 glibc-langpack-ro \
 glibc-langpack-ru \
 glibc-langpack-rw \
 glibc-langpack-sa \
 glibc-langpack-sah \
 glibc-langpack-sat \
 glibc-langpack-sc \
 glibc-langpack-sd \
 glibc-langpack-se \
 glibc-langpack-sgs \
 glibc-langpack-shn \
 glibc-langpack-shs \
 glibc-langpack-si \
 glibc-langpack-sid \
 glibc-langpack-sk \
 glibc-langpack-sl \
 glibc-langpack-sm \
 glibc-langpack-so \
 glibc-langpack-sq \
 glibc-langpack-sr \
 glibc-langpack-ss \
 glibc-langpack-ssy \
 glibc-langpack-st \
 glibc-langpack-su \
 glibc-langpack-sv \
 glibc-langpack-sw \
 glibc-langpack-syr \
 glibc-langpack-szl \
 glibc-langpack-ta \
 glibc-langpack-tcy \
 glibc-langpack-te \
 glibc-langpack-tg \
 glibc-langpack-th \
 glibc-langpack-the \
 glibc-langpack-ti \
 glibc-langpack-tig \
 glibc-langpack-tk \
 glibc-langpack-tl \
 glibc-langpack-tn \
 glibc-langpack-to \
 glibc-langpack-tok \
 glibc-langpack-tpi \
 glibc-langpack-tr \
 glibc-langpack-ts \
 glibc-langpack-tt \
 glibc-langpack-ug \
 glibc-langpack-uk \
 glibc-langpack-unm \
 glibc-langpack-ur \
 glibc-langpack-uz \
 glibc-langpack-ve \
 glibc-langpack-vi \
 glibc-langpack-wa \
 glibc-langpack-wae \
 glibc-langpack-wal \
 glibc-langpack-wo \
 glibc-langpack-xh \
 glibc-langpack-yi \
 glibc-langpack-yo \
 glibc-langpack-yue \
 glibc-langpack-yuw \
 glibc-langpack-zgh \
 glibc-langpack-zh \
 glibc-langpack-zu \
 glibc-locale-source \
 glibc-minimal-langpack \
 glibc-nss-devel \
 glibc-static \
 glibc-utils \
 libnsl \
 nss_db \
 nss_hesiod \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/glibc-2.39-58.el10_1.7.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0df1568a72e0e2f1aa61fbc2f08bd0b65915a5bf88f6af58ab691c1e67ed98ac"

URI_x86_64_v2_glibc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc}"
SRC_URI[x86_64_v2_glibc.sha256sum] = "6f1a9801dc399521d52b8ac75eb4c6778c1ddd276d67068498386a7dd7c47ab4"

URI_x86_64_v2_glibc-all-langpacks = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-all-langpacks-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-all-langpacks}"
SRC_URI[x86_64_v2_glibc-all-langpacks.sha256sum] = "1ed9281c11d32bdd94c8321918a7d8a9055382dfe49ce6659d615b4e9b2fe377"
RPROVIDES:glibc-all-langpacks:x86_64_v2 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-benchtests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-benchtests-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-benchtests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-benchtests}"
SRC_URI[x86_64_v2_glibc-benchtests.sha256sum] = "bbefb4e68da29900c71291894a0ac62e10143d898f19eeb99e34fb809b67e514"

URI_x86_64_v2_glibc-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-common-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-common}"
SRC_URI[x86_64_v2_glibc-common.sha256sum] = "5fb2a50d06beb93ec9870a72465512ea0bf906f512efa463f361813511905834"

URI_x86_64_v2_glibc-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-devel-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-devel}"
SRC_URI[x86_64_v2_glibc-devel.sha256sum] = "34eda6c9d1cf4f73062da5d5bc2e84f17c5c8114cb46171cf4fef691ac1fc40c"

URI_x86_64_v2_glibc-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-doc-2.39-58.el10_1.7.alma.1.noarch.rpm;name=x86_64_v2_glibc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-doc}"
SRC_URI[x86_64_v2_glibc-doc.sha256sum] = "b2422e9d9937d429da8df4c844201296ea1f22ce407357c48fc793ee07b10045"

URI_x86_64_v2_glibc-gconv-extra = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-gconv-extra-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-gconv-extra;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-gconv-extra}"
SRC_URI[x86_64_v2_glibc-gconv-extra.sha256sum] = "07134483ab0a5d7672e45dc1adca3a745471442c658e1c803a2bb83bdb43f3dc"

URI_x86_64_v2_glibc-langpack-aa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-aa-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-aa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-aa}"
SRC_URI[x86_64_v2_glibc-langpack-aa.sha256sum] = "525f6e653c204b895ca1924be17d841ebdfc2d1a04bf4a2d8ef216699165fbd8"
RPROVIDES:glibc-langpack-aa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-af = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-af-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-af;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-af}"
SRC_URI[x86_64_v2_glibc-langpack-af.sha256sum] = "81fae5b24e23bb72753e72d498c4559f08b85661646a30a2ea850477e02df902"
RPROVIDES:glibc-langpack-af:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-agr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-agr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-agr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-agr}"
SRC_URI[x86_64_v2_glibc-langpack-agr.sha256sum] = "c6189028dc10766a284675ce38305eff99a436246a136e50a2ef94e9f0eb73ce"
RPROVIDES:glibc-langpack-agr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ak = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ak-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ak}"
SRC_URI[x86_64_v2_glibc-langpack-ak.sha256sum] = "08d2e2a0d9a8da726ad67daaba524a1ea7d4813053e33bb99837620ffa82edb0"
RPROVIDES:glibc-langpack-ak:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-am = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-am-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-am;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-am}"
SRC_URI[x86_64_v2_glibc-langpack-am.sha256sum] = "53a250b62f5356d2cc8cdbc879cb321c2f3f9108b7522f2d0fa8c468ba9e8da0"
RPROVIDES:glibc-langpack-am:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-an = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-an-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-an;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-an}"
SRC_URI[x86_64_v2_glibc-langpack-an.sha256sum] = "d9daefa495b33f7b5d54176b58b5a7714f32daaeebdea4ff88fbce13d538c85a"
RPROVIDES:glibc-langpack-an:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-anp = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-anp-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-anp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-anp}"
SRC_URI[x86_64_v2_glibc-langpack-anp.sha256sum] = "d01b1b8d13bc9f05caf72e353b6fe0d1321998bcb23fa209947d6c789a93b13a"
RPROVIDES:glibc-langpack-anp:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ar = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ar-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ar;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ar}"
SRC_URI[x86_64_v2_glibc-langpack-ar.sha256sum] = "105eb0c417b1577ee881fc00cfe29d2c873dda20309360c239af853a53056c03"
RPROVIDES:glibc-langpack-ar:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-as = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-as-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-as;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-as}"
SRC_URI[x86_64_v2_glibc-langpack-as.sha256sum] = "9cb91a7fdc560a9b1cdfb9075a92fb0d19c7c200fcc2e32b118e7d0f9324b2e1"
RPROVIDES:glibc-langpack-as:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ast = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ast-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ast}"
SRC_URI[x86_64_v2_glibc-langpack-ast.sha256sum] = "bb3fd189a98ffa82ff7e923c85c00fb06fae5f96502de74bf538139a9924c8d9"
RPROVIDES:glibc-langpack-ast:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ayc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ayc-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ayc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ayc}"
SRC_URI[x86_64_v2_glibc-langpack-ayc.sha256sum] = "b61901a7bbc2e021390108890b04592000c53d3ec412cd0452ceb200bd64baf4"
RPROVIDES:glibc-langpack-ayc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-az = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-az-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-az;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-az}"
SRC_URI[x86_64_v2_glibc-langpack-az.sha256sum] = "76b948766d152fb3563ba9459bb76298bc84a06b6a62780e5e1888724c730f7e"
RPROVIDES:glibc-langpack-az:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-be = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-be-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-be;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-be}"
SRC_URI[x86_64_v2_glibc-langpack-be.sha256sum] = "e5a069efe3d49c3ab36d9771e5f6981d95cc0655e55c5f2fa4854b200642f18d"
RPROVIDES:glibc-langpack-be:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-bem = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bem-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bem}"
SRC_URI[x86_64_v2_glibc-langpack-bem.sha256sum] = "493ac7d5958047520b8fd205c5f9bacffa991f62e1548f36b35a3e463283a42b"
RPROVIDES:glibc-langpack-bem:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ber = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ber-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ber;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ber}"
SRC_URI[x86_64_v2_glibc-langpack-ber.sha256sum] = "529283af3541caa68ff0f1a388b154f2c7bfde29d3a6f3fd5ae5d69949e4f9f2"
RPROVIDES:glibc-langpack-ber:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-bg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bg-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bg}"
SRC_URI[x86_64_v2_glibc-langpack-bg.sha256sum] = "f28e17e8d8fb9bde9251b92e68ef5a689a7a4ec3e9f6fddf00c241a3f096ed6d"
RPROVIDES:glibc-langpack-bg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-bhb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bhb-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bhb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bhb}"
SRC_URI[x86_64_v2_glibc-langpack-bhb.sha256sum] = "6191b98e0be67a9cc432d5393063e802d38a26572c1963f6701d7d80c828173e"
RPROVIDES:glibc-langpack-bhb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-bho = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bho-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bho;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bho}"
SRC_URI[x86_64_v2_glibc-langpack-bho.sha256sum] = "7bb268a61c863e8861b0088bdcc15582f887d1644a2cbf967ec7c2e4376aa5d1"
RPROVIDES:glibc-langpack-bho:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-bi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bi-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bi}"
SRC_URI[x86_64_v2_glibc-langpack-bi.sha256sum] = "8e2ffbdd35441c7dbd58e67dbf153a2972f996ad05b7438d9a1877bbe5351351"
RPROVIDES:glibc-langpack-bi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-bn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bn-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bn}"
SRC_URI[x86_64_v2_glibc-langpack-bn.sha256sum] = "e9988a512df1463b4c07a8da4a48dcab879c9cd37a1b7795410b913e30a1494f"
RPROVIDES:glibc-langpack-bn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-bo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bo-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bo}"
SRC_URI[x86_64_v2_glibc-langpack-bo.sha256sum] = "88d562a37cfe311c156ff1639aff51b8566edaf87c5d0f1713315969bcb32ae2"
RPROVIDES:glibc-langpack-bo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-br = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-br-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-br;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-br}"
SRC_URI[x86_64_v2_glibc-langpack-br.sha256sum] = "9dd72e99959ea639ee3bd9aacae910a08b9337c9bc941a601f5108dbfe8d104e"
RPROVIDES:glibc-langpack-br:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-brx = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-brx-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-brx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-brx}"
SRC_URI[x86_64_v2_glibc-langpack-brx.sha256sum] = "5e9aba3fdadf29625e938719e77384091d4e28df78dab08f10680a6747af82ef"
RPROVIDES:glibc-langpack-brx:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-bs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-bs-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-bs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-bs}"
SRC_URI[x86_64_v2_glibc-langpack-bs.sha256sum] = "e75200c0f4a8a09bc627a3ed96a03302fb6886827601ba004c703a39688040bc"
RPROVIDES:glibc-langpack-bs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-byn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-byn-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-byn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-byn}"
SRC_URI[x86_64_v2_glibc-langpack-byn.sha256sum] = "a3c57f899a326451d6fb317ad3a17969e380a756b3be206f18d739edd0e12d95"
RPROVIDES:glibc-langpack-byn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ca = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ca-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ca;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ca}"
SRC_URI[x86_64_v2_glibc-langpack-ca.sha256sum] = "ba83b5486075faf2a6847144d0cd04ab7cc9fe388461b0409d04f60341d40c62"
RPROVIDES:glibc-langpack-ca:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ce = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ce-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ce}"
SRC_URI[x86_64_v2_glibc-langpack-ce.sha256sum] = "b832a6d3d27fc676226547793bd531aeae638c59f856cba6d0b4fc2e61e1b699"
RPROVIDES:glibc-langpack-ce:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-chr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-chr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-chr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-chr}"
SRC_URI[x86_64_v2_glibc-langpack-chr.sha256sum] = "b57e1728b480777423145e9f5641c7a41bdf2bc3849046644a31a276fde91118"
RPROVIDES:glibc-langpack-chr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ckb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ckb-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ckb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ckb}"
SRC_URI[x86_64_v2_glibc-langpack-ckb.sha256sum] = "f375c6232e20015a6f284751781ec4d2919cb2109f67a78a594d42537bc5b318"
RPROVIDES:glibc-langpack-ckb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-cmn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cmn-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cmn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cmn}"
SRC_URI[x86_64_v2_glibc-langpack-cmn.sha256sum] = "822b64063603fd3b0479b97346766d1bf01757e8d15c4ed422d10c6a7aff4050"
RPROVIDES:glibc-langpack-cmn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-crh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-crh-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-crh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-crh}"
SRC_URI[x86_64_v2_glibc-langpack-crh.sha256sum] = "08ad5caa85f8a857666442204204a2c03a64ea0a534ade472fd8d61243e1c727"
RPROVIDES:glibc-langpack-crh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-cs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cs-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cs}"
SRC_URI[x86_64_v2_glibc-langpack-cs.sha256sum] = "2c19c83cc9e0bd84cbbf6be06d8d55b8ba7850f9fd9c0bb99ce3e1cc20fdc61f"
RPROVIDES:glibc-langpack-cs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-csb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-csb-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-csb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-csb}"
SRC_URI[x86_64_v2_glibc-langpack-csb.sha256sum] = "a29517bc66e7924622c71c69ed5b6639e5ae8e7e11f44bb5aed9d99c2a35d77b"
RPROVIDES:glibc-langpack-csb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-cv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cv-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cv}"
SRC_URI[x86_64_v2_glibc-langpack-cv.sha256sum] = "63629e51283d6b244ca547161fe12cbb917ffeb546ec3d65c002627a73d44ffc"
RPROVIDES:glibc-langpack-cv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-cy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-cy-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-cy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-cy}"
SRC_URI[x86_64_v2_glibc-langpack-cy.sha256sum] = "6f43f13f75636d45ae5deac1c74a43623ca786774a64833c333aea2e2138d388"
RPROVIDES:glibc-langpack-cy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-da = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-da-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-da;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-da}"
SRC_URI[x86_64_v2_glibc-langpack-da.sha256sum] = "75bb0ca4d9a315d520812ba3814d5fb76367f5dfb0387c2e04beb150753500de"
RPROVIDES:glibc-langpack-da:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-de = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-de-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-de;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-de}"
SRC_URI[x86_64_v2_glibc-langpack-de.sha256sum] = "71ba7667c81606d342ce5bfc4011482dde472c1c46276039163724062a899b5f"
RPROVIDES:glibc-langpack-de:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-doi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-doi-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-doi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-doi}"
SRC_URI[x86_64_v2_glibc-langpack-doi.sha256sum] = "42b07704ff75606b3e475abfb8cdca1e67da97481699665fdff91eb7ebda4587"
RPROVIDES:glibc-langpack-doi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-dsb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dsb-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dsb}"
SRC_URI[x86_64_v2_glibc-langpack-dsb.sha256sum] = "c98e7a8bf5f77bd72e429d5a99b33172338bdc34c13ccab78ffe84130325f740"
RPROVIDES:glibc-langpack-dsb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-dv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dv-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dv}"
SRC_URI[x86_64_v2_glibc-langpack-dv.sha256sum] = "d15defd20eba4fe70682e0f3b12578486a2a742a99b75ebedfbec9fa3feaa089"
RPROVIDES:glibc-langpack-dv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-dz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-dz-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-dz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-dz}"
SRC_URI[x86_64_v2_glibc-langpack-dz.sha256sum] = "79c0f9c25e02191d678ec2cac86ed4a6756ff90592e1a8e7aedbe4db282b270e"
RPROVIDES:glibc-langpack-dz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-el = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-el-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-el;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-el}"
SRC_URI[x86_64_v2_glibc-langpack-el.sha256sum] = "d08e9349217d4a3c450718d0a83f8ce942669d79df7fa82aff116e48528b60f9"
RPROVIDES:glibc-langpack-el:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-en = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-en-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-en;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-en}"
SRC_URI[x86_64_v2_glibc-langpack-en.sha256sum] = "22f8a7d2e4b41c4b75a2fcbb4380ff3c8008c06236323a618713af74367988fd"
RPROVIDES:glibc-langpack-en:x86_64_v2 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-eo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eo-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-eo}"
SRC_URI[x86_64_v2_glibc-langpack-eo.sha256sum] = "a8648575ee768eb2edd4c2163978621602b008caeedcfbcc4c224e4cbcb3ee4e"
RPROVIDES:glibc-langpack-eo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-es = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-es-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-es;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-es}"
SRC_URI[x86_64_v2_glibc-langpack-es.sha256sum] = "e972bf0a79ad72458e4857562b3cdd73ba6de540cec35c1dacd7b44d9889654b"
RPROVIDES:glibc-langpack-es:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-et = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-et-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-et;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-et}"
SRC_URI[x86_64_v2_glibc-langpack-et.sha256sum] = "24b22b6c23f9a99454a25edeedc9326beae8c165f804d95fef9efc64f0ee4c80"
RPROVIDES:glibc-langpack-et:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-eu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-eu-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-eu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-eu}"
SRC_URI[x86_64_v2_glibc-langpack-eu.sha256sum] = "ca37c2e9e863f3ed549542ddd2fb282422fecc50488ab396774558dd73f64a76"
RPROVIDES:glibc-langpack-eu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-fa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fa-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fa}"
SRC_URI[x86_64_v2_glibc-langpack-fa.sha256sum] = "2603d4a56a94117af5cfe89d147c1decfcd8c2ef05eb11ad2b6091b6461a5736"
RPROVIDES:glibc-langpack-fa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ff = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ff-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ff}"
SRC_URI[x86_64_v2_glibc-langpack-ff.sha256sum] = "98aa6fc10002620f1798e140a9a8b4adefabd2e5a688a32d86926d6bb29cd83c"
RPROVIDES:glibc-langpack-ff:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-fi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fi-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fi}"
SRC_URI[x86_64_v2_glibc-langpack-fi.sha256sum] = "1960dfe033a4c83bc5c7168b61c800364a5789ea780e3438dc6719c68d5822a8"
RPROVIDES:glibc-langpack-fi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-fil = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fil-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fil;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fil}"
SRC_URI[x86_64_v2_glibc-langpack-fil.sha256sum] = "83ac63c0d5745397c890d2afc9b9de9d89406daf0095f13537ef1b30723f2d2c"
RPROVIDES:glibc-langpack-fil:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-fo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fo-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fo}"
SRC_URI[x86_64_v2_glibc-langpack-fo.sha256sum] = "d8cf0c1c95fd61e2ed9742017e4e14067241fc0a4345257b761e624a2803548e"
RPROVIDES:glibc-langpack-fo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-fr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fr}"
SRC_URI[x86_64_v2_glibc-langpack-fr.sha256sum] = "55993d602dee7179903b6e66591b50390ea4ee080e4a98adf381c2f721a081fb"
RPROVIDES:glibc-langpack-fr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-fur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fur-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fur}"
SRC_URI[x86_64_v2_glibc-langpack-fur.sha256sum] = "cb8110e6f3a6517f16797e8e1f04b529e29e7f800651559e4873e06b0942a2df"
RPROVIDES:glibc-langpack-fur:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-fy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-fy-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-fy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-fy}"
SRC_URI[x86_64_v2_glibc-langpack-fy.sha256sum] = "0f5e35a85facba4bf302f5b80995d41775fd52dfe6557029c54861243b3b2cf4"
RPROVIDES:glibc-langpack-fy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ga = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ga-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ga;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ga}"
SRC_URI[x86_64_v2_glibc-langpack-ga.sha256sum] = "021ecfbfcf89b5374972dae040d6546758130d324a0e4ede192dae4919df91ce"
RPROVIDES:glibc-langpack-ga:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-gbm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gbm-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gbm}"
SRC_URI[x86_64_v2_glibc-langpack-gbm.sha256sum] = "af013b3fdfb0ce95368dba769640f64a4fdc673e12e68cde2f0c44d18050ff21"
RPROVIDES:glibc-langpack-gbm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-gd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gd-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gd}"
SRC_URI[x86_64_v2_glibc-langpack-gd.sha256sum] = "01a7576cc568a775922b755ff93e1e1d03d264c23f399dc140d170523a4d66ee"
RPROVIDES:glibc-langpack-gd:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-gez = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gez-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gez;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gez}"
SRC_URI[x86_64_v2_glibc-langpack-gez.sha256sum] = "928f3b29c047cd9bf5db2e8e3fe2a883c0e667f66c229bbdaa77065c989a2877"
RPROVIDES:glibc-langpack-gez:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-gl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gl-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gl}"
SRC_URI[x86_64_v2_glibc-langpack-gl.sha256sum] = "dc9abbc2605a1ffdd67dfe4b0c313f8adeb305dd10bf1dd07a8858b4d1392234"
RPROVIDES:glibc-langpack-gl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-gu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gu-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gu}"
SRC_URI[x86_64_v2_glibc-langpack-gu.sha256sum] = "10620321591f1e0aab37bcc18e9babd515890de7229ef1570dbffeb1da3cee38"
RPROVIDES:glibc-langpack-gu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-gv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-gv-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-gv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-gv}"
SRC_URI[x86_64_v2_glibc-langpack-gv.sha256sum] = "4cd0e539b625f7db6fac5de446f86447052757b87a80ed3ba0524ae399fb8798"
RPROVIDES:glibc-langpack-gv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ha = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ha-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ha;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ha}"
SRC_URI[x86_64_v2_glibc-langpack-ha.sha256sum] = "69550164683508ed4b7214efebb2170fe091aaba7b2d8311d92d50d077833db7"
RPROVIDES:glibc-langpack-ha:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-hak = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hak-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hak;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hak}"
SRC_URI[x86_64_v2_glibc-langpack-hak.sha256sum] = "a9820cac9792295394d420708f23d4df60c666da0ab15eff74b4cb8acbf91b00"
RPROVIDES:glibc-langpack-hak:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-he = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-he-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-he;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-he}"
SRC_URI[x86_64_v2_glibc-langpack-he.sha256sum] = "af5e5e4e14d20096c8427d43300bd58f749c0bdb79a8270235ac7ceb65ec9a92"
RPROVIDES:glibc-langpack-he:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-hi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hi-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hi}"
SRC_URI[x86_64_v2_glibc-langpack-hi.sha256sum] = "487b73f194ad7a6de22a7b3033815a18c0abb6eb45101a1960f35f7cb75a9e1b"
RPROVIDES:glibc-langpack-hi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-hif = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hif-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hif}"
SRC_URI[x86_64_v2_glibc-langpack-hif.sha256sum] = "a7fb1a963389ea78fdd412f316f18772127c25eee6d44039a935fa166f81f403"
RPROVIDES:glibc-langpack-hif:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-hne = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hne-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hne;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hne}"
SRC_URI[x86_64_v2_glibc-langpack-hne.sha256sum] = "152d6e8e7678e7e1dd8047ce8f4c32e972ff8b69cddf37fdc5ae20b5bfa6a891"
RPROVIDES:glibc-langpack-hne:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-hr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hr}"
SRC_URI[x86_64_v2_glibc-langpack-hr.sha256sum] = "50ccca1baf63e7f46387b56ac76999134b01c075cfe666b0e17cb4c8d2622174"
RPROVIDES:glibc-langpack-hr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-hsb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hsb-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hsb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hsb}"
SRC_URI[x86_64_v2_glibc-langpack-hsb.sha256sum] = "345da3a050d19860bd64a9f27ba3ad4b86098cf7c65e17392ddf962ee6667a60"
RPROVIDES:glibc-langpack-hsb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ht = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ht-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ht;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ht}"
SRC_URI[x86_64_v2_glibc-langpack-ht.sha256sum] = "fcefe0f58922bf5ef2219eae3bb707baf34253f745d1cd7568686b32c0c615c8"
RPROVIDES:glibc-langpack-ht:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-hu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hu-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hu}"
SRC_URI[x86_64_v2_glibc-langpack-hu.sha256sum] = "12b7b3b09378b7b140c1395518282e5de8b41bea89a6d4a34fa0d24cd4110a7c"
RPROVIDES:glibc-langpack-hu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-hy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-hy-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-hy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-hy}"
SRC_URI[x86_64_v2_glibc-langpack-hy.sha256sum] = "daac913ae2e54ab06970b119a6e3cc6a29d539f23795722d8640ed4606ee1001"
RPROVIDES:glibc-langpack-hy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ia = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ia-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ia}"
SRC_URI[x86_64_v2_glibc-langpack-ia.sha256sum] = "3ec89ac34e47e18310ac0144191c0ffa096ab0291d1905fdae527e4583235037"
RPROVIDES:glibc-langpack-ia:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-id = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-id-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-id;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-id}"
SRC_URI[x86_64_v2_glibc-langpack-id.sha256sum] = "1a3b75556e809f079b11912ffc28d3373718107fc648a97e5b6d71c68a727d7a"
RPROVIDES:glibc-langpack-id:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ig-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ig}"
SRC_URI[x86_64_v2_glibc-langpack-ig.sha256sum] = "26e5b36a74705d38c09b92ea2f8d188d91000c90570325996b67cda1abb07926"
RPROVIDES:glibc-langpack-ig:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ik = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ik-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ik;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ik}"
SRC_URI[x86_64_v2_glibc-langpack-ik.sha256sum] = "c21aaaa43e431be21f2550ad269314aaf6b165e31cf252d395dd054409f7546d"
RPROVIDES:glibc-langpack-ik:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-is = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-is-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-is;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-is}"
SRC_URI[x86_64_v2_glibc-langpack-is.sha256sum] = "a415b03baa49d671134f87c4e8f13527328a938fda748712d1f6fbfdf118dcae"
RPROVIDES:glibc-langpack-is:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-it = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-it-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-it;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-it}"
SRC_URI[x86_64_v2_glibc-langpack-it.sha256sum] = "f37064372a6b5649e7c59ddb229c480229fa1bec93beab749f1dc952819b19d9"
RPROVIDES:glibc-langpack-it:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-iu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-iu-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-iu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-iu}"
SRC_URI[x86_64_v2_glibc-langpack-iu.sha256sum] = "5b3c5eec413a3b12c882d5e829bfb645994dfd2b267951873bc8e3ca42fee1d6"
RPROVIDES:glibc-langpack-iu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ja = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ja-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ja;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ja}"
SRC_URI[x86_64_v2_glibc-langpack-ja.sha256sum] = "c709b9cf670c3be6881189e2d4513c2d24e80daf4f3fbda369b2b5e616aa3e4a"
RPROVIDES:glibc-langpack-ja:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ka = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ka-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ka}"
SRC_URI[x86_64_v2_glibc-langpack-ka.sha256sum] = "4f870640658cf383c25e66794cf00343767022cd7afd3acfd8e9c8acda82c8be"
RPROVIDES:glibc-langpack-ka:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-kab = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kab-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kab}"
SRC_URI[x86_64_v2_glibc-langpack-kab.sha256sum] = "6a0a54ed118e8d520dcde85359dcc86378726afd48d9c2f0a95102e16e15676b"
RPROVIDES:glibc-langpack-kab:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-kk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kk-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kk}"
SRC_URI[x86_64_v2_glibc-langpack-kk.sha256sum] = "95fa8f8b710882c1bc56b26c50694511cb8c2469e70b3536114cd9b1d361d674"
RPROVIDES:glibc-langpack-kk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-kl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kl-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kl}"
SRC_URI[x86_64_v2_glibc-langpack-kl.sha256sum] = "4136575b5dde920c3a372f1718e3a56c540d7caa92e96bd2e15195cf1044003b"
RPROVIDES:glibc-langpack-kl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-km = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-km-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-km;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-km}"
SRC_URI[x86_64_v2_glibc-langpack-km.sha256sum] = "7eb8b9aab729f5c524c34aad5f7d9931e6bc98740163542ca9d00e39d3bfcdd7"
RPROVIDES:glibc-langpack-km:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-kn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kn-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kn}"
SRC_URI[x86_64_v2_glibc-langpack-kn.sha256sum] = "b61a57a5f18b7549c24fae4df5f97fdc08e464968e4d6d744caa63f2bd33be71"
RPROVIDES:glibc-langpack-kn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ko = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ko-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ko;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ko}"
SRC_URI[x86_64_v2_glibc-langpack-ko.sha256sum] = "3b4c0df469cd6d18affff3f0d07c38f8714cc228b8e49e9b0863ac287eeec5c7"
RPROVIDES:glibc-langpack-ko:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-kok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kok-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kok}"
SRC_URI[x86_64_v2_glibc-langpack-kok.sha256sum] = "ca6157450bae08c1b0c56cdce1bf4081fc21ad4f27482b4b375001c51fdd9479"
RPROVIDES:glibc-langpack-kok:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ks = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ks-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ks}"
SRC_URI[x86_64_v2_glibc-langpack-ks.sha256sum] = "88cfc9924b89f11532de77393f5316476b0999092e01dc589b1e115a8e5a3705"
RPROVIDES:glibc-langpack-ks:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ku = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ku-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ku;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ku}"
SRC_URI[x86_64_v2_glibc-langpack-ku.sha256sum] = "d956855cd3480d2b05c06c2bf3857837cbb67d0ce8239473fb4a3c9007b68943"
RPROVIDES:glibc-langpack-ku:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-kv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kv-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kv}"
SRC_URI[x86_64_v2_glibc-langpack-kv.sha256sum] = "4ad41c15107c4477e3bbf2ba919bb5243b4fdfe17b5adc0595a413249266e6b6"
RPROVIDES:glibc-langpack-kv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-kw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-kw-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-kw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-kw}"
SRC_URI[x86_64_v2_glibc-langpack-kw.sha256sum] = "c8ec8d4dbb9dea1cb66ba0da04af75bd701a5ddc0ca0458d1f0ff4bae044f8ea"
RPROVIDES:glibc-langpack-kw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ky = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ky-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ky;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ky}"
SRC_URI[x86_64_v2_glibc-langpack-ky.sha256sum] = "808127a6ff9410f2fda547a9f98d7d577c664df070c8db290c76f04b3d1f9439"
RPROVIDES:glibc-langpack-ky:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-lb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lb-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lb}"
SRC_URI[x86_64_v2_glibc-langpack-lb.sha256sum] = "7d1373d8434d9365936e06927baf0919f3fa3862fe2f1ddcbc0733fa5d59745f"
RPROVIDES:glibc-langpack-lb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-lg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lg-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lg}"
SRC_URI[x86_64_v2_glibc-langpack-lg.sha256sum] = "87b51528ca42ac9cee520d30b125546741f5e8339bf38a191efe4dc360fe3653"
RPROVIDES:glibc-langpack-lg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-li = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-li-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-li;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-li}"
SRC_URI[x86_64_v2_glibc-langpack-li.sha256sum] = "a4768779639478109c869774e3cf115f4c0a6391a498a97e3bcb5899a870d874"
RPROVIDES:glibc-langpack-li:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-lij = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lij-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lij;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lij}"
SRC_URI[x86_64_v2_glibc-langpack-lij.sha256sum] = "10c67f0e1605200691135dc6dc1319e017bc2728fd801ec06b9b4eae212b40d8"
RPROVIDES:glibc-langpack-lij:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ln = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ln-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ln;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ln}"
SRC_URI[x86_64_v2_glibc-langpack-ln.sha256sum] = "1d46dda03f047dff71e50d0c6e3e5d26005de8bd07e780c0183535ee608e5678"
RPROVIDES:glibc-langpack-ln:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-lo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lo-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lo}"
SRC_URI[x86_64_v2_glibc-langpack-lo.sha256sum] = "d310648282e989404f8404f5af48919e67eabb3f7ad836621a756035e13a41ac"
RPROVIDES:glibc-langpack-lo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-lt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lt-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lt}"
SRC_URI[x86_64_v2_glibc-langpack-lt.sha256sum] = "c6962a2bdd10806a4bde4c311045661bdc0068d26fae9df2da86fdd4a9e19912"
RPROVIDES:glibc-langpack-lt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-lv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lv-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lv}"
SRC_URI[x86_64_v2_glibc-langpack-lv.sha256sum] = "8068c656fbf317a43aab471d90d25f53e19f27591c817448b92f3c4a1a81f631"
RPROVIDES:glibc-langpack-lv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-lzh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-lzh-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-lzh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-lzh}"
SRC_URI[x86_64_v2_glibc-langpack-lzh.sha256sum] = "ef50e3af6473190bc1a3c6c89f9efa7cdc5b1be592a13e038900da8569d3d9a6"
RPROVIDES:glibc-langpack-lzh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mag = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mag-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mag}"
SRC_URI[x86_64_v2_glibc-langpack-mag.sha256sum] = "bfe6a9c80a15a51fadb1e77676eb7f862e5499c9d291f80f933429d7da9c6048"
RPROVIDES:glibc-langpack-mag:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mai = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mai-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mai;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mai}"
SRC_URI[x86_64_v2_glibc-langpack-mai.sha256sum] = "e075859a7d38e247868964292213b61d5bf09a484d81b4c13e28c57b34e2c0cd"
RPROVIDES:glibc-langpack-mai:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mfe = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mfe-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mfe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mfe}"
SRC_URI[x86_64_v2_glibc-langpack-mfe.sha256sum] = "5a895c66a2823a8030a14433001a27e98bfb289f9b3ddc23d1ca18e3c8077dde"
RPROVIDES:glibc-langpack-mfe:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mg-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mg}"
SRC_URI[x86_64_v2_glibc-langpack-mg.sha256sum] = "302cb56f04d99b6d4d9a4ca8f1afaace33a6e0cdcd2d3725e3549cbb985f6746"
RPROVIDES:glibc-langpack-mg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mhr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mhr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mhr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mhr}"
SRC_URI[x86_64_v2_glibc-langpack-mhr.sha256sum] = "178ae5a9ad786ac46c0517972e3779b2483801595042d2998b32fb0a29923d54"
RPROVIDES:glibc-langpack-mhr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mi-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mi}"
SRC_URI[x86_64_v2_glibc-langpack-mi.sha256sum] = "cd3ba2b428338fdea6eaca5a626f1e43aca9aec2708ee62adc8e285ed4c11cd5"
RPROVIDES:glibc-langpack-mi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-miq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-miq-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-miq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-miq}"
SRC_URI[x86_64_v2_glibc-langpack-miq.sha256sum] = "6f84f08122775bc50a7cadcbebcc7c9a0390688a62553b4d053e268b65a11ce6"
RPROVIDES:glibc-langpack-miq:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mjw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mjw-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mjw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mjw}"
SRC_URI[x86_64_v2_glibc-langpack-mjw.sha256sum] = "7c93ccbeb0e15bfa4ec2138610f2b57d73115794f997c8de526dacd61a4e3d33"
RPROVIDES:glibc-langpack-mjw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mk-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mk}"
SRC_URI[x86_64_v2_glibc-langpack-mk.sha256sum] = "cb942f9a626874f41865b3aacfa6ed85c3d3dcbaf8b6b319c89ad353c290c73c"
RPROVIDES:glibc-langpack-mk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ml = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ml-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ml}"
SRC_URI[x86_64_v2_glibc-langpack-ml.sha256sum] = "697cc471dfaf01c146e518e649ecfbab99d508923daa78b8e24c64a7e84349f3"
RPROVIDES:glibc-langpack-ml:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mn-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mn}"
SRC_URI[x86_64_v2_glibc-langpack-mn.sha256sum] = "6df4b9e82c91564b90d312f5094e4e3ea3d2bb8296f2c8d806d153147b75af21"
RPROVIDES:glibc-langpack-mn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mni = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mni-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mni;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mni}"
SRC_URI[x86_64_v2_glibc-langpack-mni.sha256sum] = "8274f4d5c13ede47e1e09ca6f555969f2c00b5460c9fef3be45fb052f4e99d22"
RPROVIDES:glibc-langpack-mni:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mnw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mnw-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mnw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mnw}"
SRC_URI[x86_64_v2_glibc-langpack-mnw.sha256sum] = "5a2fcd39b7523e663195166f4c370905f9582e16058f99dea0faad4d01b5f462"
RPROVIDES:glibc-langpack-mnw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mr}"
SRC_URI[x86_64_v2_glibc-langpack-mr.sha256sum] = "9a2b7875fa75db8b2d7954c9d7e85d43ce414d9ba55fdacf5d99d811749c913d"
RPROVIDES:glibc-langpack-mr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ms = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ms-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ms}"
SRC_URI[x86_64_v2_glibc-langpack-ms.sha256sum] = "d0420cd032cc73d8effa962d55329fadad544a00a28db77710b9f09789910f5f"
RPROVIDES:glibc-langpack-ms:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-mt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-mt-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-mt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-mt}"
SRC_URI[x86_64_v2_glibc-langpack-mt.sha256sum] = "11f7ff89c94e916aca59c72d8797169d923b78e1bca556ddd1f02c5b12a320f8"
RPROVIDES:glibc-langpack-mt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-my = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-my-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-my;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-my}"
SRC_URI[x86_64_v2_glibc-langpack-my.sha256sum] = "ff40b995ca0e8a7576590f33252f87902a03388fdce65313849913b883da48f1"
RPROVIDES:glibc-langpack-my:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-nan = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nan-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nan}"
SRC_URI[x86_64_v2_glibc-langpack-nan.sha256sum] = "4764d0a26116c4f970064c93369002ffc860e1388aa34fd98bc6ddc67e49a9b7"
RPROVIDES:glibc-langpack-nan:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-nb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nb-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nb}"
SRC_URI[x86_64_v2_glibc-langpack-nb.sha256sum] = "dc6505c22b740605d361c087225476cfcdedaddfa32a84126d9062fed0a70203"
RPROVIDES:glibc-langpack-nb:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-nds = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nds-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nds}"
SRC_URI[x86_64_v2_glibc-langpack-nds.sha256sum] = "cf248351b6b4e1e594e3417e3254f075cb5876114d9345a26acf4efe3602372e"
RPROVIDES:glibc-langpack-nds:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ne = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ne-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ne;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ne}"
SRC_URI[x86_64_v2_glibc-langpack-ne.sha256sum] = "43665cae787b8007f12ec7b92b8eade8f13df95489d41994aff34d9c9a4d8a54"
RPROVIDES:glibc-langpack-ne:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-nhn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nhn-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nhn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nhn}"
SRC_URI[x86_64_v2_glibc-langpack-nhn.sha256sum] = "3669cf372287e1eaa6c3bb35b6968baf30abb7d4519798f7b203bb707997f3d6"
RPROVIDES:glibc-langpack-nhn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-niu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-niu-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-niu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-niu}"
SRC_URI[x86_64_v2_glibc-langpack-niu.sha256sum] = "678dcbbf5b7af1ebfbac14205ed5940352258053f3a30dfa1ecad20745b9f335"
RPROVIDES:glibc-langpack-niu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-nl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nl-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nl}"
SRC_URI[x86_64_v2_glibc-langpack-nl.sha256sum] = "29770253b19e9d37136c6a62a4e7d9635332e3f3e86082ad5eba62a69e08e326"
RPROVIDES:glibc-langpack-nl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-nn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nn-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nn}"
SRC_URI[x86_64_v2_glibc-langpack-nn.sha256sum] = "008ae17706297b6570740f5514f220f016a0373401fd377a3f402338bfaabc5c"
RPROVIDES:glibc-langpack-nn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-nr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nr}"
SRC_URI[x86_64_v2_glibc-langpack-nr.sha256sum] = "21c4c67bcfc51438b72133f04242932df517a4d834f94aeaf1b9718effb8f7dc"
RPROVIDES:glibc-langpack-nr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-nso = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-nso-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-nso;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-nso}"
SRC_URI[x86_64_v2_glibc-langpack-nso.sha256sum] = "2c6d505328b10dfb8c7c40595a4c76ee24aa7c4bcd198497a6e8affa09007ace"
RPROVIDES:glibc-langpack-nso:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-oc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-oc-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-oc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-oc}"
SRC_URI[x86_64_v2_glibc-langpack-oc.sha256sum] = "f85e965121bc0773330b954ee306ee97be13d13a95b169ea2e5d9f52b46f51f2"
RPROVIDES:glibc-langpack-oc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-om = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-om-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-om;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-om}"
SRC_URI[x86_64_v2_glibc-langpack-om.sha256sum] = "1ba4d1306096f7514a2f8539b405320650062e52b7d43eadd1738d5ebb57306a"
RPROVIDES:glibc-langpack-om:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-or = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-or-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-or;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-or}"
SRC_URI[x86_64_v2_glibc-langpack-or.sha256sum] = "af6acfea5997f60eacb3a06cd000e74044c8fcbe7dae278741b96fdc00f1443c"
RPROVIDES:glibc-langpack-or:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-os = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-os-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-os;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-os}"
SRC_URI[x86_64_v2_glibc-langpack-os.sha256sum] = "3f4c769d4499629c28ddda5e15a5da592b1f068a1716fb41a5e2a427eb38ed76"
RPROVIDES:glibc-langpack-os:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-pa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pa-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pa}"
SRC_URI[x86_64_v2_glibc-langpack-pa.sha256sum] = "c4c6fb66c023e3905f6d185280f2c97b251bdd386a29fea94fbd61232ff8f1b9"
RPROVIDES:glibc-langpack-pa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-pap = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pap-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pap}"
SRC_URI[x86_64_v2_glibc-langpack-pap.sha256sum] = "cd8eda309dd0c611a69681ad867c9f9569836a65869c1bb187a14c97a2873fd3"
RPROVIDES:glibc-langpack-pap:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-pl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pl-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pl}"
SRC_URI[x86_64_v2_glibc-langpack-pl.sha256sum] = "d6b234b99d22320aa8a7240c529259e7656f787252572d011ead2a06242d949d"
RPROVIDES:glibc-langpack-pl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ps = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ps-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ps;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ps}"
SRC_URI[x86_64_v2_glibc-langpack-ps.sha256sum] = "894be75ae8992c4ddd5b8fb9e2015f187069c3071f163098bd5878686b770031"
RPROVIDES:glibc-langpack-ps:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-pt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-pt-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-pt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-pt}"
SRC_URI[x86_64_v2_glibc-langpack-pt.sha256sum] = "89583b056fa2297997f0c02951c6e21b76017984407a9a8162eeb555f8e6f1ca"
RPROVIDES:glibc-langpack-pt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-quz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-quz-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-quz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-quz}"
SRC_URI[x86_64_v2_glibc-langpack-quz.sha256sum] = "731464c1d170245faf0ad32c86bc012635ddaf8affd09fe87bfc4ae0f9cb62b4"
RPROVIDES:glibc-langpack-quz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-raj = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-raj-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-raj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-raj}"
SRC_URI[x86_64_v2_glibc-langpack-raj.sha256sum] = "523c169ccb7deae76869c7cdbfb933984cd1c0d4aebfa2fb913cde0e4cd7932e"
RPROVIDES:glibc-langpack-raj:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-rif = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rif-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rif;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-rif}"
SRC_URI[x86_64_v2_glibc-langpack-rif.sha256sum] = "ff66725f2fd493c1da872e44ce7afc95c2e3c024f79117e082150d05a4b89887"
RPROVIDES:glibc-langpack-rif:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ro = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ro-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ro}"
SRC_URI[x86_64_v2_glibc-langpack-ro.sha256sum] = "9cbfe2fda0fc43ebd7def6a7239bdbe9f5d65ee7c930d850041d97783f31f80b"
RPROVIDES:glibc-langpack-ro:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ru = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ru-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ru;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ru}"
SRC_URI[x86_64_v2_glibc-langpack-ru.sha256sum] = "dc70e19caf689940ed113dbf8cbd150d07ce46a3949b181b1e3b261698db142b"
RPROVIDES:glibc-langpack-ru:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-rw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-rw-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-rw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-rw}"
SRC_URI[x86_64_v2_glibc-langpack-rw.sha256sum] = "afdd68a0cb2473d59f20b96b96bdb1ca0107e583858d6d68c1542ec07ac7839b"
RPROVIDES:glibc-langpack-rw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sa-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sa}"
SRC_URI[x86_64_v2_glibc-langpack-sa.sha256sum] = "6add8972c8917dad5e0d8eb94f97a4323852c25934751869020e86935f389d27"
RPROVIDES:glibc-langpack-sa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sah = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sah-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sah;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sah}"
SRC_URI[x86_64_v2_glibc-langpack-sah.sha256sum] = "24fe3c314559e3513d3f438e6c04232ed83c0549fb65844e0c0951ca1e73df47"
RPROVIDES:glibc-langpack-sah:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sat = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sat-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sat}"
SRC_URI[x86_64_v2_glibc-langpack-sat.sha256sum] = "e1ef88406d66a18ba9c462149a848567737f330d523cdbc60586c7f5063cb196"
RPROVIDES:glibc-langpack-sat:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sc-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sc}"
SRC_URI[x86_64_v2_glibc-langpack-sc.sha256sum] = "d3fbe182452cf863fd0f49c7ceadbdd6737d8381ca9123bb8d68ab59f37788b4"
RPROVIDES:glibc-langpack-sc:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sd-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sd}"
SRC_URI[x86_64_v2_glibc-langpack-sd.sha256sum] = "4d558429aa442c730ed255757f272ca7b11dc4e8975e4a8478dacb0718db7e42"
RPROVIDES:glibc-langpack-sd:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-se = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-se-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-se;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-se}"
SRC_URI[x86_64_v2_glibc-langpack-se.sha256sum] = "eb1f07bc9af367f402e8e42a7117ae0a498b23cc0a603acea22415057b0d4961"
RPROVIDES:glibc-langpack-se:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sgs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sgs-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sgs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sgs}"
SRC_URI[x86_64_v2_glibc-langpack-sgs.sha256sum] = "579d953b1daa72da68e8fd18151478001968f3cafac5ca1ee6744f7ca3f133d1"
RPROVIDES:glibc-langpack-sgs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-shn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shn-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-shn}"
SRC_URI[x86_64_v2_glibc-langpack-shn.sha256sum] = "67ae02ac64166a325c796a20234e63795d6fae1a0f8637bd9d25dbf17c6044f7"
RPROVIDES:glibc-langpack-shn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-shs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-shs-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-shs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-shs}"
SRC_URI[x86_64_v2_glibc-langpack-shs.sha256sum] = "1d27df29c687ffa7c046bff0bdb62b6a32cad1e30aac87572bfcef11c6c11c3f"
RPROVIDES:glibc-langpack-shs:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-si = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-si-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-si;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-si}"
SRC_URI[x86_64_v2_glibc-langpack-si.sha256sum] = "75d2e95f033573fbb990115266c90fe76f1d6d860e89ea6b44cd30be894b26d9"
RPROVIDES:glibc-langpack-si:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sid = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sid-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sid}"
SRC_URI[x86_64_v2_glibc-langpack-sid.sha256sum] = "0061243ae0a195e2061731513003faa6148c2ac8c6573932b2b6d65f9d0775d5"
RPROVIDES:glibc-langpack-sid:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sk-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sk}"
SRC_URI[x86_64_v2_glibc-langpack-sk.sha256sum] = "86d69df28e2a0a2af264f3c0924a36495b96af802467ebe93e8598e043300400"
RPROVIDES:glibc-langpack-sk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sl-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sl}"
SRC_URI[x86_64_v2_glibc-langpack-sl.sha256sum] = "56adaf24392481f35886e2150d12a17a058a90f1cfcd57aaaff44e43b0b205bc"
RPROVIDES:glibc-langpack-sl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sm-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sm}"
SRC_URI[x86_64_v2_glibc-langpack-sm.sha256sum] = "dfe482358b98b5efaea53ec1b09b6a66579ef5e303f88fe66f60d5ae21106034"
RPROVIDES:glibc-langpack-sm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-so = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-so-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-so;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-so}"
SRC_URI[x86_64_v2_glibc-langpack-so.sha256sum] = "4b3369be97e3e1f6fdca0674c3652cc67604ac27ad27a79cb44199d317cd6c03"
RPROVIDES:glibc-langpack-so:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sq = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sq-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sq}"
SRC_URI[x86_64_v2_glibc-langpack-sq.sha256sum] = "716b2aecb03bf671e0ad6a7a0dc7d128d761d7bb95313d3827b1be31c8a5bbf3"
RPROVIDES:glibc-langpack-sq:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sr}"
SRC_URI[x86_64_v2_glibc-langpack-sr.sha256sum] = "0eb6207f701f66e2efd15e101c4b2ba9cd0990fa325c569d09086bc026217235"
RPROVIDES:glibc-langpack-sr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ss = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ss-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ss;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ss}"
SRC_URI[x86_64_v2_glibc-langpack-ss.sha256sum] = "81dfc2fb330b996c25b87a8914a5ff604fd96a7c0042e2e455e1ec91a8261d99"
RPROVIDES:glibc-langpack-ss:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ssy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ssy-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ssy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ssy}"
SRC_URI[x86_64_v2_glibc-langpack-ssy.sha256sum] = "d4ea94954279bb8b08a1f33101fb5a09bacdf723673e3965325ec7a9b292d9fa"
RPROVIDES:glibc-langpack-ssy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-st = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-st-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-st;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-st}"
SRC_URI[x86_64_v2_glibc-langpack-st.sha256sum] = "0e14b790f20f22cb397e066525920d443b6fa5c7125013d9436806eb2c5b5cd2"
RPROVIDES:glibc-langpack-st:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-su = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-su-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-su;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-su}"
SRC_URI[x86_64_v2_glibc-langpack-su.sha256sum] = "3ac5c9fdcfe8dd70972169fe91399dd7071eb5c0b4c515d5e4f854bf42c7938d"
RPROVIDES:glibc-langpack-su:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sv = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sv-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sv}"
SRC_URI[x86_64_v2_glibc-langpack-sv.sha256sum] = "7c14295a3b63c0e4f7ba12d68ec2bdd56e25b87d395aff860af48e3207287256"
RPROVIDES:glibc-langpack-sv:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-sw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-sw-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-sw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-sw}"
SRC_URI[x86_64_v2_glibc-langpack-sw.sha256sum] = "f9cb3d22e0af7627a0e73737403c63da3645018cc731b5fe6761a6558de945a6"
RPROVIDES:glibc-langpack-sw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-syr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-syr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-syr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-syr}"
SRC_URI[x86_64_v2_glibc-langpack-syr.sha256sum] = "d0a998e3aacd711014c2b219d1b7823371243ec9fb5712db96792f6cac67874c"
RPROVIDES:glibc-langpack-syr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-szl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-szl-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-szl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-szl}"
SRC_URI[x86_64_v2_glibc-langpack-szl.sha256sum] = "9fd6170fcf111f17f512629d49cc6a6dafb30840021dd27528c83d0a7216ebe5"
RPROVIDES:glibc-langpack-szl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ta = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ta-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ta}"
SRC_URI[x86_64_v2_glibc-langpack-ta.sha256sum] = "4a9ee5b4038f2f4d69af3697dacb60d42a674487af064628685794702652d795"
RPROVIDES:glibc-langpack-ta:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tcy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tcy-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tcy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tcy}"
SRC_URI[x86_64_v2_glibc-langpack-tcy.sha256sum] = "e5be6baf09e7c26d1e9134c20938a7885780635a374127a80592b3602bb48902"
RPROVIDES:glibc-langpack-tcy:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-te = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-te-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-te;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-te}"
SRC_URI[x86_64_v2_glibc-langpack-te.sha256sum] = "0b624d469f07e5f06269dd46cbafe0a0b349d358e96774b0d934c5e7fbc6100d"
RPROVIDES:glibc-langpack-te:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tg = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tg-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tg}"
SRC_URI[x86_64_v2_glibc-langpack-tg.sha256sum] = "9686967df5988a5fb685880414d0ac027294c9f156a9fe2fa06d207775b77eb8"
RPROVIDES:glibc-langpack-tg:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-th = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-th-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-th}"
SRC_URI[x86_64_v2_glibc-langpack-th.sha256sum] = "37906f15c649079a4c3cfc6ba5ac42ad657d3abc0a633e4a9086dc8fbaf3c578"
RPROVIDES:glibc-langpack-th:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-the = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-the-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-the;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-the}"
SRC_URI[x86_64_v2_glibc-langpack-the.sha256sum] = "18a8dcfc13ced23afb3be5d2276dcd5cbaad7f2b8ea2ffc5172859cf44fe252b"
RPROVIDES:glibc-langpack-the:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ti = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ti-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ti;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ti}"
SRC_URI[x86_64_v2_glibc-langpack-ti.sha256sum] = "0fdfa1060399658bbd17133dbf467123d54ad6a1a988dfbbff87e0fce48b6fdf"
RPROVIDES:glibc-langpack-ti:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tig = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tig-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tig}"
SRC_URI[x86_64_v2_glibc-langpack-tig.sha256sum] = "b11bf35f15e90936a6e48ec7a8fe3ea6c446e37ba07116e3740802269d531411"
RPROVIDES:glibc-langpack-tig:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tk-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tk}"
SRC_URI[x86_64_v2_glibc-langpack-tk.sha256sum] = "08dc2152ff084971e88c4a9f19d64be6f723b3e992859efe16d56ecc756ea215"
RPROVIDES:glibc-langpack-tk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tl-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tl}"
SRC_URI[x86_64_v2_glibc-langpack-tl.sha256sum] = "611c223e0c6f39a4727b5ee50abbe9aa4f82625b954423caa9aaff663f4a69e6"
RPROVIDES:glibc-langpack-tl:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tn = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tn-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tn}"
SRC_URI[x86_64_v2_glibc-langpack-tn.sha256sum] = "00e7967949392e4d9d9213e0fe42c1e0d5fe1d3ae567d128cf79eef2e45c3438"
RPROVIDES:glibc-langpack-tn:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-to = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-to-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-to;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-to}"
SRC_URI[x86_64_v2_glibc-langpack-to.sha256sum] = "2ac59158984bc6dab67105dbceabd0286671421645eeb656ad264f1d00aec351"
RPROVIDES:glibc-langpack-to:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tok = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tok-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tok;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tok}"
SRC_URI[x86_64_v2_glibc-langpack-tok.sha256sum] = "e08f1baa239a773469ef2768d37384a5280d2f724ed667dbe8915c3e5ddfde6c"
RPROVIDES:glibc-langpack-tok:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tpi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tpi-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tpi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tpi}"
SRC_URI[x86_64_v2_glibc-langpack-tpi.sha256sum] = "f2966619d2251d5f1548f9f9f6156cf265d8f0990dc80417aabebd8cb7f549b8"
RPROVIDES:glibc-langpack-tpi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tr = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tr-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tr}"
SRC_URI[x86_64_v2_glibc-langpack-tr.sha256sum] = "8422a19366aa3dd17bd7524a3b3c378190d63ba3af192075ceb44b44dce711ce"
RPROVIDES:glibc-langpack-tr:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ts-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ts}"
SRC_URI[x86_64_v2_glibc-langpack-ts.sha256sum] = "df92017cd596a3ff7b597a4be5c2b963cee7d8f81664819bf440bbb05973368c"
RPROVIDES:glibc-langpack-ts:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-tt = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-tt-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-tt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-tt}"
SRC_URI[x86_64_v2_glibc-langpack-tt.sha256sum] = "3127b18f31a34788a139e4f94a3691424bb590f75cacc42ceaa265324ec78c47"
RPROVIDES:glibc-langpack-tt:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ug = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ug-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ug;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ug}"
SRC_URI[x86_64_v2_glibc-langpack-ug.sha256sum] = "2bf6267ea8bbc5a698cca59b1fe70b8cd4080ec864c7e337413a32c44f77582c"
RPROVIDES:glibc-langpack-ug:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-uk = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uk-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-uk}"
SRC_URI[x86_64_v2_glibc-langpack-uk.sha256sum] = "a97125fb90227b97ffe476713b722913f9d2d98fd5060b792ee9383a7c250ed6"
RPROVIDES:glibc-langpack-uk:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-unm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-unm-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-unm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-unm}"
SRC_URI[x86_64_v2_glibc-langpack-unm.sha256sum] = "175a47e429491a52c356e3b54e8e0618c4e3a3d0a7a5fe4284844c0d6dd813d4"
RPROVIDES:glibc-langpack-unm:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ur = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ur-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ur;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ur}"
SRC_URI[x86_64_v2_glibc-langpack-ur.sha256sum] = "7e810a9c1c05eae1d41b8e89672e694f8ddcb8437fdf04f37574439dd23e11e2"
RPROVIDES:glibc-langpack-ur:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-uz = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-uz-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-uz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-uz}"
SRC_URI[x86_64_v2_glibc-langpack-uz.sha256sum] = "945dce5a8b9df1bd57cf34c14ac1f1ab67bfb0b4f59f42f98bcc228834cc3e6c"
RPROVIDES:glibc-langpack-uz:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-ve = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-ve-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-ve;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-ve}"
SRC_URI[x86_64_v2_glibc-langpack-ve.sha256sum] = "0e0791ce9c940f638866b1bb7dfa2fc4b0e1e30e6a3fcb30bf2c46d679e12735"
RPROVIDES:glibc-langpack-ve:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-vi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-vi-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-vi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-vi}"
SRC_URI[x86_64_v2_glibc-langpack-vi.sha256sum] = "78e3ab7954248a2952a15252cff17e60bf43157dfdf127865097f16aa63f39e4"
RPROVIDES:glibc-langpack-vi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-wa = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wa-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wa}"
SRC_URI[x86_64_v2_glibc-langpack-wa.sha256sum] = "ad18cdfbf5dcad465fe071197a484fe7e066df9d127018778ea9457c35c90519"
RPROVIDES:glibc-langpack-wa:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-wae = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wae-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wae;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wae}"
SRC_URI[x86_64_v2_glibc-langpack-wae.sha256sum] = "c6de3d4ccbf7afd5f05e5ea30917c6d543247d07540fda1c1330ab54034e0417"
RPROVIDES:glibc-langpack-wae:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-wal = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wal-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wal}"
SRC_URI[x86_64_v2_glibc-langpack-wal.sha256sum] = "3548bd64580be4926cb9a29dd8d79fae2efe4b725f39f8226ddcd65c3e231277"
RPROVIDES:glibc-langpack-wal:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-wo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-wo-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-wo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-wo}"
SRC_URI[x86_64_v2_glibc-langpack-wo.sha256sum] = "6b04081ae5eff26dc27e31a524bda46796cea4d0cee51b996b1eb2c9de0ff8a4"
RPROVIDES:glibc-langpack-wo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-xh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-xh-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-xh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-xh}"
SRC_URI[x86_64_v2_glibc-langpack-xh.sha256sum] = "3c5884e1a0d1cbe4dcc3ffbf6ec1b5073e828b35eaeeebbfa07876dc972b63d1"
RPROVIDES:glibc-langpack-xh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-yi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yi-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yi}"
SRC_URI[x86_64_v2_glibc-langpack-yi.sha256sum] = "4951cf5755f35d0d7c7b233239165bbf41b749babd33c29f3c0605c74421887c"
RPROVIDES:glibc-langpack-yi:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-yo = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yo-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yo}"
SRC_URI[x86_64_v2_glibc-langpack-yo.sha256sum] = "c062d8786caa5a2da2890cf0a16d40775b22adc40b422d7c6843d1506bf892e4"
RPROVIDES:glibc-langpack-yo:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-yue = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yue-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yue;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yue}"
SRC_URI[x86_64_v2_glibc-langpack-yue.sha256sum] = "4cf8ea17c271553c04d0853935b8ff45fa598890382584c7807a830c74810db6"
RPROVIDES:glibc-langpack-yue:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-yuw = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-yuw-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-yuw;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-yuw}"
SRC_URI[x86_64_v2_glibc-langpack-yuw.sha256sum] = "a3dfe1e77991ba00000b4b50ad30f008b986190e111d077abc8128397edf42cc"
RPROVIDES:glibc-langpack-yuw:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-zgh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zgh-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zgh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zgh}"
SRC_URI[x86_64_v2_glibc-langpack-zgh.sha256sum] = "779d3eeac71c2081d89ff6d91e9a76db52d4cbc1307863bca51ec5b4471d2a66"
RPROVIDES:glibc-langpack-zgh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-zh = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zh-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zh}"
SRC_URI[x86_64_v2_glibc-langpack-zh.sha256sum] = "a1243e34be0c97399a872c1196ba79cc05a3211e5af75cf1aa57ed94d8281512"
RPROVIDES:glibc-langpack-zh:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-langpack-zu = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-langpack-zu-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-langpack-zu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-langpack-zu}"
SRC_URI[x86_64_v2_glibc-langpack-zu.sha256sum] = "a9ac3afeae44cfa8a67e3998cccb614299798ad4362ffaec88ce3d07c3b86bf1"
RPROVIDES:glibc-langpack-zu:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-locale-source = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-locale-source-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-locale-source;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-locale-source}"
SRC_URI[x86_64_v2_glibc-locale-source.sha256sum] = "d7b88061a7b3e7924465828af3f299b5afaa699f854092aed418171da4ec116d"

URI_x86_64_v2_glibc-minimal-langpack = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/glibc-minimal-langpack-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-minimal-langpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-minimal-langpack}"
SRC_URI[x86_64_v2_glibc-minimal-langpack.sha256sum] = "724418fbc32035f76ece793f4a77acfdfc8426adae98367af8b4b720c694f5b7"
RPROVIDES:glibc-minimal-langpack:x86_64_v2 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_x86_64_v2_glibc-nss-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-nss-devel-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-nss-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-nss-devel}"
SRC_URI[x86_64_v2_glibc-nss-devel.sha256sum] = "72702cadc24ab2b8b1944219d722ed286154ad09f3ef55ba028de53b76a15ffc"

URI_x86_64_v2_glibc-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/glibc-static-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-static}"
SRC_URI[x86_64_v2_glibc-static.sha256sum] = "d20915c11d8010dabd365cf39974940e155387acae0ed052ab994b7dc51428be"

URI_x86_64_v2_glibc-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/glibc-utils-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_glibc-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glibc-utils}"
SRC_URI[x86_64_v2_glibc-utils.sha256sum] = "a56bef6d21dfa1ec0215526c12105dc4b02a98e7a409ac586417a59917f88e23"

URI_x86_64_v2_libnsl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnsl-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_libnsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnsl}"
SRC_URI[x86_64_v2_libnsl.sha256sum] = "f0989b0cc453207c94226945741c95a8cd56902dc4f01370892d1d07e7def9ad"

URI_x86_64_v2_nss_db = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_db-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_db;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_db}"
SRC_URI[x86_64_v2_nss_db.sha256sum] = "c39d5a07dc78fd7dfbf96045a34bdcac985bf4fff44f126c9ad1f9c27ac3b950"

URI_x86_64_v2_nss_hesiod = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nss_hesiod-2.39-58.el10_1.7.alma.1.x86_64_v2.rpm;name=x86_64_v2_nss_hesiod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nss_hesiod}"
SRC_URI[x86_64_v2_nss_hesiod.sha256sum] = "cc3b9af34ce39a032b018052e66e8c6a18826536ef2a8874a33c69760192dfb4"

URI_aarch64_glibc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc}"
SRC_URI[aarch64_glibc.sha256sum] = "51fd6085b1af46d366cc209870d26231ee207823e496609e567a421e3e3f2981"

URI_aarch64_glibc-all-langpacks = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-all-langpacks-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-all-langpacks;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-all-langpacks}"
SRC_URI[aarch64_glibc-all-langpacks.sha256sum] = "b2fa7158513bf41c8b9e676453f42550c9eaa9d932c93a4dcdc8ffc8ecb9bb16"
RPROVIDES:glibc-all-langpacks:aarch64 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-benchtests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-benchtests-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-benchtests;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-benchtests}"
SRC_URI[aarch64_glibc-benchtests.sha256sum] = "f2727cb3a9f71f3400fa32ac7fbaa94c1408012cf7e095055d8eac2c515e7a60"

URI_aarch64_glibc-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-common-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-common}"
SRC_URI[aarch64_glibc-common.sha256sum] = "076da86304e49d8030ccfed567e0696dcc118f7f165c355a308a44982c53522e"

URI_aarch64_glibc-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-devel-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-devel}"
SRC_URI[aarch64_glibc-devel.sha256sum] = "d2256b1b851ec934a1b733523d5485ec8da9f438aaec8d17e1e12296f22e4384"

URI_aarch64_glibc-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-doc-2.39-58.el10_1.7.alma.1.noarch.rpm;name=aarch64_glibc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-doc}"
SRC_URI[aarch64_glibc-doc.sha256sum] = "b2422e9d9937d429da8df4c844201296ea1f22ce407357c48fc793ee07b10045"

URI_aarch64_glibc-gconv-extra = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-gconv-extra-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-gconv-extra;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-gconv-extra}"
SRC_URI[aarch64_glibc-gconv-extra.sha256sum] = "47bcefc63ac202502da4ca5abfe73396adefa595e3d46fe0191515b48bbe3015"

URI_aarch64_glibc-langpack-aa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-aa-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-aa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-aa}"
SRC_URI[aarch64_glibc-langpack-aa.sha256sum] = "0c60466ec1617c3c8770799be94cf94796fc93896c798164ccd862a572da0ec8"
RPROVIDES:glibc-langpack-aa:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-af = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-af-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-af;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-af}"
SRC_URI[aarch64_glibc-langpack-af.sha256sum] = "792da77d1e0bcb12ee098343c243e8340ae70c4f6fb0a7fe919130483439b061"
RPROVIDES:glibc-langpack-af:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-agr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-agr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-agr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-agr}"
SRC_URI[aarch64_glibc-langpack-agr.sha256sum] = "20ce32dd92174af6c1426147be030807fff8c25076b8e380300ee9ccb52af837"
RPROVIDES:glibc-langpack-agr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ak = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ak-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ak;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ak}"
SRC_URI[aarch64_glibc-langpack-ak.sha256sum] = "7108122c7d35220fd575b1c42af2730f199cdd02c5ec7875692af3d1675bc046"
RPROVIDES:glibc-langpack-ak:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-am = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-am-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-am;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-am}"
SRC_URI[aarch64_glibc-langpack-am.sha256sum] = "556315b3254c1deae9367f22c77055c8980da08348226aaf4f1e96c517baa661"
RPROVIDES:glibc-langpack-am:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-an = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-an-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-an;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-an}"
SRC_URI[aarch64_glibc-langpack-an.sha256sum] = "a6a177797a2700a8642a5381f45cd9217b01a2a129cf7491ae6a1a8180592eb3"
RPROVIDES:glibc-langpack-an:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-anp = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-anp-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-anp;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-anp}"
SRC_URI[aarch64_glibc-langpack-anp.sha256sum] = "5a983d2ce19a38204410632113bfc71f84cf2002ba71d72710b76f0675313649"
RPROVIDES:glibc-langpack-anp:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ar = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ar-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ar;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ar}"
SRC_URI[aarch64_glibc-langpack-ar.sha256sum] = "d0254fae7689e07a96a6a768b3888cc6370ff0c9af8d30d453758f7dac296c6c"
RPROVIDES:glibc-langpack-ar:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-as = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-as-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-as;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-as}"
SRC_URI[aarch64_glibc-langpack-as.sha256sum] = "c92333e1bf43b9b4771b6654845a6103dc59c27e22bd954bfaf8db2d5f236428"
RPROVIDES:glibc-langpack-as:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ast = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ast-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ast;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ast}"
SRC_URI[aarch64_glibc-langpack-ast.sha256sum] = "0bddfc745436aee7f37e41e0534052bee44a28185115603772679b154d8f9f23"
RPROVIDES:glibc-langpack-ast:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ayc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ayc-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ayc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ayc}"
SRC_URI[aarch64_glibc-langpack-ayc.sha256sum] = "fb494ce591aaec3f760119539aa0292ebe2f57fd62b6b5fcb1e2e3b332e453a4"
RPROVIDES:glibc-langpack-ayc:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-az = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-az-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-az;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-az}"
SRC_URI[aarch64_glibc-langpack-az.sha256sum] = "50c0a9ea1d031039de965bd0d8dceece2220acbebc3e54c17a699efe7c70d2f0"
RPROVIDES:glibc-langpack-az:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-be = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-be-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-be;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-be}"
SRC_URI[aarch64_glibc-langpack-be.sha256sum] = "98aea00105431cd8e1035f072752c14fdb4cc51d02434c150285f0675e72b04c"
RPROVIDES:glibc-langpack-be:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-bem = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bem-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bem;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bem}"
SRC_URI[aarch64_glibc-langpack-bem.sha256sum] = "0c79799e7e1d9810c653120c15d239ad2ac3226cc4ddbcd8de4ec78d0c4cf22b"
RPROVIDES:glibc-langpack-bem:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ber = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ber-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ber;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ber}"
SRC_URI[aarch64_glibc-langpack-ber.sha256sum] = "59532e8c32018859e2a1582c1bf4faff6140ec9aa4031757fdaf6ead35cf3996"
RPROVIDES:glibc-langpack-ber:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-bg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bg-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bg}"
SRC_URI[aarch64_glibc-langpack-bg.sha256sum] = "22fe25131a9f7e8a10807b9ee75fcf698c2a2d226f70f6924e73959538ec644f"
RPROVIDES:glibc-langpack-bg:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-bhb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bhb-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bhb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bhb}"
SRC_URI[aarch64_glibc-langpack-bhb.sha256sum] = "2955933699b37f8823944791d875b6056d4570a2b29e8521d6e895f49bf10f90"
RPROVIDES:glibc-langpack-bhb:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-bho = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bho-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bho;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bho}"
SRC_URI[aarch64_glibc-langpack-bho.sha256sum] = "bc0ec4cde80a4cd06d2d16d1f0774f1915b4f4408b91844a8f53eb523978a54b"
RPROVIDES:glibc-langpack-bho:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-bi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bi-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bi}"
SRC_URI[aarch64_glibc-langpack-bi.sha256sum] = "bc07f2eb4ba8b9de6b46717e13df8f6413a95c7523eaa0ae1a63d233ec0c6daa"
RPROVIDES:glibc-langpack-bi:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-bn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bn-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bn}"
SRC_URI[aarch64_glibc-langpack-bn.sha256sum] = "d6723eaab76800caff9fd17720353f4b11e9d2fa978898a77b94caf95070344a"
RPROVIDES:glibc-langpack-bn:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-bo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bo-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bo}"
SRC_URI[aarch64_glibc-langpack-bo.sha256sum] = "7d5bb3567332b081d0e9c244bafaf1ad6c4d03ae07954e8eed5bbd4b0197d860"
RPROVIDES:glibc-langpack-bo:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-br = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-br-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-br;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-br}"
SRC_URI[aarch64_glibc-langpack-br.sha256sum] = "bb9e982b156a9981efc2b35d7eabed3cfbc96ad26b5bb8b8b6a7bed48a206089"
RPROVIDES:glibc-langpack-br:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-brx = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-brx-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-brx;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-brx}"
SRC_URI[aarch64_glibc-langpack-brx.sha256sum] = "6b20022482d6c08ec4e35a16b77566eeeadceb853b53ab0880420c06a2e32e33"
RPROVIDES:glibc-langpack-brx:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-bs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-bs-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-bs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-bs}"
SRC_URI[aarch64_glibc-langpack-bs.sha256sum] = "bdfac35368816f88fb3fb213b56deedbd3a94669be8841c91ed5781b034f3b32"
RPROVIDES:glibc-langpack-bs:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-byn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-byn-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-byn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-byn}"
SRC_URI[aarch64_glibc-langpack-byn.sha256sum] = "7b51546fd3817afed3a9a57f2ffe4c77f23d19a2a149b9bdd19c75a65961e2d1"
RPROVIDES:glibc-langpack-byn:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ca = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ca-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ca;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ca}"
SRC_URI[aarch64_glibc-langpack-ca.sha256sum] = "53fa6294d1f3a25315d3da2dd20e82795c12fc29e580fb8cb8746906822a5e83"
RPROVIDES:glibc-langpack-ca:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ce = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ce-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ce;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ce}"
SRC_URI[aarch64_glibc-langpack-ce.sha256sum] = "43fb1344294c688293f8651404010eaef41e6fc82e8752bafd30d65064db502c"
RPROVIDES:glibc-langpack-ce:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-chr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-chr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-chr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-chr}"
SRC_URI[aarch64_glibc-langpack-chr.sha256sum] = "41e63baa7d63d6ea9bb081aa378544644d4388f2d1fceaae9dd9310aed5a7e70"
RPROVIDES:glibc-langpack-chr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ckb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ckb-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ckb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ckb}"
SRC_URI[aarch64_glibc-langpack-ckb.sha256sum] = "bc9107ea96a19f60d09a2e1bfc5f486fc9c5dc15ef5b0dadd389821cc845be57"
RPROVIDES:glibc-langpack-ckb:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-cmn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cmn-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cmn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cmn}"
SRC_URI[aarch64_glibc-langpack-cmn.sha256sum] = "611aafe5dec7c61438527957b702a8fe7becfb8156f0ea7d04579aba09d8b56c"
RPROVIDES:glibc-langpack-cmn:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-crh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-crh-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-crh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-crh}"
SRC_URI[aarch64_glibc-langpack-crh.sha256sum] = "64b2fbb12d75425253c91fa5c338be61d9bac71f66677a82dfc06ca4bca0165d"
RPROVIDES:glibc-langpack-crh:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-cs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cs-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cs}"
SRC_URI[aarch64_glibc-langpack-cs.sha256sum] = "295d2795780410adc0c9f4f5adce725797fcecfbb9c64aa74716918d8b08415a"
RPROVIDES:glibc-langpack-cs:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-csb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-csb-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-csb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-csb}"
SRC_URI[aarch64_glibc-langpack-csb.sha256sum] = "94d896e5da6ef8456a1250afd90c1647b5f4d1c3e2879bab956e01571b875e27"
RPROVIDES:glibc-langpack-csb:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-cv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cv-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cv}"
SRC_URI[aarch64_glibc-langpack-cv.sha256sum] = "0efc95a34111a34243b12ef06027e7aeda750de638a56498ddd3bf172f747012"
RPROVIDES:glibc-langpack-cv:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-cy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-cy-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-cy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-cy}"
SRC_URI[aarch64_glibc-langpack-cy.sha256sum] = "111c6e769fb4593f1a1a260067aa25d7d610124405965bfe12168b0c305fa3dd"
RPROVIDES:glibc-langpack-cy:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-da = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-da-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-da;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-da}"
SRC_URI[aarch64_glibc-langpack-da.sha256sum] = "9055e884219ef8853cf1092cca681e05db929e21484cac2106da9068d9ed20ae"
RPROVIDES:glibc-langpack-da:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-de = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-de-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-de;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-de}"
SRC_URI[aarch64_glibc-langpack-de.sha256sum] = "c1e93857a279fd75845bebc96fc2dfd31489db0fa14ee34ebf3c81309ab02991"
RPROVIDES:glibc-langpack-de:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-doi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-doi-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-doi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-doi}"
SRC_URI[aarch64_glibc-langpack-doi.sha256sum] = "bb99d2a16e91f684d6aed6d1684cb1f3db56c89aefe3fd4b3c7bbbaae6255389"
RPROVIDES:glibc-langpack-doi:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-dsb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dsb-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dsb}"
SRC_URI[aarch64_glibc-langpack-dsb.sha256sum] = "37b9bc1ccc20a8fc9bfc957be564117d12812c89040f8a11084e023c28165398"
RPROVIDES:glibc-langpack-dsb:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-dv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dv-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dv}"
SRC_URI[aarch64_glibc-langpack-dv.sha256sum] = "c02025b4cf066c539660c7b88af9cc8af5fbd7d256755d8af1e5a571a8c5f51b"
RPROVIDES:glibc-langpack-dv:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-dz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-dz-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-dz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-dz}"
SRC_URI[aarch64_glibc-langpack-dz.sha256sum] = "8b0ab51907ef09d50254caee13295dd3cfa02f52ba6b2a2d0a4909a619741aa7"
RPROVIDES:glibc-langpack-dz:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-el = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-el-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-el;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-el}"
SRC_URI[aarch64_glibc-langpack-el.sha256sum] = "36b70505d6882c3e3309ccd2321338007bded5ddd16a7acaa3a9b92e9dc4bb5f"
RPROVIDES:glibc-langpack-el:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-en = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-en-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-en;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-en}"
SRC_URI[aarch64_glibc-langpack-en.sha256sum] = "d4da205f0ad74ebb7f7d04f37c31eafb882f7def980253ad4a820f96174ba153"
RPROVIDES:glibc-langpack-en:aarch64 = "virtual/glibc-langpack-en_or_glibc-all-langpacks virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-eo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eo-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-eo}"
SRC_URI[aarch64_glibc-langpack-eo.sha256sum] = "f40fa3acdf4b8efd5c8bb21a2477f9cc684d59f08a4b619ae5a62cc40d9d3c56"
RPROVIDES:glibc-langpack-eo:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-es = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-es-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-es;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-es}"
SRC_URI[aarch64_glibc-langpack-es.sha256sum] = "5aeaa725bcf1ca7da80f93cddb0cbc037018e67da06532253be4d846bcb2dcc1"
RPROVIDES:glibc-langpack-es:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-et = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-et-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-et;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-et}"
SRC_URI[aarch64_glibc-langpack-et.sha256sum] = "91d84e644194e670b6cf517642fd86f047b7ee966f25924f53c729edf2a09faa"
RPROVIDES:glibc-langpack-et:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-eu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-eu-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-eu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-eu}"
SRC_URI[aarch64_glibc-langpack-eu.sha256sum] = "8d4221d7bb20bb3fbd054e3e5de13da720ce1fbd6241cfdfcf8bab4d48f5f1ce"
RPROVIDES:glibc-langpack-eu:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-fa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fa-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fa}"
SRC_URI[aarch64_glibc-langpack-fa.sha256sum] = "4b0ce74eb00e1a539d8746b662ec9fe81812979db0844c727df8df10056fe48c"
RPROVIDES:glibc-langpack-fa:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ff = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ff-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ff;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ff}"
SRC_URI[aarch64_glibc-langpack-ff.sha256sum] = "de8d244d46143e9e3b6fa3317a7a0cd5d6503d27a817fa56105a973bd9c1f7dd"
RPROVIDES:glibc-langpack-ff:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-fi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fi-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fi}"
SRC_URI[aarch64_glibc-langpack-fi.sha256sum] = "4de39f308e10c0f2c6dacc9dc0ee21532d3b719b723f54d4c894f29a154c2b1c"
RPROVIDES:glibc-langpack-fi:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-fil = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fil-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fil;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fil}"
SRC_URI[aarch64_glibc-langpack-fil.sha256sum] = "8950d9a6091eae4e1c41a6e80f48de8d4c0da2fb9950560e8c5b1a51be66772c"
RPROVIDES:glibc-langpack-fil:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-fo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fo-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fo}"
SRC_URI[aarch64_glibc-langpack-fo.sha256sum] = "45248ce189d150ee4f848f14f818801440f8a634362c67c761bebf3bef19a17d"
RPROVIDES:glibc-langpack-fo:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-fr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fr}"
SRC_URI[aarch64_glibc-langpack-fr.sha256sum] = "f6b42bfe73b7e9966f6c3a7f59f3e431301cb0e62c7a4311fabd4532be43fe5f"
RPROVIDES:glibc-langpack-fr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-fur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fur-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fur;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fur}"
SRC_URI[aarch64_glibc-langpack-fur.sha256sum] = "1c45c94d654df1376ade608e11fb0092a23625ffbb1d3b06ab42717a9ed0c5d3"
RPROVIDES:glibc-langpack-fur:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-fy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-fy-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-fy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-fy}"
SRC_URI[aarch64_glibc-langpack-fy.sha256sum] = "bde1df496d74e21ebda01f2ae6a620fe6170e085b786b6789171ec11ecd7066f"
RPROVIDES:glibc-langpack-fy:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ga = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ga-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ga;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ga}"
SRC_URI[aarch64_glibc-langpack-ga.sha256sum] = "69c93a435c54510b7863c8986eb2a131768807fc2683ba4db304ad4b0293935d"
RPROVIDES:glibc-langpack-ga:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-gbm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gbm-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gbm}"
SRC_URI[aarch64_glibc-langpack-gbm.sha256sum] = "2ecf5af3e3e9e196042e51727d8ef0a962f892d0261132c9174cf74cae489739"
RPROVIDES:glibc-langpack-gbm:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-gd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gd-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gd}"
SRC_URI[aarch64_glibc-langpack-gd.sha256sum] = "b7f50a94a61005875dcc7ebd9f41b6254998b5c3f1261b4f73d436a6cd8fc111"
RPROVIDES:glibc-langpack-gd:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-gez = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gez-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gez;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gez}"
SRC_URI[aarch64_glibc-langpack-gez.sha256sum] = "c85da026f6061b55eab7953fe86e675ad6fc1c372d7016219c6d7a4403639377"
RPROVIDES:glibc-langpack-gez:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-gl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gl-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gl}"
SRC_URI[aarch64_glibc-langpack-gl.sha256sum] = "315a8169a3b6ea4ed7aeb5c4995af3a621633ae5ac2802e707765f8ff3bb34eb"
RPROVIDES:glibc-langpack-gl:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-gu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gu-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gu}"
SRC_URI[aarch64_glibc-langpack-gu.sha256sum] = "f0d9333969cced2cfd1262f7860bee5c001e8b5587d3d81762771ae91046c54d"
RPROVIDES:glibc-langpack-gu:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-gv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-gv-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-gv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-gv}"
SRC_URI[aarch64_glibc-langpack-gv.sha256sum] = "0ee85330255ced1cc1525d386cb263cec6490cd774cd19ed6c9c49588b7a324e"
RPROVIDES:glibc-langpack-gv:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ha = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ha-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ha;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ha}"
SRC_URI[aarch64_glibc-langpack-ha.sha256sum] = "a277647c9c9da15cc960d5396052ba0b2416e662e0442358e8ceb74ed6c5dbd7"
RPROVIDES:glibc-langpack-ha:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-hak = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hak-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hak;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hak}"
SRC_URI[aarch64_glibc-langpack-hak.sha256sum] = "1150cbfa7c37df8ccc209a7d7aa96c76d401eba951fc9369999ce4738b65fec6"
RPROVIDES:glibc-langpack-hak:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-he = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-he-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-he;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-he}"
SRC_URI[aarch64_glibc-langpack-he.sha256sum] = "e1b9ec1c012e4bf258cc27252322a2e232388a792de9b454b932e049ca16aa59"
RPROVIDES:glibc-langpack-he:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-hi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hi-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hi}"
SRC_URI[aarch64_glibc-langpack-hi.sha256sum] = "dcf1622fd2f8d3c4e7647e155d6d1d00b284755d89a9ea9e179e768dc6c0fe5a"
RPROVIDES:glibc-langpack-hi:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-hif = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hif-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hif;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hif}"
SRC_URI[aarch64_glibc-langpack-hif.sha256sum] = "880691acbdab9a3d79f2f9c7d2c2a9498b95ff778f44f4fd996f6c80cfba5ed1"
RPROVIDES:glibc-langpack-hif:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-hne = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hne-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hne;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hne}"
SRC_URI[aarch64_glibc-langpack-hne.sha256sum] = "7dffbd6d1995687681184e66186e7b4d037a749c594e5ef29eaa4706027086f5"
RPROVIDES:glibc-langpack-hne:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-hr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hr}"
SRC_URI[aarch64_glibc-langpack-hr.sha256sum] = "b66dd719c47d568f0508378332fd96bd364885082737486d95a5a082c0708996"
RPROVIDES:glibc-langpack-hr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-hsb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hsb-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hsb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hsb}"
SRC_URI[aarch64_glibc-langpack-hsb.sha256sum] = "89c2d18a897bec38e5729daaa185c70839e4d9c507957f4c9fc66ac82faaf915"
RPROVIDES:glibc-langpack-hsb:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ht = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ht-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ht;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ht}"
SRC_URI[aarch64_glibc-langpack-ht.sha256sum] = "0ff40ddeba8b1a0ebd107c2c5ac072469fd0242feabff396359f3a5f964b6813"
RPROVIDES:glibc-langpack-ht:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-hu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hu-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hu}"
SRC_URI[aarch64_glibc-langpack-hu.sha256sum] = "372c965aaaa9d83294261680a96d5d09f19d7b342581fe4e7b5cc0e475168e79"
RPROVIDES:glibc-langpack-hu:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-hy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-hy-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-hy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-hy}"
SRC_URI[aarch64_glibc-langpack-hy.sha256sum] = "ea1d5991064d82de2447e99b0b99410ab581bd6d65f70946731f3ccd941b57f2"
RPROVIDES:glibc-langpack-hy:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ia = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ia-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ia;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ia}"
SRC_URI[aarch64_glibc-langpack-ia.sha256sum] = "6799a3167f7b72cba44215a062230d45726790243c906934744da2c45dbb0c43"
RPROVIDES:glibc-langpack-ia:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-id = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-id-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-id;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-id}"
SRC_URI[aarch64_glibc-langpack-id.sha256sum] = "371535b6c858c67e84f052ba39701916e8f67140f87d36292a1dc51d054ce8f9"
RPROVIDES:glibc-langpack-id:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ig-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ig;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ig}"
SRC_URI[aarch64_glibc-langpack-ig.sha256sum] = "c5a6f0edf7cb2f2f5007023a936a956183efac876daa4f55c66343999b79b3de"
RPROVIDES:glibc-langpack-ig:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ik = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ik-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ik;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ik}"
SRC_URI[aarch64_glibc-langpack-ik.sha256sum] = "38a6e07d36c2c70710b375e6fcd327e7ea44b0ff9239893bb9c1583950f33268"
RPROVIDES:glibc-langpack-ik:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-is = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-is-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-is;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-is}"
SRC_URI[aarch64_glibc-langpack-is.sha256sum] = "be599862a1b1953a9b6cfde7185a85d97f24533dd83c83a3c55dafced0ebb484"
RPROVIDES:glibc-langpack-is:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-it = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-it-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-it;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-it}"
SRC_URI[aarch64_glibc-langpack-it.sha256sum] = "43cd4b6134f137ba28948cb4df164580173274b96318e8abfecef9955476111c"
RPROVIDES:glibc-langpack-it:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-iu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-iu-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-iu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-iu}"
SRC_URI[aarch64_glibc-langpack-iu.sha256sum] = "3e8ea0ec5101331cf7be39414c7d8b4755140c937841f26243ba463e43a0d1c6"
RPROVIDES:glibc-langpack-iu:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ja = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ja-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ja;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ja}"
SRC_URI[aarch64_glibc-langpack-ja.sha256sum] = "8fede701e2d882c802983df20979a680944dcec5932847556e972aadc8683947"
RPROVIDES:glibc-langpack-ja:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ka = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ka-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ka;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ka}"
SRC_URI[aarch64_glibc-langpack-ka.sha256sum] = "6e62a313d8975ae1f57247b9b85bdd93cb9f21f9a7b67b952211adaa9be3e215"
RPROVIDES:glibc-langpack-ka:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-kab = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kab-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kab;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kab}"
SRC_URI[aarch64_glibc-langpack-kab.sha256sum] = "72dcc8da14f385d9bb6eb5eacacc363a9faeda07b4cb282f1fe243c45ddb3683"
RPROVIDES:glibc-langpack-kab:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-kk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kk-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kk}"
SRC_URI[aarch64_glibc-langpack-kk.sha256sum] = "bd227bb1cf60ff1a4e23e298d0cbc75f46f72ed3bff3b5047186b2dc54e82d19"
RPROVIDES:glibc-langpack-kk:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-kl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kl-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kl}"
SRC_URI[aarch64_glibc-langpack-kl.sha256sum] = "ddf3659dc01c7f3ef3c8c33478ba4c3b5f494f51b4003589bfe11b0068119656"
RPROVIDES:glibc-langpack-kl:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-km = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-km-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-km;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-km}"
SRC_URI[aarch64_glibc-langpack-km.sha256sum] = "a64cec6361a736c416cdb362bdad3a712375cfcb1686943a4823d04d006f0a80"
RPROVIDES:glibc-langpack-km:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-kn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kn-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kn}"
SRC_URI[aarch64_glibc-langpack-kn.sha256sum] = "3a551af3c4b0a20434e63eed21333320e8482a68ccd5e9feb6faca9d8953252d"
RPROVIDES:glibc-langpack-kn:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ko = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ko-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ko;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ko}"
SRC_URI[aarch64_glibc-langpack-ko.sha256sum] = "e57d7fcf9c2bd5b26d43f2eb028365dba3920a4f8fd234dcc57bfbdc46b238ad"
RPROVIDES:glibc-langpack-ko:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-kok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kok-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kok;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kok}"
SRC_URI[aarch64_glibc-langpack-kok.sha256sum] = "8754eb7200f6b8a2866221e0b98207301995cdade07e56394364453e8e11a138"
RPROVIDES:glibc-langpack-kok:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ks = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ks-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ks;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ks}"
SRC_URI[aarch64_glibc-langpack-ks.sha256sum] = "16755b1bf7da9576b7e925cbf9413900d9e892543b64c016bc0f9e8dfb6b7e2a"
RPROVIDES:glibc-langpack-ks:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ku = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ku-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ku;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ku}"
SRC_URI[aarch64_glibc-langpack-ku.sha256sum] = "6c2135528a24447e4130bf2c3d0de8ac5f7554ca22fe2d32438a0fe3cc150025"
RPROVIDES:glibc-langpack-ku:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-kv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kv-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kv}"
SRC_URI[aarch64_glibc-langpack-kv.sha256sum] = "990c8a7d1e59fa3eb73e3b19b80eaeb8f0938782f5522f4f117ddd055c7cd0f0"
RPROVIDES:glibc-langpack-kv:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-kw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-kw-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-kw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-kw}"
SRC_URI[aarch64_glibc-langpack-kw.sha256sum] = "03a3d606caed8ebf45da86d1d18c1b2eee7b6d5dffc54c3b88315169788851e9"
RPROVIDES:glibc-langpack-kw:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ky = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ky-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ky;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ky}"
SRC_URI[aarch64_glibc-langpack-ky.sha256sum] = "f52381efb311d165e25837bfbf25c2806425ea6ae7da523b0530d13bb415fab9"
RPROVIDES:glibc-langpack-ky:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-lb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lb-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lb}"
SRC_URI[aarch64_glibc-langpack-lb.sha256sum] = "50f5736b32182a12d6a39aac301d5ee835e042e164f34569f3da35a687aec6fb"
RPROVIDES:glibc-langpack-lb:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-lg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lg-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lg}"
SRC_URI[aarch64_glibc-langpack-lg.sha256sum] = "8a1509f360bb54d713e83b22e3fa854366ca2bc409931ff29802eb21d2e84a47"
RPROVIDES:glibc-langpack-lg:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-li = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-li-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-li;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-li}"
SRC_URI[aarch64_glibc-langpack-li.sha256sum] = "aaa753abd8fb74a2f67e242be1cabd47e29c82d0f869d06e82d2787172748724"
RPROVIDES:glibc-langpack-li:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-lij = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lij-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lij;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lij}"
SRC_URI[aarch64_glibc-langpack-lij.sha256sum] = "a4604e4342b81995adf3eacf20fab6b62b04ccf489a65a2e40ca56081d6d362e"
RPROVIDES:glibc-langpack-lij:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ln = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ln-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ln;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ln}"
SRC_URI[aarch64_glibc-langpack-ln.sha256sum] = "a84950e06fba63ecc337fe254bc86d3af5aaab3ecf7aa086fc302a844ed0c44e"
RPROVIDES:glibc-langpack-ln:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-lo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lo-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lo}"
SRC_URI[aarch64_glibc-langpack-lo.sha256sum] = "2f0e292f2399413cd2b174cdbd19c4811e6ca04042f8378501ea63955253f43f"
RPROVIDES:glibc-langpack-lo:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-lt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lt-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lt}"
SRC_URI[aarch64_glibc-langpack-lt.sha256sum] = "658f97e33dbf919e5009f80f05668ab9a9db76a24d51460dc5ab4df8253e8c03"
RPROVIDES:glibc-langpack-lt:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-lv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lv-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lv}"
SRC_URI[aarch64_glibc-langpack-lv.sha256sum] = "b61ab35c3aa000ed930c0fcdf730326395dfea47d12a37b844f329bf9bebaf57"
RPROVIDES:glibc-langpack-lv:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-lzh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-lzh-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-lzh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-lzh}"
SRC_URI[aarch64_glibc-langpack-lzh.sha256sum] = "9631e7ec5a5125a4c72e5a89f055db0e53444348271034711a4a7d23691a8fef"
RPROVIDES:glibc-langpack-lzh:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mag = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mag-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mag;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mag}"
SRC_URI[aarch64_glibc-langpack-mag.sha256sum] = "1729673d679ebda52d7d407f837ee736b358b46f92be9299fe7bd32eaf887bad"
RPROVIDES:glibc-langpack-mag:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mai = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mai-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mai;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mai}"
SRC_URI[aarch64_glibc-langpack-mai.sha256sum] = "32de4672761558e2990568defa283eb02d113f0531febaf0a4ed3f8d7f874548"
RPROVIDES:glibc-langpack-mai:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mfe = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mfe-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mfe;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mfe}"
SRC_URI[aarch64_glibc-langpack-mfe.sha256sum] = "f6d007deae8222732c58f9326381de4f95ed9bcd4db703818fc283c0700d611a"
RPROVIDES:glibc-langpack-mfe:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mg-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mg}"
SRC_URI[aarch64_glibc-langpack-mg.sha256sum] = "e0d007515fc7d0b547ba705ff9ee80dbcfbc44ac17a00610694065c57799b45d"
RPROVIDES:glibc-langpack-mg:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mhr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mhr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mhr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mhr}"
SRC_URI[aarch64_glibc-langpack-mhr.sha256sum] = "af762f514a7a81000636813728acde5e5cc53360e51ce454f8247e91b7f531fa"
RPROVIDES:glibc-langpack-mhr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mi-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mi}"
SRC_URI[aarch64_glibc-langpack-mi.sha256sum] = "f5a4f47203038c3b96e62e5b463b92cbf299802e235a4590577180ac6d463663"
RPROVIDES:glibc-langpack-mi:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-miq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-miq-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-miq;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-miq}"
SRC_URI[aarch64_glibc-langpack-miq.sha256sum] = "d68b967a4305e8f76924f178bbbabfe32365752a8739d614be2d04a6b5bdaa9c"
RPROVIDES:glibc-langpack-miq:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mjw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mjw-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mjw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mjw}"
SRC_URI[aarch64_glibc-langpack-mjw.sha256sum] = "2215e7271873d998bdd62db0c401c0497653f2b470d55a8250752b9f01370a40"
RPROVIDES:glibc-langpack-mjw:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mk-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mk}"
SRC_URI[aarch64_glibc-langpack-mk.sha256sum] = "44ab7090604af8bb6b74f300ca63d9ad7e5ee02ce737d202df8e1971d2f48c84"
RPROVIDES:glibc-langpack-mk:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ml = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ml-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ml;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ml}"
SRC_URI[aarch64_glibc-langpack-ml.sha256sum] = "06ed3ec2f2b32e7d6ac066ac9088253a32b2905d07e3b290e4b609d77c6caf26"
RPROVIDES:glibc-langpack-ml:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mn-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mn}"
SRC_URI[aarch64_glibc-langpack-mn.sha256sum] = "3c3dc09972b01de04e567175242cb6bc5284990af183426b4fd1fecaf4d53fbf"
RPROVIDES:glibc-langpack-mn:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mni = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mni-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mni;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mni}"
SRC_URI[aarch64_glibc-langpack-mni.sha256sum] = "d7f01496a4e4c98fde73c4dacc568a1bc55bf40599aa68b59b3b64234348fdce"
RPROVIDES:glibc-langpack-mni:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mnw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mnw-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mnw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mnw}"
SRC_URI[aarch64_glibc-langpack-mnw.sha256sum] = "93d737c1f1a3c3af637c9e1ebec1bf2fdbe55e32e43e43abea64ab38736e8c30"
RPROVIDES:glibc-langpack-mnw:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mr}"
SRC_URI[aarch64_glibc-langpack-mr.sha256sum] = "6dccde5d8e4ab494459c91bd671c586570b6ac1340be15dafdb649a407b233a3"
RPROVIDES:glibc-langpack-mr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ms = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ms-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ms;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ms}"
SRC_URI[aarch64_glibc-langpack-ms.sha256sum] = "881510263e44a1036fdd57e3a67313c0eb9c360eae3a022e7019a7117ba30a6d"
RPROVIDES:glibc-langpack-ms:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-mt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-mt-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-mt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-mt}"
SRC_URI[aarch64_glibc-langpack-mt.sha256sum] = "9925cd735c6a7938073f42b72175bab6c674b5077b8da723397a404bcbf5c5f5"
RPROVIDES:glibc-langpack-mt:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-my = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-my-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-my;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-my}"
SRC_URI[aarch64_glibc-langpack-my.sha256sum] = "9673c49ceada10a17b907385c79fc7977aec49e13c430a954a53514c52834840"
RPROVIDES:glibc-langpack-my:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-nan = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nan-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nan;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nan}"
SRC_URI[aarch64_glibc-langpack-nan.sha256sum] = "b6d802df8629705204649e23aee0fda5c8820bd6fb1c0b08db69f416dfe2439c"
RPROVIDES:glibc-langpack-nan:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-nb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nb-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nb;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nb}"
SRC_URI[aarch64_glibc-langpack-nb.sha256sum] = "1a52f6b776099eae5210d90a448cc4dee137442c947602106b10f3af311d1b1a"
RPROVIDES:glibc-langpack-nb:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-nds = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nds-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nds;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nds}"
SRC_URI[aarch64_glibc-langpack-nds.sha256sum] = "002f8000d7787c39538afb9ceb1896d70731983700f31f822d49c2b6781acd43"
RPROVIDES:glibc-langpack-nds:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ne = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ne-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ne;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ne}"
SRC_URI[aarch64_glibc-langpack-ne.sha256sum] = "ee9f5a248701068c94f253e54dbb4c525581c783ec48c8fdd432d1f8b258140a"
RPROVIDES:glibc-langpack-ne:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-nhn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nhn-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nhn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nhn}"
SRC_URI[aarch64_glibc-langpack-nhn.sha256sum] = "8ac45b49644514e29b6e69b577e490e323aaa4c5e0903c6c6576cce9198f00de"
RPROVIDES:glibc-langpack-nhn:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-niu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-niu-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-niu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-niu}"
SRC_URI[aarch64_glibc-langpack-niu.sha256sum] = "996527e6112fe0c6b885ff7ec7be8c804bb50fb4b142d0747185dbc435f79fa0"
RPROVIDES:glibc-langpack-niu:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-nl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nl-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nl}"
SRC_URI[aarch64_glibc-langpack-nl.sha256sum] = "2efe74764f8473eb6bea65f75f002a2d8b5e71a2aadc51fba4618b33ad20a3a4"
RPROVIDES:glibc-langpack-nl:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-nn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nn-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nn}"
SRC_URI[aarch64_glibc-langpack-nn.sha256sum] = "4264fdd32b5f24914e38591dd376a2e6e021d3d3a771d7ef36b63b06bfb03b22"
RPROVIDES:glibc-langpack-nn:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-nr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nr}"
SRC_URI[aarch64_glibc-langpack-nr.sha256sum] = "36bdfb79152a285b9fb04d7c7002a7adc5bbc00faf1d73ec26f8f3ee24035c2b"
RPROVIDES:glibc-langpack-nr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-nso = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-nso-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-nso;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-nso}"
SRC_URI[aarch64_glibc-langpack-nso.sha256sum] = "8aef67c54bc041b589b40d56de30dfd06bb0266ce70cfcd933ff236295419a75"
RPROVIDES:glibc-langpack-nso:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-oc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-oc-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-oc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-oc}"
SRC_URI[aarch64_glibc-langpack-oc.sha256sum] = "14c4d31866261bb03748f1c0697db21ef6432127ea073da478a200d61c38caf8"
RPROVIDES:glibc-langpack-oc:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-om = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-om-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-om;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-om}"
SRC_URI[aarch64_glibc-langpack-om.sha256sum] = "5fceb84d82030d3a7307c11d9b85894e8174d107d5b78bc9b9e37f6cbaba4fd5"
RPROVIDES:glibc-langpack-om:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-or = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-or-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-or;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-or}"
SRC_URI[aarch64_glibc-langpack-or.sha256sum] = "a83589b8bbba032208c734eeb2a04fb719e4f04ba66f1dc618e9eb36417845ff"
RPROVIDES:glibc-langpack-or:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-os = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-os-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-os;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-os}"
SRC_URI[aarch64_glibc-langpack-os.sha256sum] = "a112157268d70aff03a373c9db8fc1218e86b70d1d4a440fcb8de9c57957eded"
RPROVIDES:glibc-langpack-os:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-pa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pa-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pa}"
SRC_URI[aarch64_glibc-langpack-pa.sha256sum] = "738482cc05797790346ffe3227b093bd33bd487af8db2ccc18e46e52175a406c"
RPROVIDES:glibc-langpack-pa:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-pap = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pap-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pap;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pap}"
SRC_URI[aarch64_glibc-langpack-pap.sha256sum] = "b1ab61647599b7e463e32e158d0e542b42c9bf84c4792035ad8a1f861f5e4048"
RPROVIDES:glibc-langpack-pap:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-pl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pl-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pl}"
SRC_URI[aarch64_glibc-langpack-pl.sha256sum] = "e424b5753448ac95ab14074ae7fc2915ea0b68334232417ea11219580ea102f2"
RPROVIDES:glibc-langpack-pl:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ps = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ps-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ps;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ps}"
SRC_URI[aarch64_glibc-langpack-ps.sha256sum] = "8702b8aaf4a8b474e8c063cc6198c6cc38d1d5aa40f610419b77148809724ef6"
RPROVIDES:glibc-langpack-ps:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-pt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-pt-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-pt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-pt}"
SRC_URI[aarch64_glibc-langpack-pt.sha256sum] = "af88c4b61ca85e31c1c4b37f6876f569462a98b58c509f62e848e2da955581da"
RPROVIDES:glibc-langpack-pt:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-quz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-quz-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-quz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-quz}"
SRC_URI[aarch64_glibc-langpack-quz.sha256sum] = "ed5fde078a6241adf82c6650bc627296143467809308ebaaddb1f169ab3b5ea9"
RPROVIDES:glibc-langpack-quz:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-raj = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-raj-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-raj;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-raj}"
SRC_URI[aarch64_glibc-langpack-raj.sha256sum] = "2449362f0f6b7de8a3bc4b87fad6ca4f2cf8f045487348c450f730443f38c972"
RPROVIDES:glibc-langpack-raj:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-rif = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rif-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rif;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-rif}"
SRC_URI[aarch64_glibc-langpack-rif.sha256sum] = "5fb683eb8038efc36c21dd2f829c7c3b6d5d3bd5d3a3952e52f1362d8d94422d"
RPROVIDES:glibc-langpack-rif:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ro = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ro-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ro;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ro}"
SRC_URI[aarch64_glibc-langpack-ro.sha256sum] = "e0ab641ddfe65dcb7b8e3e86494c55590388a0a29755f3b141e345db719a9ea1"
RPROVIDES:glibc-langpack-ro:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ru = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ru-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ru;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ru}"
SRC_URI[aarch64_glibc-langpack-ru.sha256sum] = "3e15b23205878bae345707831f0c57bf4cd37ca58dede91e31c34025d6a783f6"
RPROVIDES:glibc-langpack-ru:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-rw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-rw-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-rw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-rw}"
SRC_URI[aarch64_glibc-langpack-rw.sha256sum] = "b7d51fd504f762ea51df59c5b26bb09f93f285841bc9947285365644a23bd791"
RPROVIDES:glibc-langpack-rw:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sa-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sa}"
SRC_URI[aarch64_glibc-langpack-sa.sha256sum] = "2ebebdec794b4ecee4028749a463aa0c0fbd086e39cc60e85f80b14d4fb9ad22"
RPROVIDES:glibc-langpack-sa:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sah = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sah-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sah;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sah}"
SRC_URI[aarch64_glibc-langpack-sah.sha256sum] = "d6ee81a96301e5cd455230c2b97c2897a0addeb825a477e534708ba340407f4d"
RPROVIDES:glibc-langpack-sah:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sat = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sat-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sat;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sat}"
SRC_URI[aarch64_glibc-langpack-sat.sha256sum] = "cfa8e312fae4cfef4dfdbef8be3a7c3b5631cab89ce0f687bb5503f95e9ef9fb"
RPROVIDES:glibc-langpack-sat:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sc-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sc}"
SRC_URI[aarch64_glibc-langpack-sc.sha256sum] = "aca90bd4ab11ef659c0089e62eddbbfb55309a80d953b1bc64b6469f3dfe71aa"
RPROVIDES:glibc-langpack-sc:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sd-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sd;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sd}"
SRC_URI[aarch64_glibc-langpack-sd.sha256sum] = "16082a1fb54d80aca6f3ff224befff84c44d08592e7502fa30e55c277ade48ea"
RPROVIDES:glibc-langpack-sd:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-se = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-se-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-se;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-se}"
SRC_URI[aarch64_glibc-langpack-se.sha256sum] = "034dc290e4040873189e0297a393ad90392eb2b615020db5d2efb77807e422b4"
RPROVIDES:glibc-langpack-se:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sgs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sgs-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sgs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sgs}"
SRC_URI[aarch64_glibc-langpack-sgs.sha256sum] = "bfed3701e5f751fc4c246b3f140540b8a7b807efabca97842fa3189f67cff9b9"
RPROVIDES:glibc-langpack-sgs:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-shn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shn-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-shn}"
SRC_URI[aarch64_glibc-langpack-shn.sha256sum] = "e410849a99fd00f7c373e73b0257b041fa9e73487774dca78c0bad50f7ea84e2"
RPROVIDES:glibc-langpack-shn:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-shs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-shs-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-shs;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-shs}"
SRC_URI[aarch64_glibc-langpack-shs.sha256sum] = "61370f54a580d9d36e436d14bf139603a431735b109fafb3a0bf384906e0484f"
RPROVIDES:glibc-langpack-shs:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-si = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-si-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-si;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-si}"
SRC_URI[aarch64_glibc-langpack-si.sha256sum] = "0dd85a0b8d3efc5ed184a65d51a42b3881966945c59f579e3ff1091c59783edf"
RPROVIDES:glibc-langpack-si:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sid = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sid-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sid;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sid}"
SRC_URI[aarch64_glibc-langpack-sid.sha256sum] = "9e70812d7487b86f0f9e808d4fc34eff7933bdd26a4cfc362e698898187b3f86"
RPROVIDES:glibc-langpack-sid:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sk-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sk}"
SRC_URI[aarch64_glibc-langpack-sk.sha256sum] = "bb809e1f590df6ceea9b6fbaaf34a2f59def3a627d562edd0147c8abd39f9be4"
RPROVIDES:glibc-langpack-sk:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sl-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sl}"
SRC_URI[aarch64_glibc-langpack-sl.sha256sum] = "9bcaebd6befea5578910428ec4acce53ed816f11410d244ca4ce3397b491eff4"
RPROVIDES:glibc-langpack-sl:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sm-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sm}"
SRC_URI[aarch64_glibc-langpack-sm.sha256sum] = "cef727e4093d0671e91836a58cc2b7e67d41777477ba82f0d4101f7e9f9d4998"
RPROVIDES:glibc-langpack-sm:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-so = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-so-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-so;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-so}"
SRC_URI[aarch64_glibc-langpack-so.sha256sum] = "305adb89b3f126cf328d593712575f91f2dfae6570d51be63cad4dc62a7c4ea0"
RPROVIDES:glibc-langpack-so:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sq = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sq-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sq;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sq}"
SRC_URI[aarch64_glibc-langpack-sq.sha256sum] = "36398776d7684844c76fa6e3f37ace7827531ddbd1f929bbe172492a20b4c7fe"
RPROVIDES:glibc-langpack-sq:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sr}"
SRC_URI[aarch64_glibc-langpack-sr.sha256sum] = "e1a9ba24912ff1868dc1af53ef811d5aba21a7c8ea7f32c0d1cdf2e062671552"
RPROVIDES:glibc-langpack-sr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ss = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ss-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ss;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ss}"
SRC_URI[aarch64_glibc-langpack-ss.sha256sum] = "f11cf7eb412ba8b30f1aa1d39ae9db4f295765eb1a813fe4d9f23d7a035850ea"
RPROVIDES:glibc-langpack-ss:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ssy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ssy-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ssy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ssy}"
SRC_URI[aarch64_glibc-langpack-ssy.sha256sum] = "a779f86657483b58c4d860ec14f84f57b844df4f193a817b3cb08c820672a4cf"
RPROVIDES:glibc-langpack-ssy:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-st = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-st-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-st;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-st}"
SRC_URI[aarch64_glibc-langpack-st.sha256sum] = "e30c31a60157d3a3959af96e0bf13878e2b8245f6d54edcbe2d766e7dbc70807"
RPROVIDES:glibc-langpack-st:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-su = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-su-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-su;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-su}"
SRC_URI[aarch64_glibc-langpack-su.sha256sum] = "de1ada2f6df525686f4ecee0a4f395e125c0d568dd7a532fc340e357d0a50524"
RPROVIDES:glibc-langpack-su:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sv = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sv-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sv;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sv}"
SRC_URI[aarch64_glibc-langpack-sv.sha256sum] = "4d62550a980e4cd2e941dadb14c5336954cb6799214c31984d11cf17514a85c3"
RPROVIDES:glibc-langpack-sv:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-sw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-sw-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-sw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-sw}"
SRC_URI[aarch64_glibc-langpack-sw.sha256sum] = "241839085f93712c9b205d6628013e2604b1b2d51faccea963dc7eb99d4cf90f"
RPROVIDES:glibc-langpack-sw:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-syr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-syr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-syr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-syr}"
SRC_URI[aarch64_glibc-langpack-syr.sha256sum] = "b56dd1fc2af2a92cd9dfe751c2e90aaead57e31a44972862ab25c28c28a4e230"
RPROVIDES:glibc-langpack-syr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-szl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-szl-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-szl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-szl}"
SRC_URI[aarch64_glibc-langpack-szl.sha256sum] = "f0a5687aa29de08aab1e4015531b8273da90052b28d792eae7ba9decbc5ecb33"
RPROVIDES:glibc-langpack-szl:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ta = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ta-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ta;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ta}"
SRC_URI[aarch64_glibc-langpack-ta.sha256sum] = "72228667cf53573bae02601dbd4596c1e5bb8432ddd05b27b48db4931affef1c"
RPROVIDES:glibc-langpack-ta:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tcy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tcy-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tcy;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tcy}"
SRC_URI[aarch64_glibc-langpack-tcy.sha256sum] = "23a63c661eb34b58bd3d483e19f122c1a60742482a4d8da274b1ce0aab187a88"
RPROVIDES:glibc-langpack-tcy:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-te = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-te-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-te;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-te}"
SRC_URI[aarch64_glibc-langpack-te.sha256sum] = "be331f487343d3f419cc57aef7159d53b96cd904a851acc1ae6df45e7d7870a4"
RPROVIDES:glibc-langpack-te:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tg = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tg-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tg;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tg}"
SRC_URI[aarch64_glibc-langpack-tg.sha256sum] = "2979a32af26a3baaae68af2e348737b8961f165fad20b22d034c18c743a76124"
RPROVIDES:glibc-langpack-tg:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-th = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-th-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-th}"
SRC_URI[aarch64_glibc-langpack-th.sha256sum] = "d099cb9e4cfd3aaca6043dc63a2519e7f58765b822590fddba2551bfce39bb2b"
RPROVIDES:glibc-langpack-th:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-the = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-the-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-the;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-the}"
SRC_URI[aarch64_glibc-langpack-the.sha256sum] = "1a15b201e7dc1b32f52af38353d2de61bd3be7bed39a36896df85414d1c64e2c"
RPROVIDES:glibc-langpack-the:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ti = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ti-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ti;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ti}"
SRC_URI[aarch64_glibc-langpack-ti.sha256sum] = "43f02e77929ac5df305b12084ff873c4f6872e0c19573622d9b4063b84d60150"
RPROVIDES:glibc-langpack-ti:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tig = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tig-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tig;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tig}"
SRC_URI[aarch64_glibc-langpack-tig.sha256sum] = "9f540c58a9e131e69e0af44f29ae9b5dc77e5dbcb2e54a0faa3b6b09e0ed551e"
RPROVIDES:glibc-langpack-tig:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tk-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tk}"
SRC_URI[aarch64_glibc-langpack-tk.sha256sum] = "0a05bc378ffb1fea7e76ae230146fcba1d9509e8ef594e8bac14ba10cc612b13"
RPROVIDES:glibc-langpack-tk:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tl-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tl;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tl}"
SRC_URI[aarch64_glibc-langpack-tl.sha256sum] = "bc0a28b4b7d9f35adc2b56f2f7ceea4b0f527f5e98565bb66a7ad72e141621b7"
RPROVIDES:glibc-langpack-tl:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tn = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tn-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tn;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tn}"
SRC_URI[aarch64_glibc-langpack-tn.sha256sum] = "8c714e70163f593b17c09b5e131ab684fc543a8a6e1e9c0bba09f73e2730cd40"
RPROVIDES:glibc-langpack-tn:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-to = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-to-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-to;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-to}"
SRC_URI[aarch64_glibc-langpack-to.sha256sum] = "b76e3ec5d7080f4d318066b3a8c004fbbd132a95bfd9941762c7d23fdabd6687"
RPROVIDES:glibc-langpack-to:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tok = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tok-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tok;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tok}"
SRC_URI[aarch64_glibc-langpack-tok.sha256sum] = "718a588175d74c362b7278fcef415dbe3d1f3af05f4989585e377570ef1a0627"
RPROVIDES:glibc-langpack-tok:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tpi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tpi-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tpi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tpi}"
SRC_URI[aarch64_glibc-langpack-tpi.sha256sum] = "3cdbf36bdb7b7ddfe6752fa945c277f62e8695036d88f3051601bfa26ebf5a0a"
RPROVIDES:glibc-langpack-tpi:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tr = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tr-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tr;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tr}"
SRC_URI[aarch64_glibc-langpack-tr.sha256sum] = "1d049da6acdf2ece9670094626f2df2a263bddfdb881928301c9e0a73ffacb81"
RPROVIDES:glibc-langpack-tr:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ts-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ts;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ts}"
SRC_URI[aarch64_glibc-langpack-ts.sha256sum] = "e529bb0862975dd60b34776b1589e4b9109d2db5f478d4c0dcb50d568061e45d"
RPROVIDES:glibc-langpack-ts:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-tt = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-tt-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-tt;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-tt}"
SRC_URI[aarch64_glibc-langpack-tt.sha256sum] = "2a529a5d6cbc857d5380e7423efb7e63c62e95e8278c0b6aece906781fd0c2d7"
RPROVIDES:glibc-langpack-tt:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ug = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ug-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ug;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ug}"
SRC_URI[aarch64_glibc-langpack-ug.sha256sum] = "ce1fd00b809f1e2cbb7f646c02bae7b87e05052e845d099b07391fb612bbb4c3"
RPROVIDES:glibc-langpack-ug:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-uk = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uk-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-uk}"
SRC_URI[aarch64_glibc-langpack-uk.sha256sum] = "f316c64d0c454150de9a367767814cf5c733b5741d1104cb8bef96498b4a8a51"
RPROVIDES:glibc-langpack-uk:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-unm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-unm-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-unm;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-unm}"
SRC_URI[aarch64_glibc-langpack-unm.sha256sum] = "5aea5012d27f7c12488b0bb28952ebec87d9c964b8e90fdc0d8131bcd0e93cbf"
RPROVIDES:glibc-langpack-unm:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ur = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ur-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ur;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ur}"
SRC_URI[aarch64_glibc-langpack-ur.sha256sum] = "939b78d2bdfbb60eacd29ee8b085412edd2d0ccf59c9b1eb05e14e37d98c7fa7"
RPROVIDES:glibc-langpack-ur:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-uz = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-uz-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-uz;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-uz}"
SRC_URI[aarch64_glibc-langpack-uz.sha256sum] = "f8bea2cd2843e6d0b62d2daed8527f31b5ac89cece6f61aeb25f042a4623d315"
RPROVIDES:glibc-langpack-uz:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-ve = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-ve-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-ve;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-ve}"
SRC_URI[aarch64_glibc-langpack-ve.sha256sum] = "a3a026b14fae8888d605be00dafc56e1c3451877d355efbfe5da1175ffc912b1"
RPROVIDES:glibc-langpack-ve:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-vi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-vi-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-vi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-vi}"
SRC_URI[aarch64_glibc-langpack-vi.sha256sum] = "6e2dd67851b03689a6976118319e74ad05e447239060ea4a37f7ff7ee3097bd5"
RPROVIDES:glibc-langpack-vi:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-wa = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wa-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wa;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wa}"
SRC_URI[aarch64_glibc-langpack-wa.sha256sum] = "1aee9cadb0aa3c58c323589d3ea234eb417cad154d4f3063fdd5a77fc8d6ec33"
RPROVIDES:glibc-langpack-wa:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-wae = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wae-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wae;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wae}"
SRC_URI[aarch64_glibc-langpack-wae.sha256sum] = "edc8d316ed1817c0f6a115bde3962e839a9d84af210e8a2d49359c83cc2246db"
RPROVIDES:glibc-langpack-wae:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-wal = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wal-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wal;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wal}"
SRC_URI[aarch64_glibc-langpack-wal.sha256sum] = "8d1cfa21378d86346b1d76fc6535a05202bca5513d91acd228042fd2f69cfd81"
RPROVIDES:glibc-langpack-wal:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-wo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-wo-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-wo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-wo}"
SRC_URI[aarch64_glibc-langpack-wo.sha256sum] = "a5af19776864d2fdbe6dace50e0a4a0ad4312f2333f2c5ab8b91e9607b59bd49"
RPROVIDES:glibc-langpack-wo:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-xh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-xh-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-xh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-xh}"
SRC_URI[aarch64_glibc-langpack-xh.sha256sum] = "d0ed44c1fa45597544d71ef593824d0c2bf46a169ae8234f11ef2bf53388a95a"
RPROVIDES:glibc-langpack-xh:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-yi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yi-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yi;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yi}"
SRC_URI[aarch64_glibc-langpack-yi.sha256sum] = "29d62270dc1bbd21617f6bb0d1c87b8f312cc0890daa1b07d9950d794701646f"
RPROVIDES:glibc-langpack-yi:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-yo = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yo-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yo;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yo}"
SRC_URI[aarch64_glibc-langpack-yo.sha256sum] = "11aef7828c50a922063621f7e61df1f52faa94302389d6ae0a595ff0671513cb"
RPROVIDES:glibc-langpack-yo:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-yue = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yue-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yue;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yue}"
SRC_URI[aarch64_glibc-langpack-yue.sha256sum] = "546124e53769439c4c5c919cf6a486978cbbf7cbdd2fa100a1f389398af717a6"
RPROVIDES:glibc-langpack-yue:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-yuw = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-yuw-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-yuw;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-yuw}"
SRC_URI[aarch64_glibc-langpack-yuw.sha256sum] = "ca796a8a70438fbac1c9d62f89cc08315d7bcb2ad5cd4d46209a2353902c05a5"
RPROVIDES:glibc-langpack-yuw:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-zgh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zgh-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zgh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zgh}"
SRC_URI[aarch64_glibc-langpack-zgh.sha256sum] = "6a7a26edf5c95e8ec2008be792e28fa70d0f31773fd60091c7ef8cbb0000ce01"
RPROVIDES:glibc-langpack-zgh:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-zh = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zh-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zh;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zh}"
SRC_URI[aarch64_glibc-langpack-zh.sha256sum] = "3a7ef2aaa412e3cb9fd47cad4bba66630fb5dbe83e895a2eb89a1f401596b45b"
RPROVIDES:glibc-langpack-zh:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-langpack-zu = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-langpack-zu-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-langpack-zu;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-langpack-zu}"
SRC_URI[aarch64_glibc-langpack-zu.sha256sum] = "01427cc392c75184844aeab1dcd8cdc9fe5f18f6846563c74edc5c6dc9fdc23c"
RPROVIDES:glibc-langpack-zu:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-locale-source = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-locale-source-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-locale-source;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-locale-source}"
SRC_URI[aarch64_glibc-locale-source.sha256sum] = "b5efd4ebbd9f78690cbedec2104e9c80646f7260583ea758d42c584d2a062225"

URI_aarch64_glibc-minimal-langpack = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/glibc-minimal-langpack-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-minimal-langpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-minimal-langpack}"
SRC_URI[aarch64_glibc-minimal-langpack.sha256sum] = "06d7da2df9b4babfe203ec0bc893784c712a3fefe29cea64e243a5be29f7e2e2"
RPROVIDES:glibc-minimal-langpack:aarch64 = "virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

URI_aarch64_glibc-nss-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-nss-devel-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-nss-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-nss-devel}"
SRC_URI[aarch64_glibc-nss-devel.sha256sum] = "ae422ff05cb6eaa326577f45b248faca7591e66ac574293230e0b4fd17a48df4"

URI_aarch64_glibc-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/glibc-static-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-static}"
SRC_URI[aarch64_glibc-static.sha256sum] = "726ee366c4d05b586926c2ca723bbb57beb7ae9c25560c5ec5a88d9bb1114fd3"

URI_aarch64_glibc-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/glibc-utils-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_glibc-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_glibc-utils}"
SRC_URI[aarch64_glibc-utils.sha256sum] = "7ecbc32d9af8ece3917ceec8efaf8844bc1b49f5300c516f6d65ef82f0d157d3"

URI_aarch64_libnsl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnsl-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_libnsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnsl}"
SRC_URI[aarch64_libnsl.sha256sum] = "3857e96cf5da7eb6620d78836dd5a21a0f2c265de843ed99a8e938ac3ec88cb1"

URI_aarch64_nss_db = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_db-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_nss_db;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_db}"
SRC_URI[aarch64_nss_db.sha256sum] = "a0d67693394f8e12d9d277745ed635523a33134733f5433d90de1322f9a41dae"

URI_aarch64_nss_hesiod = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nss_hesiod-2.39-58.el10_1.7.alma.1.aarch64.rpm;name=aarch64_nss_hesiod;unpack=0"
SRC_URI:append = " ${URI_aarch64_nss_hesiod}"
SRC_URI[aarch64_nss_hesiod.sha256sum] = "1aa4ad75c60bf9fcf2986dbda44715cd365c3e5d8499e222c9f273662f6fbc2a"

RDEPENDS:glibc = " \
 basesystem \
 glibc-common \
 glibc-gconv-extra \
 libgcc \
 virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1 \
 "
RDEPENDS:glibc-all-langpacks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-benchtests = " \
 bash \
 glibc \
 python3 \
 "
RDEPENDS:glibc-common = " \
 bash \
 glibc \
 "
RDEPENDS:glibc-devel = " \
 glibc \
 kernel-headers \
 libxcrypt-devel \
 "
RDEPENDS:glibc-doc = " \
 glibc \
 "
RDEPENDS:glibc-gconv-extra = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-aa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-af = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-agr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-am = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-an = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-anp = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ar = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-as = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ast = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ayc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-az = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-be = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bem = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ber = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bhb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bho = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-br = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-brx = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-bs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-byn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ca = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ce = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-chr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ckb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cmn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-crh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-csb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-cy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-da = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-de = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-doi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-dz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-el = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-en = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-es = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-et = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-eu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ff = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fil = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-fy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ga = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gbm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gez = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-gv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ha = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hak = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-he = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hsb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ht = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-hy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ia = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-id = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ik = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-is = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-it = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-iu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ja = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ka = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kab = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-km = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ko = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ks = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ku = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-kw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ky = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-li = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lij = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ln = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-lzh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mag = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mai = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mfe = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mhr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-miq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mjw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ml = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mni = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mnw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ms = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-mt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-my = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nan = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nb = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nds = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ne = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nhn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-niu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-nso = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-oc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-om = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-or = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-os = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pap = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ps = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-pt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-quz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-raj = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rif = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ro = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ru = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-rw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sah = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sat = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sc = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sd = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-se = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sgs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-shs = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-si = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sid = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-so = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sq = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ss = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ssy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-st = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-su = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sv = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-sw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-syr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-szl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ta = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tcy = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-te = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tg = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-th = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-the = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ti = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tig = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tl = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tn = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-to = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tok = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tpi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tr = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ts = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-tt = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ug = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uk = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-unm = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ur = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-uz = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-ve = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-vi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wa = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wae = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wal = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-wo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-xh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yi = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yo = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yue = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-yuw = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zgh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zh = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-langpack-zu = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-locale-source = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-minimal-langpack = " \
 glibc \
 glibc-common \
 "
RDEPENDS:glibc-nss-devel = " \
 glibc \
 nss_db \
 nss_hesiod \
 "
RDEPENDS:glibc-static = " \
 glibc-devel \
 libxcrypt-static \
 "
RDEPENDS:glibc-utils = " \
 bash \
 gd \
 glibc \
 libpng \
 perl-interpreter \
 zlib-ng-compat \
 "
RDEPENDS:libnsl = " \
 glibc \
 "
RDEPENDS:nss_db = " \
 glibc \
 libselinux \
 "
RDEPENDS:nss_hesiod = " \
 glibc \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/glibc-langpack-en_or_glibc-all-langpacks rpm/virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"

PROVIDES:append:aarch64 = " rpm/virtual/glibc-langpack-en_or_glibc-all-langpacks rpm/virtual/glibc-langpack_eq_2.39-58.el10_1.7.alma.1"
