# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmines"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmines \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmines-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d3e2904d12357e38b4d7472a7f4315524dd580ad3e4b734caf33af03054b2e3"

URI_x86_64_v2_kmines = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmines-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmines;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmines}"
SRC_URI[x86_64_v2_kmines.sha256sum] = "a3c6b2ddb6d602c898cc9b41697fbc1f4c8a8e575e82cb04a5c07bdfc654b5d2"

URI_aarch64_kmines = "${EPEL_MIRROR}/aarch64/Packages/k/kmines-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmines;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmines}"
SRC_URI[aarch64_kmines.sha256sum] = "a6657e54d70b99ddc52985fb977e98703e1d21f5b5f45a105f73e966aeaa1e17"

RDEPENDS:kmines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
