# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcamera"
PV = "0.3.2"
PR = "3.el10_0"
PACKAGES = " \
 libcamera \
 libcamera-devel \
 libcamera-doc \
 libcamera-gstreamer \
 libcamera-ipa \
 libcamera-qcam \
 libcamera-tools \
 libcamera-v4l2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libcamera-0.3.2-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bbe69912d554aced0f22a653840be8911161f29ea01633ecb2d70f9cdd309df8"

URI_x86_64_v2_libcamera = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcamera-0.3.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libcamera;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcamera}"
SRC_URI[x86_64_v2_libcamera.sha256sum] = "d8d9a7fbe299370406586c018b8eb8a8e5d889a046c2d9db603931b303e56f63"

URI_x86_64_v2_libcamera-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcamera-devel-0.3.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libcamera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcamera-devel}"
SRC_URI[x86_64_v2_libcamera-devel.sha256sum] = "3f0709c44b74de385d28426f2ac432fb4b3760d6dceab16d293068d3f965eed2"

URI_x86_64_v2_libcamera-doc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcamera-doc-0.3.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libcamera-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcamera-doc}"
SRC_URI[x86_64_v2_libcamera-doc.sha256sum] = "3ed4e50f00e7d28c909a2c5e9fb93878caa55cee6118df506fc3c220953fb40a"

URI_x86_64_v2_libcamera-gstreamer = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcamera-gstreamer-0.3.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libcamera-gstreamer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcamera-gstreamer}"
SRC_URI[x86_64_v2_libcamera-gstreamer.sha256sum] = "a8207f78f72ae4ee8489d3bc092559c26fa1bf25064677094649eebc23c0cddb"

URI_x86_64_v2_libcamera-ipa = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcamera-ipa-0.3.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libcamera-ipa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcamera-ipa}"
SRC_URI[x86_64_v2_libcamera-ipa.sha256sum] = "052d089aebb2f5ed6390b0deb65e7d92b6cea5b540c09fa017c496cb99718bed"

URI_x86_64_v2_libcamera-qcam = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcamera-qcam-0.3.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libcamera-qcam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcamera-qcam}"
SRC_URI[x86_64_v2_libcamera-qcam.sha256sum] = "a89083055a120bc72b6e88cf1b877b4db422f2a0072dd48fe75e3a5df133dd82"

URI_x86_64_v2_libcamera-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcamera-tools-0.3.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libcamera-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcamera-tools}"
SRC_URI[x86_64_v2_libcamera-tools.sha256sum] = "386a1dbac91be25bc84bea02be8b6263595fc75fc95fe5ef3bd99334578adcfd"

URI_x86_64_v2_libcamera-v4l2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libcamera-v4l2-0.3.2-3.el10_0.x86_64_v2.rpm;name=x86_64_v2_libcamera-v4l2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcamera-v4l2}"
SRC_URI[x86_64_v2_libcamera-v4l2.sha256sum] = "d273d9cf0c5dbd59b8d0bdedaf0f2dfa57cd830cdf56c550bb80ef9f19c8edf7"

URI_aarch64_libcamera = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcamera-0.3.2-3.el10_0.aarch64.rpm;name=aarch64_libcamera;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcamera}"
SRC_URI[aarch64_libcamera.sha256sum] = "7b45e914a0d6696898f2ff888f740172f5c2bab8ed78e3b68fbb80de4431621d"

URI_aarch64_libcamera-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcamera-devel-0.3.2-3.el10_0.aarch64.rpm;name=aarch64_libcamera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcamera-devel}"
SRC_URI[aarch64_libcamera-devel.sha256sum] = "81a4730f91e4a1ead2b090c5d0aab8b9b58766aa47d884a24678e4037c6cd550"

URI_aarch64_libcamera-doc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcamera-doc-0.3.2-3.el10_0.aarch64.rpm;name=aarch64_libcamera-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcamera-doc}"
SRC_URI[aarch64_libcamera-doc.sha256sum] = "4329eae0b59ed0b272209b7bc43bed2689a16cf8046efd959b61589115cb413b"

URI_aarch64_libcamera-gstreamer = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcamera-gstreamer-0.3.2-3.el10_0.aarch64.rpm;name=aarch64_libcamera-gstreamer;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcamera-gstreamer}"
SRC_URI[aarch64_libcamera-gstreamer.sha256sum] = "32825bf166384c0016d39f11397dff3aa87b630a1388eb0ed2c76fc973d91b9b"

URI_aarch64_libcamera-ipa = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcamera-ipa-0.3.2-3.el10_0.aarch64.rpm;name=aarch64_libcamera-ipa;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcamera-ipa}"
SRC_URI[aarch64_libcamera-ipa.sha256sum] = "a6d98eb11b671469c03fe643a43efefafd9d8fb0ff9e13cc55d98a10b68effe6"

URI_aarch64_libcamera-qcam = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcamera-qcam-0.3.2-3.el10_0.aarch64.rpm;name=aarch64_libcamera-qcam;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcamera-qcam}"
SRC_URI[aarch64_libcamera-qcam.sha256sum] = "959582041f18eb93527ead9f8a090861decbc617ab72679eea3a252b4c663a53"

URI_aarch64_libcamera-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcamera-tools-0.3.2-3.el10_0.aarch64.rpm;name=aarch64_libcamera-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcamera-tools}"
SRC_URI[aarch64_libcamera-tools.sha256sum] = "e4e6c3289decc2764e05d9b09e405f8948fc174df5f2f8d1f9466b5002cc87b5"

URI_aarch64_libcamera-v4l2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libcamera-v4l2-0.3.2-3.el10_0.aarch64.rpm;name=aarch64_libcamera-v4l2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcamera-v4l2}"
SRC_URI[aarch64_libcamera-v4l2.sha256sum] = "e71473e68f7921268082c9489e7318afe98a59c7853281b93caae6a373c92a35"

RDEPENDS:libcamera = " \
 glibc \
 gnutls \
 libgcc \
 libstdc++ \
 libyaml \
 systemd-libs \
 "
RDEPENDS:libcamera-devel = " \
 libcamera \
 libcamera-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libcamera-doc = " \
 "
RDEPENDS:libcamera-gstreamer = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libcamera \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libcamera-ipa = " \
 glibc \
 libcamera \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libcamera-qcam = " \
 glibc \
 libcamera \
 libgcc \
 libstdc++ \
 libtiff \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:libcamera-tools = " \
 glibc \
 libcamera \
 libdrm \
 libevent \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 libtiff \
 libyaml \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:libcamera-v4l2 = " \
 bash \
 glibc \
 libcamera \
 libgcc \
 libstdc++ \
 "
