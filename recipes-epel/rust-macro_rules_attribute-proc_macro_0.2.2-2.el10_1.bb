# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-macro_rules_attribute-proc_macro"
PV = "0.2.2"
PR = "2.el10_1"
PACKAGES = " \
 rust-macro_rules_attribute-proc_macro+default-devel \
 rust-macro_rules_attribute-proc_macro+verbose-expansions-devel \
 rust-macro_rules_attribute-proc_macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-macro_rules_attribute-proc_macro-0.2.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "329c765988c59ebfa8708b3891a1f6ebe5c2441541c986721b7f4b66c87304be"

URI_x86_64_v2_rust-macro_rules_attribute-proc_macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute-proc_macro+default-devel-0.2.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute-proc_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute-proc_macro+default-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute-proc_macro+default-devel.sha256sum] = "27a7dd41f6d53bbc468bc4f2e5ae83e26c3b8a50f6699a264382238e3fb42e85"

URI_x86_64_v2_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute-proc_macro+verbose-expansions-devel-0.2.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel.sha256sum] = "193e8912d541e1e3f900ccd6bef88209073c329dd30b7e2839f7d7b266520144"

URI_x86_64_v2_rust-macro_rules_attribute-proc_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-macro_rules_attribute-proc_macro-devel-0.2.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-macro_rules_attribute-proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-macro_rules_attribute-proc_macro-devel}"
SRC_URI[x86_64_v2_rust-macro_rules_attribute-proc_macro-devel.sha256sum] = "326bf0e73ee33bcaa1293ea7aee9a735c3df99bb769d47e39722beb0d949ee58"

URI_aarch64_rust-macro_rules_attribute-proc_macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute-proc_macro+default-devel-0.2.2-2.el10_1.noarch.rpm;name=aarch64_rust-macro_rules_attribute-proc_macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute-proc_macro+default-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute-proc_macro+default-devel.sha256sum] = "ac034eb3d8b0dbc73f3a0f20824f861a4a876151593d9d1fbe9a04fa077ae6a0"

URI_aarch64_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute-proc_macro+verbose-expansions-devel-0.2.2-2.el10_1.noarch.rpm;name=aarch64_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute-proc_macro+verbose-expansions-devel.sha256sum] = "7a28b7370f33a5e4dd550f860fc0deb05e3bbf8f67fafd64de810691929ea857"

URI_aarch64_rust-macro_rules_attribute-proc_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-macro_rules_attribute-proc_macro-devel-0.2.2-2.el10_1.noarch.rpm;name=aarch64_rust-macro_rules_attribute-proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-macro_rules_attribute-proc_macro-devel}"
SRC_URI[aarch64_rust-macro_rules_attribute-proc_macro-devel.sha256sum] = "97bb2fa073ddfeaf3fb1cebf164f0b66f08627c4cb833ab2b132195096edbf36"

RDEPENDS:rust-macro_rules_attribute-proc_macro+default-devel = " \
 cargo \
 rust-macro_rules_attribute-proc_macro-devel \
 "
RDEPENDS:rust-macro_rules_attribute-proc_macro+verbose-expansions-devel = " \
 cargo \
 rust-macro_rules_attribute-proc_macro-devel \
 "
RDEPENDS:rust-macro_rules_attribute-proc_macro-devel = " \
 cargo \
 "
