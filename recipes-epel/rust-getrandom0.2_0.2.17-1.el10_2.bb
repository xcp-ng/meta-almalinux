# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom0.2"
PV = "0.2.17"
PR = "1.el10_2"
PACKAGES = " \
 rust-getrandom0.2+custom-devel \
 rust-getrandom0.2+default-devel \
 rust-getrandom0.2+linux_disable_fallback-devel \
 rust-getrandom0.2+rdrand-devel \
 rust-getrandom0.2+std-devel \
 rust-getrandom0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom0.2-0.2.17-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50ba276aca60093a8a3567229305d5937d88eb0cf8b9db4e1cac2d6a72d3966b"

URI_x86_64_v2_rust-getrandom0.2+custom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+custom-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+custom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+custom-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+custom-devel.sha256sum] = "0dc6f465ad6b95e92c7a142712d44f30f1be35a140d9db8607970caea4f9ea52"

URI_x86_64_v2_rust-getrandom0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+default-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+default-devel.sha256sum] = "a4fd781d8efc6c39c848f2f61b0e0364446c5523e15cb1d2cadd7eea9b7a736a"

URI_x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+linux_disable_fallback-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel.sha256sum] = "71cadb4bb8edc966f104b7f20807f16821542346e2d6c3131113a3002a404f14"

URI_x86_64_v2_rust-getrandom0.2+rdrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+rdrand-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+rdrand-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+rdrand-devel.sha256sum] = "98fbd803fe3c25cdd6ed24bcb7dc1dcdc98605a0dd107fe4f1f56ad26552c65e"

URI_x86_64_v2_rust-getrandom0.2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+std-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+std-devel.sha256sum] = "8ca97839941e4cc0065438419aafcf9defe892aaece0a36bb7f21ade287da6ee"

URI_x86_64_v2_rust-getrandom0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2-devel-0.2.17-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2-devel.sha256sum] = "19858ba670e6177435fcd09b19c2fe4e274caa75e4166872acf298567cef1c8e"

URI_aarch64_rust-getrandom0.2+custom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+custom-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom0.2+custom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+custom-devel}"
SRC_URI[aarch64_rust-getrandom0.2+custom-devel.sha256sum] = "67669c64f08b3c7c26402bbd5124051025bc8ed907b01b1ced20ddcfced74061"

URI_aarch64_rust-getrandom0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+default-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+default-devel}"
SRC_URI[aarch64_rust-getrandom0.2+default-devel.sha256sum] = "cc527059af7353ee5bb0e96763965b8d00470c5baa82b7b2c6faaae76cdd2a53"

URI_aarch64_rust-getrandom0.2+linux_disable_fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+linux_disable_fallback-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom0.2+linux_disable_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+linux_disable_fallback-devel}"
SRC_URI[aarch64_rust-getrandom0.2+linux_disable_fallback-devel.sha256sum] = "7dd6697b3e882c6e954167c37b8c17d663f703106444e9e6800cd6025ba10c9c"

URI_aarch64_rust-getrandom0.2+rdrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+rdrand-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom0.2+rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+rdrand-devel}"
SRC_URI[aarch64_rust-getrandom0.2+rdrand-devel.sha256sum] = "565a1c903bb3a59176f8f86aab87ca6c5c20ff157879b53afbab9f927e6e8542"

URI_aarch64_rust-getrandom0.2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+std-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+std-devel}"
SRC_URI[aarch64_rust-getrandom0.2+std-devel.sha256sum] = "11472bd99be1a7f157de07b4bf347f032385c37a6deee231521c1d073b81fba7"

URI_aarch64_rust-getrandom0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2-devel-0.2.17-1.el10_2.noarch.rpm;name=aarch64_rust-getrandom0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2-devel}"
SRC_URI[aarch64_rust-getrandom0.2-devel.sha256sum] = "e2ec529941929f40793f878a2352d67549050059bd3e3c85460cd2537e260d72"

RDEPENDS:rust-getrandom0.2+custom-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+default-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+linux_disable_fallback-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+rdrand-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+std-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 "
