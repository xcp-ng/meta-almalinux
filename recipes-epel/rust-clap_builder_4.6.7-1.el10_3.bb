# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_builder"
PV = "4.6.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+color-devel \
 rust-clap_builder+debug-devel \
 rust-clap_builder+default-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-doc-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+unstable-styles-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-clap_builder-4.6.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "08772d00f96fe4118d6122e7f1a52264b3f339639597c4bb1f0a5c635e19a52e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+cargo-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+cargo-devel.sha256sum] = "b2201c17cc5986b5ca00d3b28c0c7a13b9c19718e89f17ac253a8a77f7b3366c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+color-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+color-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+color-devel.sha256sum] = "36fa735e20eaa09d3cfab09744edb7c4f536aff3c6e50752853360546d6c2728"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+debug-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+debug-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+debug-devel.sha256sum] = "8c7aa127246e054e07c4cab413b544db63b813bc21b462241a9e989ce0509a5e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+default-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+default-devel.sha256sum] = "6a694dd103df68e19b6b97d815a1c7826d08b93f68c43a6c69aa44323196a120"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+deprecated-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+deprecated-devel.sha256sum] = "140e6ef069c71c18e90a6fb52ece12149f159015d18803cf451515023de29e85"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+env-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+env-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+env-devel.sha256sum] = "974f5ff94820232edafbeb667ca8de5517df4a8e21f791eb48015f5fd445cb8b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+error-context-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+error-context-devel.sha256sum] = "157addbd431e6285089204946ca493f513743d1be6c2a778fc5c49db2aacd328"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+help-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+help-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+help-devel.sha256sum] = "2e40771adf6f5056f263997885cda4ad880b953082e9c7e6ff82002a5851ea31"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+std-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+std-devel.sha256sum] = "dcd5f109d5e525f585958bad5ebf8137ec0399b41464b2c727959fc9faf0a7cd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+string-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+string-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+string-devel.sha256sum] = "e740084322577b27b1c7c6e98b0b68a045a904d416342864bd7b6ebbfc05a0b0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+suggestions-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+suggestions-devel.sha256sum] = "42d03bf6416ddeb4ed68a1754e40965ca8e9783e50168634e0ef4e4bbd3fa60d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unicode-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+unicode-devel.sha256sum] = "3deeb77fd9e451b2223892950052c08f9572479a89165042ecaca5ca7bc101dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-doc-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-doc-devel.sha256sum] = "186ea6a5a1b87bc014a2c53ff33ad0f0a556a9b20990c4cc5ae1be5614c03460"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-ext-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-ext-devel.sha256sum] = "419bf9d834b7e47aa419a068ef32a7b6d4c6b68515f206c4bbe4121bd4df2df7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-styles-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-styles-devel.sha256sum] = "f75ff87ab0579dd81a0c4e71c7952b31bbd2dd37a7ecd8a1d14789ee9130d8f2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-v5-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-v5-devel.sha256sum] = "65665be06028e99979bcc70f56fc73d331a713acd40cb335caeadae98e5aebe0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+usage-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+usage-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+usage-devel.sha256sum] = "510c874fbee453282b990b3c58c31eac32d94adf2c94d3a90602c9c05ced7f6b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+wrap_help-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder+wrap_help-devel.sha256sum] = "7a3bdeabca39e90f1f62a904e152403b6fe9610bc53f0587835753690e25dcb0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder-devel-4.6.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder-devel;unpack=0"
SRC_URI[x86_64_v2_rust-clap_builder-devel.sha256sum] = "492bf8439181fc007a6c16ce8de2933318e44492a0626197607608efbc273c6e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+cargo-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+cargo-devel.sha256sum] = "2538dccc1469f6aa32e7f030b1755c75bf40a4694f70abc9e96343d16f693fb6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+color-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+color-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+color-devel.sha256sum] = "c71099b30bf9d0c8ee1da182e25672adab69e11edeae64d47def1248bf48c867"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+debug-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+debug-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+debug-devel.sha256sum] = "48cbb46c6be826b25fb09506198471f21a95205bb2584aae6b86a91e865f9626"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+default-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+default-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+default-devel.sha256sum] = "72e9b754452f2e9c4d100e187be5a53aa68252439bfc5e1f87c4e5594e50305f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+deprecated-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+deprecated-devel.sha256sum] = "4d1f3b71908a2c90c85284d7656b7df1b46dc900f67cd84318f011c6899773d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+env-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+env-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+env-devel.sha256sum] = "ebf3b0ee2671efc5904b9337ec17767fd092f99a87860ae6cbf29e5bb1d24e0f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+error-context-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+error-context-devel.sha256sum] = "3a46207b2e48fe2f10fa2105d8e12ede54939f5b65bdd36fbd37c3cbfa57ea07"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+help-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+help-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+help-devel.sha256sum] = "d9b0c29860290068d8c12c6c7bf71501494cab28c308ffc94414749c5277c5d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+std-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+std-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+std-devel.sha256sum] = "8e95c5502e7a84da225bf8d414d92b948925d1dcfacf696b3a8b962a46cfe2bf"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+string-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+string-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+string-devel.sha256sum] = "7a9bc543deee791d2efdd39874eb85a01898667b95155ebfc6daaadd9b446019"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+suggestions-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+suggestions-devel.sha256sum] = "11af44b19dc75e20402c85211ad5f3b7c83bb83e13e68cc5df2bb8600af190c1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unicode-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+unicode-devel.sha256sum] = "cdb045ea67dbd9acf8a7068667c201c39417b1a2990afb633ae33b900ba9020b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-doc-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+unstable-doc-devel.sha256sum] = "66930a3d0c1c1aada810e47d30182e2025fdac85e567fa089b2edbcd39de6c30"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-ext-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+unstable-ext-devel.sha256sum] = "79a6735e03815565134f4ddd03bb3042eb7e75367e11817d627efb058a65820c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-styles-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+unstable-styles-devel.sha256sum] = "7be4d8c3c9d48e619f4aef6b616ec5439ac79db4f76d8488fbf46f37d1b6fe42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-v5-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+unstable-v5-devel.sha256sum] = "f4fc3626517dc30c29e3b9d7ee7e1ab121d01c8c1e75708f96bf10e9ecd82f95"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+usage-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+usage-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+usage-devel.sha256sum] = "7347b876d7d8634781a95ec413ae373771fd82635679dc4c7e27c5f5047c4769"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+wrap_help-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder+wrap_help-devel.sha256sum] = "1113858570773e7b25f20a5cbf03d862e4ba49be02d20d3bdee4cbd09d129e4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder-devel-4.6.7-1.el10_3.noarch.rpm;name=aarch64_rust-clap_builder-devel;unpack=0"
SRC_URI[aarch64_rust-clap_builder-devel.sha256sum] = "235ed23d20d193313a5d071f1a78fd6b8ff4ae53d53e5f0b6b5c2b9df416e031"

RDEPENDS:rust-clap_builder+cargo-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+default-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+deprecated-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+env-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+error-context-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+help-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+std-devel = " \
 cargo \
 rust-anstyle+std-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+string-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+suggestions-devel = " \
 cargo \
 rust-clap_builder+error-context-devel \
 rust-clap_builder-devel \
 rust-strsim+default-devel \
 "
RDEPENDS:rust-clap_builder+unicode-devel = " \
 cargo \
 rust-clap_builder-devel \
 rust-unicase+default-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-clap_builder+unstable-doc-devel = " \
 cargo \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-ext-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-styles-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-v5-devel = " \
 cargo \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+usage-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+wrap_help-devel = " \
 cargo \
 rust-clap_builder+help-devel \
 rust-clap_builder-devel \
 rust-terminal_size+default-devel \
 "
RDEPENDS:rust-clap_builder-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-clap_lex+default-devel \
 "
