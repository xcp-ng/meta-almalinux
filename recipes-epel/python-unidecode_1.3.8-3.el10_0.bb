# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-unidecode"
PV = "1.3.8"
PR = "3.el10_0"
PACKAGES = " \
 python3-unidecode \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-unidecode-1.3.8-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d9d01a7c96596a472da56e7460fdc2ddf03bad056f0acc3a8eaca36022b82ac"

URI_x86_64_v2_python3-unidecode = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-unidecode-1.3.8-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-unidecode;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-unidecode}"
SRC_URI[x86_64_v2_python3-unidecode.sha256sum] = "151ed090fcdfd13adf3070632ceb0ea36eece8de50989a9ae784d92730972781"

URI_aarch64_python3-unidecode = "${EPEL_MIRROR}/aarch64/Packages/p/python3-unidecode-1.3.8-3.el10_0.noarch.rpm;name=aarch64_python3-unidecode;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-unidecode}"
SRC_URI[aarch64_python3-unidecode.sha256sum] = "06cf6c7a3becd2d726e8d5c5142d6d7f5806515d7ee9f536aee77247b6a35bcc"

RDEPENDS:python3-unidecode = " \
 python3 \
 "
