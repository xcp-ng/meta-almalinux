# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-difftastic"
PV = "0.63.0"
PR = "4.el10_0"
PACKAGES = " \
 difftastic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-difftastic-0.63.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd855b85557fbf9550e0d96b1ed8315f37e1eccbf634f0d243e8246afb6d99bc"

URI_x86_64_v2_difftastic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/difftastic-0.63.0-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_difftastic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_difftastic}"
SRC_URI[x86_64_v2_difftastic.sha256sum] = "42d7ac8bb08332488703dbb643fd05ab1cd604dbd2f2007acab3ee1b6bf065b9"

URI_aarch64_difftastic = "${EPEL_MIRROR}/aarch64/Packages/d/difftastic-0.63.0-4.el10_0.aarch64.rpm;name=aarch64_difftastic;unpack=0"
SRC_URI:append = " ${URI_aarch64_difftastic}"
SRC_URI[aarch64_difftastic.sha256sum] = "b5ed67b4f163edccef92d2d5a9604e73efaf43e7074049503e851a7b9adbcfea"

RDEPENDS:difftastic = " \
 glibc \
 libgcc \
 libstdc++ \
 "
