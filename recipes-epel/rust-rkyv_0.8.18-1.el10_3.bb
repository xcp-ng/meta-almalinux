# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv"
PV = "0.8.18"
PR = "1.el10_3"
PACKAGES = " \
 rust-rkyv+aligned-devel \
 rust-rkyv+alloc-devel \
 rust-rkyv+big_endian-devel \
 rust-rkyv+bytecheck-devel \
 rust-rkyv+default-devel \
 rust-rkyv+little_endian-devel \
 rust-rkyv+pointer_width_16-devel \
 rust-rkyv+pointer_width_32-devel \
 rust-rkyv+pointer_width_64-devel \
 rust-rkyv+smallvec-1-devel \
 rust-rkyv+std-devel \
 rust-rkyv+unaligned-devel \
 rust-rkyv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv-0.8.18-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bf027c154c41ad737a8393fec83bf2ffa2bf81ed165d524cc344619b18b57d5e"

URI_x86_64_v2_rust-rkyv+aligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+aligned-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+aligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+aligned-devel}"
SRC_URI[x86_64_v2_rust-rkyv+aligned-devel.sha256sum] = "97c725a063455e378a869f8b9fb577d3b4b12281f4124eff5895823930880e9a"

URI_x86_64_v2_rust-rkyv+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+alloc-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+alloc-devel}"
SRC_URI[x86_64_v2_rust-rkyv+alloc-devel.sha256sum] = "50b4c6dd986c7b7c19d37051b2222ff7f98380a1c0263b9ce09d448bc0c338f1"

URI_x86_64_v2_rust-rkyv+big_endian-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+big_endian-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+big_endian-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+big_endian-devel}"
SRC_URI[x86_64_v2_rust-rkyv+big_endian-devel.sha256sum] = "5321fb0aee11ed31795ed29add1976a13a32884bfd44006b7b56180962c9449d"

URI_x86_64_v2_rust-rkyv+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+bytecheck-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv+bytecheck-devel.sha256sum] = "26c9e279859ffd781809b4b79fff6e9fc91dd83ebda0cc8e99f15a1a17a9d515"

URI_x86_64_v2_rust-rkyv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+default-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv+default-devel.sha256sum] = "dbfceff86830d1ed894f2d1ffe977547a4f8f873ebff9dee7b6c0860c4443e95"

URI_x86_64_v2_rust-rkyv+little_endian-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+little_endian-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+little_endian-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+little_endian-devel}"
SRC_URI[x86_64_v2_rust-rkyv+little_endian-devel.sha256sum] = "6722db888b2960ec58c7a99b44bfd6d77d7aa2c275126f3e04890c5b4aa1bc70"

URI_x86_64_v2_rust-rkyv+pointer_width_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_16-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_16-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_16-devel.sha256sum] = "d7f8de38a20731dfcd6852b1ed45664e01fc7f26fd2547903668300a572c9688"

URI_x86_64_v2_rust-rkyv+pointer_width_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_32-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_32-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_32-devel.sha256sum] = "88772e1e0d78c13010850338549d1ec9f5b72a1ef3d6d29ffcdfdf096670e421"

URI_x86_64_v2_rust-rkyv+pointer_width_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+pointer_width_64-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+pointer_width_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+pointer_width_64-devel}"
SRC_URI[x86_64_v2_rust-rkyv+pointer_width_64-devel.sha256sum] = "e9e141393768034a18ecdc07d8691584caee044ca6d033da3bb64913cd59e9ff"

URI_x86_64_v2_rust-rkyv+smallvec-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+smallvec-1-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+smallvec-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+smallvec-1-devel}"
SRC_URI[x86_64_v2_rust-rkyv+smallvec-1-devel.sha256sum] = "cd1c00a3568665fc8f70b466143ab62d683e161cbb064d90340e67adc0a0cc4d"

URI_x86_64_v2_rust-rkyv+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+std-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+std-devel}"
SRC_URI[x86_64_v2_rust-rkyv+std-devel.sha256sum] = "e5216bd4167a6dee2feac6ac3b3afb8fffb6ea5ae7a3615abb3c2c96fa159628"

URI_x86_64_v2_rust-rkyv+unaligned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv+unaligned-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv+unaligned-devel}"
SRC_URI[x86_64_v2_rust-rkyv+unaligned-devel.sha256sum] = "eb87c6ce4e06d52b6d7b0b58539df7d4db6e15ceee434067290f45146a001383"

URI_x86_64_v2_rust-rkyv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv-devel-0.8.18-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv-devel}"
SRC_URI[x86_64_v2_rust-rkyv-devel.sha256sum] = "c822da642d1b420700ac09c325cd1f4eb488f5c57804e34ff0856f06ddf75f01"

URI_aarch64_rust-rkyv+aligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+aligned-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+aligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+aligned-devel}"
SRC_URI[aarch64_rust-rkyv+aligned-devel.sha256sum] = "ea43d6dba07dbc1fa2f80acae0cbc6ac192313918185802798c3bfe0d88a20d3"

URI_aarch64_rust-rkyv+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+alloc-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+alloc-devel}"
SRC_URI[aarch64_rust-rkyv+alloc-devel.sha256sum] = "b65fe14ab45b5017aa55f706e4846c629b123994c1c8c033930d62392c6c5018"

URI_aarch64_rust-rkyv+big_endian-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+big_endian-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+big_endian-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+big_endian-devel}"
SRC_URI[aarch64_rust-rkyv+big_endian-devel.sha256sum] = "deb87fde685e581c08b55c8ef5b1926ad4ef3eaf793a2361edb3a12777581c94"

URI_aarch64_rust-rkyv+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+bytecheck-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv+bytecheck-devel.sha256sum] = "a92ad677ba1238fcfeca70f6659335b3fb753ae6022cf1821ededb823330485a"

URI_aarch64_rust-rkyv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+default-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+default-devel}"
SRC_URI[aarch64_rust-rkyv+default-devel.sha256sum] = "ffa61f6e0435147439f0d51a9070df06a6cdcbe2f60e5c22126c5f51e27461c0"

URI_aarch64_rust-rkyv+little_endian-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+little_endian-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+little_endian-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+little_endian-devel}"
SRC_URI[aarch64_rust-rkyv+little_endian-devel.sha256sum] = "da6dd87e2e0e968df7ce532f52ff4a2ac40ca7c3154848aac28a7aa9b10c39ef"

URI_aarch64_rust-rkyv+pointer_width_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_16-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_16-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_16-devel.sha256sum] = "f3ade8384fc29fdc55cb5495dea07014380aefdb55b5e7396407f2af1b530507"

URI_aarch64_rust-rkyv+pointer_width_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_32-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_32-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_32-devel.sha256sum] = "678e57ffc68c619baa200a71821a51c1384728093cf65312d6d2820b4acb050b"

URI_aarch64_rust-rkyv+pointer_width_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+pointer_width_64-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+pointer_width_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+pointer_width_64-devel}"
SRC_URI[aarch64_rust-rkyv+pointer_width_64-devel.sha256sum] = "3f5a76ee32d367d17ca5b46e88a1dac7de7e737adb8309b4b4b45c237b9ae15a"

URI_aarch64_rust-rkyv+smallvec-1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+smallvec-1-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+smallvec-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+smallvec-1-devel}"
SRC_URI[aarch64_rust-rkyv+smallvec-1-devel.sha256sum] = "e4f2018a5bd0c6ec9dcd93547545a61b1fef3820cd08a50a24bee39541be888a"

URI_aarch64_rust-rkyv+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+std-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+std-devel}"
SRC_URI[aarch64_rust-rkyv+std-devel.sha256sum] = "f024141e98e791daa4930d8086d5d44caf59b7d21dc98dfba1047052d1501c7b"

URI_aarch64_rust-rkyv+unaligned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv+unaligned-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv+unaligned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv+unaligned-devel}"
SRC_URI[aarch64_rust-rkyv+unaligned-devel.sha256sum] = "ed3341b9af51c1de7ba98e81fbaea2a9a100d1422661b0bc4deb5a0a4f16ef49"

URI_aarch64_rust-rkyv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv-devel-0.8.18-1.el10_3.noarch.rpm;name=aarch64_rust-rkyv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv-devel}"
SRC_URI[aarch64_rust-rkyv-devel.sha256sum] = "0a9c42c73a256f71a2c10b515b01a80b35f9113a42a0a4e72780b0364210cb18"

RDEPENDS:rust-rkyv+aligned-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+alloc-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-rancor+alloc-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+big_endian-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+bytecheck-devel = " \
 cargo \
 rust-bytecheck+simdutf8-devel \
 rust-bytecheck-devel \
 rust-rend+bytecheck-devel \
 rust-rkyv-devel \
 rust-rkyv_derive+bytecheck-devel \
 "
RDEPENDS:rust-rkyv+default-devel = " \
 cargo \
 rust-rkyv+bytecheck-devel \
 rust-rkyv+std-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+little_endian-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_16-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_32-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+pointer_width_64-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+smallvec-1-devel = " \
 cargo \
 rust-rkyv-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-rkyv+std-devel = " \
 cargo \
 rust-ptr_meta+std-devel \
 rust-rkyv+alloc-devel \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv+unaligned-devel = " \
 cargo \
 rust-rkyv-devel \
 "
RDEPENDS:rust-rkyv-devel = " \
 cargo \
 rust \
 rust-munge-devel \
 rust-ptr_meta-devel \
 rust-rancor-devel \
 rust-rend-devel \
 rust-rkyv_derive-devel \
 "
