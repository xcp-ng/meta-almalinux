# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-sdk"
PV = "6.7.3"
PR = "1.el10_3"
PACKAGES = " \
 plasma-sdk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-sdk-6.7.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1eefae80e5d2a56411ee8789df62ec1ffc9f585614dd34c1300b8c53be173bf"

URI_x86_64_v2_plasma-sdk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-sdk-6.7.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-sdk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-sdk}"
SRC_URI[x86_64_v2_plasma-sdk.sha256sum] = "1c25f99a4285cb53f8ccdb2d55076d90b0d4c321d932194b6a639cf1c9c75893"

URI_aarch64_plasma-sdk = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-sdk-6.7.3-1.el10_3.aarch64.rpm;name=aarch64_plasma-sdk;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-sdk}"
SRC_URI[aarch64_plasma-sdk.sha256sum] = "1ef793e6bdeab4a42cb2ab9c8000922077df93c661d99599f445e1fdc5b5e6b3"

RDEPENDS:plasma-sdk = " \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kpackage \
 kf6-ksvg \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 libplasma \
 libstdc++ \
 plasma5support \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
