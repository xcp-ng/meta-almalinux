# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-entrypoints"
PV = "0.4"
PR = "11.el10_2"
PACKAGES = " \
 python-entrypoints-doc \
 python3-entrypoints \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-entrypoints-0.4-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd65727c09ffee36efc0cd5044cf46d91fc44d6c65e4b989af6db55abae6222b"

URI_x86_64_v2_python-entrypoints-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-entrypoints-doc-0.4-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-entrypoints-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-entrypoints-doc}"
SRC_URI[x86_64_v2_python-entrypoints-doc.sha256sum] = "879986831e213617f3481d60504672e8f0ef75c8c3db5737c06d24d664d4a1c0"

URI_x86_64_v2_python3-entrypoints = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-entrypoints-0.4-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-entrypoints;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-entrypoints}"
SRC_URI[x86_64_v2_python3-entrypoints.sha256sum] = "8452cfcbb588e755ee049434550c340300053f1d1ec3c14cb9e49c07ccda2d69"

URI_aarch64_python-entrypoints-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-entrypoints-doc-0.4-11.el10_2.noarch.rpm;name=aarch64_python-entrypoints-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-entrypoints-doc}"
SRC_URI[aarch64_python-entrypoints-doc.sha256sum] = "994203ea92c4eb39baf96ea56199fb5210025244f15dc2942be46c201eb8dc42"

URI_aarch64_python3-entrypoints = "${EPEL_MIRROR}/aarch64/Packages/p/python3-entrypoints-0.4-11.el10_2.noarch.rpm;name=aarch64_python3-entrypoints;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-entrypoints}"
SRC_URI[aarch64_python3-entrypoints.sha256sum] = "fbf6eb0186e1a45b68869169b40c459a6e174348746f49868afbff8c60af0502"

RDEPENDS:python-entrypoints-doc = " \
 "
RDEPENDS:python3-entrypoints = " \
 python3 \
 "
