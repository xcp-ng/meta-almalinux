# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libXt"
PV = "1.3.0"
PR = "5.el10"
PACKAGES = " \
 libXt \
 libXt-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libXt-1.3.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "289f22361174066bbaaabb266ebc8443c5faf19c8fade6b787c44009ea140ae7"

URI_x86_64_v2_libXt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXt-1.3.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXt}"
SRC_URI[x86_64_v2_libXt.sha256sum] = "8cda6fb244a9f576f794f4469f37c5aab03202e0c61c7d1d9ef907bec839d7fb"

URI_x86_64_v2_libXt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libXt-devel-1.3.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_libXt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libXt-devel}"
SRC_URI[x86_64_v2_libXt-devel.sha256sum] = "53ce32f39b6d134b95025d7c6b79ae821ce2e3c43304e6ef1f1b7392c10f27b3"

URI_aarch64_libXt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXt-1.3.0-5.el10.aarch64.rpm;name=aarch64_libXt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXt}"
SRC_URI[aarch64_libXt.sha256sum] = "382ad43c7ee1c372be76c6ea101f450123edd164b3cd7f2b3f0de90d336cf12f"

URI_aarch64_libXt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libXt-devel-1.3.0-5.el10.aarch64.rpm;name=aarch64_libXt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libXt-devel}"
SRC_URI[aarch64_libXt-devel.sha256sum] = "1f8d8705f50e459258b4dba2ca1c8fe7ddd06d8c0bb461fab09cd049f3c40cf2"

RDEPENDS:libXt = " \
 glibc \
 libICE \
 libSM \
 libX11 \
 "
RDEPENDS:libXt-devel = " \
 libICE-devel \
 libSM-devel \
 libX11-devel \
 libXt \
 pkgconf-pkg-config \
 xorg-x11-proto-devel \
 "
