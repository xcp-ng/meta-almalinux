# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-oslo-serialization"
PV = "5.9.1"
PR = "2.el10_2"
PACKAGES = " \
 python-oslo-serialization-doc \
 python3-oslo-serialization \
 python3-oslo-serialization-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-oslo-serialization-5.9.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63d6f082a5e015e478791d3b4ce02263d518afb4b79a0e8e48d556404d4de89a"

URI_x86_64_v2_python-oslo-serialization-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-oslo-serialization-doc-5.9.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-oslo-serialization-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-oslo-serialization-doc}"
SRC_URI[x86_64_v2_python-oslo-serialization-doc.sha256sum] = "08fb902c5d688e00f2c22410cdfdf5fe366298eaccbf6363e29f9465c59ba91b"

URI_x86_64_v2_python3-oslo-serialization = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-serialization-5.9.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-serialization;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-serialization}"
SRC_URI[x86_64_v2_python3-oslo-serialization.sha256sum] = "cae04c03b523744c772b841ddbfc525f1015c2842493e31ea3201874cc139481"

URI_x86_64_v2_python3-oslo-serialization-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-oslo-serialization-tests-5.9.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-oslo-serialization-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-oslo-serialization-tests}"
SRC_URI[x86_64_v2_python3-oslo-serialization-tests.sha256sum] = "d243be90c15815990f7fb43d630387a1449625864588041afd6811da253b7bc9"

URI_aarch64_python-oslo-serialization-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-oslo-serialization-doc-5.9.1-2.el10_2.noarch.rpm;name=aarch64_python-oslo-serialization-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-oslo-serialization-doc}"
SRC_URI[aarch64_python-oslo-serialization-doc.sha256sum] = "a04fd74a6ba9b23ecaf468d54e96f25c2f025e2987911c633709c44f6221685c"

URI_aarch64_python3-oslo-serialization = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-serialization-5.9.1-2.el10_2.noarch.rpm;name=aarch64_python3-oslo-serialization;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-serialization}"
SRC_URI[aarch64_python3-oslo-serialization.sha256sum] = "1183c9c5dd6ef8514b7241f377047900cbb3e442b4e8ac2ecf7a405fb5148cd3"

URI_aarch64_python3-oslo-serialization-tests = "${EPEL_MIRROR}/aarch64/Packages/p/python3-oslo-serialization-tests-5.9.1-2.el10_2.noarch.rpm;name=aarch64_python3-oslo-serialization-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-oslo-serialization-tests}"
SRC_URI[aarch64_python3-oslo-serialization-tests.sha256sum] = "52556bff212aeefd3ec7affa187b81ab10f39de9895ad9f00733927f6f913801"

RDEPENDS:python-oslo-serialization-doc = " \
 python3-oslo-serialization \
 "
RDEPENDS:python3-oslo-serialization = " \
 python3 \
 python3-msgpack \
 python3-oslo-utils \
 "
RDEPENDS:python3-oslo-serialization-tests = " \
 python3 \
 python3-oslo-serialization \
 "
