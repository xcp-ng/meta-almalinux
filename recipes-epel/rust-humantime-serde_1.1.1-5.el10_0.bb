# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-humantime-serde"
PV = "1.1.1"
PR = "5.el10_0"
PACKAGES = " \
 rust-humantime-serde+default-devel \
 rust-humantime-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-humantime-serde-1.1.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05bce611ab53c569a66537b1cf646f51d0823df87f69a2b94e87fe2a24490603"

URI_x86_64_v2_rust-humantime-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime-serde+default-devel-1.1.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime-serde+default-devel}"
SRC_URI[x86_64_v2_rust-humantime-serde+default-devel.sha256sum] = "29e572bf214cf369936f1869bbaf4093dfd0b76e350257dc5ef3fb817061797d"

URI_x86_64_v2_rust-humantime-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime-serde-devel-1.1.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime-serde-devel}"
SRC_URI[x86_64_v2_rust-humantime-serde-devel.sha256sum] = "f13c5a7c435227923d4578a21932962d724ee70abc82a79cad28d4aefa85b859"

URI_aarch64_rust-humantime-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime-serde+default-devel-1.1.1-5.el10_0.noarch.rpm;name=aarch64_rust-humantime-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime-serde+default-devel}"
SRC_URI[aarch64_rust-humantime-serde+default-devel.sha256sum] = "b4ff2c7e4df7e23412c37556bb8c99a400110483071f4e9130c86de095d6b801"

URI_aarch64_rust-humantime-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime-serde-devel-1.1.1-5.el10_0.noarch.rpm;name=aarch64_rust-humantime-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime-serde-devel}"
SRC_URI[aarch64_rust-humantime-serde-devel.sha256sum] = "d3bed02eb385be956b2fdd4c42039c9fff56734b3958cb8b7006e0c168f833c7"

RDEPENDS:rust-humantime-serde+default-devel = " \
 cargo \
 rust-humantime-serde-devel \
 "
RDEPENDS:rust-humantime-serde-devel = " \
 cargo \
 rust-humantime+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
