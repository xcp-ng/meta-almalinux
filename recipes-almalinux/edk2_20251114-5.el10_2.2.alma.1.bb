# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "edk2"
PV = "20251114"
PR = "5.el10_2.2.alma.1"
PACKAGES = " \
 edk2-aarch64 \
 edk2-ovmf \
 edk2-tools \
 edk2-tools-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/edk2-20251114-5.el10_2.2.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ed7206a06743f55bf5d49ab2281d1373b2cede119f6082223f74a74ac8fe8fc9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-aarch64-20251114-5.el10_2.2.alma.1.noarch.rpm;name=x86_64_v2_edk2-aarch64;unpack=0"
SRC_URI[x86_64_v2_edk2-aarch64.sha256sum] = "7fddab75a6a135b92c8e8b42056a06b37b3c13b2761e237d4a042d8c4982b6dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-ovmf-20251114-5.el10_2.2.alma.1.noarch.rpm;name=x86_64_v2_edk2-ovmf;unpack=0"
SRC_URI[x86_64_v2_edk2-ovmf.sha256sum] = "8a1c6c7eabbb6b845087603e99711cae9f775eb67e712e3207b3b23ac8167730"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-20251114-5.el10_2.2.alma.1.x86_64_v2.rpm;name=x86_64_v2_edk2-tools;unpack=0"
SRC_URI[x86_64_v2_edk2-tools.sha256sum] = "fecff9868da774bdd71607c8490bbceee5caec2148f06197de9d3c15295283a8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/edk2-tools-doc-20251114-5.el10_2.2.alma.1.noarch.rpm;name=x86_64_v2_edk2-tools-doc;unpack=0"
SRC_URI[x86_64_v2_edk2-tools-doc.sha256sum] = "46e3a05f302bed559f22a1c11c1c8e6d1f87276751054d1e1a9b59a113b71fa1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-aarch64-20251114-5.el10_2.2.alma.1.noarch.rpm;name=aarch64_edk2-aarch64;unpack=0"
SRC_URI[aarch64_edk2-aarch64.sha256sum] = "7fddab75a6a135b92c8e8b42056a06b37b3c13b2761e237d4a042d8c4982b6dc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-ovmf-20251114-5.el10_2.2.alma.1.noarch.rpm;name=aarch64_edk2-ovmf;unpack=0"
SRC_URI[aarch64_edk2-ovmf.sha256sum] = "8a1c6c7eabbb6b845087603e99711cae9f775eb67e712e3207b3b23ac8167730"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-20251114-5.el10_2.2.alma.1.aarch64.rpm;name=aarch64_edk2-tools;unpack=0"
SRC_URI[aarch64_edk2-tools.sha256sum] = "51b6c917864bc93ab791a803e1239a19bad37d20f3684ea611ec82ec8645f715"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/edk2-tools-doc-20251114-5.el10_2.2.alma.1.noarch.rpm;name=aarch64_edk2-tools-doc;unpack=0"
SRC_URI[aarch64_edk2-tools-doc.sha256sum] = "46e3a05f302bed559f22a1c11c1c8e6d1f87276751054d1e1a9b59a113b71fa1"

RDEPENDS:edk2-aarch64 = " \
 "
RDEPENDS:edk2-ovmf = " \
 "
RDEPENDS:edk2-tools = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:edk2-tools-doc = " \
 "
