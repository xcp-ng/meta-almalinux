# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "debmirror"
PV = "2.48"
PR = "3.el10_2"
PACKAGES = " \
 debmirror \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/debmirror-2.48-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfe27231b4b099ece14799d9329742ba98d2bba65c20bcdec341637262f163d8"

URI_x86_64_v2_debmirror = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/debmirror-2.48-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_debmirror;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_debmirror}"
SRC_URI[x86_64_v2_debmirror.sha256sum] = "71e40b103db95308bf2b0a8814ae34789d7ab3f0cc8de6add684461b93e5d1ac"

URI_aarch64_debmirror = "${EPEL_MIRROR}/aarch64/Packages/d/debmirror-2.48-3.el10_2.noarch.rpm;name=aarch64_debmirror;unpack=0"
SRC_URI:append = " ${URI_aarch64_debmirror}"
SRC_URI[aarch64_debmirror.sha256sum] = "a07d847aa9e45cae07dba7bfbae4c446bf3b38577aebb1775916040344eb4966"

RDEPENDS:debmirror = " \
 bzip2 \
 ed \
 findutils \
 gnupg2 \
 gzip \
 patch \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Fcntl \
 perl-File-Path \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IO-Compress \
 perl-LockFile-Simple \
 perl-MIME-Base64 \
 perl-PathTools \
 perl-Storable \
 perl-URI \
 perl-if \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-libwww-perl \
 rsync \
 virtual/coreutils \
 "
