# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distribution-gpg-keys"
PV = "1.121"
PR = "1.el10_3"
PACKAGES = " \
 distribution-gpg-keys \
 distribution-gpg-keys-copr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/distribution-gpg-keys-1.121-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f64de6b2ebe96c6846d9a04c99c6470d776a8edb042e76b9362bd1f6eb6f8c2b"

URI_x86_64_v2_distribution-gpg-keys = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-1.121-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distribution-gpg-keys}"
SRC_URI[x86_64_v2_distribution-gpg-keys.sha256sum] = "33152b688d28a3dce327bff32d9f59bbc8e934655617273d3adbeca136f20d9b"

URI_x86_64_v2_distribution-gpg-keys-copr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distribution-gpg-keys-copr-1.121-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_distribution-gpg-keys-copr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distribution-gpg-keys-copr}"
SRC_URI[x86_64_v2_distribution-gpg-keys-copr.sha256sum] = "aaf49cd3b7022286beb7f30c8af089581f76fa18db9ac5f881e3b948929e468c"

URI_aarch64_distribution-gpg-keys = "${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-1.121-1.el10_3.noarch.rpm;name=aarch64_distribution-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_aarch64_distribution-gpg-keys}"
SRC_URI[aarch64_distribution-gpg-keys.sha256sum] = "881820c2981b5dde46ed3b07658a8b74f60bf5a15c715e8e90268ed00e0a0e9e"

URI_aarch64_distribution-gpg-keys-copr = "${EPEL_MIRROR}/aarch64/Packages/d/distribution-gpg-keys-copr-1.121-1.el10_3.noarch.rpm;name=aarch64_distribution-gpg-keys-copr;unpack=0"
SRC_URI:append = " ${URI_aarch64_distribution-gpg-keys-copr}"
SRC_URI[aarch64_distribution-gpg-keys-copr.sha256sum] = "634b68efd4a4ccbe9dd42f65ff8ce7bb78a5157b645887b71edf6dce7973dcfb"

RDEPENDS:distribution-gpg-keys = " \
 "
RDEPENDS:distribution-gpg-keys-copr = " \
 "
