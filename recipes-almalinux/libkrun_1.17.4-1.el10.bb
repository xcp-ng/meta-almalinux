# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libkrun"
PV = "1.17.4"
PR = "1.el10"
PACKAGES = " \
 libkrun \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libkrun-1.17.4-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6f5a601e9e3c1adfaf39aa6770118d88c2a08b0e99a5bc66bfaacc4b1d7e055"

URI_x86_64_v2_libkrun = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libkrun-1.17.4-1.el10.x86_64_v2.rpm;name=x86_64_v2_libkrun;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libkrun}"
SRC_URI[x86_64_v2_libkrun.sha256sum] = "82b877eb1a3fe8167dde2961000b4046517bc84746e409636968df09c0ec0984"

URI_aarch64_libkrun = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libkrun-1.17.4-1.el10.aarch64.rpm;name=aarch64_libkrun;unpack=0"
SRC_URI:append = " ${URI_aarch64_libkrun}"
SRC_URI[aarch64_libkrun.sha256sum] = "fca8f789f67406bb045651156aea9711ac47af9825fb39a54ef950ad121ef6a2"

RDEPENDS:libkrun = " \
 glibc \
 libcap-ng \
 libgcc \
 "
