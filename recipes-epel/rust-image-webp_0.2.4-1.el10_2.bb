# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-image-webp"
PV = "0.2.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-image-webp+default-devel \
 rust-image-webp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-image-webp-0.2.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "759cc8c2b58e67e0c203956cebbed459ca19c1676768cf71a30d5e7eea20a7fa"

URI_x86_64_v2_rust-image-webp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-webp+default-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-webp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-webp+default-devel}"
SRC_URI[x86_64_v2_rust-image-webp+default-devel.sha256sum] = "699647c8743a2f437498c86f2698164491566fe0cf10a941edc4dfe6a987c69a"

URI_x86_64_v2_rust-image-webp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-webp-devel-0.2.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-webp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-webp-devel}"
SRC_URI[x86_64_v2_rust-image-webp-devel.sha256sum] = "99de104ab7b09649423644b256b35c858a1a58e4e617ea625ad171cf9e6087e5"

URI_aarch64_rust-image-webp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-webp+default-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-image-webp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-webp+default-devel}"
SRC_URI[aarch64_rust-image-webp+default-devel.sha256sum] = "6f8e7e0ccc06cd5f444bc6574ab83e5b31d37b4abc5cfd6818b0f0d24b9127ae"

URI_aarch64_rust-image-webp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-webp-devel-0.2.4-1.el10_2.noarch.rpm;name=aarch64_rust-image-webp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-webp-devel}"
SRC_URI[aarch64_rust-image-webp-devel.sha256sum] = "494bfbb330214eac8edafa8da888d6575a53236ffaae1ffe0376d0222024cb0d"

RDEPENDS:rust-image-webp+default-devel = " \
 cargo \
 rust-image-webp-devel \
 "
RDEPENDS:rust-image-webp-devel = " \
 cargo \
 rust \
 rust-byteorder-lite+default-devel \
 rust-quick-error+default-devel \
 "
