# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-lock"
PV = "3.4.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-async-lock+default-devel \
 rust-async-lock+std-devel \
 rust-async-lock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-lock-3.4.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8799c62f22bb63c67e1847acc4c0c1ef0d9ab23dd5e4cb135b573a286071e63e"

URI_x86_64_v2_rust-async-lock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-lock+default-devel-3.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-lock+default-devel}"
SRC_URI[x86_64_v2_rust-async-lock+default-devel.sha256sum] = "634945c58683879be85d0348d1d25af81c19917d8174c74f320f640840d8fb2f"

URI_x86_64_v2_rust-async-lock+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-lock+std-devel-3.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-lock+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-lock+std-devel}"
SRC_URI[x86_64_v2_rust-async-lock+std-devel.sha256sum] = "38eace3744c449b859efc6797bc2daa8258871668870ca245de0368b640c929d"

URI_x86_64_v2_rust-async-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-lock-devel-3.4.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-lock-devel}"
SRC_URI[x86_64_v2_rust-async-lock-devel.sha256sum] = "273aff235b2bcf3a564c4615bbec4c63067006692f737e01c3642dc3439da4a2"

URI_aarch64_rust-async-lock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-lock+default-devel-3.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-async-lock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-lock+default-devel}"
SRC_URI[aarch64_rust-async-lock+default-devel.sha256sum] = "0b38c4635a386ca44fb613806d9b1150fca08c34f5b4a31f76a50993badf6cda"

URI_aarch64_rust-async-lock+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-lock+std-devel-3.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-async-lock+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-lock+std-devel}"
SRC_URI[aarch64_rust-async-lock+std-devel.sha256sum] = "3ee7d6acf16dcf3987c2f078281abd1ac5d12ae3acbd088e5bf470aad8aab005"

URI_aarch64_rust-async-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-lock-devel-3.4.1-1.el10_0.noarch.rpm;name=aarch64_rust-async-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-lock-devel}"
SRC_URI[aarch64_rust-async-lock-devel.sha256sum] = "6811a2070131b5a8ed12174a7ac4de08cd1dd58158ab2924e6e765ad446eee7c"

RDEPENDS:rust-async-lock+default-devel = " \
 cargo \
 rust-async-lock+std-devel \
 rust-async-lock-devel \
 "
RDEPENDS:rust-async-lock+std-devel = " \
 cargo \
 rust-async-lock-devel \
 rust-event-listener+std-devel \
 rust-event-listener-strategy+std-devel \
 "
RDEPENDS:rust-async-lock-devel = " \
 cargo \
 rust \
 rust-event-listener-devel \
 rust-event-listener-strategy-devel \
 rust-pin-project-lite+default-devel \
 "
