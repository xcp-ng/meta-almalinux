# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gcc-toolset-15"
PV = "15.0"
PR = "11.el10"
PACKAGES = " \
 gcc-toolset-15 \
 gcc-toolset-15-devel \
 gcc-toolset-15-runtime \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gcc-toolset-15-15.0-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "403469c91a5d7c4bbb33dc1b548d66bdee04c0c0fd11d9b2bf012ce90bcdce64"

URI_x86_64_v2_gcc-toolset-15 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-15.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15}"
SRC_URI[x86_64_v2_gcc-toolset-15.sha256sum] = "66ed736c30d6e17f4ef71bb7e56eff0b0fc740476be100d26aef126f102b2a19"

URI_x86_64_v2_gcc-toolset-15-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-devel-15.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-devel}"
SRC_URI[x86_64_v2_gcc-toolset-15-devel.sha256sum] = "a3e6b8faf30471aeda46b8c31aeb5c200c15511691b2e4ba676ca86773b04985"

URI_x86_64_v2_gcc-toolset-15-runtime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gcc-toolset-15-runtime-15.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_gcc-toolset-15-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gcc-toolset-15-runtime}"
SRC_URI[x86_64_v2_gcc-toolset-15-runtime.sha256sum] = "3443ff793214ae2eac40d0a89dc023e3599e454419088c68e350d8e3fdaaf377"

URI_aarch64_gcc-toolset-15 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-15.0-11.el10.aarch64.rpm;name=aarch64_gcc-toolset-15;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15}"
SRC_URI[aarch64_gcc-toolset-15.sha256sum] = "c3a69a59986fd5bfbec299eec10d40a9e6a1295783ffb428f3d5c3509785d0db"

URI_aarch64_gcc-toolset-15-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-devel-15.0-11.el10.aarch64.rpm;name=aarch64_gcc-toolset-15-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-devel}"
SRC_URI[aarch64_gcc-toolset-15-devel.sha256sum] = "bece301138a18861b52753d85ca57432e12355d8bc2866f87fffe1e6333d590b"

URI_aarch64_gcc-toolset-15-runtime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gcc-toolset-15-runtime-15.0-11.el10.aarch64.rpm;name=aarch64_gcc-toolset-15-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_gcc-toolset-15-runtime}"
SRC_URI[aarch64_gcc-toolset-15-runtime.sha256sum] = "d2b689ac508eb05e5fa391fee7f462c97b6fc543fd7823770807a9c27ed333da"

RDEPENDS:gcc-toolset-15 = " \
 gcc-toolset-15-binutils \
 gcc-toolset-15-gcc \
 gcc-toolset-15-gcc-c++ \
 gcc-toolset-15-gcc-gfortran \
 gcc-toolset-15-runtime \
 "
RDEPENDS:gcc-toolset-15-devel = " \
 "
RDEPENDS:gcc-toolset-15-runtime = " \
 bash \
 "
