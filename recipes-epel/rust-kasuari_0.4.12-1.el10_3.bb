# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-kasuari"
PV = "0.4.12"
PR = "1.el10_3"
PACKAGES = " \
 rust-kasuari+default-devel \
 rust-kasuari+document-features-devel \
 rust-kasuari+portable-atomic-devel \
 rust-kasuari+std-devel \
 rust-kasuari-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-kasuari-0.4.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02a6ed1413cc780cdc30ddc338791def354222ea8327d0d7369f28df85fefe9e"

URI_x86_64_v2_rust-kasuari+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari+default-devel-0.4.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari+default-devel}"
SRC_URI[x86_64_v2_rust-kasuari+default-devel.sha256sum] = "c60de6df7d6d794cec2c28ce703ee67ef3f42d8382a8e892cf5523a18b743bc0"

URI_x86_64_v2_rust-kasuari+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari+document-features-devel-0.4.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari+document-features-devel}"
SRC_URI[x86_64_v2_rust-kasuari+document-features-devel.sha256sum] = "2bed3a71259009e5d6eb1db317bdaebda0fa76ed6b789701e4815cb8fb7a83cd"

URI_x86_64_v2_rust-kasuari+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari+portable-atomic-devel-0.4.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-kasuari+portable-atomic-devel.sha256sum] = "fa6ca735e964ca022260237252f617fca8aed3f1469b5b8edd971e0271f36b3e"

URI_x86_64_v2_rust-kasuari+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari+std-devel-0.4.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari+std-devel}"
SRC_URI[x86_64_v2_rust-kasuari+std-devel.sha256sum] = "d44b55b8baaa6c40948dc73ec0a7e051463a4b547919256029dd3bdd0f9faa94"

URI_x86_64_v2_rust-kasuari-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-kasuari-devel-0.4.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-kasuari-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-kasuari-devel}"
SRC_URI[x86_64_v2_rust-kasuari-devel.sha256sum] = "8d87582bab460219738c1380d6dbc0d5aa83b677022b83a2ffd63ddc9b9c2a5b"

URI_aarch64_rust-kasuari+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari+default-devel-0.4.12-1.el10_3.noarch.rpm;name=aarch64_rust-kasuari+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari+default-devel}"
SRC_URI[aarch64_rust-kasuari+default-devel.sha256sum] = "f9d190f6887ad3aecbe65f618abc091952faf6c14bb4f2c8d250cd73b4c5acb0"

URI_aarch64_rust-kasuari+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari+document-features-devel-0.4.12-1.el10_3.noarch.rpm;name=aarch64_rust-kasuari+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari+document-features-devel}"
SRC_URI[aarch64_rust-kasuari+document-features-devel.sha256sum] = "5174bd45378eb28bed65b4083634f71554397085756ed9d13e8c2131078b7ff1"

URI_aarch64_rust-kasuari+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari+portable-atomic-devel-0.4.12-1.el10_3.noarch.rpm;name=aarch64_rust-kasuari+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari+portable-atomic-devel}"
SRC_URI[aarch64_rust-kasuari+portable-atomic-devel.sha256sum] = "a504e9ca27c4799e32f59743c3cace4280bae350121ba492e4f5700df234c4ea"

URI_aarch64_rust-kasuari+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari+std-devel-0.4.12-1.el10_3.noarch.rpm;name=aarch64_rust-kasuari+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari+std-devel}"
SRC_URI[aarch64_rust-kasuari+std-devel.sha256sum] = "92e4cd83130d61db9ada8f1b9db3809d3744e5c417d4f297174ec40aee337016"

URI_aarch64_rust-kasuari-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-kasuari-devel-0.4.12-1.el10_3.noarch.rpm;name=aarch64_rust-kasuari-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-kasuari-devel}"
SRC_URI[aarch64_rust-kasuari-devel.sha256sum] = "d863436741545370276bf4574f659d73e606b8c573cbbbca353bc2d5cc2cc14e"

RDEPENDS:rust-kasuari+default-devel = " \
 cargo \
 rust-kasuari+std-devel \
 rust-kasuari-devel \
 "
RDEPENDS:rust-kasuari+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-kasuari-devel \
 "
RDEPENDS:rust-kasuari+portable-atomic-devel = " \
 cargo \
 rust-kasuari-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 "
RDEPENDS:rust-kasuari+std-devel = " \
 cargo \
 rust-kasuari-devel \
 rust-portable-atomic+require-cas-devel \
 rust-portable-atomic+std-devel \
 rust-portable-atomic-devel \
 rust-thiserror+std-devel \
 "
RDEPENDS:rust-kasuari-devel = " \
 cargo \
 rust \
 rust-hashbrown0.16+default-devel \
 rust-thiserror-devel \
 "
