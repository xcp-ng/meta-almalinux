# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imagequant"
PV = "4.3.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-imagequant+_internal_c_ffi-devel \
 rust-imagequant+default-devel \
 rust-imagequant+large_palettes-devel \
 rust-imagequant+threads-devel \
 rust-imagequant-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imagequant-4.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f80c7c16cae5726cf8f4a789a9f20bfdc57610ad998432e07b20299d0a846c8e"

URI_x86_64_v2_rust-imagequant+_internal_c_ffi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imagequant+_internal_c_ffi-devel-4.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imagequant+_internal_c_ffi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imagequant+_internal_c_ffi-devel}"
SRC_URI[x86_64_v2_rust-imagequant+_internal_c_ffi-devel.sha256sum] = "a2e3a61c4498ca6fe121ab92874d53e53d23ce99e7b1d3a0ccc4cc52eb29879e"

URI_x86_64_v2_rust-imagequant+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imagequant+default-devel-4.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imagequant+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imagequant+default-devel}"
SRC_URI[x86_64_v2_rust-imagequant+default-devel.sha256sum] = "2ca1d5db5b5d146d1f14fed8f23ee599715ebf91531cfd2dfa75517e7fe5517f"

URI_x86_64_v2_rust-imagequant+large_palettes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imagequant+large_palettes-devel-4.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imagequant+large_palettes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imagequant+large_palettes-devel}"
SRC_URI[x86_64_v2_rust-imagequant+large_palettes-devel.sha256sum] = "89a211d2ee28e5050e83f87564b42c6a3aeb3bbf0c3f2a5056f248541ef3175f"

URI_x86_64_v2_rust-imagequant+threads-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imagequant+threads-devel-4.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imagequant+threads-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imagequant+threads-devel}"
SRC_URI[x86_64_v2_rust-imagequant+threads-devel.sha256sum] = "609df19a1c890355190136d2eef922e00652d27575ea518a71262f16ff31a074"

URI_x86_64_v2_rust-imagequant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imagequant-devel-4.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imagequant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imagequant-devel}"
SRC_URI[x86_64_v2_rust-imagequant-devel.sha256sum] = "51254364e5ed7a0d3c27feb3a4a3f5c972e17289270b4949094634f4e59394d2"

URI_aarch64_rust-imagequant+_internal_c_ffi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imagequant+_internal_c_ffi-devel-4.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-imagequant+_internal_c_ffi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imagequant+_internal_c_ffi-devel}"
SRC_URI[aarch64_rust-imagequant+_internal_c_ffi-devel.sha256sum] = "3303cb98693393d55b47963bc9ee37e5e9b208f8862b631a10e7e670888d128b"

URI_aarch64_rust-imagequant+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imagequant+default-devel-4.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-imagequant+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imagequant+default-devel}"
SRC_URI[aarch64_rust-imagequant+default-devel.sha256sum] = "8c8ac52ff9387925e78ac5f58407aa2501cd8cd799b0ff98eae110c52511b3d3"

URI_aarch64_rust-imagequant+large_palettes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imagequant+large_palettes-devel-4.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-imagequant+large_palettes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imagequant+large_palettes-devel}"
SRC_URI[aarch64_rust-imagequant+large_palettes-devel.sha256sum] = "8c90d28d9dffc90fb1111e3393079905b2d94d375e23a8f41c0cbd01047722bd"

URI_aarch64_rust-imagequant+threads-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imagequant+threads-devel-4.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-imagequant+threads-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imagequant+threads-devel}"
SRC_URI[aarch64_rust-imagequant+threads-devel.sha256sum] = "f48e6d317661bf86035f6a69e0cca19976d1c87ad2dd8f90799a3be73373c482"

URI_aarch64_rust-imagequant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imagequant-devel-4.3.3-1.el10_0.noarch.rpm;name=aarch64_rust-imagequant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imagequant-devel}"
SRC_URI[aarch64_rust-imagequant-devel.sha256sum] = "6aef9625baa3200cbe91bbff002d535e0c3e712d2f4eb20147a8609bf55916bb"

RDEPENDS:rust-imagequant+_internal_c_ffi-devel = " \
 cargo \
 rust-imagequant-devel \
 "
RDEPENDS:rust-imagequant+default-devel = " \
 cargo \
 rust-imagequant+threads-devel \
 rust-imagequant-devel \
 "
RDEPENDS:rust-imagequant+large_palettes-devel = " \
 cargo \
 rust-imagequant-devel \
 "
RDEPENDS:rust-imagequant+threads-devel = " \
 cargo \
 rust-imagequant-devel \
 rust-rayon+default-devel \
 rust-thread_local+default-devel \
 "
RDEPENDS:rust-imagequant-devel = " \
 cargo \
 rust \
 rust-arrayvec+default-devel \
 rust-once_cell+default-devel \
 rust-rgb+bytemuck-devel \
 rust-rgb-devel \
 "
