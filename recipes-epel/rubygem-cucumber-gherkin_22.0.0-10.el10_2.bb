# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-gherkin"
PV = "22.0.0"
PR = "10.el10_2"
PACKAGES = " \
 rubygem-cucumber-gherkin \
 rubygem-cucumber-gherkin-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-gherkin-22.0.0-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67f7067a5834674f199b960d9baf2df2c3412487ed428e3f9e7d54b539092ce7"

URI_x86_64_v2_rubygem-cucumber-gherkin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-gherkin-22.0.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-gherkin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-gherkin}"
SRC_URI[x86_64_v2_rubygem-cucumber-gherkin.sha256sum] = "b7d6d6a7ace91a5bdaf95dc6720bf98d6a94593267102aa8e816add0373d6874"

URI_x86_64_v2_rubygem-cucumber-gherkin-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-gherkin-doc-22.0.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-gherkin-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-gherkin-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-gherkin-doc.sha256sum] = "09d53545bd9363839060d1e6f022e67a0f42be9ee38cd91de6fbeba8a96caf89"

URI_aarch64_rubygem-cucumber-gherkin = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-gherkin-22.0.0-10.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-gherkin;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-gherkin}"
SRC_URI[aarch64_rubygem-cucumber-gherkin.sha256sum] = "7c8eeeeca75f3d77259b4ec3747d5cdc8d2988d6294a3a7afce5996c58617ee1"

URI_aarch64_rubygem-cucumber-gherkin-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-gherkin-doc-22.0.0-10.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-gherkin-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-gherkin-doc}"
SRC_URI[aarch64_rubygem-cucumber-gherkin-doc.sha256sum] = "29aaccb82428b54d37def929e8901ad2f4874880a8a5c44234db0da3127f88f3"

RDEPENDS:rubygem-cucumber-gherkin = " \
 ruby \
 rubygem-cucumber-messages \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-gherkin-doc = " \
 rubygem-cucumber-gherkin \
 "
