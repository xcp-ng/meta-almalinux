# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-nikic-php-parser5"
PV = "5.5.0"
PR = "1.el10_0"
PACKAGES = " \
 php-nikic-php-parser5 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-nikic-php-parser5-5.5.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e5b80b35720eb3ad9c55a43d54eaa49c37e944712c92b0cd6427d40aeea0323"

URI_x86_64_v2_php-nikic-php-parser5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-nikic-php-parser5-5.5.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_php-nikic-php-parser5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-nikic-php-parser5}"
SRC_URI[x86_64_v2_php-nikic-php-parser5.sha256sum] = "98a33d20ad2af103fcecd061e5fd7adc4643e062e1c5754a3ed077a62f913326"

URI_aarch64_php-nikic-php-parser5 = "${EPEL_MIRROR}/aarch64/Packages/p/php-nikic-php-parser5-5.5.0-1.el10_0.noarch.rpm;name=aarch64_php-nikic-php-parser5;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-nikic-php-parser5}"
SRC_URI[aarch64_php-nikic-php-parser5.sha256sum] = "2f6a40aa7bf5ec2517f0755480fb28ae8e70a433aa8ef8783c7f8083e0493466"

RDEPENDS:php-nikic-php-parser5 = " \
 php-cli \
 php-common \
 php-fedora-autoloader \
 "
