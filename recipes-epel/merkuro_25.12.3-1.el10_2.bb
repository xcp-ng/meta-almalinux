# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "merkuro"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 merkuro \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/merkuro-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b700a01fea454dc8eb8c0e1d7f0cc2a91e83c0eabe8d96abf159eef878f497d"

URI_x86_64_v2_merkuro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/merkuro-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_merkuro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_merkuro}"
SRC_URI[x86_64_v2_merkuro.sha256sum] = "7c8cfa57838a7ddda3402350270628c2f0ba4961ebe3651bcc8ce2d9cb33a18e"

URI_aarch64_merkuro = "${EPEL_MIRROR}/aarch64/Packages/m/merkuro-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_merkuro;unpack=0"
SRC_URI:append = " ${URI_aarch64_merkuro}"
SRC_URI[aarch64_merkuro.sha256sum] = "64c95974301723ec7bd404ecec13bacfc51de319363ad813cd21d73340a9beab"

RDEPENDS:merkuro = " \
 akonadi-calendar \
 akonadi-contacts \
 akonadi-mime \
 akonadi-search \
 akonadi-server \
 glibc \
 gpgmepp \
 kf6-kcalendarcore \
 kf6-kcodecs \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcontacts \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kidentitymanagement \
 kmailtransport \
 kmbox \
 kmime \
 libgcc \
 libkdepim \
 libkleo \
 libstdc++ \
 mailcommon \
 messagelib \
 mimetreeparser \
 pimcommon \
 qgpgme-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
