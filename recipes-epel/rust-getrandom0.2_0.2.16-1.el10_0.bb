# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-getrandom0.2"
PV = "0.2.16"
PR = "1.el10_0"
PACKAGES = " \
 rust-getrandom0.2+custom-devel \
 rust-getrandom0.2+default-devel \
 rust-getrandom0.2+linux_disable_fallback-devel \
 rust-getrandom0.2+rdrand-devel \
 rust-getrandom0.2+std-devel \
 rust-getrandom0.2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-getrandom0.2-0.2.16-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe2260d23df823b4c43851b7abbb373463d82ea9d858c6b1a90aa96f0abb8b7b"

URI_x86_64_v2_rust-getrandom0.2+custom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+custom-devel-0.2.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+custom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+custom-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+custom-devel.sha256sum] = "d2b77d44638e9d9e6240fb8e276d0bf6bc624c9ce6525d4ef8145710b1e94f23"

URI_x86_64_v2_rust-getrandom0.2+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+default-devel-0.2.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+default-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+default-devel.sha256sum] = "d3bcbf577fd9d047957f85125bf4696ce70f7d2ffc7a5a3d04b118de4a5991c7"

URI_x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+linux_disable_fallback-devel-0.2.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+linux_disable_fallback-devel.sha256sum] = "a0563e82c8c3f770948a58f4d4124642335f2b633a405ff1724dc6dece87cae3"

URI_x86_64_v2_rust-getrandom0.2+rdrand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+rdrand-devel-0.2.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+rdrand-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+rdrand-devel.sha256sum] = "942fb21a549fde607c5f9974dfac6ddbaac86f108dea7caceff0ce344615631f"

URI_x86_64_v2_rust-getrandom0.2+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2+std-devel-0.2.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2+std-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2+std-devel.sha256sum] = "6c3fa5013950aa299fe28a2195f1d9f7174842d709a8dee215f95e0dfbb69fc8"

URI_x86_64_v2_rust-getrandom0.2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-getrandom0.2-devel-0.2.16-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-getrandom0.2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-getrandom0.2-devel}"
SRC_URI[x86_64_v2_rust-getrandom0.2-devel.sha256sum] = "82c208de6642acdfb4be2bf426f0b2957be8a16e2f0f7e9f0f6251279a69f637"

URI_aarch64_rust-getrandom0.2+custom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+custom-devel-0.2.16-1.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.2+custom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+custom-devel}"
SRC_URI[aarch64_rust-getrandom0.2+custom-devel.sha256sum] = "1f7446a94b57d68091ba13c0ac08eb2210666547fdbf2078c7dfcf7d68883394"

URI_aarch64_rust-getrandom0.2+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+default-devel-0.2.16-1.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.2+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+default-devel}"
SRC_URI[aarch64_rust-getrandom0.2+default-devel.sha256sum] = "4ead57b505c0d04600a70a2779ec2585278a811a91e8f781e8c8f4d45f5afa97"

URI_aarch64_rust-getrandom0.2+linux_disable_fallback-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+linux_disable_fallback-devel-0.2.16-1.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.2+linux_disable_fallback-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+linux_disable_fallback-devel}"
SRC_URI[aarch64_rust-getrandom0.2+linux_disable_fallback-devel.sha256sum] = "e9f45c34c9f323e7ee031d5014ee76f806d749eb8280a7d7372260fe09d74a32"

URI_aarch64_rust-getrandom0.2+rdrand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+rdrand-devel-0.2.16-1.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.2+rdrand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+rdrand-devel}"
SRC_URI[aarch64_rust-getrandom0.2+rdrand-devel.sha256sum] = "5dc63d0e8a7fdd40f928aaf17a81e84f11587f449c68f4039397cd226f54ce73"

URI_aarch64_rust-getrandom0.2+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2+std-devel-0.2.16-1.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.2+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2+std-devel}"
SRC_URI[aarch64_rust-getrandom0.2+std-devel.sha256sum] = "bce0dd00ac61889cbd779c5e3a3b2eb8424298cc7802fa4c37104396a57f0fd4"

URI_aarch64_rust-getrandom0.2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-getrandom0.2-devel-0.2.16-1.el10_0.noarch.rpm;name=aarch64_rust-getrandom0.2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-getrandom0.2-devel}"
SRC_URI[aarch64_rust-getrandom0.2-devel.sha256sum] = "c02ab30ec3c3a0597c80c5f7f384049ee984926109e56b69685c4ef559cdaf8d"

RDEPENDS:rust-getrandom0.2+custom-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+default-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+linux_disable_fallback-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+rdrand-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2+std-devel = " \
 cargo \
 rust-getrandom0.2-devel \
 "
RDEPENDS:rust-getrandom0.2-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 rust-libc-devel \
 "
