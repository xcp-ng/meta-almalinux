# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-astropy-header"
PV = "0.2.2"
PR = "10.el10_1"
PACKAGES = " \
 python3-pytest-astropy-header \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-astropy-header-0.2.2-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "88b7345591fdc78518e773e56e077fc01a2352ccdf339b74d2e830df28d13662"

URI_x86_64_v2_python3-pytest-astropy-header = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-astropy-header-0.2.2-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-astropy-header;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-astropy-header}"
SRC_URI[x86_64_v2_python3-pytest-astropy-header.sha256sum] = "7880a825c535d00ff7b319a7c40537d6924e327fb569fbade6f56943de3ca580"

URI_aarch64_python3-pytest-astropy-header = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-astropy-header-0.2.2-10.el10_1.noarch.rpm;name=aarch64_python3-pytest-astropy-header;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-astropy-header}"
SRC_URI[aarch64_python3-pytest-astropy-header.sha256sum] = "381e1a73bc883400a41f1746cff12bff4250a8fd0e6797a5d3113077d3f7b575"

RDEPENDS:python3-pytest-astropy-header = " \
 python3 \
 python3-pytest \
 "
