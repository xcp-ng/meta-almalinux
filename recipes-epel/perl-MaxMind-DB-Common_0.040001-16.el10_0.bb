# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-MaxMind-DB-Common"
PV = "0.040001"
PR = "16.el10_0"
PACKAGES = " \
 perl-MaxMind-DB-Common \
 perl-MaxMind-DB-Common-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-MaxMind-DB-Common-0.040001-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad67f07bacb93fda56f25feda428c3794510978f1f5b0ef76768f235b433237f"

URI_x86_64_v2_perl-MaxMind-DB-Common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MaxMind-DB-Common-0.040001-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MaxMind-DB-Common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MaxMind-DB-Common}"
SRC_URI[x86_64_v2_perl-MaxMind-DB-Common.sha256sum] = "db8ba09b42e25124c2b795b0da6b085d3e5a1dccbaa1d0e1a56cbed18c9d689a"

URI_x86_64_v2_perl-MaxMind-DB-Common-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-MaxMind-DB-Common-tests-0.040001-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-MaxMind-DB-Common-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-MaxMind-DB-Common-tests}"
SRC_URI[x86_64_v2_perl-MaxMind-DB-Common-tests.sha256sum] = "68e8fcc9352443f7a0320541c829e4b687d1aae2d394772fa1b9db3e387012d5"

URI_aarch64_perl-MaxMind-DB-Common = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MaxMind-DB-Common-0.040001-16.el10_0.noarch.rpm;name=aarch64_perl-MaxMind-DB-Common;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MaxMind-DB-Common}"
SRC_URI[aarch64_perl-MaxMind-DB-Common.sha256sum] = "a4f5efddf142653a4ee961955378995449928f3b742541cf1d67d28f1a946550"

URI_aarch64_perl-MaxMind-DB-Common-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-MaxMind-DB-Common-tests-0.040001-16.el10_0.noarch.rpm;name=aarch64_perl-MaxMind-DB-Common-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-MaxMind-DB-Common-tests}"
SRC_URI[aarch64_perl-MaxMind-DB-Common-tests.sha256sum] = "87714028477ed4ab66825dc1fc5081d80c25bb42a8fc7196c433c61631ba2cd3"

RDEPENDS:perl-MaxMind-DB-Common = " \
 perl-Carp \
 perl-Data-Dumper-Concise \
 perl-DateTime \
 perl-Exporter \
 perl-List-AllUtils \
 perl-Math-BigInt \
 perl-MaxMind-DB-Common \
 perl-Moo \
 perl-MooX-StrictConstructor \
 perl-Scalar-List-Utils \
 perl-Sub-Quote \
 perl-autodie \
 perl-constant \
 perl-libs \
 perl-namespace-autoclean \
 perl-overload \
 "
RDEPENDS:perl-MaxMind-DB-Common-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-Math-BigInt \
 perl-MaxMind-DB-Common \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
