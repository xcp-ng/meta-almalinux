# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror-impl"
PV = "2.0.18"
PR = "1.el10_2"
PACKAGES = " \
 rust-thiserror-impl+default-devel \
 rust-thiserror-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-impl-2.0.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc18ac07c3a5d17986328f840754b94acb35d11a58ade9679c316652bccd6b79"

URI_x86_64_v2_rust-thiserror-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl+default-devel-2.0.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-impl+default-devel}"
SRC_URI[x86_64_v2_rust-thiserror-impl+default-devel.sha256sum] = "636ea69a9c6506323f98707237924c173e187acadddc7121bf389603dbdc6da4"

URI_x86_64_v2_rust-thiserror-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl-devel-2.0.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-impl-devel}"
SRC_URI[x86_64_v2_rust-thiserror-impl-devel.sha256sum] = "b3c87ef58d7d2f74e6151ffd96a6c366ded14e36cba4632449bdc908ba616422"

URI_aarch64_rust-thiserror-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl+default-devel-2.0.18-1.el10_2.noarch.rpm;name=aarch64_rust-thiserror-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-impl+default-devel}"
SRC_URI[aarch64_rust-thiserror-impl+default-devel.sha256sum] = "056c453d59979562866f6ac83ea5e11fa74d6b4139e59e022265275b96d28f94"

URI_aarch64_rust-thiserror-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl-devel-2.0.18-1.el10_2.noarch.rpm;name=aarch64_rust-thiserror-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-impl-devel}"
SRC_URI[aarch64_rust-thiserror-impl-devel.sha256sum] = "91318c1dce561468b613e165498de7c895d7a0835aa41b85df1cdbbf0ea01071"

RDEPENDS:rust-thiserror-impl+default-devel = " \
 cargo \
 rust-thiserror-impl-devel \
 "
RDEPENDS:rust-thiserror-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
