# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-simple-ca"
PV = "5.4"
PR = "4.el10_0"
PACKAGES = " \
 globus-simple-ca \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/globus-simple-ca-5.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a4a34975f3378a6c6597345a8158fbfefc2760e66a8e35b60abd24cc1bf30cb1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-simple-ca-5.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-simple-ca;unpack=0"
SRC_URI[x86_64_v2_globus-simple-ca.sha256sum] = "351db7f739da10199e818c58a3399a28fe17035636435de5149f954416ab6383"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-simple-ca-5.4-4.el10_0.noarch.rpm;name=aarch64_globus-simple-ca;unpack=0"
SRC_URI[aarch64_globus-simple-ca.sha256sum] = "2c377e3e19c71aa2fd317a21335b0377cb88e2deb0ed0422b69b7605ea5909bf"

RDEPENDS:globus-simple-ca = " \
 bash \
 globus-common-progs \
 globus-gsi-cert-utils-progs \
 openssl \
 "
