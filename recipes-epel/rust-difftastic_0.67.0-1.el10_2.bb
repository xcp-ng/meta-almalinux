# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-difftastic"
PV = "0.67.0"
PR = "1.el10_2"
PACKAGES = " \
 difftastic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-difftastic-0.67.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3500a295384036109e506ac0fa151761e7e6eb16e2592d4a1b25fff3d091384"

URI_x86_64_v2_difftastic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/difftastic-0.67.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_difftastic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_difftastic}"
SRC_URI[x86_64_v2_difftastic.sha256sum] = "c4bfc58a83f2a530b64c5dd262ad80e43cca42bc7c0dd92c64f20d40077c2368"

URI_aarch64_difftastic = "${EPEL_MIRROR}/aarch64/Packages/d/difftastic-0.67.0-1.el10_2.aarch64.rpm;name=aarch64_difftastic;unpack=0"
SRC_URI:append = " ${URI_aarch64_difftastic}"
SRC_URI[aarch64_difftastic.sha256sum] = "ba3a8a26aecc8c5bda701e2c622bf9e5d8f0236e095a7c9f5a67bf809cff28e7"

RDEPENDS:difftastic = " \
 glibc \
 jemalloc \
 libgcc \
 libstdc++ \
 "
