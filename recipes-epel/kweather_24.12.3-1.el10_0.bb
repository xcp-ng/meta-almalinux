# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweather"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kweather \
 kweather-plasma-applet \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kweather-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "fd047bde116ad0a29e9afb3e782b41186814348835056e0bee8765aac5c008e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather;unpack=0"
SRC_URI[x86_64_v2_kweather.sha256sum] = "513c5dd69a07ceebe759df65ecd70063809bb200dd55450a9c642559bd02cb15"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-plasma-applet-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather-plasma-applet;unpack=0"
SRC_URI[x86_64_v2_kweather-plasma-applet.sha256sum] = "1e4197c84a2dd918665ca1de76a1c9f181a3000229be53ecd419a6f271630a35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kweather-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kweather;unpack=0"
SRC_URI[aarch64_kweather.sha256sum] = "be3eee15452c78720c7a28a24044d9563f6fa6961f578da442bce6b0c721b5cb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kweather-plasma-applet-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kweather-plasma-applet;unpack=0"
SRC_URI[aarch64_kweather-plasma-applet.sha256sum] = "9c37c7759f808728c3841c37a58109590b1b20c716b918161ec8be3fbbe952d9"

RDEPENDS:kweather = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kweathercore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 "
RDEPENDS:kweather-plasma-applet = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kirigami \
 kf6-kirigami-addons \
 kweather \
 kweathercore \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
