# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-MemInfo"
PV = "0.99"
PR = "32.el10_1"
PACKAGES = " \
 perl-Sys-MemInfo \
 perl-Sys-MemInfo-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Sys-MemInfo-0.99-32.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6c0c2df6613da3cba742aecd543e7faf09db663295e6a436c8c1d90a0da89988"

URI_x86_64_v2_perl-Sys-MemInfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-MemInfo-0.99-32.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-MemInfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-MemInfo}"
SRC_URI[x86_64_v2_perl-Sys-MemInfo.sha256sum] = "b6b04558841d7c9a9617f1a36abe5bca566c4b4527c65627161fa003c77d3e44"

URI_x86_64_v2_perl-Sys-MemInfo-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Sys-MemInfo-tests-0.99-32.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Sys-MemInfo-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-MemInfo-tests}"
SRC_URI[x86_64_v2_perl-Sys-MemInfo-tests.sha256sum] = "b5f7319b4125ff0ef01b12061aaa668ea28a23ba3792fbe3d3662e4ce2c2886c"

URI_aarch64_perl-Sys-MemInfo = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-MemInfo-0.99-32.el10_1.aarch64.rpm;name=aarch64_perl-Sys-MemInfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-MemInfo}"
SRC_URI[aarch64_perl-Sys-MemInfo.sha256sum] = "09b0ba661349f10bc815106c8f821033914ba596bcc4b6d31a7c970b26e3e878"

URI_aarch64_perl-Sys-MemInfo-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Sys-MemInfo-tests-0.99-32.el10_1.noarch.rpm;name=aarch64_perl-Sys-MemInfo-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-MemInfo-tests}"
SRC_URI[aarch64_perl-Sys-MemInfo-tests.sha256sum] = "9fc614c6834a620baae304e85d639df4432d416a55b43ba0e13b5e742e94c481"

RDEPENDS:perl-Sys-MemInfo = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:perl-Sys-MemInfo-tests = " \
 bash \
 perl-Data-Dumper \
 perl-Sys-MemInfo \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
