# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oxygen-sounds"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 oxygen-sounds \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/oxygen-sounds-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9279ecb10f973ce75cdb91c940ed1a79048cbaa82c58661ac60362f27ab1e89"

URI_x86_64_v2_oxygen-sounds = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-sounds-6.6.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-sounds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_oxygen-sounds}"
SRC_URI[x86_64_v2_oxygen-sounds.sha256sum] = "96fdd0091b9a9ac51602f7575c502b5f8a75c993ca28a77d3d816abd49f5b6c9"

URI_aarch64_oxygen-sounds = "${EPEL_MIRROR}/aarch64/Packages/o/oxygen-sounds-6.6.4-1.el10_2.noarch.rpm;name=aarch64_oxygen-sounds;unpack=0"
SRC_URI:append = " ${URI_aarch64_oxygen-sounds}"
SRC_URI[aarch64_oxygen-sounds.sha256sum] = "53840d905304a7d7c9a415c26f62c82e6e153c265bc65f84b4102f5ca5bdf51e"

RDEPENDS:oxygen-sounds = " \
 "
