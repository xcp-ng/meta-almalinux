# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing-tree"
PV = "0.4.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tracing-tree+default-devel \
 rust-tracing-tree+time-devel \
 rust-tracing-tree+tracing-log-devel \
 rust-tracing-tree-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-tree-0.4.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edcf231855fe95f8c602d283b9aa635d4431bfa58382c6a8bd1dd605cbaafacd"

URI_x86_64_v2_rust-tracing-tree+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree+default-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree+default-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree+default-devel.sha256sum] = "272aab22628b451309bc62c03a849716cd14c7126f777f447aacdcffc71bf8ca"

URI_x86_64_v2_rust-tracing-tree+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree+time-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree+time-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree+time-devel.sha256sum] = "abe7a447a4df3f83ff646620fd3bdba759bd7aebe5e328b15bdab5cf9a2d991d"

URI_x86_64_v2_rust-tracing-tree+tracing-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree+tracing-log-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree+tracing-log-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree+tracing-log-devel.sha256sum] = "af25b0a521f3711680b5c95c75b5a5664ab0c76a2cf23dacaa8f7716cfe7cb63"

URI_x86_64_v2_rust-tracing-tree-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-tree-devel-0.4.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-tree-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-tree-devel}"
SRC_URI[x86_64_v2_rust-tracing-tree-devel.sha256sum] = "a8c9dea00f22f6a75fb5b6e7af6508362fd700489db1721c3d69d1741ab17e3d"

URI_aarch64_rust-tracing-tree+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree+default-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-tree+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree+default-devel}"
SRC_URI[aarch64_rust-tracing-tree+default-devel.sha256sum] = "ee619f10485dc3f198146073f40645bb65819399a450a273b560e883be4968c1"

URI_aarch64_rust-tracing-tree+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree+time-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-tree+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree+time-devel}"
SRC_URI[aarch64_rust-tracing-tree+time-devel.sha256sum] = "f4e134978ef7662cf39b74c2bdfa4e4710dc9ec30d8d704927f9e6e49034fc31"

URI_aarch64_rust-tracing-tree+tracing-log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree+tracing-log-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-tree+tracing-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree+tracing-log-devel}"
SRC_URI[aarch64_rust-tracing-tree+tracing-log-devel.sha256sum] = "597d13d14dc82017e08deb4935514438740de9b4ae84f6773d1e9bc767900725"

URI_aarch64_rust-tracing-tree-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-tree-devel-0.4.1-1.el10_2.noarch.rpm;name=aarch64_rust-tracing-tree-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-tree-devel}"
SRC_URI[aarch64_rust-tracing-tree-devel.sha256sum] = "740b21b52c69a89a7a4a9ade49facbc21ec282f1ce71cd26ef248f63e3f28d37"

RDEPENDS:rust-tracing-tree+default-devel = " \
 cargo \
 rust-tracing-tree+tracing-log-devel \
 rust-tracing-tree-devel \
 "
RDEPENDS:rust-tracing-tree+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+local-offset-devel \
 rust-tracing-tree-devel \
 "
RDEPENDS:rust-tracing-tree+tracing-log-devel = " \
 cargo \
 rust-tracing-log+log-tracer-devel \
 rust-tracing-log+std-devel \
 rust-tracing-log-devel \
 rust-tracing-tree-devel \
 "
RDEPENDS:rust-tracing-tree-devel = " \
 cargo \
 rust \
 rust-nu-ansi-term+default-devel \
 rust-tracing-core+default-devel \
 rust-tracing-subscriber+fmt-devel \
 rust-tracing-subscriber+registry-devel \
 rust-tracing-subscriber+std-devel \
 rust-tracing-subscriber-devel \
 "
