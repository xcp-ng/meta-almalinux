# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-knetic-govaluate"
PV = "3.0.0"
PR = "18.20190622git9aa4983.el10_0"
PACKAGES = " \
 golang-github-knetic-govaluate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-knetic-govaluate-3.0.0-18.20190622git9aa4983.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8ae19246410c344ff9ce5029303c686c85e5900ddf504d060ee6ed4ecc051f6d"

URI_aarch64_golang-github-knetic-govaluate-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-knetic-govaluate-devel-3.0.0-18.20190622git9aa4983.el10_0.noarch.rpm;name=aarch64_golang-github-knetic-govaluate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-knetic-govaluate-devel}"
SRC_URI[aarch64_golang-github-knetic-govaluate-devel.sha256sum] = "d64d929083e3858edf58989c1caafdd70692437ee29fa9b2dc8364c8dcc93c9f"

RDEPENDS:golang-github-knetic-govaluate-devel = " \
 go-filesystem \
 "
