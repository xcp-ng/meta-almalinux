# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-target-lexicon"
PV = "0.13.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-target-lexicon+arch_z80-devel \
 rust-target-lexicon+arch_zkasm-devel \
 rust-target-lexicon+default-devel \
 rust-target-lexicon+serde-devel \
 rust-target-lexicon+serde_support-devel \
 rust-target-lexicon+std-devel \
 rust-target-lexicon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-target-lexicon-0.13.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "398090c072f0457cb210af231c671d49ad63feab33dbe5a11c5e98b201a286a3"

URI_x86_64_v2_rust-target-lexicon+arch_z80-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+arch_z80-devel-0.13.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+arch_z80-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+arch_z80-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+arch_z80-devel.sha256sum] = "e3724ff9309f50415b3ce0fa44b187137765e8643442963acb165d61290e14a8"

URI_x86_64_v2_rust-target-lexicon+arch_zkasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+arch_zkasm-devel-0.13.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+arch_zkasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+arch_zkasm-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+arch_zkasm-devel.sha256sum] = "d7708356b99b6e08dff157db75c0337e873e036fad4c91bae75e8d61d8844290"

URI_x86_64_v2_rust-target-lexicon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+default-devel-0.13.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+default-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+default-devel.sha256sum] = "16c0c1cd3242f9660ee8852cdf76b5247d0a1be65e8878f9dc3aa4bf581ce6dc"

URI_x86_64_v2_rust-target-lexicon+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+serde-devel-0.13.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+serde-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+serde-devel.sha256sum] = "32a451520f1acb99f3d5d52a44b6c93b92543c68cbb43a3a40503fdb76a7311a"

URI_x86_64_v2_rust-target-lexicon+serde_support-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+serde_support-devel-0.13.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+serde_support-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+serde_support-devel.sha256sum] = "7b6606d962446512bc1e09c627d69b9008fe813bdf6d738369b28614cbf9f6c6"

URI_x86_64_v2_rust-target-lexicon+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon+std-devel-0.13.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon+std-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon+std-devel.sha256sum] = "c6f8b95421c0c07f69c61c5648e768d8958b3b53c5a4df05c39472c787d16bfc"

URI_x86_64_v2_rust-target-lexicon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-lexicon-devel-0.13.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-lexicon-devel}"
SRC_URI[x86_64_v2_rust-target-lexicon-devel.sha256sum] = "cda9280ec22627106a0234487758638a062defbd65b4ad1cca98017c2a41fbbe"

URI_aarch64_rust-target-lexicon+arch_z80-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+arch_z80-devel-0.13.5-1.el10_1.noarch.rpm;name=aarch64_rust-target-lexicon+arch_z80-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+arch_z80-devel}"
SRC_URI[aarch64_rust-target-lexicon+arch_z80-devel.sha256sum] = "58af7bb842fe7a5110aee086a209358700a5cec705a0106d5fad69a32d715fc1"

URI_aarch64_rust-target-lexicon+arch_zkasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+arch_zkasm-devel-0.13.5-1.el10_1.noarch.rpm;name=aarch64_rust-target-lexicon+arch_zkasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+arch_zkasm-devel}"
SRC_URI[aarch64_rust-target-lexicon+arch_zkasm-devel.sha256sum] = "4599afcf8c24a9665f5d7f2ca5ff0fd993348b86d37f996c1e46a6d353d753c2"

URI_aarch64_rust-target-lexicon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+default-devel-0.13.5-1.el10_1.noarch.rpm;name=aarch64_rust-target-lexicon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+default-devel}"
SRC_URI[aarch64_rust-target-lexicon+default-devel.sha256sum] = "44624f3467aaa63df10eb0b4c739988b76966ce8575c088b3f471f919651783f"

URI_aarch64_rust-target-lexicon+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+serde-devel-0.13.5-1.el10_1.noarch.rpm;name=aarch64_rust-target-lexicon+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+serde-devel}"
SRC_URI[aarch64_rust-target-lexicon+serde-devel.sha256sum] = "23c2e2e5496067530c6a07d58bcb850288d64bb356494dcd5fc3e45977dc0611"

URI_aarch64_rust-target-lexicon+serde_support-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+serde_support-devel-0.13.5-1.el10_1.noarch.rpm;name=aarch64_rust-target-lexicon+serde_support-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+serde_support-devel}"
SRC_URI[aarch64_rust-target-lexicon+serde_support-devel.sha256sum] = "7de7f22b7fa2d75ff044520dc829b72673ad31c746fb915494734f1236549441"

URI_aarch64_rust-target-lexicon+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon+std-devel-0.13.5-1.el10_1.noarch.rpm;name=aarch64_rust-target-lexicon+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon+std-devel}"
SRC_URI[aarch64_rust-target-lexicon+std-devel.sha256sum] = "f23b3bb9bb407dd9dc7679945eafb4f060d72e886493addb228ec6769924bff1"

URI_aarch64_rust-target-lexicon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-lexicon-devel-0.13.5-1.el10_1.noarch.rpm;name=aarch64_rust-target-lexicon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-lexicon-devel}"
SRC_URI[aarch64_rust-target-lexicon-devel.sha256sum] = "4451ac0ccd71e3ed2631e41e3643db64c2e2dca560693359fb383eba2ea219c8"

RDEPENDS:rust-target-lexicon+arch_z80-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+arch_zkasm-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+default-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+serde_support-devel = " \
 cargo \
 rust-target-lexicon+serde-devel \
 rust-target-lexicon+std-devel \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon+std-devel = " \
 cargo \
 rust-target-lexicon-devel \
 "
RDEPENDS:rust-target-lexicon-devel = " \
 cargo \
 "
