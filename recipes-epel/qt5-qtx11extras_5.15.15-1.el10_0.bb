# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtx11extras"
PV = "5.15.15"
PR = "1.el10_0"
PACKAGES = " \
 qt5-qtx11extras \
 qt5-qtx11extras-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtx11extras-5.15.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22baed4a7bc5301245c793ca2da9d9fddceef6432b6a3d6b8636a10620b2e0ee"

URI_x86_64_v2_qt5-qtx11extras = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtx11extras-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtx11extras;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtx11extras}"
SRC_URI[x86_64_v2_qt5-qtx11extras.sha256sum] = "6d6568c02864eb7d63e8a997c43597df27f5f310d850fb29d0af7f052350f314"

URI_x86_64_v2_qt5-qtx11extras-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtx11extras-devel-5.15.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtx11extras-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtx11extras-devel}"
SRC_URI[x86_64_v2_qt5-qtx11extras-devel.sha256sum] = "948ea90482b19df13211a5d2ea4e5b1aadee649d9dc6d34e9abe640f91216a14"

URI_aarch64_qt5-qtx11extras = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtx11extras-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtx11extras;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtx11extras}"
SRC_URI[aarch64_qt5-qtx11extras.sha256sum] = "81a18e7dc8799485893266a0da01e1e4c84e546aa8729b0e5c9a809b2837bb47"

URI_aarch64_qt5-qtx11extras-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtx11extras-devel-5.15.15-1.el10_0.aarch64.rpm;name=aarch64_qt5-qtx11extras-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtx11extras-devel}"
SRC_URI[aarch64_qt5-qtx11extras-devel.sha256sum] = "ff8ededb8aa0163feaef021ec1e791c6c3c11c5351c1e4f09de7660e99e3fb8f"

RDEPENDS:qt5-qtx11extras = " \
 glibc \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:qt5-qtx11extras-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtx11extras \
 "
