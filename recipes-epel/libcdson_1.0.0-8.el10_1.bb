# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libcdson"
PV = "1.0.0"
PR = "8.el10_1"
PACKAGES = " \
 libcdson \
 libcdson-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libcdson-1.0.0-8.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad10e352be7b9c93c440d3374e186309e810a24b0ccb0fc79772011cd9accfcd"

URI_x86_64_v2_libcdson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcdson-1.0.0-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcdson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcdson}"
SRC_URI[x86_64_v2_libcdson.sha256sum] = "282809617a49e7389f349ebd8419229a38d97c71428b14476729fd47d24a4914"

URI_x86_64_v2_libcdson-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libcdson-devel-1.0.0-8.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libcdson-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libcdson-devel}"
SRC_URI[x86_64_v2_libcdson-devel.sha256sum] = "3b0f275e462fa05142bcb27b35df6df90b262d894bfac3683fc6dd2b2dd8f167"

URI_aarch64_libcdson = "${EPEL_MIRROR}/aarch64/Packages/l/libcdson-1.0.0-8.el10_1.aarch64.rpm;name=aarch64_libcdson;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcdson}"
SRC_URI[aarch64_libcdson.sha256sum] = "ee635c4bd98ba8cb003ef67d94eb0bd94641c47b672787fb9873ab926bc02471"

URI_aarch64_libcdson-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libcdson-devel-1.0.0-8.el10_1.aarch64.rpm;name=aarch64_libcdson-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libcdson-devel}"
SRC_URI[aarch64_libcdson-devel.sha256sum] = "7811c3c6366d4a5a2ac0fb1a1f6eeac89d4b26e9fa66fbc60275ec14e4b625dc"

RDEPENDS:libcdson = " \
 glibc \
 "
RDEPENDS:libcdson-devel = " \
 libcdson \
 pkgconf-pkg-config \
 "
