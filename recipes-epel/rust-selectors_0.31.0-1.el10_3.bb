# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-selectors"
PV = "0.31.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-selectors+bench-devel \
 rust-selectors+default-devel \
 rust-selectors-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-selectors-0.31.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64dbb5e680fb6d1a18bda36981608bb05b8b2058c9c84649fc70536e99885602"

URI_x86_64_v2_rust-selectors+bench-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selectors+bench-devel-0.31.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selectors+bench-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selectors+bench-devel}"
SRC_URI[x86_64_v2_rust-selectors+bench-devel.sha256sum] = "1443a90bd121097755c7629be870c2f10aed970404b3ba5848a22aa85955f6ba"

URI_x86_64_v2_rust-selectors+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selectors+default-devel-0.31.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selectors+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selectors+default-devel}"
SRC_URI[x86_64_v2_rust-selectors+default-devel.sha256sum] = "d15d0b440ca96cf78504b7e640ea63a920f0a03d88b9890f2d0bfee5341150d7"

URI_x86_64_v2_rust-selectors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-selectors-devel-0.31.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-selectors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-selectors-devel}"
SRC_URI[x86_64_v2_rust-selectors-devel.sha256sum] = "2f843ca8f34b49a713d7cc856c7f2330237db6417180f63106d3c967af71c81b"

URI_aarch64_rust-selectors+bench-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selectors+bench-devel-0.31.0-1.el10_3.noarch.rpm;name=aarch64_rust-selectors+bench-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selectors+bench-devel}"
SRC_URI[aarch64_rust-selectors+bench-devel.sha256sum] = "7865c4d123fef36af3356712ec995504c249cf097865aceee045bdaacc8e6b15"

URI_aarch64_rust-selectors+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selectors+default-devel-0.31.0-1.el10_3.noarch.rpm;name=aarch64_rust-selectors+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selectors+default-devel}"
SRC_URI[aarch64_rust-selectors+default-devel.sha256sum] = "760f03e11ed3b8f7de7ca137a8018d15edc1b0d37abbf09b3669c2ea6c249a28"

URI_aarch64_rust-selectors-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-selectors-devel-0.31.0-1.el10_3.noarch.rpm;name=aarch64_rust-selectors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-selectors-devel}"
SRC_URI[aarch64_rust-selectors-devel.sha256sum] = "19d76177232c6b41595b24bd0817d2d8367479c0e222c3f0afe704c783f9bf17"

RDEPENDS:rust-selectors+bench-devel = " \
 cargo \
 rust-selectors-devel \
 "
RDEPENDS:rust-selectors+default-devel = " \
 cargo \
 rust-selectors-devel \
 "
RDEPENDS:rust-selectors-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-cssparser+default-devel \
 rust-derive_more+add-devel \
 rust-derive_more+add_assign-devel \
 rust-derive_more+default-devel \
 rust-fxhash+default-devel \
 rust-log+default-devel \
 rust-new_debug_unreachable+default-devel \
 rust-phf0.11+default-devel \
 rust-phf_codegen0.11+default-devel \
 rust-precomputed-hash+default-devel \
 rust-servo_arc+default-devel \
 rust-smallvec+default-devel \
 "
