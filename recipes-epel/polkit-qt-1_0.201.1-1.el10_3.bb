# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "polkit-qt-1"
PV = "0.201.1"
PR = "1.el10_3"
PACKAGES = " \
 polkit-qt5-1 \
 polkit-qt5-1-devel \
 polkit-qt6-1 \
 polkit-qt6-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/polkit-qt-1-0.201.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5078aad0fb83b2dbb8e69aed734bcb109bdb5e4bcd602e9e5606d50909d9fc17"

URI_x86_64_v2_polkit-qt5-1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt5-1-0.201.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt5-1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt5-1}"
SRC_URI[x86_64_v2_polkit-qt5-1.sha256sum] = "27540840882c883d79d9c95352bb6b36fe3d964b16f9e5422eeee1b548441a95"

URI_x86_64_v2_polkit-qt5-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt5-1-devel-0.201.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt5-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt5-1-devel}"
SRC_URI[x86_64_v2_polkit-qt5-1-devel.sha256sum] = "58db558cfb47145cae2c528ccfb5b549eea117ac5547c689a026a71edb52cb71"

URI_x86_64_v2_polkit-qt6-1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt6-1-0.201.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt6-1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt6-1}"
SRC_URI[x86_64_v2_polkit-qt6-1.sha256sum] = "79fb2446870a74b5331fd17586ce96f4f32017eedb63ad7d5ab9c6aefdfbb49d"

URI_x86_64_v2_polkit-qt6-1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/polkit-qt6-1-devel-0.201.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_polkit-qt6-1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_polkit-qt6-1-devel}"
SRC_URI[x86_64_v2_polkit-qt6-1-devel.sha256sum] = "129b70854ba614510de1c358cce1501c97a035dff98aca8652a2b12483b8fe5c"

URI_aarch64_polkit-qt5-1 = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt5-1-0.201.1-1.el10_3.aarch64.rpm;name=aarch64_polkit-qt5-1;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt5-1}"
SRC_URI[aarch64_polkit-qt5-1.sha256sum] = "d17fc87ed99b24ec3895e8a3f13aa46e699a8816ee7948db0408d450a213c7c0"

URI_aarch64_polkit-qt5-1-devel = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt5-1-devel-0.201.1-1.el10_3.aarch64.rpm;name=aarch64_polkit-qt5-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt5-1-devel}"
SRC_URI[aarch64_polkit-qt5-1-devel.sha256sum] = "39e7929500a59713b880ef2baf50979404c8069bf4fba917b5f0ef59cbb84a26"

URI_aarch64_polkit-qt6-1 = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt6-1-0.201.1-1.el10_3.aarch64.rpm;name=aarch64_polkit-qt6-1;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt6-1}"
SRC_URI[aarch64_polkit-qt6-1.sha256sum] = "8d075fd3ac19cd7cca1a644a4f86284fae3ef7ed01cc2a42a878b57f2d5127e1"

URI_aarch64_polkit-qt6-1-devel = "${EPEL_MIRROR}/aarch64/Packages/p/polkit-qt6-1-devel-0.201.1-1.el10_3.aarch64.rpm;name=aarch64_polkit-qt6-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_polkit-qt6-1-devel}"
SRC_URI[aarch64_polkit-qt6-1-devel.sha256sum] = "7b9249a79ec456a5c96fde9a625784a94a237217308453711601a228ee92b07d"

RDEPENDS:polkit-qt5-1 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 polkit-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
RDEPENDS:polkit-qt5-1-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 polkit-qt5-1 \
 polkit-qt5-1-devel \
 qt5-qtbase-devel \
 "
RDEPENDS:polkit-qt6-1 = " \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 polkit-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:polkit-qt6-1-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 polkit-qt6-1 \
 polkit-qt6-1-devel \
 qt6-qtbase-devel \
 "
