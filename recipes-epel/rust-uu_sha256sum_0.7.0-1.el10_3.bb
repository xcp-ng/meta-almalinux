# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_sha256sum"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_sha256sum+default-devel \
 rust-uu_sha256sum-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_sha256sum-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5baeffa4756559bd081ea3db8419a6915c80149cdf6e1fbc6a2759f98e7a48b7"

URI_x86_64_v2_rust-uu_sha256sum+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha256sum+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha256sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha256sum+default-devel}"
SRC_URI[x86_64_v2_rust-uu_sha256sum+default-devel.sha256sum] = "bb525841415ff51884d8c6d48e7827fac0a4addb0ba3c2ad53c2a18971b85cee"

URI_x86_64_v2_rust-uu_sha256sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_sha256sum-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_sha256sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_sha256sum-devel}"
SRC_URI[x86_64_v2_rust-uu_sha256sum-devel.sha256sum] = "1678be5f5d2b5ab27246dfcaaa6e5229243f3ac169b9af4184d48a74d48c4123"

URI_aarch64_rust-uu_sha256sum+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha256sum+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha256sum+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha256sum+default-devel}"
SRC_URI[aarch64_rust-uu_sha256sum+default-devel.sha256sum] = "620c47040b8b19e7a9f47a4ceeb35e7903eab6666c7be537492fd23cc28912b0"

URI_aarch64_rust-uu_sha256sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_sha256sum-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_sha256sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_sha256sum-devel}"
SRC_URI[aarch64_rust-uu_sha256sum-devel.sha256sum] = "fb4d62180d814a6a21c587bbc6f01f23fb8dc3a06f65320af024dd60728935a9"

RDEPENDS:rust-uu_sha256sum+default-devel = " \
 cargo \
 rust-uu_sha256sum-devel \
 "
RDEPENDS:rust-uu_sha256sum-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uu_checksum_common+default-devel \
 rust-uucore+checksum-devel \
 rust-uucore+default-devel \
 rust-uucore+encoding-devel \
 rust-uucore+hardware-devel \
 rust-uucore+sum-devel \
 "
