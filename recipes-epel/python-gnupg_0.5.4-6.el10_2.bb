# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-gnupg"
PV = "0.5.4"
PR = "6.el10_2"
PACKAGES = " \
 python3-gnupg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-gnupg-0.5.4-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0216795ee6e5c63a36f7c7e99856a77f6a1d02bf8945a0aa2fd133d1b5e3b7e1"

URI_x86_64_v2_python3-gnupg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gnupg-0.5.4-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-gnupg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gnupg}"
SRC_URI[x86_64_v2_python3-gnupg.sha256sum] = "f97e1c0bbb8cc869337a993c956a349092c1051e096358505090f1a3e4900b60"

URI_aarch64_python3-gnupg = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gnupg-0.5.4-6.el10_2.noarch.rpm;name=aarch64_python3-gnupg;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gnupg}"
SRC_URI[aarch64_python3-gnupg.sha256sum] = "858f3acc0896d9f450b4fc3c3c11dfae65548a2109088469d3826fc6e7b014a4"

RDEPENDS:python3-gnupg = " \
 gnupg2 \
 python3 \
 "
