# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bincode"
PV = "2.0.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-bincode+alloc-devel \
 rust-bincode+bincode_derive-devel \
 rust-bincode+default-devel \
 rust-bincode+derive-devel \
 rust-bincode+serde-devel \
 rust-bincode+std-devel \
 rust-bincode-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bincode-2.0.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "406963e52e73f8c87a29a010452ced5427a28c28c2e71d8410130549aa1d2ced"

URI_x86_64_v2_rust-bincode+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode+alloc-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode+alloc-devel}"
SRC_URI[x86_64_v2_rust-bincode+alloc-devel.sha256sum] = "05b286bef080986f8d10736a95d82b8ec981f8db6acee4f90f96a968936b0fd3"

URI_x86_64_v2_rust-bincode+bincode_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode+bincode_derive-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode+bincode_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode+bincode_derive-devel}"
SRC_URI[x86_64_v2_rust-bincode+bincode_derive-devel.sha256sum] = "9202fe40a5ad95418804c5e35dab5fdd5b77a64d1bb6b2e4e8e0e97830c73519"

URI_x86_64_v2_rust-bincode+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode+default-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode+default-devel}"
SRC_URI[x86_64_v2_rust-bincode+default-devel.sha256sum] = "97d324a5e5f16d33a40479709c62192e85b226971a349e204e4a9dc1bca63dd5"

URI_x86_64_v2_rust-bincode+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode+derive-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode+derive-devel}"
SRC_URI[x86_64_v2_rust-bincode+derive-devel.sha256sum] = "bfa637381a33930da34606219a97ca7d909a27c52cb94ee3d86a2eedd3e62f0b"

URI_x86_64_v2_rust-bincode+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode+serde-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode+serde-devel}"
SRC_URI[x86_64_v2_rust-bincode+serde-devel.sha256sum] = "357e49cac610c8d5809c43886156e45a799406a4cb8260cd6876c1cbcaffc9de"

URI_x86_64_v2_rust-bincode+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode+std-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode+std-devel}"
SRC_URI[x86_64_v2_rust-bincode+std-devel.sha256sum] = "2995e49ed701c34df446d073f87d953ae8ae51dc86514c7677793f7a3a129c5c"

URI_x86_64_v2_rust-bincode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bincode-devel-2.0.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bincode-devel}"
SRC_URI[x86_64_v2_rust-bincode-devel.sha256sum] = "6fb9760d795b87ce7fb164f7995b986cb3975450b884aa7b5d84e9705fe48788"

URI_aarch64_rust-bincode+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode+alloc-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-bincode+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode+alloc-devel}"
SRC_URI[aarch64_rust-bincode+alloc-devel.sha256sum] = "b3a34fbb367ea954b71e5292ce9951614932aa641ce4319823114ffd8ae45511"

URI_aarch64_rust-bincode+bincode_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode+bincode_derive-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-bincode+bincode_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode+bincode_derive-devel}"
SRC_URI[aarch64_rust-bincode+bincode_derive-devel.sha256sum] = "7ec7eaa473a62efa98b64a3a3ee24eb671056797c2894ac01736dd52a271fb35"

URI_aarch64_rust-bincode+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode+default-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-bincode+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode+default-devel}"
SRC_URI[aarch64_rust-bincode+default-devel.sha256sum] = "64563dd718e21c6df9fd5b72820fd76c39ea58c5f11c24f8ca86a09cd278cc7d"

URI_aarch64_rust-bincode+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode+derive-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-bincode+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode+derive-devel}"
SRC_URI[aarch64_rust-bincode+derive-devel.sha256sum] = "0321142d7f83e80366f09c0e6626af58270f171de9799b7d409b4d4112baf2d2"

URI_aarch64_rust-bincode+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode+serde-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-bincode+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode+serde-devel}"
SRC_URI[aarch64_rust-bincode+serde-devel.sha256sum] = "010094bc8c44ead8bb83756f323ebcc3221bacc4090b505680b6986e7a9cc892"

URI_aarch64_rust-bincode+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode+std-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-bincode+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode+std-devel}"
SRC_URI[aarch64_rust-bincode+std-devel.sha256sum] = "a71c8190305e90688ce7dacdebc3a7d103190c2ed566bc7450658dec59a41127"

URI_aarch64_rust-bincode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bincode-devel-2.0.1-1.el10_1.noarch.rpm;name=aarch64_rust-bincode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bincode-devel}"
SRC_URI[aarch64_rust-bincode-devel.sha256sum] = "393ea03be81e20fb8d3ad3b5e47780adec2a4bc0b1783a640cef1c59b9223e5a"

RDEPENDS:rust-bincode+alloc-devel = " \
 cargo \
 rust-bincode-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bincode+bincode_derive-devel = " \
 cargo \
 rust-bincode-devel \
 rust-bincode_derive+default-devel \
 "
RDEPENDS:rust-bincode+default-devel = " \
 cargo \
 rust-bincode+derive-devel \
 rust-bincode+std-devel \
 rust-bincode-devel \
 "
RDEPENDS:rust-bincode+derive-devel = " \
 cargo \
 rust-bincode+bincode_derive-devel \
 rust-bincode-devel \
 "
RDEPENDS:rust-bincode+serde-devel = " \
 cargo \
 rust-bincode-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bincode+std-devel = " \
 cargo \
 rust-bincode+alloc-devel \
 rust-bincode-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bincode-devel = " \
 cargo \
 rust \
 rust-unty+default-devel \
 "
