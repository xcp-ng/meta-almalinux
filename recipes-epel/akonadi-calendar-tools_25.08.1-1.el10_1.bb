# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "akonadi-calendar-tools"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 akonadi-calendar-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/akonadi-calendar-tools-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2da238d2256a17f57c20c345ca5b02b866bd4e3f52903deceacdc21c1a347c6b"

URI_x86_64_v2_akonadi-calendar-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/akonadi-calendar-tools-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_akonadi-calendar-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_akonadi-calendar-tools}"
SRC_URI[x86_64_v2_akonadi-calendar-tools.sha256sum] = "65849324d21583ca5b5914b062847711faa00a8dc9194765705775e377e72781"

URI_aarch64_akonadi-calendar-tools = "${EPEL_MIRROR}/aarch64/Packages/a/akonadi-calendar-tools-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_akonadi-calendar-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_akonadi-calendar-tools}"
SRC_URI[aarch64_akonadi-calendar-tools.sha256sum] = "409f24a3065a6993245c04c8eba16228b389dd26e3d906acf7e7ff7caa1452bf"

RDEPENDS:akonadi-calendar-tools = " \
 akonadi-calendar \
 akonadi-server \
 calendarsupport \
 glibc \
 kf6-kcalendarcore \
 kf6-kcoreaddons \
 kf6-ki18n \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
