# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-SGMLSpm"
PV = "1.03ii"
PR = "64.el10"
PACKAGES = " \
 perl-SGMLSpm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/perl-SGMLSpm-1.03ii-64.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "09426a259e9f33a23524bd543b18a271b857d21d325966c956e32c27143f83d9"

URI_x86_64_v2_perl-SGMLSpm = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/perl-SGMLSpm-1.03ii-64.el10.noarch.rpm;name=x86_64_v2_perl-SGMLSpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-SGMLSpm}"
SRC_URI[x86_64_v2_perl-SGMLSpm.sha256sum] = "cc6838ebab144f0660647b536a3e057d77687a00851ecd2c7ee1746361b8d4e3"

URI_aarch64_perl-SGMLSpm = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/perl-SGMLSpm-1.03ii-64.el10.noarch.rpm;name=aarch64_perl-SGMLSpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-SGMLSpm}"
SRC_URI[aarch64_perl-SGMLSpm.sha256sum] = "cc6838ebab144f0660647b536a3e057d77687a00851ecd2c7ee1746361b8d4e3"

RDEPENDS:perl-SGMLSpm = " \
 openjade \
 perl-Carp \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 "
