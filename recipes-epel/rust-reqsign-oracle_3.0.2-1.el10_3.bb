# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-oracle"
PV = "3.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-oracle+default-devel \
 rust-reqsign-oracle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-oracle-3.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "41f726b960beaca2731bab3971e57880d062768a156869e48792a9f3ff340c29"

URI_x86_64_v2_rust-reqsign-oracle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-oracle+default-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-oracle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-oracle+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-oracle+default-devel.sha256sum] = "89c9e5bb758bac7cc4ff49c0e0db9f3ca4847277bf5b6a8a853a8d8a458a0d41"

URI_x86_64_v2_rust-reqsign-oracle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-oracle-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-oracle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-oracle-devel}"
SRC_URI[x86_64_v2_rust-reqsign-oracle-devel.sha256sum] = "d5c2654f98e19be1d83dc1a3db19f9c833710716817fe22f370365a77b2a4a8c"

URI_aarch64_rust-reqsign-oracle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-oracle+default-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-oracle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-oracle+default-devel}"
SRC_URI[aarch64_rust-reqsign-oracle+default-devel.sha256sum] = "7080822b19fc725e861b58d7aa8308e7b59729873684a15b24f6cb3548b7c652"

URI_aarch64_rust-reqsign-oracle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-oracle-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-oracle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-oracle-devel}"
SRC_URI[aarch64_rust-reqsign-oracle-devel.sha256sum] = "1aa74f730127d364d483648e11dcd4e1b4315841171dbc7ee669d9ce141cffc2"

RDEPENDS:rust-reqsign-oracle+default-devel = " \
 cargo \
 rust-reqsign-oracle-devel \
 "
RDEPENDS:rust-reqsign-oracle-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-base64_0.22+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-reqsign-core+default-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-rust-ini+default-devel \
 "
