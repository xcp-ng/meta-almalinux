# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulp-cli-deb"
PV = "0.4.3"
PR = "3.el10_1"
PACKAGES = " \
 pulp-cli-deb \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pulp-cli-deb-0.4.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d37e7104c6accde21618956d364f9895325118505f44d076752fbb236ff172d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulp-cli-deb-0.4.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_pulp-cli-deb;unpack=0"
SRC_URI[x86_64_v2_pulp-cli-deb.sha256sum] = "5d98311caec569378d93bfa36d49a80d4047894698da043339d05b910e402908"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pulp-cli-deb-0.4.3-3.el10_1.noarch.rpm;name=aarch64_pulp-cli-deb;unpack=0"
SRC_URI[aarch64_pulp-cli-deb.sha256sum] = "ebb8d19ee2bfc0e0e104d4e733e1455f85c8d3c7a963a4b5353543c4ef0a320b"

RDEPENDS:pulp-cli-deb = " \
 pulp-cli \
 python3 \
 python3-pulp-glue-deb \
 "
