# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stringprep"
PV = "0.1.5"
PR = "5.el10_3"
PACKAGES = " \
 rust-stringprep+default-devel \
 rust-stringprep-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stringprep-0.1.5-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d7f614b7e7166ebf3e07981b41fd5904f452f76ecf0d58f3198d6629177a1709"

URI_x86_64_v2_rust-stringprep+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stringprep+default-devel-0.1.5-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stringprep+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stringprep+default-devel}"
SRC_URI[x86_64_v2_rust-stringprep+default-devel.sha256sum] = "98146a7ec9fe9e0e576f03317d9dcd4cf77b8ef9947f5d8abddd9f74dd221b36"

URI_x86_64_v2_rust-stringprep-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stringprep-devel-0.1.5-5.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stringprep-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stringprep-devel}"
SRC_URI[x86_64_v2_rust-stringprep-devel.sha256sum] = "5aceef2727264d7b02eee324b73521ef7037d867a66be0b98203a4805761872f"

URI_aarch64_rust-stringprep+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stringprep+default-devel-0.1.5-5.el10_3.noarch.rpm;name=aarch64_rust-stringprep+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stringprep+default-devel}"
SRC_URI[aarch64_rust-stringprep+default-devel.sha256sum] = "e6df3ce4c3cd69f1faebea8afb503f1349834e5dc5184f017a8695a5ab76355a"

URI_aarch64_rust-stringprep-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stringprep-devel-0.1.5-5.el10_3.noarch.rpm;name=aarch64_rust-stringprep-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stringprep-devel}"
SRC_URI[aarch64_rust-stringprep-devel.sha256sum] = "ea916d8098573e414bfbc372fb4dbd59cb5e8a0869ab1931919cd23a42d40616"

RDEPENDS:rust-stringprep+default-devel = " \
 cargo \
 rust-stringprep-devel \
 "
RDEPENDS:rust-stringprep-devel = " \
 cargo \
 rust-unicode-bidi+default-devel \
 rust-unicode-normalization+default-devel \
 rust-unicode-properties+default-devel \
 "
