# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psm"
PV = "0.1.27"
PR = "1.el10_2"
PACKAGES = " \
 rust-psm+default-devel \
 rust-psm-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-psm-0.1.27-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8572a85fbf9333ce4f298d9230e56d9731e63d2e0758cbcfee1fb4d5553daa4"

URI_x86_64_v2_rust-psm+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psm+default-devel-0.1.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psm+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psm+default-devel}"
SRC_URI[x86_64_v2_rust-psm+default-devel.sha256sum] = "e77a0252075a00217ff65a5e4c42399f148537fd2a581259610e57fbe4e9b117"

URI_x86_64_v2_rust-psm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psm-devel-0.1.27-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psm-devel}"
SRC_URI[x86_64_v2_rust-psm-devel.sha256sum] = "43d085478b22f315d143a90aa1d9e19810fc861a480783fc6b75d9820d14645d"

URI_aarch64_rust-psm+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psm+default-devel-0.1.27-1.el10_2.noarch.rpm;name=aarch64_rust-psm+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psm+default-devel}"
SRC_URI[aarch64_rust-psm+default-devel.sha256sum] = "0336a9fb6c0c7ba940f1b2466e3c2a0437328ada90cba8d73a1d988f62f4eb96"

URI_aarch64_rust-psm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psm-devel-0.1.27-1.el10_2.noarch.rpm;name=aarch64_rust-psm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psm-devel}"
SRC_URI[aarch64_rust-psm-devel.sha256sum] = "31a5492cead4bd3bf6879ab9f04ce2e7b3feac1a9600291ff2322b3e18a367a0"

RDEPENDS:rust-psm+default-devel = " \
 cargo \
 rust-psm-devel \
 "
RDEPENDS:rust-psm-devel = " \
 cargo \
 rust-cc+default-devel \
 "
