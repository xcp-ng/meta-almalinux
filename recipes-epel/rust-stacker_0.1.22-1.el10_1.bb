# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-stacker"
PV = "0.1.22"
PR = "1.el10_1"
PACKAGES = " \
 rust-stacker+default-devel \
 rust-stacker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-stacker-0.1.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9f53908a7a0bf1dcd836f9e92854f33620c2ece0b4bb1e812c22310f30bff30a"

URI_x86_64_v2_rust-stacker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stacker+default-devel-0.1.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stacker+default-devel}"
SRC_URI[x86_64_v2_rust-stacker+default-devel.sha256sum] = "71d5e680fcc27372e578770b960da35798d98882cd21af75ba1416e84814e651"

URI_x86_64_v2_rust-stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-stacker-devel-0.1.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-stacker-devel}"
SRC_URI[x86_64_v2_rust-stacker-devel.sha256sum] = "63f1b97e1d31c8f681c0969422aeb5225a2d91bfc10788e66d5e137ce8fbb895"

URI_aarch64_rust-stacker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stacker+default-devel-0.1.22-1.el10_1.noarch.rpm;name=aarch64_rust-stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stacker+default-devel}"
SRC_URI[aarch64_rust-stacker+default-devel.sha256sum] = "0f944b8fe91f8ebd47844cfaf7697fc1b07c83fb94276cdd9dba22b158f66326"

URI_aarch64_rust-stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-stacker-devel-0.1.22-1.el10_1.noarch.rpm;name=aarch64_rust-stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-stacker-devel}"
SRC_URI[aarch64_rust-stacker-devel.sha256sum] = "1d1bea8eb87625dd55dd94c27e431b750a5430e9df3ad0472072696c2ea4eec4"

RDEPENDS:rust-stacker+default-devel = " \
 cargo \
 rust-stacker-devel \
 "
RDEPENDS:rust-stacker-devel = " \
 cargo \
 rust \
 rust-cc+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-psm+default-devel \
 "
