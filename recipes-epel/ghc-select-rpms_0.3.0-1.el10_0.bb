# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-select-rpms"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES:x86_64_v2 = " \
 ghc-select-rpms \
 ghc-select-rpms-devel \
 ghc-select-rpms-doc \
"
PACKAGES:aarch64 = " \
 ghc-select-rpms \
 ghc-select-rpms-devel \
 ghc-select-rpms-doc \
 ghc-select-rpms-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-select-rpms-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30d0e7ce3626d668c402bc15d032f32bfbe7d76b98adf8e65fa9ab3dc5fd3090"

URI_x86_64_v2_ghc-select-rpms = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-select-rpms-0.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-select-rpms;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-select-rpms}"
SRC_URI[x86_64_v2_ghc-select-rpms.sha256sum] = "843bc7cda833f31d77265d2fb9f81f12284a8898616e9617a1a06263b760ed80"

URI_x86_64_v2_ghc-select-rpms-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-select-rpms-devel-0.3.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-select-rpms-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-select-rpms-devel}"
SRC_URI[x86_64_v2_ghc-select-rpms-devel.sha256sum] = "a9573149ace1046d44238fcac5725361785c47eb66ff1eb17057542a8add389e"

URI_x86_64_v2_ghc-select-rpms-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-select-rpms-doc-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-select-rpms-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-select-rpms-doc}"
SRC_URI[x86_64_v2_ghc-select-rpms-doc.sha256sum] = "417c8ecbd11c20bf121e260b0fbbf78f841f19d5515985b40cffa49a12395a69"

URI_aarch64_ghc-select-rpms = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-select-rpms-0.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-select-rpms;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-select-rpms}"
SRC_URI[aarch64_ghc-select-rpms.sha256sum] = "f1348836188c419339238a61e7cc331b1174ea8caac1cb31ac900e16cc217b29"

URI_aarch64_ghc-select-rpms-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-select-rpms-devel-0.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-select-rpms-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-select-rpms-devel}"
SRC_URI[aarch64_ghc-select-rpms-devel.sha256sum] = "e82c5466792f4b4a1f5257ad1ff5b500c261ea170c4122aebefa74a55f98af0f"

URI_aarch64_ghc-select-rpms-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-select-rpms-doc-0.3.0-1.el10_0.noarch.rpm;name=aarch64_ghc-select-rpms-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-select-rpms-doc}"
SRC_URI[aarch64_ghc-select-rpms-doc.sha256sum] = "5178b3626e15d63aecc3cb374495b9156679bf5affdf66c0dbe34be9039d2bad"

URI_aarch64_ghc-select-rpms-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-select-rpms-prof-0.3.0-1.el10_0.aarch64.rpm;name=aarch64_ghc-select-rpms-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-select-rpms-prof}"
SRC_URI[aarch64_ghc-select-rpms-prof.sha256sum] = "86395c326b19bb9029481fed088526a45abbf464c6cff72ed7463f4df26eeb6a"

RDEPENDS:ghc-select-rpms = " \
 ghc-Glob \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-clock \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-dlist \
 ghc-exceptions \
 ghc-extra \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-haskeline \
 ghc-mtl \
 ghc-optparse-applicative \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-prettyprinter-ansi-terminal \
 ghc-process \
 ghc-rpm-nvr \
 ghc-safe \
 ghc-simple-cmd \
 ghc-simple-cmd-args \
 ghc-simple-prompt \
 ghc-stm \
 ghc-template-haskell \
 ghc-terminfo \
 ghc-text \
 ghc-time \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc-select-rpms-devel = " \
 ghc-Glob-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-extra-devel \
 ghc-filepath-devel \
 ghc-rpm-nvr-devel \
 ghc-safe-devel \
 ghc-select-rpms \
 ghc-simple-cmd-args-devel \
 ghc-simple-cmd-devel \
 ghc-simple-prompt-devel \
 "
RDEPENDS:ghc-select-rpms-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-select-rpms-prof = " \
 ghc-Glob-prof \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-extra-prof \
 ghc-filepath-prof \
 ghc-rpm-nvr-prof \
 ghc-safe-prof \
 ghc-select-rpms-devel \
 ghc-simple-cmd-args-prof \
 ghc-simple-cmd-prof \
 ghc-simple-prompt-prof \
 "
