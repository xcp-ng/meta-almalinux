# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php8.4-pecl-xpass"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 php8.4-pecl-xpass \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/php8.4-pecl-xpass-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c51613bd9c4574465af51705e6f2828fb53ae6ab935cc54abe0fe7a78363237c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php8.4-pecl-xpass-1.1.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php8.4-pecl-xpass;unpack=0"
SRC_URI[x86_64_v2_php8.4-pecl-xpass.sha256sum] = "1329af64d567d90c3d67887814c073869a33844a8c689c66f5aabe73b6cf0206"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/php8.4-pecl-xpass-1.1.0-1.el10_2.aarch64.rpm;name=aarch64_php8.4-pecl-xpass;unpack=0"
SRC_URI[aarch64_php8.4-pecl-xpass.sha256sum] = "eb9d3ea368e093c43d118fbc67c83cc28d845c6e6fb2243715b358604289d412"

RDEPENDS:php8.4-pecl-xpass = " \
 glibc \
 libxcrypt \
 php8.4-common \
 "
