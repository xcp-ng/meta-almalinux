# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thread_local"
PV = "1.1.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-thread_local+default-devel \
 rust-thread_local+nightly-devel \
 rust-thread_local-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thread_local-1.1.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e32309becadb889f7fa069f5bbb8565fb40233ab567a116c242c7545b52e248"

URI_x86_64_v2_rust-thread_local+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local+default-devel-1.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local+default-devel}"
SRC_URI[x86_64_v2_rust-thread_local+default-devel.sha256sum] = "054c69eed814f80f5fc7879c341b362207e0513146d622844de447e3a655413a"

URI_x86_64_v2_rust-thread_local+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local+nightly-devel-1.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local+nightly-devel}"
SRC_URI[x86_64_v2_rust-thread_local+nightly-devel.sha256sum] = "cfdc5befd485368af33125eb540dc07a74394cfe14c4f027d4614fa232c1dd48"

URI_x86_64_v2_rust-thread_local-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thread_local-devel-1.1.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thread_local-devel}"
SRC_URI[x86_64_v2_rust-thread_local-devel.sha256sum] = "7f6288877763f43535cda39ca1d23db1b8aa4915e109f1b94f4dd72fc59b56ca"

URI_aarch64_rust-thread_local+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local+default-devel-1.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-thread_local+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local+default-devel}"
SRC_URI[aarch64_rust-thread_local+default-devel.sha256sum] = "0df1a4039374a444af837a842ef0cabd5dd32582985486f0c7f82f427d31e7e3"

URI_aarch64_rust-thread_local+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local+nightly-devel-1.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-thread_local+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local+nightly-devel}"
SRC_URI[aarch64_rust-thread_local+nightly-devel.sha256sum] = "7ae50735f4c845a11a57d50eb3e5a0c4f2f4a3318a61c1726ab4d5c31e91e609"

URI_aarch64_rust-thread_local-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thread_local-devel-1.1.9-1.el10_1.noarch.rpm;name=aarch64_rust-thread_local-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thread_local-devel}"
SRC_URI[aarch64_rust-thread_local-devel.sha256sum] = "09a79b491302c01f9c96f996a5f18534e036ebe6a0bd35f641b386400a03ba93"

RDEPENDS:rust-thread_local+default-devel = " \
 cargo \
 rust-thread_local-devel \
 "
RDEPENDS:rust-thread_local+nightly-devel = " \
 cargo \
 rust-thread_local-devel \
 "
RDEPENDS:rust-thread_local-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "
