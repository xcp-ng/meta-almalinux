# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cfgv"
PV = "3.5.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-cfgv \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cfgv-3.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d659cd299f7a7e6d41c903bf72493473d34faa95c61e4e65fc1efd05ddb43a3b"

URI_x86_64_v2_python3-cfgv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cfgv-3.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cfgv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cfgv}"
SRC_URI[x86_64_v2_python3-cfgv.sha256sum] = "b859c1e8a99ac0a40cb76b4753653acc4490fdc2397d1f0656d9dda58f9f189c"

URI_aarch64_python3-cfgv = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cfgv-3.5.0-1.el10_1.noarch.rpm;name=aarch64_python3-cfgv;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cfgv}"
SRC_URI[aarch64_python3-cfgv.sha256sum] = "424eb03b7001f1488a74fcacf3fb9334a94d28ca8e6830a468d096402002620c"

RDEPENDS:python3-cfgv = " \
 python3 \
 "
