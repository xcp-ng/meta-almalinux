# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-PostgreSQL"
PV = "1.29"
PR = "13.el10_3"
PACKAGES = " \
 perl-Test-PostgreSQL \
 perl-Test-PostgreSQL-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Test-PostgreSQL-1.29-13.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a52e7169d07668ec95fbc5cb4ab6e5842b56721fcb6122356c7bbf982aabb81a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-PostgreSQL-1.29-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-PostgreSQL;unpack=0"
SRC_URI[x86_64_v2_perl-Test-PostgreSQL.sha256sum] = "3eccba4ea12291c682b5c7c32b53beb3ac2110de23defbe26cb92cb93933897a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-PostgreSQL-tests-1.29-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-PostgreSQL-tests;unpack=0"
SRC_URI[x86_64_v2_perl-Test-PostgreSQL-tests.sha256sum] = "b3ef7d1175ed6be5742576cb8ea6983a28d91a154eb0af195ba59bdbf78ee6d4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-PostgreSQL-1.29-13.el10_3.noarch.rpm;name=aarch64_perl-Test-PostgreSQL;unpack=0"
SRC_URI[aarch64_perl-Test-PostgreSQL.sha256sum] = "0f96a6e0989d39a2724fd529a047850389e5aaa5332e0bb74f0cc5c14d4cd830"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-PostgreSQL-tests-1.29-13.el10_3.noarch.rpm;name=aarch64_perl-Test-PostgreSQL-tests;unpack=0"
SRC_URI[aarch64_perl-Test-PostgreSQL-tests.sha256sum] = "0c8091f6242cd54002be9672d76445f5de6c904ff514d1228c1447d6a7d8eceb"

RDEPENDS:perl-Test-PostgreSQL = " \
 perl-DBD-Pg \
 perl-DBI \
 perl-File-Temp \
 perl-File-Which \
 perl-Function-Parameters \
 perl-Moo \
 perl-POSIX \
 perl-PathTools \
 perl-Tie-Hash-Method \
 perl-Try-Tiny \
 perl-Type-Tiny \
 perl-User-pwent \
 perl-libs \
 postgresql-server \
 "
RDEPENDS:perl-Test-PostgreSQL-tests = " \
 bash \
 perl-DBI \
 perl-File-Temp \
 perl-POSIX \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-PostgreSQL \
 perl-Test-SharedFork \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 "
