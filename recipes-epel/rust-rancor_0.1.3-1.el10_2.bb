# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rancor"
PV = "0.1.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-rancor+alloc-devel \
 rust-rancor+default-devel \
 rust-rancor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rancor-0.1.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee5374c4e6c9cc29122beff1b20fd49b7af51c35c5ddd8049070d225e11f3413"

URI_x86_64_v2_rust-rancor+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor+alloc-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor+alloc-devel}"
SRC_URI[x86_64_v2_rust-rancor+alloc-devel.sha256sum] = "88fce0968af90f38a439db8ff77cdadee2c8a1758ef12d962d57c846c3a58880"

URI_x86_64_v2_rust-rancor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor+default-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor+default-devel}"
SRC_URI[x86_64_v2_rust-rancor+default-devel.sha256sum] = "d0dc9c018b34b88cdb9e0256098114a22adbc64f0ad2a2271db3a03812c14cba"

URI_x86_64_v2_rust-rancor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rancor-devel-0.1.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rancor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rancor-devel}"
SRC_URI[x86_64_v2_rust-rancor-devel.sha256sum] = "d387b0a835f48728463f5923404bae4a19ac08aa69ad7cd9fe76b4c6aa25dedc"

URI_aarch64_rust-rancor+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor+alloc-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-rancor+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor+alloc-devel}"
SRC_URI[aarch64_rust-rancor+alloc-devel.sha256sum] = "c195bd954560c86222cf8d40ad60b1f42242a0aa0314fbf0c9f1d475bb3b570f"

URI_aarch64_rust-rancor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor+default-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-rancor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor+default-devel}"
SRC_URI[aarch64_rust-rancor+default-devel.sha256sum] = "e2939cf03c85c69b5baac924e1f5b41432927460bd3b18afac26a2a53de00a35"

URI_aarch64_rust-rancor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rancor-devel-0.1.3-1.el10_2.noarch.rpm;name=aarch64_rust-rancor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rancor-devel}"
SRC_URI[aarch64_rust-rancor-devel.sha256sum] = "187bfde264ac9de2f4a20794af5fc069f15f35dd7e54e1f115f52bb8e4bf86b8"

RDEPENDS:rust-rancor+alloc-devel = " \
 cargo \
 rust-rancor-devel \
 "
RDEPENDS:rust-rancor+default-devel = " \
 cargo \
 rust-rancor+alloc-devel \
 rust-rancor-devel \
 "
RDEPENDS:rust-rancor-devel = " \
 cargo \
 rust \
 rust-ptr_meta+derive-devel \
 rust-ptr_meta-devel \
 "
