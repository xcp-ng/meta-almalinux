# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cim-schema"
PV = "2.54.1"
PR = "6.el10"
PACKAGES = " \
 cim-schema \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cim-schema-2.54.1-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "666f2f51f8daef4334e97df6ff375353cbf3bbfecedc171360f11cc0962c0a20"

URI_x86_64_v2_cim-schema = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cim-schema-2.54.1-6.el10.noarch.rpm;name=x86_64_v2_cim-schema;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cim-schema}"
SRC_URI[x86_64_v2_cim-schema.sha256sum] = "08f391d2220a4a03cbf41662aec2e7330aca8a6e54fef06e649d38fc9fba5197"

URI_aarch64_cim-schema = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cim-schema-2.54.1-6.el10.noarch.rpm;name=aarch64_cim-schema;unpack=0"
SRC_URI:append = " ${URI_aarch64_cim-schema}"
SRC_URI[aarch64_cim-schema.sha256sum] = "08f391d2220a4a03cbf41662aec2e7330aca8a6e54fef06e649d38fc9fba5197"

RDEPENDS:cim-schema = " \
 "
