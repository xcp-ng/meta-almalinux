# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "maven-shared-incremental"
PV = "1.1"
PR = "34.el10"
PACKAGES = " \
 maven-shared-incremental \
 maven-shared-incremental-javadoc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/maven-shared-incremental-1.1-34.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30f8a94383e627c540f56038f70b66e9c3c9db3c1d675514bb0f78d1fc80bf2e"

URI_x86_64_v2_maven-shared-incremental = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-shared-incremental-1.1-34.el10.noarch.rpm;name=x86_64_v2_maven-shared-incremental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-shared-incremental}"
SRC_URI[x86_64_v2_maven-shared-incremental.sha256sum] = "ff1f3bcfe0b637aa17626d6e35e75abd29746b530077eba51b7763350c29f547"

URI_x86_64_v2_maven-shared-incremental-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/maven-shared-incremental-javadoc-1.1-34.el10.noarch.rpm;name=x86_64_v2_maven-shared-incremental-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_maven-shared-incremental-javadoc}"
SRC_URI[x86_64_v2_maven-shared-incremental-javadoc.sha256sum] = "d9c31499f9fbba38089952f3314c68b8c1c899bc3af951963b310fbdf21d2ee9"

URI_aarch64_maven-shared-incremental = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-shared-incremental-1.1-34.el10.noarch.rpm;name=aarch64_maven-shared-incremental;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-shared-incremental}"
SRC_URI[aarch64_maven-shared-incremental.sha256sum] = "ff1f3bcfe0b637aa17626d6e35e75abd29746b530077eba51b7763350c29f547"

URI_aarch64_maven-shared-incremental-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/maven-shared-incremental-javadoc-1.1-34.el10.noarch.rpm;name=aarch64_maven-shared-incremental-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_maven-shared-incremental-javadoc}"
SRC_URI[aarch64_maven-shared-incremental-javadoc.sha256sum] = "d9c31499f9fbba38089952f3314c68b8c1c899bc3af951963b310fbdf21d2ee9"

RDEPENDS:maven-shared-incremental = " \
 javapackages-filesystem \
 maven-lib \
 maven-shared-utils \
 plexus-containers-component-annotations \
 "
RDEPENDS:maven-shared-incremental-javadoc = " \
 javapackages-filesystem \
 "
