# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-what4"
PV = "1.5.1"
PR = "3.el10_0"
PACKAGES = " \
 ghc-what4 \
 ghc-what4-devel \
 ghc-what4-doc \
 ghc-what4-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-what4-1.5.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb9374bfb0c9fc0bbaee2d54143676dfa7ef0e9b18a0de9645fb045578e2d6e6"

URI_x86_64_v2_ghc-what4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-what4-1.5.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-what4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-what4}"
SRC_URI[x86_64_v2_ghc-what4.sha256sum] = "48d481c0f2f91ab7a2f19b18780f334d2cadc9216661e016ef7882133484ae86"

URI_x86_64_v2_ghc-what4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-what4-devel-1.5.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-what4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-what4-devel}"
SRC_URI[x86_64_v2_ghc-what4-devel.sha256sum] = "d65ff695c384d9dd3fdafaf4a3b36f84ba462fab552816704ba85354e321cbdd"

URI_x86_64_v2_ghc-what4-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-what4-doc-1.5.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-what4-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-what4-doc}"
SRC_URI[x86_64_v2_ghc-what4-doc.sha256sum] = "6f8566e5d36b7d9e1b06cfd5c2b1785e9a789bac7d47fc18d60af53d9b8b3517"

URI_x86_64_v2_ghc-what4-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-what4-prof-1.5.1-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-what4-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-what4-prof}"
SRC_URI[x86_64_v2_ghc-what4-prof.sha256sum] = "b548dbd3ed3649e0af8c8c9d064542cf3b04f6ffb241f453a5e565081077d3bd"

URI_aarch64_ghc-what4 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-what4-1.5.1-3.el10_0.aarch64.rpm;name=aarch64_ghc-what4;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-what4}"
SRC_URI[aarch64_ghc-what4.sha256sum] = "eab741d3d65c643b52083bb549b544e09c1b4f7facf47c97cd3b966b81d95c39"

URI_aarch64_ghc-what4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-what4-devel-1.5.1-3.el10_0.aarch64.rpm;name=aarch64_ghc-what4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-what4-devel}"
SRC_URI[aarch64_ghc-what4-devel.sha256sum] = "83e2a37538e6c26d2ca4e8c54a2e690413278d30cd081519a8335e3040a2edf6"

URI_aarch64_ghc-what4-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-what4-doc-1.5.1-3.el10_0.noarch.rpm;name=aarch64_ghc-what4-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-what4-doc}"
SRC_URI[aarch64_ghc-what4-doc.sha256sum] = "bf75c975f82d891f4e2dd861388803ddffbd23926e4d7550503576730f893a13"

URI_aarch64_ghc-what4-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-what4-prof-1.5.1-3.el10_0.aarch64.rpm;name=aarch64_ghc-what4-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-what4-prof}"
SRC_URI[aarch64_ghc-what4-prof.sha256sum] = "c970ed143ad8fc7a5673d5709a3d377c0ff4dd8e729de21d5cb74bfceaa03277"

RDEPENDS:ghc-what4 = " \
 ghc-BoundedChan \
 ghc-OneTuple \
 ghc-StateVar \
 ghc-adjunctions \
 ghc-array \
 ghc-assoc \
 ghc-async \
 ghc-attoparsec \
 ghc-base \
 ghc-base-compat \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-bimap \
 ghc-binary \
 ghc-bitwise \
 ghc-boring \
 ghc-bv-sized \
 ghc-bytestring \
 ghc-call-stack \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-concurrent-extra \
 ghc-config-value \
 ghc-constraints \
 ghc-containers \
 ghc-contravariant \
 ghc-deepseq \
 ghc-deriving-compat \
 ghc-directory \
 ghc-distributive \
 ghc-exceptions \
 ghc-filepath \
 ghc-fingertree \
 ghc-free \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-gitrev \
 ghc-hashable \
 ghc-hashtables \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-logarithms \
 ghc-invariant \
 ghc-io-streams \
 ghc-kan-extensions \
 ghc-lens \
 ghc-libBF \
 ghc-megaparsec \
 ghc-mtl \
 ghc-network \
 ghc-ordered-containers \
 ghc-os-string \
 ghc-panic \
 ghc-parallel \
 ghc-parameterized-utils \
 ghc-parsec \
 ghc-parser-combinators \
 ghc-pretty \
 ghc-prettyprinter \
 ghc-primitive \
 ghc-process \
 ghc-profunctors \
 ghc-random \
 ghc-reflection \
 ghc-s-cargot \
 ghc-safe-exceptions \
 ghc-scientific \
 ghc-semigroupoids \
 ghc-semigroups \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-tagged \
 ghc-template-haskell \
 ghc-temporary \
 ghc-text \
 ghc-th-abstraction \
 ghc-th-lift \
 ghc-th-lift-instances \
 ghc-these \
 ghc-time \
 ghc-transformers \
 ghc-transformers-base \
 ghc-transformers-compat \
 ghc-unbounded-delays \
 ghc-unix \
 ghc-unliftio \
 ghc-unliftio-core \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-vector \
 ghc-vector-stream \
 ghc-versions \
 ghc-void \
 ghc-zenc \
 ghc-zlib \
 ghc-zlib-bindings \
 glibc \
 gmp \
 zlib-ng-compat \
 "
RDEPENDS:ghc-what4-devel = " \
 ghc-BoundedChan-devel \
 ghc-async-devel \
 ghc-attoparsec-devel \
 ghc-base-devel \
 ghc-bifunctors-devel \
 ghc-bimap-devel \
 ghc-bv-sized-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-concurrent-extra-devel \
 ghc-config-value-devel \
 ghc-containers-devel \
 ghc-deepseq-devel \
 ghc-deriving-compat-devel \
 ghc-directory-devel \
 ghc-exceptions-devel \
 ghc-filepath-devel \
 ghc-fingertree-devel \
 ghc-hashable-devel \
 ghc-hashtables-devel \
 ghc-io-streams-devel \
 ghc-lens-devel \
 ghc-libBF-devel \
 ghc-megaparsec-devel \
 ghc-mtl-devel \
 ghc-ordered-containers-devel \
 ghc-panic-devel \
 ghc-parameterized-utils-devel \
 ghc-parsec-devel \
 ghc-prettyprinter-devel \
 ghc-process-devel \
 ghc-s-cargot-devel \
 ghc-scientific-devel \
 ghc-stm-devel \
 ghc-template-haskell-devel \
 ghc-temporary-devel \
 ghc-text-devel \
 ghc-th-lift-devel \
 ghc-th-lift-instances-devel \
 ghc-time-devel \
 ghc-transformers-devel \
 ghc-unliftio-devel \
 ghc-unordered-containers-devel \
 ghc-utf8-string-devel \
 ghc-vector-devel \
 ghc-versions-devel \
 ghc-what4 \
 ghc-zenc-devel \
 glibc \
 gmp \
 libffi \
 zlib-ng-compat \
 "
RDEPENDS:ghc-what4-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-what4-prof = " \
 ghc-BoundedChan-prof \
 ghc-async-prof \
 ghc-attoparsec-prof \
 ghc-base-prof \
 ghc-bifunctors-prof \
 ghc-bimap-prof \
 ghc-bv-sized-prof \
 ghc-bytestring-prof \
 ghc-concurrent-extra-prof \
 ghc-config-value-prof \
 ghc-containers-prof \
 ghc-deepseq-prof \
 ghc-deriving-compat-prof \
 ghc-directory-prof \
 ghc-exceptions-prof \
 ghc-filepath-prof \
 ghc-fingertree-prof \
 ghc-hashable-prof \
 ghc-hashtables-prof \
 ghc-io-streams-prof \
 ghc-lens-prof \
 ghc-libBF-prof \
 ghc-megaparsec-prof \
 ghc-mtl-prof \
 ghc-ordered-containers-prof \
 ghc-panic-prof \
 ghc-parameterized-utils-prof \
 ghc-parsec-prof \
 ghc-prettyprinter-prof \
 ghc-process-prof \
 ghc-s-cargot-prof \
 ghc-scientific-prof \
 ghc-stm-prof \
 ghc-template-haskell-prof \
 ghc-temporary-prof \
 ghc-text-prof \
 ghc-th-lift-instances-prof \
 ghc-th-lift-prof \
 ghc-time-prof \
 ghc-transformers-prof \
 ghc-unliftio-prof \
 ghc-unordered-containers-prof \
 ghc-utf8-string-prof \
 ghc-vector-prof \
 ghc-versions-prof \
 ghc-what4-devel \
 ghc-zenc-prof \
 "
