# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libevent"
PV = "2.1.13"
PR = "1.el10"
PACKAGES = " \
 libevent \
 libevent-devel \
 libevent-doc \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libevent-2.1.13-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ede1209485e707c01de1f9f113e425bec8f15a924b336f360eb7db6c4a3a599c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libevent-2.1.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_libevent;unpack=0"
SRC_URI[x86_64_v2_libevent.sha256sum] = "31f5528b6b387a5013f15fd1041c56cea17751767ac7cba8bfc6bda9ea753775"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libevent-devel-2.1.13-1.el10.x86_64_v2.rpm;name=x86_64_v2_libevent-devel;unpack=0"
SRC_URI[x86_64_v2_libevent-devel.sha256sum] = "3cb6eb3e6b6f2bd3a13999453f5b10e800a28e38cdeadb5f4767c4f41fcb283e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libevent-doc-2.1.13-1.el10.noarch.rpm;name=x86_64_v2_libevent-doc;unpack=0"
SRC_URI[x86_64_v2_libevent-doc.sha256sum] = "c44ee2d01608f62902fc4f60aa924950da5ee53dfd1526c15e031d901078bf9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libevent-2.1.13-1.el10.aarch64.rpm;name=aarch64_libevent;unpack=0"
SRC_URI[aarch64_libevent.sha256sum] = "9d7f66b9564a71226ab15036266354cd07d38883167da063512779289c7c543f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libevent-devel-2.1.13-1.el10.aarch64.rpm;name=aarch64_libevent-devel;unpack=0"
SRC_URI[aarch64_libevent-devel.sha256sum] = "f03f2e13d09e34be512f42ee2592044513629c1871a940b6bb79af4625d1c7d8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libevent-doc-2.1.13-1.el10.noarch.rpm;name=aarch64_libevent-doc;unpack=0"
SRC_URI[aarch64_libevent-doc.sha256sum] = "c44ee2d01608f62902fc4f60aa924950da5ee53dfd1526c15e031d901078bf9a"

RDEPENDS:libevent = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:libevent-devel = " \
 libevent \
 libevent-devel \
 pkgconf-pkg-config \
 python3 \
 "
RDEPENDS:libevent-doc = " \
 "
