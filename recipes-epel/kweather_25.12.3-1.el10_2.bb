# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweather"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kweather \
 kweather-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kweather-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9d9d2540e611e7f0e7fb772f3b673267aa95b75fd97562de4afc4d6be48338a3"

URI_x86_64_v2_kweather = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweather}"
SRC_URI[x86_64_v2_kweather.sha256sum] = "c7445dd1b1034fdd4a48e8576201723711dcff11f7c9c041b29f752315698b7a"

URI_x86_64_v2_kweather-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweather-plasma-applet-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweather-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweather-plasma-applet}"
SRC_URI[x86_64_v2_kweather-plasma-applet.sha256sum] = "e1f340eb6536949332f39561af25115ce0be88ec407a4f776a1069ea0efdc715"

URI_aarch64_kweather = "${EPEL_MIRROR}/aarch64/Packages/k/kweather-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kweather;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweather}"
SRC_URI[aarch64_kweather.sha256sum] = "0fcae533ffe31efad722239b56338f51229573e735716ffe6c94944a85e7f1e9"

URI_aarch64_kweather-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kweather-plasma-applet-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kweather-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweather-plasma-applet}"
SRC_URI[aarch64_kweather-plasma-applet.sha256sum] = "075d2471dc5a681bea72832861c43293fcf6458247749d380f8469ed74eda34e"

RDEPENDS:kweather = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kholidays \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kweathercore \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtdeclarative \
 "
RDEPENDS:kweather-plasma-applet = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kirigami \
 kf6-kirigami-addons \
 kweather \
 kweathercore \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
