# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-jod-thread"
PV = "0.1.2"
PR = "3.el10_1"
PACKAGES = " \
 rust-jod-thread+default-devel \
 rust-jod-thread-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-jod-thread-0.1.2-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "30d55cdc1c8c83bfa1d8f65351549d133021e7487f46dd47c7b2e9e41b0b9cee"

URI_x86_64_v2_rust-jod-thread+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jod-thread+default-devel-0.1.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jod-thread+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jod-thread+default-devel}"
SRC_URI[x86_64_v2_rust-jod-thread+default-devel.sha256sum] = "301f925bcf3a2b031b8a163aa57d52d65b09183876a67cc415dd8284f3d6266f"

URI_x86_64_v2_rust-jod-thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-jod-thread-devel-0.1.2-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-jod-thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-jod-thread-devel}"
SRC_URI[x86_64_v2_rust-jod-thread-devel.sha256sum] = "5a362b4dab2803c84dd20083c3961d8cc405089c2370725b39a87f606d446d52"

URI_aarch64_rust-jod-thread+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jod-thread+default-devel-0.1.2-3.el10_1.noarch.rpm;name=aarch64_rust-jod-thread+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jod-thread+default-devel}"
SRC_URI[aarch64_rust-jod-thread+default-devel.sha256sum] = "79fd7ebc76a1cdd079cd933a40bd4be2108446daec3599a0405abaf3febab8ca"

URI_aarch64_rust-jod-thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-jod-thread-devel-0.1.2-3.el10_1.noarch.rpm;name=aarch64_rust-jod-thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-jod-thread-devel}"
SRC_URI[aarch64_rust-jod-thread-devel.sha256sum] = "fd19cdc9735ab10c3054b66ebf242307974c0b989a3d27733b96bbbc014a6c2c"

RDEPENDS:rust-jod-thread+default-devel = " \
 cargo \
 rust-jod-thread-devel \
 "
RDEPENDS:rust-jod-thread-devel = " \
 cargo \
 "
