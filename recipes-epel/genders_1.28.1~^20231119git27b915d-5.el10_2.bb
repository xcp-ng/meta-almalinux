# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "genders"
PV = "1.28.1~^20231119git27b915d"
PR = "5.el10_2"
PACKAGES = " \
 genders \
 genders-compat \
 genders-java \
 genders-java-devel \
 genders-javadoc \
 genders-perl \
 libgenders \
 libgenders-devel \
 libgendersplusplus \
 libgendersplusplus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/genders-1.28.1~^20231119git27b915d-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "160f8144fd184c57e8906d2aa03e26e694a5a79d70a35959f692680ce7817f1b"

URI_x86_64_v2_genders = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders}"
SRC_URI[x86_64_v2_genders.sha256sum] = "99c48a5ffb868790bb807000ecc24b49a1d5a7f2afd476aa949374c89dcc95a5"

URI_x86_64_v2_genders-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-compat-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_genders-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-compat}"
SRC_URI[x86_64_v2_genders-compat.sha256sum] = "6b08de452a8e9edff8b68a7464f87714d294634ccd6416a99a53bdddbbd3865a"

URI_x86_64_v2_genders-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-java-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-java}"
SRC_URI[x86_64_v2_genders-java.sha256sum] = "fc5dc8fb756e488240c3abee9ae62e0545a5828f221a0c31713b87aa1d870a7f"

URI_x86_64_v2_genders-java-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-java-devel-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-java-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-java-devel}"
SRC_URI[x86_64_v2_genders-java-devel.sha256sum] = "0348d5ce6ed2138adb2fa0a3d54684c1a969d0cc44e07de631b251b775779bd0"

URI_x86_64_v2_genders-javadoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-javadoc-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-javadoc}"
SRC_URI[x86_64_v2_genders-javadoc.sha256sum] = "4c2520bf76973a2031676957442526c2aa88e51c31f9f648af40675bcea384c1"

URI_x86_64_v2_genders-perl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/genders-perl-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_genders-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_genders-perl}"
SRC_URI[x86_64_v2_genders-perl.sha256sum] = "a7453d1d5c714dac2daebd38ddcd11c8510e09354fe85322ce481772107f8f3f"

URI_x86_64_v2_libgenders = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgenders-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgenders;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgenders}"
SRC_URI[x86_64_v2_libgenders.sha256sum] = "af9c39aec3cc92860a03039819a48195bd5d6a44bf0d78c9c2bf41c70c99eaf3"

URI_x86_64_v2_libgenders-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgenders-devel-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgenders-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgenders-devel}"
SRC_URI[x86_64_v2_libgenders-devel.sha256sum] = "9457211f7c1f80f0ae69e19ed79933a3f2f85bd52a41f1ce2b880be25eb30105"

URI_x86_64_v2_libgendersplusplus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgendersplusplus-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgendersplusplus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgendersplusplus}"
SRC_URI[x86_64_v2_libgendersplusplus.sha256sum] = "ed60d3900e8b50af83f4873bbeaffc196e1a158c3dcd6fc80b8d471b1a87754e"

URI_x86_64_v2_libgendersplusplus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgendersplusplus-devel-1.28.1~^20231119git27b915d-5.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgendersplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgendersplusplus-devel}"
SRC_URI[x86_64_v2_libgendersplusplus-devel.sha256sum] = "ab2d6239789a1dad30700aa4387e25df15fe4cd4c20ed53f1d01d4900b7572e2"

URI_aarch64_genders = "${EPEL_MIRROR}/aarch64/Packages/g/genders-1.28.1~^20231119git27b915d-5.el10_2.aarch64.rpm;name=aarch64_genders;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders}"
SRC_URI[aarch64_genders.sha256sum] = "6f4c1bf16e06b75f3ad49e03c725fb7d35ba89d1bf96392aef2b24b5ce2c5ac9"

URI_aarch64_genders-compat = "${EPEL_MIRROR}/aarch64/Packages/g/genders-compat-1.28.1~^20231119git27b915d-5.el10_2.noarch.rpm;name=aarch64_genders-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-compat}"
SRC_URI[aarch64_genders-compat.sha256sum] = "02f38b067b4b74fff79022e9303db9f22729c3f90c2e49d484153c249952a869"

URI_aarch64_genders-java = "${EPEL_MIRROR}/aarch64/Packages/g/genders-java-1.28.1~^20231119git27b915d-5.el10_2.aarch64.rpm;name=aarch64_genders-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-java}"
SRC_URI[aarch64_genders-java.sha256sum] = "250b76adf4f9e63136d1f2c5346d685e963e18a9f4d471b998a82960932e81b2"

URI_aarch64_genders-java-devel = "${EPEL_MIRROR}/aarch64/Packages/g/genders-java-devel-1.28.1~^20231119git27b915d-5.el10_2.aarch64.rpm;name=aarch64_genders-java-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-java-devel}"
SRC_URI[aarch64_genders-java-devel.sha256sum] = "c873817ce7f089eeebd5453842694e5f89e5f32253b7a48445fefaf0f55cd7ec"

URI_aarch64_genders-javadoc = "${EPEL_MIRROR}/aarch64/Packages/g/genders-javadoc-1.28.1~^20231119git27b915d-5.el10_2.aarch64.rpm;name=aarch64_genders-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-javadoc}"
SRC_URI[aarch64_genders-javadoc.sha256sum] = "3932f7103ebff8f55a1e3c012af2623b366f7638aedba26211b4f5fc80f1d7a3"

URI_aarch64_genders-perl = "${EPEL_MIRROR}/aarch64/Packages/g/genders-perl-1.28.1~^20231119git27b915d-5.el10_2.aarch64.rpm;name=aarch64_genders-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_genders-perl}"
SRC_URI[aarch64_genders-perl.sha256sum] = "a1e187faadb57032602e787187b17b1eea17ce25b4b36ef3124039709c451d8f"

URI_aarch64_libgenders = "${EPEL_MIRROR}/aarch64/Packages/l/libgenders-1.28.1~^20231119git27b915d-5.el10_2.aarch64.rpm;name=aarch64_libgenders;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgenders}"
SRC_URI[aarch64_libgenders.sha256sum] = "61c50565089d8ea44a6262fee055608420de88aeb52869d97767a17bbac26c90"

URI_aarch64_libgenders-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgenders-devel-1.28.1~^20231119git27b915d-5.el10_2.aarch64.rpm;name=aarch64_libgenders-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgenders-devel}"
SRC_URI[aarch64_libgenders-devel.sha256sum] = "303d3fbac8ed4c346c358f248760604c9ad941fb21c7df82f0a0fbceb75d8904"

URI_aarch64_libgendersplusplus = "${EPEL_MIRROR}/aarch64/Packages/l/libgendersplusplus-1.28.1~^20231119git27b915d-5.el10_2.aarch64.rpm;name=aarch64_libgendersplusplus;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgendersplusplus}"
SRC_URI[aarch64_libgendersplusplus.sha256sum] = "ca46c22aee069194d7e678f1c3d024f07d02ddc1fa3a47fe7d815705b23e7ccd"

URI_aarch64_libgendersplusplus-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgendersplusplus-devel-1.28.1~^20231119git27b915d-5.el10_2.aarch64.rpm;name=aarch64_libgendersplusplus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgendersplusplus-devel}"
SRC_URI[aarch64_libgendersplusplus-devel.sha256sum] = "56460b428aca1ceccd2b7118ab1315e713f36aff736858e4a7c7bb929b674d50"

RDEPENDS:genders = " \
 glibc \
 libgenders \
 "
RDEPENDS:genders-compat = " \
 "
RDEPENDS:genders-java = " \
 glibc \
 libgenders \
 "
RDEPENDS:genders-java-devel = " \
 genders-java \
 "
RDEPENDS:genders-javadoc = " \
 "
RDEPENDS:genders-perl = " \
 genders-perl \
 glibc \
 libgenders \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 "
RDEPENDS:libgenders = " \
 glibc \
 "
RDEPENDS:libgenders-devel = " \
 libgenders \
 "
RDEPENDS:libgendersplusplus = " \
 glibc \
 libgcc \
 libgenders \
 libstdc++ \
 "
RDEPENDS:libgendersplusplus-devel = " \
 libgenders-devel \
 libgendersplusplus \
 "
