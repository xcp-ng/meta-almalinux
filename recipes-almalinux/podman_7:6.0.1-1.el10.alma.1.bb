# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman"
PE = "7"
PV = "6.0.1"
PR = "1.el10.alma.1"
PACKAGES = " \
 podman \
 podman-docker \
 podman-remote \
 podman-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/podman-6.0.1-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "325514fde528782b7708e2212c383a02cddf05c296f8a2446e94623034183987"

URI_x86_64_v2_podman = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-6.0.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman}"
SRC_URI[x86_64_v2_podman.sha256sum] = "6c113f6d912f760fd01b849f4d5708f34ba4311066ed24d53d48f6c02da2152c"
RPROVIDES:podman:x86_64_v2 = "virtual/podman_or_/usr/bin/docker"

URI_x86_64_v2_podman-docker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-docker-6.0.1-1.el10.alma.1.noarch.rpm;name=x86_64_v2_podman-docker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-docker}"
SRC_URI[x86_64_v2_podman-docker.sha256sum] = "5940dba92e7f0ebc730f1eb36f6273092c9644b6bc168981509c8561f0b739d0"
RPROVIDES:podman-docker:x86_64_v2 = "virtual/podman_or_/usr/bin/docker"

URI_x86_64_v2_podman-remote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/podman-remote-6.0.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-remote}"
SRC_URI[x86_64_v2_podman-remote.sha256sum] = "13ab6deebd40d8db77680e79dd258ab89cf09c3fcb7e6282b8893c9368a9fec4"

URI_x86_64_v2_podman-tests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/podman-tests-6.0.1-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_podman-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-tests}"
SRC_URI[x86_64_v2_podman-tests.sha256sum] = "98bdd6cdda5f1eebeeefbbc532a07a515eb0949515643d9387a6ec37f0c1132f"

URI_aarch64_podman = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-6.0.1-1.el10.alma.1.aarch64.rpm;name=aarch64_podman;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman}"
SRC_URI[aarch64_podman.sha256sum] = "d0d5d294d20276dab6b90cfd13ac48c1d320e053c76357c2fb7173ed69c0e990"
RPROVIDES:podman:aarch64 = "virtual/podman_or_/usr/bin/docker"

URI_aarch64_podman-docker = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-docker-6.0.1-1.el10.alma.1.noarch.rpm;name=aarch64_podman-docker;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-docker}"
SRC_URI[aarch64_podman-docker.sha256sum] = "5940dba92e7f0ebc730f1eb36f6273092c9644b6bc168981509c8561f0b739d0"
RPROVIDES:podman-docker:aarch64 = "virtual/podman_or_/usr/bin/docker"

URI_aarch64_podman-remote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/podman-remote-6.0.1-1.el10.alma.1.aarch64.rpm;name=aarch64_podman-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-remote}"
SRC_URI[aarch64_podman-remote.sha256sum] = "7192975e2910abf2b130accc7279d9539514a8585aff0a1184024581c0a425be"

URI_aarch64_podman-tests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/podman-tests-6.0.1-1.el10.alma.1.aarch64.rpm;name=aarch64_podman-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-tests}"
SRC_URI[aarch64_podman-tests.sha256sum] = "c1e7bd70f8153a52eb809bdfb29b8bc178cfe98716f31ac5b18af415b162cff5"

RDEPENDS:podman = " \
 catatonit \
 conmon \
 containers-common-extra \
 glibc \
 gpgme \
 libgcc \
 libseccomp \
 podman-sequoia \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-docker = " \
 bash \
 podman \
 "
RDEPENDS:podman-remote = " \
 glibc \
 gpgme \
 libgcc \
 shadow-utils-subid \
 sqlite-libs \
 "
RDEPENDS:podman-tests = " \
 attr \
 bash \
 buildah \
 glibc \
 gnupg2 \
 gpgme \
 httpd-tools \
 jq \
 libgcc \
 libseccomp \
 nmap-ncat \
 openssl \
 podman \
 shadow-utils-subid \
 skopeo \
 socat \
 sqlite-libs \
 xfsprogs \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/podman_or_/usr/bin/docker"

PROVIDES:append:aarch64 = " rpm/virtual/podman_or_/usr/bin/docker"
