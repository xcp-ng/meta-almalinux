# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnbd"
PV = "1.25.7"
PR = "1.el10"
PACKAGES = " \
 libnbd \
 libnbd-bash-completion \
 libnbd-devel \
 nbdfuse \
 ocaml-libnbd \
 ocaml-libnbd-devel \
 python3-libnbd \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnbd-1.25.7-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac8f5b8cf85a92c40e08357ae4f2957d1d1c885dcbb38202131dccd1b93eff26"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - ocaml-libnbd-devel: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd-devel: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd-devel: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd-devel: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd-devel: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd-devel: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd-devel: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd-devel: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd-devel: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd-devel: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd-devel: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd-devel: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd-devel: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd-devel: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd-devel: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda
# - ocaml-libnbd-devel: ocamlx(Stdlib__Bigarray) = 2fb6f37865dd77a707635669254911e1
# - ocaml-libnbd-devel: ocamlx(Stdlib__Callback) = bafc96ea60f2aa399fe753ac0e40f764
# - ocaml-libnbd-devel: ocamlx(Stdlib__Gc) = 197914694cd716338b4da966236687f4
# - ocaml-libnbd: ocaml(CamlinternalFormatBasics) = 2ef2d91ced81f6c72f852bab8ab406e0
# - ocaml-libnbd: ocaml(Stdlib) = e8d9af458547c45080a71b9a6eaed658
# - ocaml-libnbd: ocaml(Stdlib__Bigarray) = 8317b42277334e4ae5794d3cbabcaf4f
# - ocaml-libnbd: ocaml(Stdlib__Bytes) = d5a54ebfd096c4af2a47315dda118f2d
# - ocaml-libnbd: ocaml(Stdlib__Callback) = b855f824a6cb0f4b58dc69a6e79a49a1
# - ocaml-libnbd: ocaml(Stdlib__Complex) = 052959c6d02e4e692e7944dd137c4095
# - ocaml-libnbd: ocaml(Stdlib__Either) = d56b2e9ca14b69fdeef09f3b2fbd10ad
# - ocaml-libnbd: ocaml(Stdlib__Gc) = 117a859136e8d0cad6ff77491c390228
# - ocaml-libnbd: ocaml(Stdlib__Int32) = 9cc80815720f462a0569c994dd5f43cc
# - ocaml-libnbd: ocaml(Stdlib__Obj) = 592f14b225bd7cf0051f4b04372640d7
# - ocaml-libnbd: ocaml(Stdlib__Printexc) = 1e5e75f741ca414dd916c0c65b646827
# - ocaml-libnbd: ocaml(Stdlib__Seq) = ac22688c50c848ab417492a023ff76ab
# - ocaml-libnbd: ocaml(Stdlib__String) = cdb3775f91c0e999766c3b2a50f03a7d
# - ocaml-libnbd: ocaml(Stdlib__Uchar) = 7eb8f0d1a7c18933885eaef3b23d79f4
# - ocaml-libnbd: ocaml(Unix) = 59e61ff7441dfacaa24d4eed6d45eeda

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-1.25.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnbd;unpack=0"
SRC_URI[x86_64_v2_libnbd.sha256sum] = "f83ed37c0187f4573c5e12bcc6c0faacbb19477472db5ff27eec164dbca62b50"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnbd-bash-completion-1.25.7-1.el10.noarch.rpm;name=x86_64_v2_libnbd-bash-completion;unpack=0"
SRC_URI[x86_64_v2_libnbd-bash-completion.sha256sum] = "c736dd57b68447b3ef73592ee4fd465862c85c6a60ae64543b5e9d120efd6c18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnbd-devel-1.25.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_libnbd-devel;unpack=0"
SRC_URI[x86_64_v2_libnbd-devel.sha256sum] = "3ca128e2525b44798980d0a3e4e3ab6861da60aacb29b6d82a668ffd7ced08fe"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nbdfuse-1.25.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_nbdfuse;unpack=0"
SRC_URI[x86_64_v2_nbdfuse.sha256sum] = "461baffab89f245fca6bb3dad3486ed7b7438a88ed1b904ccae5ff37a5a60578"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-1.25.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd;unpack=0"
SRC_URI[x86_64_v2_ocaml-libnbd.sha256sum] = "5af9dd0e2338f22462a125c9e75d1d7a39662446d1759b3b36913654943a72cd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ocaml-libnbd-devel-1.25.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_ocaml-libnbd-devel;unpack=0"
SRC_URI[x86_64_v2_ocaml-libnbd-devel.sha256sum] = "8aec676e0255b185f2419be97046e58e6a66c3b7d2fbeaaa22c645987066da3c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnbd-1.25.7-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libnbd;unpack=0"
SRC_URI[x86_64_v2_python3-libnbd.sha256sum] = "249de8262102b9535151981cf6851b20a558a65ff0fff6064cc20f0454096200"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-1.25.7-1.el10.aarch64.rpm;name=aarch64_libnbd;unpack=0"
SRC_URI[aarch64_libnbd.sha256sum] = "145f8a904a0a7f037a168c3eff9c21bdb6e880ce2e28612a4435d3138cf2f024"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnbd-bash-completion-1.25.7-1.el10.noarch.rpm;name=aarch64_libnbd-bash-completion;unpack=0"
SRC_URI[aarch64_libnbd-bash-completion.sha256sum] = "c736dd57b68447b3ef73592ee4fd465862c85c6a60ae64543b5e9d120efd6c18"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnbd-devel-1.25.7-1.el10.aarch64.rpm;name=aarch64_libnbd-devel;unpack=0"
SRC_URI[aarch64_libnbd-devel.sha256sum] = "bdf103353f73ae66e06876d614a643f2428c32177a52cdcf7f1b34e9d1bfc53c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nbdfuse-1.25.7-1.el10.aarch64.rpm;name=aarch64_nbdfuse;unpack=0"
SRC_URI[aarch64_nbdfuse.sha256sum] = "d2b68f9bf07e5479de1560db6a94069ea6d74ee7ef0af07cc0001274534ac597"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-1.25.7-1.el10.aarch64.rpm;name=aarch64_ocaml-libnbd;unpack=0"
SRC_URI[aarch64_ocaml-libnbd.sha256sum] = "0a60c7bafa01bd131cb21aa7cfdbfa2af240c6130338173874d3f94b8b9c92e9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ocaml-libnbd-devel-1.25.7-1.el10.aarch64.rpm;name=aarch64_ocaml-libnbd-devel;unpack=0"
SRC_URI[aarch64_ocaml-libnbd-devel.sha256sum] = "b19b0a8c8db53dab59e1ac4d8e66f370863c8d578000d93fafe785e4161de491"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnbd-1.25.7-1.el10.aarch64.rpm;name=aarch64_python3-libnbd;unpack=0"
SRC_URI[aarch64_python3-libnbd.sha256sum] = "efa8cee7e5ae1502ed40821a3448ff88810871faf17e8fb950fe65a7c7e7f73f"

RDEPENDS:libnbd = " \
 glibc \
 gnutls \
 libxml2 \
 "
RDEPENDS:libnbd-bash-completion = " \
 bash-completion \
 libnbd \
 "
RDEPENDS:libnbd-devel = " \
 libnbd \
 pkgconf-pkg-config \
 "
RDEPENDS:nbdfuse = " \
 fuse3-libs \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd = " \
 glibc \
 libnbd \
 "
RDEPENDS:ocaml-libnbd-devel = " \
 ocaml-libnbd \
 "
RDEPENDS:python3-libnbd = " \
 bash \
 glibc \
 gnutls \
 libnbd \
 libxml2 \
 python3 \
 "
