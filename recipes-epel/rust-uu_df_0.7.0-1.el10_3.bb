# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_df"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_df+default-devel \
 rust-uu_df-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_df-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fc844bc3ea809e13839ef11047f79fa14f5e0d5427909afd8768bfa0677ec6e1"

URI_x86_64_v2_rust-uu_df+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_df+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_df+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_df+default-devel}"
SRC_URI[x86_64_v2_rust-uu_df+default-devel.sha256sum] = "6cddea555af08de7469dd88f88baa0361ba6b20ee81fcf2521b4b8fc013f07fa"

URI_x86_64_v2_rust-uu_df-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_df-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_df-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_df-devel}"
SRC_URI[x86_64_v2_rust-uu_df-devel.sha256sum] = "266f173eb526b9039e43bca8bfc8f0864efc44da3f5aca85d126dbee6b47f84f"

URI_aarch64_rust-uu_df+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_df+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_df+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_df+default-devel}"
SRC_URI[aarch64_rust-uu_df+default-devel.sha256sum] = "338ba0a3e71d425d7d98cd80b31971ce3857c972910f1112ccbd323af02aef21"

URI_aarch64_rust-uu_df-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_df-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_df-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_df-devel}"
SRC_URI[aarch64_rust-uu_df-devel.sha256sum] = "c025d02870c5ae1928ef26e1a31e9ce41792ee4a8148b226a119d9c5357fe965"

RDEPENDS:rust-uu_df+default-devel = " \
 cargo \
 rust-uu_df-devel \
 "
RDEPENDS:rust-uu_df-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-thiserror+default-devel \
 rust-unicode-width+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 rust-uucore+fsext-devel \
 rust-uucore+libc-devel \
 rust-uucore+parser-size-devel \
 "
