# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-chardet"
PV = "5.2.0"
PR = "19.el10_2"
PACKAGES = " \
 python3-chardet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-chardet-5.2.0-19.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fd8043e0923be013b3fdbc3651d887ce1cb47afba8a6aaa4337ada855a0c1bfd"

URI_x86_64_v2_python3-chardet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-chardet-5.2.0-19.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-chardet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-chardet}"
SRC_URI[x86_64_v2_python3-chardet.sha256sum] = "9344222028f1e83d875be7dbc7fe010d69c1e20bdbe880ea3d9df7f78aa7777d"

URI_aarch64_python3-chardet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-chardet-5.2.0-19.el10_2.noarch.rpm;name=aarch64_python3-chardet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-chardet}"
SRC_URI[aarch64_python3-chardet.sha256sum] = "c166713bb0fa3d7842a74d258fd3c1da81719d28e3b2d08324f701c1371d8478"

RDEPENDS:python3-chardet = " \
 python3 \
 "
