# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "seatd"
PV = "0.9.3"
PR = "1.el10_2"
PACKAGES = " \
 libseat \
 libseat-devel \
 seatd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/seatd-0.9.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4062f1cc199ee0e4c5bccbe21540ec74825075eaf96dd61d88ab7b25f11c5959"

URI_x86_64_v2_libseat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libseat-0.9.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libseat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseat}"
SRC_URI[x86_64_v2_libseat.sha256sum] = "35df4416df893097df94746b4280d9c14c983d6121ef87b9f6ecb196ebac0169"

URI_x86_64_v2_libseat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libseat-devel-0.9.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libseat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libseat-devel}"
SRC_URI[x86_64_v2_libseat-devel.sha256sum] = "2a6691b534cdfd2945838c72f45a7ac1761d25deb88158095fa7e9b94a1f71c3"

URI_x86_64_v2_seatd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/seatd-0.9.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_seatd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_seatd}"
SRC_URI[x86_64_v2_seatd.sha256sum] = "1f0e7622d45a769f54166b4eb802f38768f80cc177d35925507c68a2c901083e"

URI_aarch64_libseat = "${EPEL_MIRROR}/aarch64/Packages/l/libseat-0.9.3-1.el10_2.aarch64.rpm;name=aarch64_libseat;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseat}"
SRC_URI[aarch64_libseat.sha256sum] = "af71fe1b45764947b55c4b1a6c18f1e21ed23597bca528b37038a444b3045f14"

URI_aarch64_libseat-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libseat-devel-0.9.3-1.el10_2.aarch64.rpm;name=aarch64_libseat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libseat-devel}"
SRC_URI[aarch64_libseat-devel.sha256sum] = "4360bc50b60f4d4f886d1a3ee1bb9986c6b118b1b170967feefdac0996562ca5"

URI_aarch64_seatd = "${EPEL_MIRROR}/aarch64/Packages/s/seatd-0.9.3-1.el10_2.aarch64.rpm;name=aarch64_seatd;unpack=0"
SRC_URI:append = " ${URI_aarch64_seatd}"
SRC_URI[aarch64_seatd.sha256sum] = "ee358515fe4e5ada1791bf59b730f32923c859d77b15acc15e9b8ac9f829f41e"

RDEPENDS:libseat = " \
 glibc \
 systemd-libs \
 "
RDEPENDS:libseat-devel = " \
 libseat \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:seatd = " \
 bash \
 glibc \
 "
