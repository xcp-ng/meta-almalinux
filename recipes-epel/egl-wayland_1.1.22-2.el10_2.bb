# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "egl-wayland"
PV = "1.1.22"
PR = "2.el10_2"
PACKAGES = " \
 egl-wayland \
 egl-wayland-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/e/egl-wayland-1.1.22-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ef8ed5d5fc5648e7b5b3b426af1857ee59bfa61fd79c5e137a4bf4360cb39ead"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland-1.1.22-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland;unpack=0"
SRC_URI[x86_64_v2_egl-wayland.sha256sum] = "8412c443b4774a9112e8d1abfccdf9713d86741dcd1455999970d01127542668"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/egl-wayland-devel-1.1.22-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_egl-wayland-devel;unpack=0"
SRC_URI[x86_64_v2_egl-wayland-devel.sha256sum] = "555da748cc3340845f8662e8e607d285345d11e2aa479715d2a6e6b78b8cf619"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland-1.1.22-2.el10_2.aarch64.rpm;name=aarch64_egl-wayland;unpack=0"
SRC_URI[aarch64_egl-wayland.sha256sum] = "835434092dcfbcfaa782c747e86a1f358bcb7f90dca39390747b61e231009e49"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/e/egl-wayland-devel-1.1.22-2.el10_2.aarch64.rpm;name=aarch64_egl-wayland-devel;unpack=0"
SRC_URI[aarch64_egl-wayland-devel.sha256sum] = "161c40f5f13f2a5bdc5baaab154ee277e6c8fd17892d18f95f4e74e2e249d256"

RDEPENDS:egl-wayland = " \
 glibc \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libwayland-server \
 "
RDEPENDS:egl-wayland-devel = " \
 egl-wayland \
 eglexternalplatform-devel \
 pkgconf-pkg-config \
 "
