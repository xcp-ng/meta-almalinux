# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipython"
PV = "8.32.0"
PR = "5.el10_1"
PACKAGES = " \
 python3-ipython \
 python3-ipython+notebook \
 python3-ipython+test \
 python3-ipython-doc \
 python3-ipython-sphinx \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ipython-8.32.0-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af725cf9ae0e2cd8f489ee7cb197adf0c0ff2780d981e2ddde675ec269734cac"

URI_x86_64_v2_python3-ipython = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipython-8.32.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipython;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipython}"
SRC_URI[x86_64_v2_python3-ipython.sha256sum] = "799140a80b3a3dfde5a85398ce04a97c71e4b1d69751ff783c6c29198d7317de"

URI_x86_64_v2_python3-ipython+notebook = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipython+notebook-8.32.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipython+notebook;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipython+notebook}"
SRC_URI[x86_64_v2_python3-ipython+notebook.sha256sum] = "a77bce28016489859cd4349a403fb268c321d6268d6ac9269fc03b2e3d2c7e5a"

URI_x86_64_v2_python3-ipython+test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipython+test-8.32.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipython+test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipython+test}"
SRC_URI[x86_64_v2_python3-ipython+test.sha256sum] = "7484e34ddb3312ce5ba5457e51bd239dd802a2686f385c45eaa30da875634f11"

URI_x86_64_v2_python3-ipython-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipython-doc-8.32.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipython-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipython-doc}"
SRC_URI[x86_64_v2_python3-ipython-doc.sha256sum] = "a31732d7fa861cb119a287cfc47f3b39edc6dec2f4ae0ccf8c00093ff275cf33"

URI_x86_64_v2_python3-ipython-sphinx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipython-sphinx-8.32.0-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipython-sphinx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipython-sphinx}"
SRC_URI[x86_64_v2_python3-ipython-sphinx.sha256sum] = "77902cde4331b3a0cd7ecda2c9c966d12a60da70fcecf9622d089abc15f11579"

URI_aarch64_python3-ipython = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipython-8.32.0-5.el10_1.noarch.rpm;name=aarch64_python3-ipython;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipython}"
SRC_URI[aarch64_python3-ipython.sha256sum] = "511f7ab96d5fc183be91c1db143a1e49ac71a01a81d4be22d91b4f62a1efb890"

URI_aarch64_python3-ipython+notebook = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipython+notebook-8.32.0-5.el10_1.noarch.rpm;name=aarch64_python3-ipython+notebook;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipython+notebook}"
SRC_URI[aarch64_python3-ipython+notebook.sha256sum] = "903a2ec3d94d4837d2b03a82bf04a66b0e797b687b659ff3fdb07b59ae82b852"

URI_aarch64_python3-ipython+test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipython+test-8.32.0-5.el10_1.noarch.rpm;name=aarch64_python3-ipython+test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipython+test}"
SRC_URI[aarch64_python3-ipython+test.sha256sum] = "dddd74fe122c3707bbc2a441b3c06e072b9eba5ca193f6ed7091a2676fa7ab1d"

URI_aarch64_python3-ipython-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipython-doc-8.32.0-5.el10_1.noarch.rpm;name=aarch64_python3-ipython-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipython-doc}"
SRC_URI[aarch64_python3-ipython-doc.sha256sum] = "e02d88996a3a34fa1a3cb5cee2a83746366c0a47db195adb98dc3fe5e73d1b9e"

URI_aarch64_python3-ipython-sphinx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipython-sphinx-8.32.0-5.el10_1.noarch.rpm;name=aarch64_python3-ipython-sphinx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipython-sphinx}"
SRC_URI[aarch64_python3-ipython-sphinx.sha256sum] = "6055b5f33a42c452d1843f6a259e962d28b8a7b3871049e5ff381b7521ca6023"

RDEPENDS:python3-ipython = " \
 python3 \
 python3-decorator \
 python3-jedi \
 python3-matplotlib-inline \
 python3-pexpect \
 python3-prompt-toolkit \
 python3-pygments \
 python3-stack-data \
 python3-traitlets \
 texlive-amscls \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-tools \
 "
RDEPENDS:python3-ipython+notebook = " \
 python3 \
 python3-ipython \
 python3-ipywidgets \
 python3-notebook \
 "
RDEPENDS:python3-ipython+test = " \
 python3 \
 python3-ipykernel \
 python3-ipython \
 python3-jupyter-client \
 python3-nbformat \
 python3-packaging \
 python3-pickleshare \
 python3-pytest \
 python3-pytest-asyncio \
 python3-testpath \
 texlive-amscls \
 texlive-amsfonts \
 texlive-amsmath \
 texlive-dvipng \
 texlive-tools \
 "
RDEPENDS:python3-ipython-doc = " \
 "
RDEPENDS:python3-ipython-sphinx = " \
 python3 \
 python3-ipython \
 python3-sphinx \
 "
