# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmplot"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmplot \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmplot-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd70a66edcda4ea603287fb42d34293df4cb34df299c90ffb1176c7313b5d125"

URI_x86_64_v2_kmplot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmplot-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmplot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmplot}"
SRC_URI[x86_64_v2_kmplot.sha256sum] = "6492d149d92f9f6c325412c667bb5692fb3e655109c9aa3cbc072a5e79081b14"

URI_aarch64_kmplot = "${EPEL_MIRROR}/aarch64/Packages/k/kmplot-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmplot;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmplot}"
SRC_URI[aarch64_kmplot.sha256sum] = "b946f7e9b8bbda6b761e132d273e30b5b95aac293d83bab9d731c1bd012b5b65"

RDEPENDS:kmplot = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
