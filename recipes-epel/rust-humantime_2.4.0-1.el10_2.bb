# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-humantime"
PV = "2.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-humantime+default-devel \
 rust-humantime+mu-devel \
 rust-humantime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-humantime-2.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92565fd0dc6e72743cfab18a61dc010282fd9559fe76480e98a3eb5b69f21846"

URI_x86_64_v2_rust-humantime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime+default-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime+default-devel}"
SRC_URI[x86_64_v2_rust-humantime+default-devel.sha256sum] = "0b9937ce980a7d172cd26916ec09755ca59d709ca66d13e37338a025335882ae"

URI_x86_64_v2_rust-humantime+mu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime+mu-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime+mu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime+mu-devel}"
SRC_URI[x86_64_v2_rust-humantime+mu-devel.sha256sum] = "cce7ec40509f9fc54750d4b8e3ca891a641a191666d8ac16d36a2b27b14d4d14"

URI_x86_64_v2_rust-humantime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humantime-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humantime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humantime-devel}"
SRC_URI[x86_64_v2_rust-humantime-devel.sha256sum] = "ac300bf2c3f08a7882a2afb690ac11c18cc8ba8279ea853057c784f716619ef3"

URI_aarch64_rust-humantime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime+default-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-humantime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime+default-devel}"
SRC_URI[aarch64_rust-humantime+default-devel.sha256sum] = "62127d629b81502c52e361622e4738586cdf71941bae10c751552c4552c176d4"

URI_aarch64_rust-humantime+mu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime+mu-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-humantime+mu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime+mu-devel}"
SRC_URI[aarch64_rust-humantime+mu-devel.sha256sum] = "fe8f867efecb6fb5fe02057f6ed83fd10631f6476fb95dfad7c4f87d6bcf4b1e"

URI_aarch64_rust-humantime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humantime-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-humantime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humantime-devel}"
SRC_URI[aarch64_rust-humantime-devel.sha256sum] = "57cec74888a6f5342301371c689dae9e5141af303e64021b2b990bd28875d36e"

RDEPENDS:rust-humantime+default-devel = " \
 cargo \
 rust-humantime-devel \
 "
RDEPENDS:rust-humantime+mu-devel = " \
 cargo \
 rust-humantime-devel \
 "
RDEPENDS:rust-humantime-devel = " \
 cargo \
 rust \
 "
