# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arrayvec"
PV = "0.7.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-arrayvec+default-devel \
 rust-arrayvec+serde-devel \
 rust-arrayvec+std-devel \
 rust-arrayvec+zeroize-devel \
 rust-arrayvec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arrayvec-0.7.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7fb1ed8cf0fb869cb4973b6a8f7ef7f5a46b109e1a7d9eb823f07b087b9904a2"

URI_x86_64_v2_rust-arrayvec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+default-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+default-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+default-devel.sha256sum] = "4ab2761d9d531385b62988794195d78aaf443435c9e42c65c228363dad0a4182"

URI_x86_64_v2_rust-arrayvec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+serde-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+serde-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+serde-devel.sha256sum] = "2fd86466e77b65766c85e315d15342d753d625eb810055c6fb52e78acf11c8d7"

URI_x86_64_v2_rust-arrayvec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+std-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+std-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+std-devel.sha256sum] = "34d243d0279d56b49b9775ee8df26f8532c0af2636949c5851396bbea109a33a"

URI_x86_64_v2_rust-arrayvec+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec+zeroize-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec+zeroize-devel}"
SRC_URI[x86_64_v2_rust-arrayvec+zeroize-devel.sha256sum] = "1e0e3ad9342588b0693143eba62cdca4148c56cc48a737ddb2bc8ae04fe76329"

URI_x86_64_v2_rust-arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arrayvec-devel-0.7.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arrayvec-devel}"
SRC_URI[x86_64_v2_rust-arrayvec-devel.sha256sum] = "4904c6ededac4dfc03a0e6d71a4f23f0d5fe8e1caf87c8a614ae8e17234f3004"

URI_aarch64_rust-arrayvec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+default-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-arrayvec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+default-devel}"
SRC_URI[aarch64_rust-arrayvec+default-devel.sha256sum] = "48739dccd7b20617007e86c26d08c1b043bd52ba512f2fab920f7c2eda723649"

URI_aarch64_rust-arrayvec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+serde-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-arrayvec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+serde-devel}"
SRC_URI[aarch64_rust-arrayvec+serde-devel.sha256sum] = "6851b9988b9618cc746cba12c53f319bb17ceb1c31a2c2e77087e9deb9bf7e27"

URI_aarch64_rust-arrayvec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+std-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-arrayvec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+std-devel}"
SRC_URI[aarch64_rust-arrayvec+std-devel.sha256sum] = "552267bae512c20e1e2283ed59caaac214dc2f97f3ac95c5061d817e0c488bad"

URI_aarch64_rust-arrayvec+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec+zeroize-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-arrayvec+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec+zeroize-devel}"
SRC_URI[aarch64_rust-arrayvec+zeroize-devel.sha256sum] = "b0225fbf6c9616788d570cc0efc5f21f0c7522ec0f8783dea357472e8db325ee"

URI_aarch64_rust-arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arrayvec-devel-0.7.6-1.el10_0.noarch.rpm;name=aarch64_rust-arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arrayvec-devel}"
SRC_URI[aarch64_rust-arrayvec-devel.sha256sum] = "a5c752046b88bd5e84f426da6d97521255e75a82b92bbc4e814ab72bae584bcb"

RDEPENDS:rust-arrayvec+default-devel = " \
 cargo \
 rust-arrayvec+std-devel \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-arrayvec+serde-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-arrayvec+std-devel = " \
 cargo \
 rust-arrayvec-devel \
 "
RDEPENDS:rust-arrayvec+zeroize-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-arrayvec-devel = " \
 cargo \
 rust \
 "
