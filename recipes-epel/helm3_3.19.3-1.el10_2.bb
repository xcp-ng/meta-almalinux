# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "helm3"
PV = "3.19.3"
PR = "1.el10_2"
PACKAGES = " \
 helm3 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/h/helm3-3.19.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cc92b1bd845c797a42d859ab77cffa0b40ce6553f438a1d84dbe9c3a8b1701a"

URI_x86_64_v2_helm3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/helm3-3.19.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_helm3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_helm3}"
SRC_URI[x86_64_v2_helm3.sha256sum] = "9d46b5dccce82ad784d0f194b6312aac5870a755eaa95e2979de61db45144d6b"

URI_aarch64_helm3 = "${EPEL_MIRROR}/aarch64/Packages/h/helm3-3.19.3-1.el10_2.aarch64.rpm;name=aarch64_helm3;unpack=0"
SRC_URI:append = " ${URI_aarch64_helm3}"
SRC_URI[aarch64_helm3.sha256sum] = "7cf9e618ca08208cac936bd549248c22a90f9fcc419f71fc6be35700563cbf05"

RDEPENDS:helm3 = " \
 glibc \
 "
