# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rayon"
PV = "1.10.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-rayon+default-devel \
 rust-rayon-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rayon-1.10.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "55c5e67b8e4ce96054f8121c5ede7b418040b28c33606fc9559b0a6520b4d985"

URI_x86_64_v2_rust-rayon+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon+default-devel-1.10.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon+default-devel}"
SRC_URI[x86_64_v2_rust-rayon+default-devel.sha256sum] = "476aaa52e4929cefa482553b587473213501d4a3c3d17977beb92797d4ad36b7"

URI_x86_64_v2_rust-rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rayon-devel-1.10.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rayon-devel}"
SRC_URI[x86_64_v2_rust-rayon-devel.sha256sum] = "49e52c8ea886a487b515c989703bee82c0c1758bc8969c0dd70154192ffe8b11"

URI_aarch64_rust-rayon+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon+default-devel-1.10.0-2.el10_0.noarch.rpm;name=aarch64_rust-rayon+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon+default-devel}"
SRC_URI[aarch64_rust-rayon+default-devel.sha256sum] = "a7e7a71c0111f125178d1b8258d2557d4e665b5eb205358929aae31c950c46e3"

URI_aarch64_rust-rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rayon-devel-1.10.0-2.el10_0.noarch.rpm;name=aarch64_rust-rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rayon-devel}"
SRC_URI[aarch64_rust-rayon-devel.sha256sum] = "e81e5a8c7ad6faff9c27a0e643cad52e81d9c4167cb4daa721a8fe8838f8284c"

RDEPENDS:rust-rayon+default-devel = " \
 cargo \
 rust-rayon-devel \
 "
RDEPENDS:rust-rayon-devel = " \
 cargo \
 rust \
 rust-either-devel \
 rust-rayon-core+default-devel \
 "
