# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-httpx"
PV = "0.28.1"
PR = "2.el10_0"
PACKAGES = " \
 python3-httpx \
 python3-httpx+brotli \
 python3-httpx+cli \
 python3-httpx+http2 \
 python3-httpx+socks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-httpx-0.28.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea666dc4d2a8fa5adca3d0404a81881a990f294de75fccd5f223ab306173b443"

URI_x86_64_v2_python3-httpx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx}"
SRC_URI[x86_64_v2_python3-httpx.sha256sum] = "0cdffceab680557eb49b9e29239f9c773e695239c63db97356dd8e67029dec18"

URI_x86_64_v2_python3-httpx+brotli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+brotli-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+brotli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+brotli}"
SRC_URI[x86_64_v2_python3-httpx+brotli.sha256sum] = "cffba9bc8c17cd40a0177877ae36b13f564c4966b6c01a55aec5f2de043376b5"

URI_x86_64_v2_python3-httpx+cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+cli-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+cli}"
SRC_URI[x86_64_v2_python3-httpx+cli.sha256sum] = "12f938b8aad8ef31b971d7c58271b06aa8b30ebfff2bb7850ba3ca7698bab1cb"

URI_x86_64_v2_python3-httpx+http2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+http2-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+http2}"
SRC_URI[x86_64_v2_python3-httpx+http2.sha256sum] = "ffd2b91d5cc39a3bc6e9a419cd5869d0c2da413e2a6e4e553fa396b60c6bb134"

URI_x86_64_v2_python3-httpx+socks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-httpx+socks-0.28.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-httpx+socks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-httpx+socks}"
SRC_URI[x86_64_v2_python3-httpx+socks.sha256sum] = "d5269b5ccbea68ca990e285780906d5bfdaa8c376183c906ee7b51073231147e"

URI_aarch64_python3-httpx = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx-0.28.1-2.el10_0.noarch.rpm;name=aarch64_python3-httpx;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx}"
SRC_URI[aarch64_python3-httpx.sha256sum] = "5d8287174891934666549e0678e3bd67f131c9bfc30d5ee94b788436e36dc7d2"

URI_aarch64_python3-httpx+brotli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+brotli-0.28.1-2.el10_0.noarch.rpm;name=aarch64_python3-httpx+brotli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+brotli}"
SRC_URI[aarch64_python3-httpx+brotli.sha256sum] = "40c75aa501ba4626b0f1b4a9a890093a36ddf5ac3d8f7aa98482186836a2e597"

URI_aarch64_python3-httpx+cli = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+cli-0.28.1-2.el10_0.noarch.rpm;name=aarch64_python3-httpx+cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+cli}"
SRC_URI[aarch64_python3-httpx+cli.sha256sum] = "4857a4540d6c85146bb811a0823deafffbb2d693307a2aa652a22d9dd1c1d4cf"

URI_aarch64_python3-httpx+http2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+http2-0.28.1-2.el10_0.noarch.rpm;name=aarch64_python3-httpx+http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+http2}"
SRC_URI[aarch64_python3-httpx+http2.sha256sum] = "2b163c78092b0018720d741bbda4925ca7f74b8bb0324a43858efa5211e56ea8"

URI_aarch64_python3-httpx+socks = "${EPEL_MIRROR}/aarch64/Packages/p/python3-httpx+socks-0.28.1-2.el10_0.noarch.rpm;name=aarch64_python3-httpx+socks;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-httpx+socks}"
SRC_URI[aarch64_python3-httpx+socks.sha256sum] = "47b7c65df22ffd406b0ad719488b021b5aaea82016bf905b7243078b9f04544f"

RDEPENDS:python3-httpx = " \
 python3 \
 python3-anyio \
 python3-certifi \
 python3-httpcore \
 python3-idna \
 "
RDEPENDS:python3-httpx+brotli = " \
 python3 \
 python3-brotli \
 python3-httpx \
 "
RDEPENDS:python3-httpx+cli = " \
 python3 \
 python3-click \
 python3-httpx \
 python3-pygments \
 python3-rich \
 "
RDEPENDS:python3-httpx+http2 = " \
 python3 \
 python3-h2 \
 python3-httpx \
 "
RDEPENDS:python3-httpx+socks = " \
 python3 \
 python3-httpx \
 python3-socksio \
 "
