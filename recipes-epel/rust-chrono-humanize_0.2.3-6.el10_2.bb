# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-chrono-humanize"
PV = "0.2.3"
PR = "6.el10_2"
PACKAGES = " \
 rust-chrono-humanize+default-devel \
 rust-chrono-humanize+pedantic-devel \
 rust-chrono-humanize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-chrono-humanize-0.2.3-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12072e047f9ced31cdfdc8753a129656afa70e4a4fbcc74c6ac7f5b20b56f0b2"

URI_x86_64_v2_rust-chrono-humanize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-humanize+default-devel-0.2.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-humanize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-humanize+default-devel}"
SRC_URI[x86_64_v2_rust-chrono-humanize+default-devel.sha256sum] = "30b73d740267f6519aa319dd29ded2bdd7b03b37114b252c09d25cf819510aaf"

URI_x86_64_v2_rust-chrono-humanize+pedantic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-humanize+pedantic-devel-0.2.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-humanize+pedantic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-humanize+pedantic-devel}"
SRC_URI[x86_64_v2_rust-chrono-humanize+pedantic-devel.sha256sum] = "f9bc88e42fe116b7be38018a5cd9728996c490293834b0e37544070b971566fa"

URI_x86_64_v2_rust-chrono-humanize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-chrono-humanize-devel-0.2.3-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-chrono-humanize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-chrono-humanize-devel}"
SRC_URI[x86_64_v2_rust-chrono-humanize-devel.sha256sum] = "020c70fbf3dbaae8763a615431fe04d01308c331a116d557042b620ec7c9ef66"

URI_aarch64_rust-chrono-humanize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-humanize+default-devel-0.2.3-6.el10_2.noarch.rpm;name=aarch64_rust-chrono-humanize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-humanize+default-devel}"
SRC_URI[aarch64_rust-chrono-humanize+default-devel.sha256sum] = "5f7c33fb9ad8bcb4e4d05f9fe1dd7039fbdfef66f87189d0d750a025aa5c8bcf"

URI_aarch64_rust-chrono-humanize+pedantic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-humanize+pedantic-devel-0.2.3-6.el10_2.noarch.rpm;name=aarch64_rust-chrono-humanize+pedantic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-humanize+pedantic-devel}"
SRC_URI[aarch64_rust-chrono-humanize+pedantic-devel.sha256sum] = "2970e6a689e5976e060b1795b2cf071fa821e6fb11d00f721107f56361d46d02"

URI_aarch64_rust-chrono-humanize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-chrono-humanize-devel-0.2.3-6.el10_2.noarch.rpm;name=aarch64_rust-chrono-humanize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-chrono-humanize-devel}"
SRC_URI[aarch64_rust-chrono-humanize-devel.sha256sum] = "c36c4382b02caa7eda6e0032ad1b8227f7e72876ba4cf6c611ee4ef06ae98bfc"

RDEPENDS:rust-chrono-humanize+default-devel = " \
 cargo \
 rust-chrono-humanize-devel \
 "
RDEPENDS:rust-chrono-humanize+pedantic-devel = " \
 cargo \
 rust-chrono-humanize-devel \
 "
RDEPENDS:rust-chrono-humanize-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 "
