# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base64_0.13"
PV = "0.13.1"
PR = "5.el10_0"
PACKAGES = " \
 rust-base64_0.13+alloc-devel \
 rust-base64_0.13+default-devel \
 rust-base64_0.13+std-devel \
 rust-base64_0.13-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base64_0.13-0.13.1-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9fe1b8a999a8e239bc9f2953585d00ac0d2b899ad4f4938de5cba02e0658795"

URI_x86_64_v2_rust-base64_0.13+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64_0.13+alloc-devel-0.13.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64_0.13+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64_0.13+alloc-devel}"
SRC_URI[x86_64_v2_rust-base64_0.13+alloc-devel.sha256sum] = "3a3939c71e1bcffecb0f1acc52eeaa0f83fe15a7f697d04964b78b9ff6414486"

URI_x86_64_v2_rust-base64_0.13+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64_0.13+default-devel-0.13.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64_0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64_0.13+default-devel}"
SRC_URI[x86_64_v2_rust-base64_0.13+default-devel.sha256sum] = "938b04f74eb2fb78c9a2589d85c23883aa67bddeba8abfd873f81c22357189cd"

URI_x86_64_v2_rust-base64_0.13+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64_0.13+std-devel-0.13.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64_0.13+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64_0.13+std-devel}"
SRC_URI[x86_64_v2_rust-base64_0.13+std-devel.sha256sum] = "b5ba3ca8666b13503724d8288ea8dfc3ab0f1829bb526e56d391f25fbcac3286"

URI_x86_64_v2_rust-base64_0.13-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base64_0.13-devel-0.13.1-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base64_0.13-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base64_0.13-devel}"
SRC_URI[x86_64_v2_rust-base64_0.13-devel.sha256sum] = "650d58abe357d9264cd0fcd1d518685aa8930dd5ac29b4f79a47218eca5d70af"

URI_aarch64_rust-base64_0.13+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64_0.13+alloc-devel-0.13.1-5.el10_0.noarch.rpm;name=aarch64_rust-base64_0.13+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64_0.13+alloc-devel}"
SRC_URI[aarch64_rust-base64_0.13+alloc-devel.sha256sum] = "513735c0ec51a0af5df7bdf7b4932c19eeaa4deffe3ebbf066ea0ab622ab9775"

URI_aarch64_rust-base64_0.13+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64_0.13+default-devel-0.13.1-5.el10_0.noarch.rpm;name=aarch64_rust-base64_0.13+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64_0.13+default-devel}"
SRC_URI[aarch64_rust-base64_0.13+default-devel.sha256sum] = "15f562973818347acf45e472aa5619964ab74c4f496466fcd2f861e1524660ff"

URI_aarch64_rust-base64_0.13+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64_0.13+std-devel-0.13.1-5.el10_0.noarch.rpm;name=aarch64_rust-base64_0.13+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64_0.13+std-devel}"
SRC_URI[aarch64_rust-base64_0.13+std-devel.sha256sum] = "b09de5e921ce0de402f4ccc7a5323e126e75bf05d360aa68d7bf4511793cf78c"

URI_aarch64_rust-base64_0.13-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base64_0.13-devel-0.13.1-5.el10_0.noarch.rpm;name=aarch64_rust-base64_0.13-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base64_0.13-devel}"
SRC_URI[aarch64_rust-base64_0.13-devel.sha256sum] = "a52aafa396717c6f3396f01eb2e96be9aafc7d6979d48a4fb89d1bb1af2184cc"

RDEPENDS:rust-base64_0.13+alloc-devel = " \
 cargo \
 rust-base64_0.13-devel \
 "
RDEPENDS:rust-base64_0.13+default-devel = " \
 cargo \
 rust-base64_0.13+std-devel \
 rust-base64_0.13-devel \
 "
RDEPENDS:rust-base64_0.13+std-devel = " \
 cargo \
 rust-base64_0.13-devel \
 "
RDEPENDS:rust-base64_0.13-devel = " \
 cargo \
 "
