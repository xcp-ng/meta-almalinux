# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libpaper"
PE = "1"
PV = "2.1.1"
PR = "7.el10"
PACKAGES = " \
 libpaper \
 libpaper-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libpaper-2.1.1-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3329b7ba2af90920fcab5b3a1749adb08196bff3611063669bc8b87312ba0a0e"

URI_x86_64_v2_libpaper = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libpaper-2.1.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_libpaper;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpaper}"
SRC_URI[x86_64_v2_libpaper.sha256sum] = "e7036ef9879114ee94e94a475326043d8dee05066cf7b77d77f63a476beac5d2"

URI_x86_64_v2_libpaper-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libpaper-devel-2.1.1-7.el10.x86_64_v2.rpm;name=x86_64_v2_libpaper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libpaper-devel}"
SRC_URI[x86_64_v2_libpaper-devel.sha256sum] = "ac000109c10ddd3b69d5dcea6c9ab3729f37fb9d9c0615a8b34cf3390835794a"

URI_aarch64_libpaper = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libpaper-2.1.1-7.el10.aarch64.rpm;name=aarch64_libpaper;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpaper}"
SRC_URI[aarch64_libpaper.sha256sum] = "128cb27f0ae2faf8531f8b00f488b49478187a3e0fa5f1aae851f615441d5f59"

URI_aarch64_libpaper-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libpaper-devel-2.1.1-7.el10.aarch64.rpm;name=aarch64_libpaper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpaper-devel}"
SRC_URI[aarch64_libpaper-devel.sha256sum] = "c01d8711a07aafefcd5fada2c201b996070b083901be5df6faf7556ef9e5820f"

RDEPENDS:libpaper = " \
 glibc \
 "
RDEPENDS:libpaper-devel = " \
 libpaper \
 "
