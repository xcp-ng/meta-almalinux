# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "konqueror"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 konqueror \
 konqueror-devel \
 konqueror-libs \
 kwebenginepart \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/konqueror-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2b9f9996024362afb81d0cd20b6e28cc7f5da51c067001601ab5554c2ad72e2"

URI_x86_64_v2_konqueror = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror}"
SRC_URI[x86_64_v2_konqueror.sha256sum] = "fd83e9246621e4b1710ae1ae3abd072ad1264623c964b76cfc1cf45375ab1b67"

URI_x86_64_v2_konqueror-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror-devel}"
SRC_URI[x86_64_v2_konqueror-devel.sha256sum] = "fb71e14ae1fb34aad6adfc40baab73afa7f480e19ee2f0bf7ad30144bde89eea"

URI_x86_64_v2_konqueror-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/konqueror-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_konqueror-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_konqueror-libs}"
SRC_URI[x86_64_v2_konqueror-libs.sha256sum] = "0862218d59f4f662e887c6ba990f26defcc70a99faa4376404df75d1b47dcd83"

URI_x86_64_v2_kwebenginepart = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kwebenginepart-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kwebenginepart;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kwebenginepart}"
SRC_URI[x86_64_v2_kwebenginepart.sha256sum] = "8732b1c0b904c453e4d07d50b4c09abd3a8a3510a6a39a539a70888a7b46e27f"

URI_aarch64_konqueror = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_konqueror;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror}"
SRC_URI[aarch64_konqueror.sha256sum] = "25fc3c58086602f42de20277d21462936afe472f33558118b6f658892e2b2c4e"

URI_aarch64_konqueror-devel = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_konqueror-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror-devel}"
SRC_URI[aarch64_konqueror-devel.sha256sum] = "40484cbd2500cd21c782eab67387a6910bc2c897c01dc49afd03e5a0f1d064cf"

URI_aarch64_konqueror-libs = "${EPEL_MIRROR}/aarch64/Packages/k/konqueror-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_konqueror-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_konqueror-libs}"
SRC_URI[aarch64_konqueror-libs.sha256sum] = "de3962e918b21ed44416e92d530eecc3eee4049cc63fa8c0d7256eed88a8ead3"

URI_aarch64_kwebenginepart = "${EPEL_MIRROR}/aarch64/Packages/k/kwebenginepart-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kwebenginepart;unpack=0"
SRC_URI:append = " ${URI_aarch64_kwebenginepart}"
SRC_URI[aarch64_kwebenginepart.sha256sum] = "42a42d93249fcd00e0a8463273b64a8b9ae58e9c2faee120782499a760c5171a"

RDEPENDS:konqueror = " \
 glibc \
 hicolor-icon-theme \
 keditbookmarks \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 kwebenginepart \
 libstdc++ \
 plasma-activities \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
RDEPENDS:konqueror-devel = " \
 cmake-filesystem \
 konqueror \
 konqueror-libs \
 "
RDEPENDS:konqueror-libs = " \
 glibc \
 kf6-karchive \
 kf6-kbookmarks \
 kf6-kcmutils \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdesu \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-file-widgets \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 konqueror \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 zlib-ng-compat \
 "
RDEPENDS:kwebenginepart = " \
 glibc \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kjobwidgets \
 kf6-kparts \
 kf6-kservice \
 kf6-kwallet-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-sonnet \
 konqueror-libs \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwebengine \
 "
