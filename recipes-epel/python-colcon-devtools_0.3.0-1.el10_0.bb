# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-devtools"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-devtools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-devtools-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b5e9eb96071eec9d3a1f0470d0f440ae3f026cc532d6cbfa46515dbfb2f35fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-devtools-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-devtools;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-devtools.sha256sum] = "779a61ac420fbdf2f7e2cc8d7e3c829e0001cf1fc857ebfd60f747d37a752552"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-devtools-0.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-devtools;unpack=0"
SRC_URI[aarch64_python3-colcon-devtools.sha256sum] = "b95e2ff132120d5a3a8708e98cdcd1881ee704132c921f87856ab56c2d00fbf5"

RDEPENDS:python3-colcon-devtools = " \
 python3 \
 python3-colcon-core \
 python3-packaging \
 "
