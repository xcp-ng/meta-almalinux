# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vte291"
PV = "0.78.6"
PR = "1.el10"
PACKAGES = " \
 vte-profile \
 vte291 \
 vte291-devel \
 vte291-gtk4 \
 vte291-gtk4-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/vte291-0.78.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9cd32f38cd759c62a3c55d89a7b61b7acb3172742b83710d53fb0351546e9c9"

URI_x86_64_v2_vte-profile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte-profile-0.78.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte-profile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte-profile}"
SRC_URI[x86_64_v2_vte-profile.sha256sum] = "d68fd55eca2aa6fd3d3d68511dcce72ab616d9056c181cb46eb68dd2c8fe8216"

URI_x86_64_v2_vte291 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte291-0.78.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291}"
SRC_URI[x86_64_v2_vte291.sha256sum] = "489aa47cf0da56248425bb46a20c456df2b963f59d71622926f9aacc852568a1"

URI_x86_64_v2_vte291-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vte291-devel-0.78.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291-devel}"
SRC_URI[x86_64_v2_vte291-devel.sha256sum] = "af0c310b3c29e7ecebb0506af7933a5ee83c2e0d71ebc7d07ccff9d19f0c6c82"

URI_x86_64_v2_vte291-gtk4 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/vte291-gtk4-0.78.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-gtk4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291-gtk4}"
SRC_URI[x86_64_v2_vte291-gtk4.sha256sum] = "a97eb70090a3bd55a0bf4353146a49b8a57569cb1d6161376ad11e1b9e5b01aa"

URI_x86_64_v2_vte291-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/vte291-gtk4-devel-0.78.6-1.el10.x86_64_v2.rpm;name=x86_64_v2_vte291-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vte291-gtk4-devel}"
SRC_URI[x86_64_v2_vte291-gtk4-devel.sha256sum] = "17e4a46eecc91ae5225706dbf13d8173ee61a80a063ce7dd4c56a3876bef9152"

URI_aarch64_vte-profile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte-profile-0.78.6-1.el10.aarch64.rpm;name=aarch64_vte-profile;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte-profile}"
SRC_URI[aarch64_vte-profile.sha256sum] = "5a55763a85f18d2f70c79b4e135ab5ac3391312e24650cef528e6421b6798a49"

URI_aarch64_vte291 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte291-0.78.6-1.el10.aarch64.rpm;name=aarch64_vte291;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291}"
SRC_URI[aarch64_vte291.sha256sum] = "3ab914a29a274027ef11ce4f5e0188e9d71a99117853b78c6b2a606a0fe2866a"

URI_aarch64_vte291-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vte291-devel-0.78.6-1.el10.aarch64.rpm;name=aarch64_vte291-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291-devel}"
SRC_URI[aarch64_vte291-devel.sha256sum] = "52d431b0f116ba2bcad72a616adbcfe33b6f62a7e2a07bab0c99dccefdc4d0bd"

URI_aarch64_vte291-gtk4 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/vte291-gtk4-0.78.6-1.el10.aarch64.rpm;name=aarch64_vte291-gtk4;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291-gtk4}"
SRC_URI[aarch64_vte291-gtk4.sha256sum] = "9c9444035b330b3ac9ffd34f0b10d802738721224b80f14cb2e65a1c78854edb"

URI_aarch64_vte291-gtk4-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/vte291-gtk4-devel-0.78.6-1.el10.aarch64.rpm;name=aarch64_vte291-gtk4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vte291-gtk4-devel}"
SRC_URI[aarch64_vte291-gtk4-devel.sha256sum] = "8a8198c25f893a5beb2743c9496fd246f2aba8b70ab0b2cfab116f83f99171c4"

RDEPENDS:vte-profile = " \
 glibc \
 "
RDEPENDS:vte291 = " \
 atk \
 cairo \
 cairo-gobject \
 fribidi \
 glib2 \
 glibc \
 gnutls \
 gtk3 \
 libgcc \
 libicu \
 libstdc++ \
 lz4-libs \
 pango \
 pcre2 \
 systemd-libs \
 vte-profile \
 "
RDEPENDS:vte291-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 gtk3 \
 gtk3-devel \
 libgcc \
 libstdc++ \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vte291 \
 "
RDEPENDS:vte291-gtk4 = " \
 cairo \
 cairo-gobject \
 fribidi \
 glib2 \
 glibc \
 gnutls \
 graphene \
 gtk4 \
 libgcc \
 libicu \
 libstdc++ \
 lz4-libs \
 pango \
 pcre2 \
 systemd-libs \
 vte291 \
 "
RDEPENDS:vte291-gtk4-devel = " \
 cairo \
 cairo-devel \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glib2-devel \
 glibc \
 gtk4 \
 gtk4-devel \
 libgcc \
 libstdc++ \
 pango \
 pango-devel \
 pkgconf-pkg-config \
 vte291-devel \
 vte291-gtk4 \
 "
