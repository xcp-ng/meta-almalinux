# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-futures-macro"
PV = "0.3.33"
PR = "1.el10_3"
PACKAGES = " \
 rust-futures-macro+default-devel \
 rust-futures-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-futures-macro-0.3.33-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a49a88ca78b2d0e5aac438d502ce44de0abff476add032bca7e847c6ffb4b80"

URI_x86_64_v2_rust-futures-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-macro+default-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-macro+default-devel}"
SRC_URI[x86_64_v2_rust-futures-macro+default-devel.sha256sum] = "e645ad08b4acca13637c6821dfd23234fbed07010ad4a1e889f00e6abd4fbab8"

URI_x86_64_v2_rust-futures-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-futures-macro-devel-0.3.33-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-futures-macro-devel}"
SRC_URI[x86_64_v2_rust-futures-macro-devel.sha256sum] = "f88e46870282f9054fbe3cd012e4d438111e4503f131d0d934058315d6f5ef9f"

URI_aarch64_rust-futures-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-macro+default-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-macro+default-devel}"
SRC_URI[aarch64_rust-futures-macro+default-devel.sha256sum] = "331c4252e13377fc5619acfe9b0f129f162a5ace4992906a5a8ddd18b9f8dd7a"

URI_aarch64_rust-futures-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-futures-macro-devel-0.3.33-1.el10_3.noarch.rpm;name=aarch64_rust-futures-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-futures-macro-devel}"
SRC_URI[aarch64_rust-futures-macro-devel.sha256sum] = "655aad88240ddb9781997243615e2c9a5823ac0f03781c04b935a7d8fa5402d6"

RDEPENDS:rust-futures-macro+default-devel = " \
 cargo \
 rust-futures-macro-devel \
 "
RDEPENDS:rust-futures-macro-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+full-devel \
 "
