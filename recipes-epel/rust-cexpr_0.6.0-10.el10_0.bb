# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cexpr"
PV = "0.6.0"
PR = "10.el10_0"
PACKAGES = " \
 rust-cexpr+default-devel \
 rust-cexpr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cexpr-0.6.0-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "038f7d13a85a568fbe2fbf375233731090360e47d32e4b4601b6f465c2d37273"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cexpr+default-devel-0.6.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cexpr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cexpr+default-devel.sha256sum] = "706b69b618157f595ad651b65bbed43f08eae29a0b7f2911d416dca18cb2c7b7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cexpr-devel-0.6.0-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cexpr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cexpr-devel.sha256sum] = "6809b21c9d9bf26d95fbc87c446c5ab15343c7397ec4bb872e9a1e28287cc8d5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cexpr+default-devel-0.6.0-10.el10_0.noarch.rpm;name=aarch64_rust-cexpr+default-devel;unpack=0"
SRC_URI[aarch64_rust-cexpr+default-devel.sha256sum] = "f63d0fcf43a91add0e19e964e2dc7dd948d840d44fa20f2b73e4858b163f6a76"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cexpr-devel-0.6.0-10.el10_0.noarch.rpm;name=aarch64_rust-cexpr-devel;unpack=0"
SRC_URI[aarch64_rust-cexpr-devel.sha256sum] = "4c84806d7cf414cb98df88e53883efc16ecf69d466a5993910517c13388049cb"

RDEPENDS:rust-cexpr+default-devel = " \
 cargo \
 rust-cexpr-devel \
 "
RDEPENDS:rust-cexpr-devel = " \
 cargo \
 rust-nom+std-devel \
 rust-nom-devel \
 "
