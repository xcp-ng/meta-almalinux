# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libusb-compat-0.1"
PV = "0.1.9"
PR = "1.el10_3"
PACKAGES = " \
 libusb-compat-0.1 \
 libusb-compat-0.1-devel \
 libusb-compat-0.1-tests-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libusb-compat-0.1-0.1.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e9311aa0d60864b589ae4d6223e4d4c83e4953e1399f498684ff63aceb9d88a"

URI_x86_64_v2_libusb-compat-0.1 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusb-compat-0.1-0.1.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusb-compat-0.1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb-compat-0.1}"
SRC_URI[x86_64_v2_libusb-compat-0.1.sha256sum] = "42e73fd01b9121508b773af430b24dec3c0cd86d7f6c78657719dadd4c575f60"

URI_x86_64_v2_libusb-compat-0.1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusb-compat-0.1-devel-0.1.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusb-compat-0.1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb-compat-0.1-devel}"
SRC_URI[x86_64_v2_libusb-compat-0.1-devel.sha256sum] = "747a423f3a763b6e2a75ec1276897c045dfc23adada4638f2b3dc7fdecf091c0"

URI_x86_64_v2_libusb-compat-0.1-tests-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libusb-compat-0.1-tests-examples-0.1.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libusb-compat-0.1-tests-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libusb-compat-0.1-tests-examples}"
SRC_URI[x86_64_v2_libusb-compat-0.1-tests-examples.sha256sum] = "da29f8ce870f77cea0a40ed84a606e8bdc68cc6990b50f6497900b14c7dd5973"

URI_aarch64_libusb-compat-0.1 = "${EPEL_MIRROR}/aarch64/Packages/l/libusb-compat-0.1-0.1.9-1.el10_3.aarch64.rpm;name=aarch64_libusb-compat-0.1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb-compat-0.1}"
SRC_URI[aarch64_libusb-compat-0.1.sha256sum] = "5351d56d2e4651714fac81d77932da267ca502dadb142118b8f1ba31ffb82edb"

URI_aarch64_libusb-compat-0.1-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libusb-compat-0.1-devel-0.1.9-1.el10_3.aarch64.rpm;name=aarch64_libusb-compat-0.1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb-compat-0.1-devel}"
SRC_URI[aarch64_libusb-compat-0.1-devel.sha256sum] = "126c25b532ed4a0ed4ee564896d5b8b22f6eef0737dd60969256fa35ced73a53"

URI_aarch64_libusb-compat-0.1-tests-examples = "${EPEL_MIRROR}/aarch64/Packages/l/libusb-compat-0.1-tests-examples-0.1.9-1.el10_3.aarch64.rpm;name=aarch64_libusb-compat-0.1-tests-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_libusb-compat-0.1-tests-examples}"
SRC_URI[aarch64_libusb-compat-0.1-tests-examples.sha256sum] = "7e533e66d10ead88980dac16baf196da1a660ca45501b4e2b7dfa855440dce38"

RDEPENDS:libusb-compat-0.1 = " \
 glibc \
 libusb1 \
 "
RDEPENDS:libusb-compat-0.1-devel = " \
 bash \
 libusb-compat-0.1 \
 libusb1-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libusb-compat-0.1-tests-examples = " \
 glibc \
 libusb-compat-0.1 \
 "
