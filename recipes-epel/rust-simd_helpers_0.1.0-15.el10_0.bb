# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-simd_helpers"
PV = "0.1.0"
PR = "15.el10_0"
PACKAGES = " \
 rust-simd_helpers+default-devel \
 rust-simd_helpers-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-simd_helpers-0.1.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "005396cf042d413b56221dc9aaf9c79e6dd5f77ae045539bc69145fc19263547"

URI_x86_64_v2_rust-simd_helpers+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd_helpers+default-devel-0.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd_helpers+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd_helpers+default-devel}"
SRC_URI[x86_64_v2_rust-simd_helpers+default-devel.sha256sum] = "2cb81c800c5b8c0f971a79f3bec4cf6711b91ef8c2744bbae82eb33c9d17229f"

URI_x86_64_v2_rust-simd_helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-simd_helpers-devel-0.1.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-simd_helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-simd_helpers-devel}"
SRC_URI[x86_64_v2_rust-simd_helpers-devel.sha256sum] = "abfb5ebe3af0e0e41bb78989acb187cea66991c06077e751e504a4db5256d292"

URI_aarch64_rust-simd_helpers+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd_helpers+default-devel-0.1.0-15.el10_0.noarch.rpm;name=aarch64_rust-simd_helpers+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd_helpers+default-devel}"
SRC_URI[aarch64_rust-simd_helpers+default-devel.sha256sum] = "fa90f9832a83cbdbd5694665775ec85bfbe8303c3f370537a666a5bf1073567f"

URI_aarch64_rust-simd_helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-simd_helpers-devel-0.1.0-15.el10_0.noarch.rpm;name=aarch64_rust-simd_helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-simd_helpers-devel}"
SRC_URI[aarch64_rust-simd_helpers-devel.sha256sum] = "deb67801dff276822c8c0f35c848b5121dc883892a2428696fe123ef9fead5a0"

RDEPENDS:rust-simd_helpers+default-devel = " \
 cargo \
 rust-simd_helpers-devel \
 "
RDEPENDS:rust-simd_helpers-devel = " \
 cargo \
 rust-quote+default-devel \
 "
