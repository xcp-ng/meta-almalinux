# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-python-ulid"
PV = "3.2.1"
PR = "1.el10_3"
PACKAGES = " \
 python3-python-ulid \
 python3-python-ulid+pydantic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-python-ulid-3.2.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "49e8cc0bb21319e7dd784d17284b28f368a874dd8af04358da69fdd462867aeb"

URI_x86_64_v2_python3-python-ulid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-ulid-3.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-ulid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-ulid}"
SRC_URI[x86_64_v2_python3-python-ulid.sha256sum] = "2eed7f4eee418cd92660973bd5c335a4339bb6b8cf8d6fa2812ba1b791d3f956"

URI_x86_64_v2_python3-python-ulid+pydantic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-python-ulid+pydantic-3.2.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-python-ulid+pydantic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-python-ulid+pydantic}"
SRC_URI[x86_64_v2_python3-python-ulid+pydantic.sha256sum] = "70f16a49b96d12299b77a9f98f4caa55f9e581b04b8b0de4b85c30b4e9bdbeaa"

URI_aarch64_python3-python-ulid = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-ulid-3.2.1-1.el10_3.noarch.rpm;name=aarch64_python3-python-ulid;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-ulid}"
SRC_URI[aarch64_python3-python-ulid.sha256sum] = "7049227b936309ebecb112e485b03bf61c7f74b1a737b9e9add693f3a4e65f4a"

URI_aarch64_python3-python-ulid+pydantic = "${EPEL_MIRROR}/aarch64/Packages/p/python3-python-ulid+pydantic-3.2.1-1.el10_3.noarch.rpm;name=aarch64_python3-python-ulid+pydantic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-python-ulid+pydantic}"
SRC_URI[aarch64_python3-python-ulid+pydantic.sha256sum] = "0891bf7870825fef41927c973116f59f9e1e0503ad972b6100cc4038c06e7b49"

RDEPENDS:python3-python-ulid = " \
 python3 \
 "
RDEPENDS:python3-python-ulid+pydantic = " \
 python3 \
 python3-pydantic \
 python3-python-ulid \
 "
