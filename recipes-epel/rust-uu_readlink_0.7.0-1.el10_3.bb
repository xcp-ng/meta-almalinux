# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_readlink"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_readlink+default-devel \
 rust-uu_readlink-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_readlink-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "987a3592c17793f3d904882c3e5c2bb44ed98f497a6dd65c15f20086f1ab1493"

URI_x86_64_v2_rust-uu_readlink+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_readlink+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_readlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_readlink+default-devel}"
SRC_URI[x86_64_v2_rust-uu_readlink+default-devel.sha256sum] = "37c797514ef0689caf7afa92d18bdac4e699c4d240373764f53070dccd2963ca"

URI_x86_64_v2_rust-uu_readlink-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_readlink-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_readlink-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_readlink-devel}"
SRC_URI[x86_64_v2_rust-uu_readlink-devel.sha256sum] = "da3262ffa811b6f8d9815791de5bce980554d4aebcaea5ad4c8fa9ad9c32e07d"

URI_aarch64_rust-uu_readlink+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_readlink+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_readlink+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_readlink+default-devel}"
SRC_URI[aarch64_rust-uu_readlink+default-devel.sha256sum] = "016911ea7ba372ef55578375eac7846e0e1475da70cf5d3fc74a81afb842487c"

URI_aarch64_rust-uu_readlink-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_readlink-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_readlink-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_readlink-devel}"
SRC_URI[aarch64_rust-uu_readlink-devel.sha256sum] = "13e5954ae552b0ab56152f9d8ec8b705d6e6761809a9fe28709cc1dfa080302a"

RDEPENDS:rust-uu_readlink+default-devel = " \
 cargo \
 rust-uu_readlink-devel \
 "
RDEPENDS:rust-uu_readlink-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 "
