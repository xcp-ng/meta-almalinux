# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Gtk3-ImageView"
PV = "12"
PR = "3.el10_2"
PACKAGES = " \
 perl-Gtk3-ImageView \
 perl-Gtk3-ImageView-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Gtk3-ImageView-12-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "054f5847729f7f5fcf7c3a749408411831c49e5a9b25782a8080155eae4b30d5"

URI_x86_64_v2_perl-Gtk3-ImageView = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-ImageView-12-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-ImageView;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-ImageView}"
SRC_URI[x86_64_v2_perl-Gtk3-ImageView.sha256sum] = "043bd56a6a694591066a441d7e37022540798dc5159969b70436234fc2c544fd"

URI_x86_64_v2_perl-Gtk3-ImageView-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Gtk3-ImageView-tests-12-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Gtk3-ImageView-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Gtk3-ImageView-tests}"
SRC_URI[x86_64_v2_perl-Gtk3-ImageView-tests.sha256sum] = "1056e4aab156b938426cbbe377575851235c1710360e3037ee0eef841bf00d80"

URI_aarch64_perl-Gtk3-ImageView = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-ImageView-12-3.el10_2.noarch.rpm;name=aarch64_perl-Gtk3-ImageView;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-ImageView}"
SRC_URI[aarch64_perl-Gtk3-ImageView.sha256sum] = "be98300408fe456459da6a5b2d9545a7a28b9a17cea6261bfd8d4d7ddb24b6a6"

URI_aarch64_perl-Gtk3-ImageView-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Gtk3-ImageView-tests-12-3.el10_2.noarch.rpm;name=aarch64_perl-Gtk3-ImageView-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Gtk3-ImageView-tests}"
SRC_URI[aarch64_perl-Gtk3-ImageView-tests.sha256sum] = "1c7645e37532a4306a20aa7176412b8f4d403c245998a18b57a2575437df3a8a"

RDEPENDS:perl-Gtk3-ImageView = " \
 perl-Cairo \
 perl-Carp \
 perl-Glib \
 perl-Gtk3 \
 perl-Gtk3-ImageView \
 perl-Readonly \
 perl-Scalar-List-Utils \
 perl-base \
 perl-if \
 perl-libs \
 "
RDEPENDS:perl-Gtk3-ImageView-tests = " \
 ImageMagick-perl \
 bash \
 mutter \
 perl-Carp-Always \
 perl-ExtUtils-MakeMaker \
 perl-File-Temp \
 perl-Glib \
 perl-Gtk3 \
 perl-Gtk3-ImageView \
 perl-MIME-Base64 \
 perl-PathTools \
 perl-Test-Deep \
 perl-Test-Harness \
 perl-Test-MockObject \
 perl-Test-Simple \
 perl-Try-Tiny \
 perl-interpreter \
 perl-libs \
 virtual/coreutils \
 xwayland-run \
 "
