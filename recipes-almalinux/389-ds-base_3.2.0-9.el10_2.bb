# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "389-ds-base"
PV = "3.2.0"
PR = "9.el10_2"
PACKAGES = " \
 389-ds-base \
 389-ds-base-bdb \
 389-ds-base-devel \
 389-ds-base-libs \
 389-ds-base-snmp \
 python3-lib389 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/389-ds-base-3.2.0-9.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff6df6201345327da7fc31f2ba12f72ee300580f2f11493fa0dfd7a715c594f2"

URI_x86_64_v2_389-ds-base = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-3.2.0-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base}"
SRC_URI[x86_64_v2_389-ds-base.sha256sum] = "b889759e1f8d5ef1528619138f5dae6348802a208ceb8f8eca0704a60b9e665e"

URI_x86_64_v2_389-ds-base-bdb = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-bdb-3.2.0-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-bdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-bdb}"
SRC_URI[x86_64_v2_389-ds-base-bdb.sha256sum] = "c82cfb57b5b804049f30d5bdaf01350dc00f00749b352b411a35c44414022804"

URI_x86_64_v2_389-ds-base-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/389-ds-base-devel-3.2.0-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-devel}"
SRC_URI[x86_64_v2_389-ds-base-devel.sha256sum] = "d661d2dc53a83f923ca4d5dd744ef3503f7d2ad5dd48b51aa929cf802b1f1684"

URI_x86_64_v2_389-ds-base-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-libs-3.2.0-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-libs}"
SRC_URI[x86_64_v2_389-ds-base-libs.sha256sum] = "bf02666432177b282009d7e4b6648e2477416a048465552a82610f8a8350bd6b"

URI_x86_64_v2_389-ds-base-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/389-ds-base-snmp-3.2.0-9.el10_2.x86_64_v2.rpm;name=x86_64_v2_389-ds-base-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_389-ds-base-snmp}"
SRC_URI[x86_64_v2_389-ds-base-snmp.sha256sum] = "115cd522eb964d0f493910cc0dd5587dba6e471945baf3c8c1dd9b0542ec2346"

URI_x86_64_v2_python3-lib389 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-lib389-3.2.0-9.el10_2.noarch.rpm;name=x86_64_v2_python3-lib389;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-lib389}"
SRC_URI[x86_64_v2_python3-lib389.sha256sum] = "27cf3e06e99257f4c51c72088b1f9e5f48d590b294e516768385c0f484ac53a2"

URI_aarch64_389-ds-base = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-3.2.0-9.el10_2.aarch64.rpm;name=aarch64_389-ds-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base}"
SRC_URI[aarch64_389-ds-base.sha256sum] = "4a8dd3fde6ef2a85e4863e0f96a5373530b21de0529dd0e2fde27165d8612c06"

URI_aarch64_389-ds-base-bdb = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-bdb-3.2.0-9.el10_2.aarch64.rpm;name=aarch64_389-ds-base-bdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-bdb}"
SRC_URI[aarch64_389-ds-base-bdb.sha256sum] = "01c142c097940ab8992fd12e7dafe6e996929ba729528e4a138d6c4e02f19430"

URI_aarch64_389-ds-base-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/389-ds-base-devel-3.2.0-9.el10_2.aarch64.rpm;name=aarch64_389-ds-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-devel}"
SRC_URI[aarch64_389-ds-base-devel.sha256sum] = "04c3dd5d4e3a78c2216bf63f0f3e6c28285d3a43fead3aa448fea7d6ec6981dd"

URI_aarch64_389-ds-base-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-libs-3.2.0-9.el10_2.aarch64.rpm;name=aarch64_389-ds-base-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-libs}"
SRC_URI[aarch64_389-ds-base-libs.sha256sum] = "62a5e76842e95e60efc9902c80d50e66fb6458d5f05c6bcc86a56fc3fb03163a"

URI_aarch64_389-ds-base-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/389-ds-base-snmp-3.2.0-9.el10_2.aarch64.rpm;name=aarch64_389-ds-base-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_389-ds-base-snmp}"
SRC_URI[aarch64_389-ds-base-snmp.sha256sum] = "1614ba50ec72223d40e0c8fb858260855b9f573452c652b520b47124ed24a2af"

URI_aarch64_python3-lib389 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-lib389-3.2.0-9.el10_2.noarch.rpm;name=aarch64_python3-lib389;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-lib389}"
SRC_URI[aarch64_python3-lib389.sha256sum] = "27cf3e06e99257f4c51c72088b1f9e5f48d590b294e516768385c0f484ac53a2"

RDEPENDS:389-ds-base = " \
 389-ds-base-libs \
 acl \
 bash \
 cracklib \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 cyrus-sasl-lib \
 cyrus-sasl-md5 \
 cyrus-sasl-plain \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libicu \
 libstdc++ \
 libxcrypt \
 lmdb-libs \
 nspr \
 nss \
 nss-tools \
 nss-util \
 openldap \
 openldap-clients \
 openssl-libs \
 pam-libs \
 pcre2 \
 perl-Archive-Tar \
 perl-debugger \
 perl-interpreter \
 perl-sigtrap \
 policycoreutils-python-utils \
 python3 \
 python3-file-magic \
 python3-lib389 \
 python3-libsemanage \
 shadow-utils \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:389-ds-base-bdb = " \
 389-ds-base \
 389-ds-base-libs \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 lmdb-libs \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-devel = " \
 389-ds-base-libs \
 nspr-devel \
 nss-devel \
 openldap-devel \
 pkgconf-pkg-config \
 systemd-libs \
 "
RDEPENDS:389-ds-base-libs = " \
 cracklib \
 cyrus-sasl-lib \
 glibc \
 json-c \
 krb5-libs \
 libcom_err \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 nss-util \
 openldap \
 openssl-libs \
 pcre2 \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:389-ds-base-snmp = " \
 389-ds-base \
 bash \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 nspr \
 openldap \
 "
RDEPENDS:python3-lib389 = " \
 389-ds-base \
 iproute \
 openssl \
 openssl-perl \
 python3 \
 python3-argcomplete \
 python3-cryptography \
 python3-dateutil \
 python3-distro \
 python3-ldap \
 python3-libselinux \
 python3-psutil \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-setuptools \
 "
