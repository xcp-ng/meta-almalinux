# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-formencode"
PV = "2.1.0"
PR = "6.el10_0"
PACKAGES = " \
 python-formencode-langpacks \
 python3-formencode \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-formencode-2.1.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "eb600ca73c23f7d611a69163d5e347fccd1f8fb72568f7ee379cdd40afbe5041"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-formencode-langpacks-2.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-formencode-langpacks;unpack=0"
SRC_URI[x86_64_v2_python-formencode-langpacks.sha256sum] = "22c8219af3d909b953785b6de0413223e161f50579917d2175e9859bcca1918c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-formencode-2.1.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-formencode;unpack=0"
SRC_URI[x86_64_v2_python3-formencode.sha256sum] = "d244eda03facfe343720ea35c4ea2ae02a24edca3ba084b029b5e0a3de9fcc86"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-formencode-langpacks-2.1.0-6.el10_0.noarch.rpm;name=aarch64_python-formencode-langpacks;unpack=0"
SRC_URI[aarch64_python-formencode-langpacks.sha256sum] = "0005a4db24cd921be1d409a169ac6a52db7f1ede6f54a7d9b667939b3183f464"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-formencode-2.1.0-6.el10_0.noarch.rpm;name=aarch64_python3-formencode;unpack=0"
SRC_URI[aarch64_python3-formencode.sha256sum] = "699ed326ccd4320f84c542e700aa773b40534a6d030c959aa543ecee4441f500"

RDEPENDS:python-formencode-langpacks = " \
 "
RDEPENDS:python3-formencode = " \
 python-formencode-langpacks \
 python3 \
 python3-setuptools \
 "
