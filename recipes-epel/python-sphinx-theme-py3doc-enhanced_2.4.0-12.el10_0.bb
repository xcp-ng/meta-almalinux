# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-theme-py3doc-enhanced"
PV = "2.4.0"
PR = "12.el10_0"
PACKAGES = " \
 python3-sphinx-theme-py3doc-enhanced \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-sphinx-theme-py3doc-enhanced-2.4.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee97992d2b5cde81e8df9742cf8c768f61c877475cae06316f507e098e5e88f0"

URI_x86_64_v2_python3-sphinx-theme-py3doc-enhanced = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-sphinx-theme-py3doc-enhanced-2.4.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-sphinx-theme-py3doc-enhanced;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-theme-py3doc-enhanced}"
SRC_URI[x86_64_v2_python3-sphinx-theme-py3doc-enhanced.sha256sum] = "73308651d39971725b18e255a6b23e861fa0b09d9c2e137add534cd66c669014"

URI_aarch64_python3-sphinx-theme-py3doc-enhanced = "${EPEL_MIRROR}/aarch64/Packages/p/python3-sphinx-theme-py3doc-enhanced-2.4.0-12.el10_0.noarch.rpm;name=aarch64_python3-sphinx-theme-py3doc-enhanced;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-theme-py3doc-enhanced}"
SRC_URI[aarch64_python3-sphinx-theme-py3doc-enhanced.sha256sum] = "19b327ad9292192f66e70b8334800c9faba1df3c87575f99f25ccf5c84700ab4"

RDEPENDS:python3-sphinx-theme-py3doc-enhanced = " \
 python3 \
 "
