# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libdeflate"
PV = "1.25"
PR = "2.el10_0"
PACKAGES = " \
 libdeflate \
 libdeflate-devel \
 libdeflate-utils \
 mingw32-libdeflate \
 mingw32-libdeflate-utils \
 mingw64-libdeflate \
 mingw64-libdeflate-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libdeflate-1.25-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c5d0d89d3ffbc0873699e2394013402996b77a5fb81b32c400358040f31f0d2f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-1.25-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate;unpack=0"
SRC_URI[x86_64_v2_libdeflate.sha256sum] = "4f6d7bedd715afc294433c788821eee9c7c07823de2f5eb7355fa3a2cced120e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-devel-1.25-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate-devel;unpack=0"
SRC_URI[x86_64_v2_libdeflate-devel.sha256sum] = "b53a2c7a92883ff7c4358ad1bf47b01fbe45033bbb02d84b2f778c8d39994ffd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libdeflate-utils-1.25-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libdeflate-utils;unpack=0"
SRC_URI[x86_64_v2_libdeflate-utils.sha256sum] = "348e5b02d27c4828f6db862f69600fbcdb49bd96392ea982d3457eed2b3ce64a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libdeflate-1.25-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libdeflate;unpack=0"
SRC_URI[x86_64_v2_mingw32-libdeflate.sha256sum] = "22eab777896ff45fc33857a1cfe3b606f58b3ac81c968feaf839f776f51245ec"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw32-libdeflate-utils-1.25-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw32-libdeflate-utils;unpack=0"
SRC_URI[x86_64_v2_mingw32-libdeflate-utils.sha256sum] = "ae96e84aa44c79df5afae2e90ad52412fe2ca5d109a31af6b3987abbb8b72750"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libdeflate-1.25-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libdeflate;unpack=0"
SRC_URI[x86_64_v2_mingw64-libdeflate.sha256sum] = "620f9ded665c6d73e290b4def6a05f1de034e7810e0301ba3467b4103dede6ad"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mingw64-libdeflate-utils-1.25-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_mingw64-libdeflate-utils;unpack=0"
SRC_URI[x86_64_v2_mingw64-libdeflate-utils.sha256sum] = "ca15a7c6e34a7e3299212894f8d8d5d37537f708cec17c585874d083f7ac3d1f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-1.25-2.el10_0.aarch64.rpm;name=aarch64_libdeflate;unpack=0"
SRC_URI[aarch64_libdeflate.sha256sum] = "8b4a763326fe7445696b750db0dc3ef8bfaf68c00dd805eb955fcc3bf4d75e70"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-devel-1.25-2.el10_0.aarch64.rpm;name=aarch64_libdeflate-devel;unpack=0"
SRC_URI[aarch64_libdeflate-devel.sha256sum] = "f3ed6c48ae8c18181c631cd9c6594c1593b7ace098a19b61444d77c37a7d7d0a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libdeflate-utils-1.25-2.el10_0.aarch64.rpm;name=aarch64_libdeflate-utils;unpack=0"
SRC_URI[aarch64_libdeflate-utils.sha256sum] = "c3441f582ff249dd61852bce86bc12e6ca0b304a4e8882dd38d938de1067209e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mingw32-libdeflate-1.25-2.el10_0.noarch.rpm;name=aarch64_mingw32-libdeflate;unpack=0"
SRC_URI[aarch64_mingw32-libdeflate.sha256sum] = "70f25ed6787f78032dccb9c78e5ec042309b5d06bebdcfa6f3b69f05b7c367fa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mingw32-libdeflate-utils-1.25-2.el10_0.noarch.rpm;name=aarch64_mingw32-libdeflate-utils;unpack=0"
SRC_URI[aarch64_mingw32-libdeflate-utils.sha256sum] = "fe7e07406d308bc38fbc8a9a08769563da47a7aa6438da3910ee871fb5d9a10b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mingw64-libdeflate-1.25-2.el10_0.noarch.rpm;name=aarch64_mingw64-libdeflate;unpack=0"
SRC_URI[aarch64_mingw64-libdeflate.sha256sum] = "26d1fe59b0678ef8c83dc98a6699c528740d8d1d66f32c23e640f6094a4d6d42"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mingw64-libdeflate-utils-1.25-2.el10_0.noarch.rpm;name=aarch64_mingw64-libdeflate-utils;unpack=0"
SRC_URI[aarch64_mingw64-libdeflate-utils.sha256sum] = "94c77374b91d67f91162e7391283b9580d42e5e45ec1d290eed481e66f9dec92"

RDEPENDS:libdeflate = " \
 glibc \
 "
RDEPENDS:libdeflate-devel = " \
 cmake-filesystem \
 libdeflate \
 pkgconf-pkg-config \
 "
RDEPENDS:libdeflate-utils = " \
 glibc \
 libdeflate \
 "
RDEPENDS:mingw32-libdeflate = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw32-libdeflate-utils = " \
 mingw32-crt \
 mingw32-filesystem \
 mingw32-libdeflate \
 "
RDEPENDS:mingw64-libdeflate = " \
 mingw64-crt \
 mingw64-filesystem \
 "
RDEPENDS:mingw64-libdeflate-utils = " \
 mingw64-crt \
 mingw64-filesystem \
 mingw64-libdeflate \
 "
