# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-DBI"
PV = "3.0.17"
PR = "54.el10_3"
PACKAGES = " \
 perl-Class-DBI \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Class-DBI-3.0.17-54.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "039bdfcaa500735efef0dec5040aa840f938de0ad549fa89ff7faa960ab735eb"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-DBI-3.0.17-54.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-DBI;unpack=0"
SRC_URI[x86_64_v2_perl-Class-DBI.sha256sum] = "92697db7118fb50f9b6a2536eddb73ac9eaa62a01d666119bd4a8121ee9e5e77"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-DBI-3.0.17-54.el10_3.noarch.rpm;name=aarch64_perl-Class-DBI;unpack=0"
SRC_URI[aarch64_perl-Class-DBI.sha256sum] = "733250e483be2175e0f067ad7902f068cc27927ca4b610daaf323973c3e28117"

RDEPENDS:perl-Class-DBI = " \
 perl-Carp \
 perl-Class-Accessor \
 perl-Class-DBI \
 perl-Class-Data-Inheritable \
 perl-Class-Trigger \
 perl-Clone \
 perl-File-Temp \
 perl-Ima-DBI \
 perl-Scalar-List-Utils \
 perl-Storable \
 perl-UNIVERSAL-moniker \
 perl-base \
 perl-libs \
 perl-overload \
 perl-vars \
 perl-version \
 "
