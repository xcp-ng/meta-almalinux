# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ff"
PV = "0.13.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-ff+alloc-devel \
 rust-ff+bits-devel \
 rust-ff+bitvec-devel \
 rust-ff+byteorder-devel \
 rust-ff+default-devel \
 rust-ff+std-devel \
 rust-ff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ff-0.13.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c8e8ce28881e75cab22b7366cd283e3f4bb3e071c95565ec2270d321db0c8d8"

URI_x86_64_v2_rust-ff+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+alloc-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+alloc-devel}"
SRC_URI[x86_64_v2_rust-ff+alloc-devel.sha256sum] = "80126744b0cb3e938bf8690c20ba06b87c6b308712b2706edcbc8f961f486fc1"

URI_x86_64_v2_rust-ff+bits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+bits-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+bits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+bits-devel}"
SRC_URI[x86_64_v2_rust-ff+bits-devel.sha256sum] = "62f9d4956d61111ee1ed012cf0b8089c8f2b5f9f54a805ceb8bbea3dece6812f"

URI_x86_64_v2_rust-ff+bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+bitvec-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+bitvec-devel}"
SRC_URI[x86_64_v2_rust-ff+bitvec-devel.sha256sum] = "301e920f7f8b45c6dcc33912ea69aed5f69fc875bf1251c0643e2f1de37e7230"

URI_x86_64_v2_rust-ff+byteorder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+byteorder-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+byteorder-devel}"
SRC_URI[x86_64_v2_rust-ff+byteorder-devel.sha256sum] = "aa9278cc9278bb2c8eadb0a592be61a689e36e00b9227f2afc46721d4ea0889e"

URI_x86_64_v2_rust-ff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+default-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+default-devel}"
SRC_URI[x86_64_v2_rust-ff+default-devel.sha256sum] = "28ce1412191bc5e4b4a2e614cb291f9a2f57fceac7c7fe626e33444b8073d332"

URI_x86_64_v2_rust-ff+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+std-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+std-devel}"
SRC_URI[x86_64_v2_rust-ff+std-devel.sha256sum] = "6f33a8fbfb64b0e4bfb5e18603fe07dc5bfd227380f4f4d82cb0e9992a29157d"

URI_x86_64_v2_rust-ff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff-devel-0.13.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff-devel}"
SRC_URI[x86_64_v2_rust-ff-devel.sha256sum] = "f2259c4abe47765fbe3dd88a5200666448ff6b69de519793429a7e02bf4aeccd"

URI_aarch64_rust-ff+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+alloc-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-ff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+alloc-devel}"
SRC_URI[aarch64_rust-ff+alloc-devel.sha256sum] = "c3ddb5593cd2c5343435f7c6c73191c9d28e289ae198ca72f6583e98314dfa3a"

URI_aarch64_rust-ff+bits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+bits-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-ff+bits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+bits-devel}"
SRC_URI[aarch64_rust-ff+bits-devel.sha256sum] = "d8bfb6371df2af21898a3a79da5bead1bd8e15a3925fdd61e8a1029650bd68d1"

URI_aarch64_rust-ff+bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+bitvec-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-ff+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+bitvec-devel}"
SRC_URI[aarch64_rust-ff+bitvec-devel.sha256sum] = "036e21d60fb34dd504af46c1b48f6790b48d4420c05095c87b6b2a1e90c92789"

URI_aarch64_rust-ff+byteorder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+byteorder-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-ff+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+byteorder-devel}"
SRC_URI[aarch64_rust-ff+byteorder-devel.sha256sum] = "66c077fc913c699cead09b94056e51af9c724faba38a7a06e00017a1c7c591fd"

URI_aarch64_rust-ff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+default-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-ff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+default-devel}"
SRC_URI[aarch64_rust-ff+default-devel.sha256sum] = "9c96c405bcf7b82370c786981bba6d58ad820e5c703057ae9f99c99eaf3a61e9"

URI_aarch64_rust-ff+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+std-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-ff+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+std-devel}"
SRC_URI[aarch64_rust-ff+std-devel.sha256sum] = "cf848cb3df37cae1bffe2ef0ac0dbdeb98ed4dda8c845102bad3ef588e4b1427"

URI_aarch64_rust-ff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff-devel-0.13.1-1.el10_1.noarch.rpm;name=aarch64_rust-ff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff-devel}"
SRC_URI[aarch64_rust-ff-devel.sha256sum] = "137cf07ff9efb6ca6fc8bec52333c99c84d27caeee1ec81eef2002540dd8824b"

RDEPENDS:rust-ff+alloc-devel = " \
 cargo \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+bits-devel = " \
 cargo \
 rust-ff+bitvec-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+bitvec-devel = " \
 cargo \
 rust-bitvec-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+byteorder-devel = " \
 cargo \
 rust-byteorder-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+default-devel = " \
 cargo \
 rust-ff+bits-devel \
 rust-ff+std-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+std-devel = " \
 cargo \
 rust-ff+alloc-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff-devel = " \
 cargo \
 rust \
 rust-rand_core0.6-devel \
 rust-subtle+i128-devel \
 rust-subtle-devel \
 "
