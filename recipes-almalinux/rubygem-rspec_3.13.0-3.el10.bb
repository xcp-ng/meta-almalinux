# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-rspec"
PV = "3.13.0"
PR = "3.el10"
PACKAGES = " \
 rubygem-rspec \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/rubygem-rspec-3.13.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3a673a006bee6b218ddf2b3ef696706ea31932dc3c43421ec54a611e3521301"

URI_x86_64_v2_rubygem-rspec = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/rubygem-rspec-3.13.0-3.el10.noarch.rpm;name=x86_64_v2_rubygem-rspec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-rspec}"
SRC_URI[x86_64_v2_rubygem-rspec.sha256sum] = "313f9ad81fa3f270e3030a5a49be76ce700a0d1345f0fd99112aa70b05cc0db6"

URI_aarch64_rubygem-rspec = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/rubygem-rspec-3.13.0-3.el10.noarch.rpm;name=aarch64_rubygem-rspec;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-rspec}"
SRC_URI[aarch64_rubygem-rspec.sha256sum] = "313f9ad81fa3f270e3030a5a49be76ce700a0d1345f0fd99112aa70b05cc0db6"

RDEPENDS:rubygem-rspec = " \
 rubygem-rspec-core \
 rubygem-rspec-expectations \
 rubygem-rspec-mocks \
 rubygems \
 "
