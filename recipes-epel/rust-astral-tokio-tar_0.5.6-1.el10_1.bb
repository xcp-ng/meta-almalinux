# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-astral-tokio-tar"
PV = "0.5.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-astral-tokio-tar+default-devel \
 rust-astral-tokio-tar+xattr-devel \
 rust-astral-tokio-tar-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-astral-tokio-tar-0.5.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f72f5894d2df128312ad054c8e343f48d8a7b6ed88d37b24f4945ddb3f97f1f2"

URI_x86_64_v2_rust-astral-tokio-tar+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tokio-tar+default-devel-0.5.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tokio-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tokio-tar+default-devel}"
SRC_URI[x86_64_v2_rust-astral-tokio-tar+default-devel.sha256sum] = "96776691804683b261809855ce85f807f6913c21f0391bcbd18e0593ca42fbdf"

URI_x86_64_v2_rust-astral-tokio-tar+xattr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tokio-tar+xattr-devel-0.5.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tokio-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tokio-tar+xattr-devel}"
SRC_URI[x86_64_v2_rust-astral-tokio-tar+xattr-devel.sha256sum] = "aea58744a67e72d7a5b04f6740e316c206905a92864bdc3c474a8d5da129f9cb"

URI_x86_64_v2_rust-astral-tokio-tar-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-astral-tokio-tar-devel-0.5.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-astral-tokio-tar-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-astral-tokio-tar-devel}"
SRC_URI[x86_64_v2_rust-astral-tokio-tar-devel.sha256sum] = "bdde25b934ee1f077a6bb1a2414681ba893b9241d0f470b69b0f61a706fe14f2"

URI_aarch64_rust-astral-tokio-tar+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tokio-tar+default-devel-0.5.6-1.el10_1.noarch.rpm;name=aarch64_rust-astral-tokio-tar+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tokio-tar+default-devel}"
SRC_URI[aarch64_rust-astral-tokio-tar+default-devel.sha256sum] = "082be4683f30973ae5303cdd170114c731e2986b6b634b1cb35e565488f11a5a"

URI_aarch64_rust-astral-tokio-tar+xattr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tokio-tar+xattr-devel-0.5.6-1.el10_1.noarch.rpm;name=aarch64_rust-astral-tokio-tar+xattr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tokio-tar+xattr-devel}"
SRC_URI[aarch64_rust-astral-tokio-tar+xattr-devel.sha256sum] = "8dfabae6fd2749a40b8565f58388b4141a1763e3251ee887558c4eb7654b03b1"

URI_aarch64_rust-astral-tokio-tar-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-astral-tokio-tar-devel-0.5.6-1.el10_1.noarch.rpm;name=aarch64_rust-astral-tokio-tar-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-astral-tokio-tar-devel}"
SRC_URI[aarch64_rust-astral-tokio-tar-devel.sha256sum] = "d1d92fda6988f4113ac8faa4012d3ccd28db87bea89663d1561e9dbdafc719a2"

RDEPENDS:rust-astral-tokio-tar+default-devel = " \
 cargo \
 rust-astral-tokio-tar+xattr-devel \
 rust-astral-tokio-tar-devel \
 "
RDEPENDS:rust-astral-tokio-tar+xattr-devel = " \
 cargo \
 rust-astral-tokio-tar-devel \
 rust-xattr+default-devel \
 "
RDEPENDS:rust-astral-tokio-tar-devel = " \
 bash \
 cargo \
 rust \
 rust-filetime+default-devel \
 rust-futures-core+default-devel \
 rust-libc+default-devel \
 rust-portable-atomic+default-devel \
 rust-rustc-hash+default-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+io-util-devel \
 rust-tokio+rt-devel \
 rust-tokio-stream+default-devel \
 "
