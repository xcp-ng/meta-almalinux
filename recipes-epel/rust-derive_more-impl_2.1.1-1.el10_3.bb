# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-derive_more-impl"
PV = "2.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-derive_more-impl+add-devel \
 rust-derive_more-impl+add_assign-devel \
 rust-derive_more-impl+as_ref-devel \
 rust-derive_more-impl+constructor-devel \
 rust-derive_more-impl+debug-devel \
 rust-derive_more-impl+default-devel \
 rust-derive_more-impl+deref-devel \
 rust-derive_more-impl+deref_mut-devel \
 rust-derive_more-impl+display-devel \
 rust-derive_more-impl+eq-devel \
 rust-derive_more-impl+error-devel \
 rust-derive_more-impl+from-devel \
 rust-derive_more-impl+from_str-devel \
 rust-derive_more-impl+full-devel \
 rust-derive_more-impl+index-devel \
 rust-derive_more-impl+index_mut-devel \
 rust-derive_more-impl+into-devel \
 rust-derive_more-impl+into_iterator-devel \
 rust-derive_more-impl+is_variant-devel \
 rust-derive_more-impl+mul-devel \
 rust-derive_more-impl+mul_assign-devel \
 rust-derive_more-impl+not-devel \
 rust-derive_more-impl+sum-devel \
 rust-derive_more-impl+testing-helpers-devel \
 rust-derive_more-impl+try_from-devel \
 rust-derive_more-impl+try_into-devel \
 rust-derive_more-impl+try_unwrap-devel \
 rust-derive_more-impl+unwrap-devel \
 rust-derive_more-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-derive_more-impl-2.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e83c011f7b344af119abda467ab18698b9cfe366fba0039db73824b099afdccf"

URI_x86_64_v2_rust-derive_more-impl+add-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+add-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+add-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+add-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+add-devel.sha256sum] = "ec7b3537c638a218231c76e687115d9b96203afc6a51771272aca4cd7c2204de"

URI_x86_64_v2_rust-derive_more-impl+add_assign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+add_assign-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+add_assign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+add_assign-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+add_assign-devel.sha256sum] = "711236e36cf1aae99efe095ad754a77276d53604671df8c4078bd3b7aec0eb20"

URI_x86_64_v2_rust-derive_more-impl+as_ref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+as_ref-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+as_ref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+as_ref-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+as_ref-devel.sha256sum] = "504092e7087808eae06cd3ba8e39cfde145496cec3bba39c470c0e049c2ea4cb"

URI_x86_64_v2_rust-derive_more-impl+constructor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+constructor-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+constructor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+constructor-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+constructor-devel.sha256sum] = "3bdb33d4d3ac9489f7cbf62aa4d942292ae593ac40e4618239c1c0e18de9de70"

URI_x86_64_v2_rust-derive_more-impl+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+debug-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+debug-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+debug-devel.sha256sum] = "62f3e00fe095c461d218d7269b720212bc56a61aa0479ccb283511a7d342f602"

URI_x86_64_v2_rust-derive_more-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+default-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+default-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+default-devel.sha256sum] = "2e4f0f0777e15fbea95201df0806d911d9ea2010c959215b0b6c79e33352bdb5"

URI_x86_64_v2_rust-derive_more-impl+deref-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+deref-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+deref-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+deref-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+deref-devel.sha256sum] = "c3107c8ca6347663c2b0e05a6977c7dae957abbf97806b492d732d64029c2a62"

URI_x86_64_v2_rust-derive_more-impl+deref_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+deref_mut-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+deref_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+deref_mut-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+deref_mut-devel.sha256sum] = "670ed702d20f07b04fe7c7c943fafa3d432ec01b739df84b0843f9552094a38b"

URI_x86_64_v2_rust-derive_more-impl+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+display-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+display-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+display-devel.sha256sum] = "e5dbf6867281d638a97b2b333bd1adc2b4218ffba032ee300bc4d36ed02deb23"

URI_x86_64_v2_rust-derive_more-impl+eq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+eq-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+eq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+eq-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+eq-devel.sha256sum] = "52e5fbee9a28bcd9efd471a0ab502d89c41218a330204d3c35b6b21f3c8e836c"

URI_x86_64_v2_rust-derive_more-impl+error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+error-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+error-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+error-devel.sha256sum] = "481d6daa5a65279311375fd79d27e8b4a3f8320291a126c788244a6daac67199"

URI_x86_64_v2_rust-derive_more-impl+from-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+from-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+from-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+from-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+from-devel.sha256sum] = "bb3247321cf037810e1a05b1e5b17bf000eb287badd7631810fca0714c4f1326"

URI_x86_64_v2_rust-derive_more-impl+from_str-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+from_str-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+from_str-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+from_str-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+from_str-devel.sha256sum] = "432af7e8078725c88cc3cee2aa2300091152cf9e7382d52c51bd739131918610"

URI_x86_64_v2_rust-derive_more-impl+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+full-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+full-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+full-devel.sha256sum] = "2ea957dd408781fa4cc9b0a2469b731e1ae358a68decfa143858620252cb8d30"

URI_x86_64_v2_rust-derive_more-impl+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+index-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+index-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+index-devel.sha256sum] = "385894845ccd1af57f8319bdee072c6d0ce3fe72c3a95af93410448228a6297b"

URI_x86_64_v2_rust-derive_more-impl+index_mut-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+index_mut-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+index_mut-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+index_mut-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+index_mut-devel.sha256sum] = "294bedca726dbb8f04093e82f6a888aedd9dcbb74d679a3d00fae3c9e7249405"

URI_x86_64_v2_rust-derive_more-impl+into-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+into-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+into-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+into-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+into-devel.sha256sum] = "13b4e06b553e9422ee03b73b60c353a78b60984b6855869260dfb9aaac128c14"

URI_x86_64_v2_rust-derive_more-impl+into_iterator-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+into_iterator-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+into_iterator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+into_iterator-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+into_iterator-devel.sha256sum] = "826f4ae646385b09aa31df8fe145ac0bc26ee916877e2224bbcf6a2089d52518"

URI_x86_64_v2_rust-derive_more-impl+is_variant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+is_variant-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+is_variant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+is_variant-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+is_variant-devel.sha256sum] = "d3869033c04e47df9d583b926037e5372e0211a5c2a15ab992e95946bf10d99f"

URI_x86_64_v2_rust-derive_more-impl+mul-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+mul-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+mul-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+mul-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+mul-devel.sha256sum] = "b2202f89f34e9f475084bc925221bf687881582326eff0513a7aafa89105b28f"

URI_x86_64_v2_rust-derive_more-impl+mul_assign-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+mul_assign-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+mul_assign-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+mul_assign-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+mul_assign-devel.sha256sum] = "abacaef455cc48fc0d9fda5e635dc4374eed50eefb89fd95801b38280ec82544"

URI_x86_64_v2_rust-derive_more-impl+not-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+not-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+not-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+not-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+not-devel.sha256sum] = "01bd9ada848e2d53eb02e5d9be6e7125b0175d654c6db235d6c2c3fed2aa31ed"

URI_x86_64_v2_rust-derive_more-impl+sum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+sum-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+sum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+sum-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+sum-devel.sha256sum] = "07ecaf84f89947ecbcc59f1db9b7799f6b5be47357d896d98ca38a4292ee1c98"

URI_x86_64_v2_rust-derive_more-impl+testing-helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+testing-helpers-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+testing-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+testing-helpers-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+testing-helpers-devel.sha256sum] = "efc2d2803520de9040127434696b2b9ce51127438819886af017377f691fe60e"

URI_x86_64_v2_rust-derive_more-impl+try_from-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+try_from-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+try_from-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+try_from-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+try_from-devel.sha256sum] = "99342dfc7bd8aaa2e0c228949ff089d252dc82e1295853f848adaa34c05c7e46"

URI_x86_64_v2_rust-derive_more-impl+try_into-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+try_into-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+try_into-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+try_into-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+try_into-devel.sha256sum] = "6204103861bee96695a090a1e94ff51bfa731b99a30a313f3c78c755cf0d0845"

URI_x86_64_v2_rust-derive_more-impl+try_unwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+try_unwrap-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+try_unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+try_unwrap-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+try_unwrap-devel.sha256sum] = "3b01d4d3934d39096f865afbdc52197ad1559818c143d4095c21d859e34e5bf7"

URI_x86_64_v2_rust-derive_more-impl+unwrap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl+unwrap-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl+unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl+unwrap-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl+unwrap-devel.sha256sum] = "523150517c5f9e36212560d8aba7418b5f87a55b94ce7c731fbb9b0dd70b6817"

URI_x86_64_v2_rust-derive_more-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-derive_more-impl-devel-2.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-derive_more-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-derive_more-impl-devel}"
SRC_URI[x86_64_v2_rust-derive_more-impl-devel.sha256sum] = "8e4b7f7d96a19f7252571b2981d239e24f6777e7587fd0610c0bbe3acc3ec5c4"

URI_aarch64_rust-derive_more-impl+add-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+add-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+add-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+add-devel}"
SRC_URI[aarch64_rust-derive_more-impl+add-devel.sha256sum] = "96048226e4ae5991066b48d72e0ba927dbc00d4655dd7bb2881c501a7c63fc8e"

URI_aarch64_rust-derive_more-impl+add_assign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+add_assign-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+add_assign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+add_assign-devel}"
SRC_URI[aarch64_rust-derive_more-impl+add_assign-devel.sha256sum] = "fd6dae1add0c66145db0c89b60fb64937f7b700b21b8693b5f0b85294e2d914b"

URI_aarch64_rust-derive_more-impl+as_ref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+as_ref-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+as_ref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+as_ref-devel}"
SRC_URI[aarch64_rust-derive_more-impl+as_ref-devel.sha256sum] = "64ecc35a4e34c3db2458b59c3b6696e62a5a8d66f4b11482b151eae4ed2dd0f9"

URI_aarch64_rust-derive_more-impl+constructor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+constructor-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+constructor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+constructor-devel}"
SRC_URI[aarch64_rust-derive_more-impl+constructor-devel.sha256sum] = "0d6480433f12344fd5823859bfc8d9ee99ead6459c4d34b9390882588f31b8ab"

URI_aarch64_rust-derive_more-impl+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+debug-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+debug-devel}"
SRC_URI[aarch64_rust-derive_more-impl+debug-devel.sha256sum] = "ec0cead54970b0fdd85051f41720a74035ef60dea7e291e52621d8a18377e204"

URI_aarch64_rust-derive_more-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+default-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+default-devel}"
SRC_URI[aarch64_rust-derive_more-impl+default-devel.sha256sum] = "d4345054b4805baaedfd28ffe59a02be87be7412d56185827870e59f6df0885e"

URI_aarch64_rust-derive_more-impl+deref-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+deref-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+deref-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+deref-devel}"
SRC_URI[aarch64_rust-derive_more-impl+deref-devel.sha256sum] = "2eea21ac7837d5976d007ba802b2a48e7f2709b0cf33960fcc99823ed0a738a8"

URI_aarch64_rust-derive_more-impl+deref_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+deref_mut-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+deref_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+deref_mut-devel}"
SRC_URI[aarch64_rust-derive_more-impl+deref_mut-devel.sha256sum] = "0848b46aba5617f25dfc4e7706639e6fd5807c391ef483d7990a556ed9a5047b"

URI_aarch64_rust-derive_more-impl+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+display-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+display-devel}"
SRC_URI[aarch64_rust-derive_more-impl+display-devel.sha256sum] = "492ec14027657c246a4206d8dc30dc069ca633c2e0c2db64352fb5f94476cec3"

URI_aarch64_rust-derive_more-impl+eq-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+eq-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+eq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+eq-devel}"
SRC_URI[aarch64_rust-derive_more-impl+eq-devel.sha256sum] = "68fd171e72748d9bdf0745b0026c0ad3c1c10a5d360a099d6995ffbe2278ce7b"

URI_aarch64_rust-derive_more-impl+error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+error-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+error-devel}"
SRC_URI[aarch64_rust-derive_more-impl+error-devel.sha256sum] = "c77a35b698c5c57b94ca26d848001fbe493875eb2f9a0e5bab9d377f1b8ace9e"

URI_aarch64_rust-derive_more-impl+from-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+from-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+from-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+from-devel}"
SRC_URI[aarch64_rust-derive_more-impl+from-devel.sha256sum] = "8ed9aed9eee1d08c97f95e952b0f928c2adc9d74536ab8cb417fb26badf12e5d"

URI_aarch64_rust-derive_more-impl+from_str-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+from_str-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+from_str-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+from_str-devel}"
SRC_URI[aarch64_rust-derive_more-impl+from_str-devel.sha256sum] = "d5a5d47ecc1dfbeb264a07c5210bca400678b1c36171345878dbe35fe92168a9"

URI_aarch64_rust-derive_more-impl+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+full-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+full-devel}"
SRC_URI[aarch64_rust-derive_more-impl+full-devel.sha256sum] = "8f57272130cdb7d71fbfcb753c2b0c4517671fb7533e3606b72c6de54117f906"

URI_aarch64_rust-derive_more-impl+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+index-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+index-devel}"
SRC_URI[aarch64_rust-derive_more-impl+index-devel.sha256sum] = "cf6930cd13a5e2db6e6758b9198239738abeaafb166210aab6a8f750e7de962d"

URI_aarch64_rust-derive_more-impl+index_mut-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+index_mut-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+index_mut-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+index_mut-devel}"
SRC_URI[aarch64_rust-derive_more-impl+index_mut-devel.sha256sum] = "3bea7b40104c61e22c11e334f31dbac2b9fb5167b5f412ce6e75ace471db9a4e"

URI_aarch64_rust-derive_more-impl+into-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+into-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+into-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+into-devel}"
SRC_URI[aarch64_rust-derive_more-impl+into-devel.sha256sum] = "d6ad1162c636d22c61ddc8e40ade29fe3805e1274e17af427965fc677a27be25"

URI_aarch64_rust-derive_more-impl+into_iterator-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+into_iterator-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+into_iterator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+into_iterator-devel}"
SRC_URI[aarch64_rust-derive_more-impl+into_iterator-devel.sha256sum] = "efb3fee1e1e349778322f6ac13e63308b647473766cbf13b96926ab75d9a1946"

URI_aarch64_rust-derive_more-impl+is_variant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+is_variant-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+is_variant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+is_variant-devel}"
SRC_URI[aarch64_rust-derive_more-impl+is_variant-devel.sha256sum] = "786d132beaf099d9aa3a7b204f307758f6b3af06ddc1339ff9f4c21c7ab63774"

URI_aarch64_rust-derive_more-impl+mul-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+mul-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+mul-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+mul-devel}"
SRC_URI[aarch64_rust-derive_more-impl+mul-devel.sha256sum] = "d1b35afdf3c64080e54055a1b18889ff732560e1b5c5f878e2291b7f6645af25"

URI_aarch64_rust-derive_more-impl+mul_assign-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+mul_assign-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+mul_assign-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+mul_assign-devel}"
SRC_URI[aarch64_rust-derive_more-impl+mul_assign-devel.sha256sum] = "bdf02fbd11d5af624a2416db429dc18951497b795760d86c134d33ef2a924e25"

URI_aarch64_rust-derive_more-impl+not-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+not-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+not-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+not-devel}"
SRC_URI[aarch64_rust-derive_more-impl+not-devel.sha256sum] = "7755b1d620ced3096c9ce5f5795db6112e4a193e9a2d6d41a4b3398b4b296c32"

URI_aarch64_rust-derive_more-impl+sum-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+sum-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+sum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+sum-devel}"
SRC_URI[aarch64_rust-derive_more-impl+sum-devel.sha256sum] = "2790f4a9fd0f89d050f75083ee7c8066033746f0aa635a8c564adab0a03f3a3c"

URI_aarch64_rust-derive_more-impl+testing-helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+testing-helpers-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+testing-helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+testing-helpers-devel}"
SRC_URI[aarch64_rust-derive_more-impl+testing-helpers-devel.sha256sum] = "82a52b32636bf4699e7ff49980178ce01cf6a822431b2ee128c22d3bd92fc27f"

URI_aarch64_rust-derive_more-impl+try_from-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+try_from-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+try_from-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+try_from-devel}"
SRC_URI[aarch64_rust-derive_more-impl+try_from-devel.sha256sum] = "1e8db219f96c205ee9edfe961154167101fb4a12b6ca7f62a05dc0e6d25bab91"

URI_aarch64_rust-derive_more-impl+try_into-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+try_into-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+try_into-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+try_into-devel}"
SRC_URI[aarch64_rust-derive_more-impl+try_into-devel.sha256sum] = "aab2aa45881ec5933da36203ab27c01705a389b06989b15555ee57fa34043088"

URI_aarch64_rust-derive_more-impl+try_unwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+try_unwrap-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+try_unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+try_unwrap-devel}"
SRC_URI[aarch64_rust-derive_more-impl+try_unwrap-devel.sha256sum] = "805fb3e067e4708ea631fc132ee5984c3d34719995619b9e4a97bde9dfcda773"

URI_aarch64_rust-derive_more-impl+unwrap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl+unwrap-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl+unwrap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl+unwrap-devel}"
SRC_URI[aarch64_rust-derive_more-impl+unwrap-devel.sha256sum] = "41c3ae46b72411f54ecbee6403b9b56b66fb0f85bc13de3fcaee98c9e4d4d6a5"

URI_aarch64_rust-derive_more-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-derive_more-impl-devel-2.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-derive_more-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-derive_more-impl-devel}"
SRC_URI[aarch64_rust-derive_more-impl-devel.sha256sum] = "b1f39187a3cbace48946883856d1e071582ff0c77df957a1c70b35d81bc0fff3"

RDEPENDS:rust-derive_more-impl+add-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+visit-devel \
 "
RDEPENDS:rust-derive_more-impl+add_assign-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+visit-devel \
 "
RDEPENDS:rust-derive_more-impl+as_ref-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+visit-devel \
 "
RDEPENDS:rust-derive_more-impl+constructor-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+debug-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-unicode-xid+default-devel \
 "
RDEPENDS:rust-derive_more-impl+default-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+deref-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+deref_mut-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+display-devel = " \
 cargo \
 rust-convert_case+default-devel \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-unicode-xid+default-devel \
 "
RDEPENDS:rust-derive_more-impl+eq-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+visit-devel \
 "
RDEPENDS:rust-derive_more-impl+error-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+from-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+from_str-devel = " \
 cargo \
 rust-convert_case+default-devel \
 rust-derive_more-impl-devel \
 rust-syn2+full-devel \
 rust-syn2+visit-devel \
 "
RDEPENDS:rust-derive_more-impl+full-devel = " \
 cargo \
 rust-derive_more-impl+add-devel \
 rust-derive_more-impl+add_assign-devel \
 rust-derive_more-impl+as_ref-devel \
 rust-derive_more-impl+constructor-devel \
 rust-derive_more-impl+debug-devel \
 rust-derive_more-impl+deref-devel \
 rust-derive_more-impl+deref_mut-devel \
 rust-derive_more-impl+display-devel \
 rust-derive_more-impl+eq-devel \
 rust-derive_more-impl+error-devel \
 rust-derive_more-impl+from-devel \
 rust-derive_more-impl+from_str-devel \
 rust-derive_more-impl+index-devel \
 rust-derive_more-impl+index_mut-devel \
 rust-derive_more-impl+into-devel \
 rust-derive_more-impl+into_iterator-devel \
 rust-derive_more-impl+is_variant-devel \
 rust-derive_more-impl+mul-devel \
 rust-derive_more-impl+mul_assign-devel \
 rust-derive_more-impl+not-devel \
 rust-derive_more-impl+sum-devel \
 rust-derive_more-impl+try_from-devel \
 rust-derive_more-impl+try_into-devel \
 rust-derive_more-impl+try_unwrap-devel \
 rust-derive_more-impl+unwrap-devel \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+index-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+index_mut-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+into-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+visit-mut-devel \
 "
RDEPENDS:rust-derive_more-impl+into_iterator-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+is_variant-devel = " \
 cargo \
 rust-convert_case+default-devel \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+mul-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+visit-devel \
 "
RDEPENDS:rust-derive_more-impl+mul_assign-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+visit-devel \
 "
RDEPENDS:rust-derive_more-impl+not-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 "
RDEPENDS:rust-derive_more-impl+sum-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+testing-helpers-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+full-devel \
 "
RDEPENDS:rust-derive_more-impl+try_from-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+try_into-devel = " \
 cargo \
 rust-derive_more-impl-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 rust-syn2+visit-mut-devel \
 "
RDEPENDS:rust-derive_more-impl+try_unwrap-devel = " \
 cargo \
 rust-convert_case+default-devel \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl+unwrap-devel = " \
 cargo \
 rust-convert_case+default-devel \
 rust-derive_more-impl-devel \
 "
RDEPENDS:rust-derive_more-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rustc_version+default-devel \
 rust-syn2+default-devel \
 "
