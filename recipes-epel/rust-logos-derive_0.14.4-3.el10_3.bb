# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-logos-derive"
PV = "0.14.4"
PR = "3.el10_3"
PACKAGES = " \
 rust-logos-derive+debug-devel \
 rust-logos-derive+default-devel \
 rust-logos-derive+forbid_unsafe-devel \
 rust-logos-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-logos-derive-0.14.4-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6b0f5b551004823d5ee2186f59001aea57b1386ea315dcaacff028276233098"

URI_x86_64_v2_rust-logos-derive+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-derive+debug-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-derive+debug-devel}"
SRC_URI[x86_64_v2_rust-logos-derive+debug-devel.sha256sum] = "d93fed71bc6d3a8977eddb9fbd4214eb7becbd81dcd7d6f0bf1fe5776a9b583a"

URI_x86_64_v2_rust-logos-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-derive+default-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-derive+default-devel}"
SRC_URI[x86_64_v2_rust-logos-derive+default-devel.sha256sum] = "c7d53b4a339639d8b89f5cc4436a052cc63e88ee088b4565a89ba98b158c6b8d"

URI_x86_64_v2_rust-logos-derive+forbid_unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-derive+forbid_unsafe-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-derive+forbid_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-derive+forbid_unsafe-devel}"
SRC_URI[x86_64_v2_rust-logos-derive+forbid_unsafe-devel.sha256sum] = "dd148312a0f2badeb36ee27d53c28b9da2daf28a0a623d80ae882488c952cdae"

URI_x86_64_v2_rust-logos-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-logos-derive-devel-0.14.4-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-logos-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-logos-derive-devel}"
SRC_URI[x86_64_v2_rust-logos-derive-devel.sha256sum] = "c3822e4111390113fed35bbaf2c58866251deac50de2a7611e4135b424a8acd8"

URI_aarch64_rust-logos-derive+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-derive+debug-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos-derive+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-derive+debug-devel}"
SRC_URI[aarch64_rust-logos-derive+debug-devel.sha256sum] = "29b31d5114146a0f817268b59b991dd6a4c4760c5c2cb84467dc3ac35d84c902"

URI_aarch64_rust-logos-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-derive+default-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-derive+default-devel}"
SRC_URI[aarch64_rust-logos-derive+default-devel.sha256sum] = "8f3f4ef36d7cc184ca82122892439dd5ae3bd570690728eed97048ea4d03c907"

URI_aarch64_rust-logos-derive+forbid_unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-derive+forbid_unsafe-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos-derive+forbid_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-derive+forbid_unsafe-devel}"
SRC_URI[aarch64_rust-logos-derive+forbid_unsafe-devel.sha256sum] = "ab1a4ec85a331d955f2757b113582635ea1a8d5378076705240c96b938d57f99"

URI_aarch64_rust-logos-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-logos-derive-devel-0.14.4-3.el10_3.noarch.rpm;name=aarch64_rust-logos-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-logos-derive-devel}"
SRC_URI[aarch64_rust-logos-derive-devel.sha256sum] = "9ac6571530cb2343f92461609790c19744aa0cc358d6a3429440abbdceb619f8"

RDEPENDS:rust-logos-derive+debug-devel = " \
 cargo \
 rust-logos-codegen+debug-devel \
 rust-logos-derive-devel \
 "
RDEPENDS:rust-logos-derive+default-devel = " \
 cargo \
 rust-logos-derive-devel \
 "
RDEPENDS:rust-logos-derive+forbid_unsafe-devel = " \
 cargo \
 rust-logos-codegen+forbid_unsafe-devel \
 rust-logos-derive-devel \
 "
RDEPENDS:rust-logos-derive-devel = " \
 cargo \
 rust \
 rust-logos-codegen+default-devel \
 "
