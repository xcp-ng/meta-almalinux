# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spamassassin-iXhash2"
PV = "4.00"
PR = "6.el10_2"
PACKAGES = " \
 spamassassin-iXhash2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spamassassin-iXhash2-4.00-6.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e62e3b597f10fa2e1c7b51e5c6d1a0de9badc5c6caeab6a24a3c129c09398adc"

URI_x86_64_v2_spamassassin-iXhash2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spamassassin-iXhash2-4.00-6.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_spamassassin-iXhash2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spamassassin-iXhash2}"
SRC_URI[x86_64_v2_spamassassin-iXhash2.sha256sum] = "465ed2e12d51dd2619bea82f9d78b526bbac30cc913f395fc395574adf544752"

URI_aarch64_spamassassin-iXhash2 = "${EPEL_MIRROR}/aarch64/Packages/s/spamassassin-iXhash2-4.00-6.el10_2.noarch.rpm;name=aarch64_spamassassin-iXhash2;unpack=0"
SRC_URI:append = " ${URI_aarch64_spamassassin-iXhash2}"
SRC_URI[aarch64_spamassassin-iXhash2.sha256sum] = "52127f87b3c303537ca8afc6604c53733847ab9bbf21e99fc8e8a1b9a6892961"

RDEPENDS:spamassassin-iXhash2 = " \
 perl-Digest-MD5 \
 perl-libs \
 perl-vars \
 spamassassin \
 "
