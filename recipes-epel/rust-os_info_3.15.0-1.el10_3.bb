# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-os_info"
PV = "3.15.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-os_info+default-devel \
 rust-os_info+schemars-devel \
 rust-os_info+serde-devel \
 rust-os_info-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-os_info-3.15.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16845f38b9470a6bbdcd9694a8b32ab767c1c8527a8c7d58705c2c2e9d23994a"

URI_x86_64_v2_rust-os_info+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+default-devel-3.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+default-devel}"
SRC_URI[x86_64_v2_rust-os_info+default-devel.sha256sum] = "5db3ec3049354995f59fe3da3c200bc22937278511919d64a4a2b92a5cf16f68"

URI_x86_64_v2_rust-os_info+schemars-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+schemars-devel-3.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+schemars-devel}"
SRC_URI[x86_64_v2_rust-os_info+schemars-devel.sha256sum] = "4e772b458ee312db5c1631a31e03409f42ceb8f24e19cfba52433e14b260741b"

URI_x86_64_v2_rust-os_info+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info+serde-devel-3.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info+serde-devel}"
SRC_URI[x86_64_v2_rust-os_info+serde-devel.sha256sum] = "aca75325be98792ba6faff5f91f45212a6d5f496258812a67874e54f285cf112"

URI_x86_64_v2_rust-os_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-os_info-devel-3.15.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-os_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-os_info-devel}"
SRC_URI[x86_64_v2_rust-os_info-devel.sha256sum] = "29a1484423c17c724007c1e6374cfa9ad788bda72e8c0e7f0e79b8b056237b61"

URI_aarch64_rust-os_info+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+default-devel-3.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-os_info+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+default-devel}"
SRC_URI[aarch64_rust-os_info+default-devel.sha256sum] = "b4b2c22375897b35c1acd20039cd56cad8332951e5c0aba122fb5cf8826b8988"

URI_aarch64_rust-os_info+schemars-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+schemars-devel-3.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-os_info+schemars-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+schemars-devel}"
SRC_URI[aarch64_rust-os_info+schemars-devel.sha256sum] = "e4287e010b67b4e1262486c538d8d3900850f894a73e0331577d9e65998e2263"

URI_aarch64_rust-os_info+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info+serde-devel-3.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-os_info+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info+serde-devel}"
SRC_URI[aarch64_rust-os_info+serde-devel.sha256sum] = "2b6e6ff73fb9d1b689ee062d842013e3075262725820f9e692a675282d24e464"

URI_aarch64_rust-os_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-os_info-devel-3.15.0-1.el10_3.noarch.rpm;name=aarch64_rust-os_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-os_info-devel}"
SRC_URI[aarch64_rust-os_info-devel.sha256sum] = "c433e4192ffb1885e21b331f8215b5ffe3f8ba65125c283450bd6f5cd66d96b7"

RDEPENDS:rust-os_info+default-devel = " \
 cargo \
 rust-os_info+serde-devel \
 rust-os_info-devel \
 "
RDEPENDS:rust-os_info+schemars-devel = " \
 cargo \
 rust-os_info-devel \
 rust-schemars+default-devel \
 "
RDEPENDS:rust-os_info+serde-devel = " \
 cargo \
 rust-os_info-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-os_info-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-nix+default-devel \
 rust-nix+feature-devel \
 "
