# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "eglexternalplatform"
PV = "1.2.1"
PR = "1.el10_1"
PACKAGES = " \
 eglexternalplatform-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/eglexternalplatform-1.2.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c17203577848373664538e45cf5297fcae330a321297e236b96f69cf1e4179d"

URI_x86_64_v2_eglexternalplatform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/eglexternalplatform-devel-1.2.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_eglexternalplatform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_eglexternalplatform-devel}"
SRC_URI[x86_64_v2_eglexternalplatform-devel.sha256sum] = "e8059251033b49340f17cd9d19622f2721d52c939aa2b6e7bae72a05a96c0440"

URI_aarch64_eglexternalplatform-devel = "${EPEL_MIRROR}/aarch64/Packages/e/eglexternalplatform-devel-1.2.1-1.el10_1.noarch.rpm;name=aarch64_eglexternalplatform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_eglexternalplatform-devel}"
SRC_URI[aarch64_eglexternalplatform-devel.sha256sum] = "02892ebc3468cc73e52bd5ae222ca61dc5b01145c29f652a15276b909eb15238"

RDEPENDS:eglexternalplatform-devel = " \
 pkgconf-pkg-config \
 "
