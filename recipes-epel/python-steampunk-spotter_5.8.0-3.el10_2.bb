# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-steampunk-spotter"
PV = "5.8.0"
PR = "3.el10_2"
PACKAGES = " \
 python3-steampunk-spotter \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-steampunk-spotter-5.8.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aca7d4429031bded4053fce6ba1960daa928e98c56695767bf4a6082b7d2e6bc"

URI_x86_64_v2_python3-steampunk-spotter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-steampunk-spotter-5.8.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-steampunk-spotter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-steampunk-spotter}"
SRC_URI[x86_64_v2_python3-steampunk-spotter.sha256sum] = "f95b6118712b252bc0970ccdb6cf290ed8a94f17110b560c57f7f0270812c78b"

URI_aarch64_python3-steampunk-spotter = "${EPEL_MIRROR}/aarch64/Packages/p/python3-steampunk-spotter-5.8.0-3.el10_2.noarch.rpm;name=aarch64_python3-steampunk-spotter;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-steampunk-spotter}"
SRC_URI[aarch64_python3-steampunk-spotter.sha256sum] = "1a6635d54649782bcaec5869c638b42aba34d6454c19dd0382cd314d31a629e3"

RDEPENDS:python3-steampunk-spotter = " \
 python3 \
 python3-colorama \
 python3-detect-secrets \
 python3-pydantic \
 python3-requests \
 python3-rich \
 python3-ruamel-yaml \
 "
