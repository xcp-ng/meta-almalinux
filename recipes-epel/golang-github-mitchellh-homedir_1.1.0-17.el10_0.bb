# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-mitchellh-homedir"
PV = "1.1.0"
PR = "17.el10_0"
PACKAGES = " \
 golang-github-mitchellh-homedir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-mitchellh-homedir-1.1.0-17.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b40e8ea614dc641e8a6cfe082475373d4c6c349952f32d2c307e589c7028ce12"

URI_x86_64_v2_golang-github-mitchellh-homedir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-mitchellh-homedir-devel-1.1.0-17.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-mitchellh-homedir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-mitchellh-homedir-devel}"
SRC_URI[x86_64_v2_golang-github-mitchellh-homedir-devel.sha256sum] = "f3d19e308817971dccbb40dbea250095c46f40b6c44b8296940ed1d00bbd1a41"

URI_aarch64_golang-github-mitchellh-homedir-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-mitchellh-homedir-devel-1.1.0-17.el10_0.noarch.rpm;name=aarch64_golang-github-mitchellh-homedir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-mitchellh-homedir-devel}"
SRC_URI[aarch64_golang-github-mitchellh-homedir-devel.sha256sum] = "7d8e8477f5fa8fd0c3ff15640633d5c019bb26f7af11063fdf343a145454e689"

RDEPENDS:golang-github-mitchellh-homedir-devel = " \
 go-filesystem \
 "
