# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipfft"
PV = "6.4.2"
PR = "2.el10_1"
PACKAGES:x86_64_v2 = " \
 hipfft \
 hipfft-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipfft-6.4.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aaeb942618503ba705e39009f206e117702d9707f9e21ff8bdd2ee132b4de9a6"

URI_x86_64_v2_hipfft = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipfft-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipfft;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipfft}"
SRC_URI[x86_64_v2_hipfft.sha256sum] = "d68c11c5b6dbb3b1dd65ea8c4776541fab1978687f362697d5a5dcc377cdd9ca"

URI_x86_64_v2_hipfft-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipfft-devel-6.4.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipfft-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipfft-devel}"
SRC_URI[x86_64_v2_hipfft-devel.sha256sum] = "a8f4bbe65409be045436bc98d445adbc9a422f5f21af726c959c5d2543d8a7d9"

RDEPENDS:hipfft = " \
 glibc \
 libgcc \
 libstdc++ \
 rocfft \
 rocm-hip \
 "
RDEPENDS:hipfft-devel = " \
 cmake-filesystem \
 hipfft \
 "
