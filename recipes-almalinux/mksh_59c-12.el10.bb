# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mksh"
PV = "59c"
PR = "12.el10"
PACKAGES = " \
 mksh \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/mksh-59c-12.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "96d8eef96e89c88aba980fd6f529598b5cf3a1fb9216ac6efec01933279795ef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/mksh-59c-12.el10.x86_64_v2.rpm;name=x86_64_v2_mksh;unpack=0"
SRC_URI[x86_64_v2_mksh.sha256sum] = "a10a0063b6498dee1fbca3c455c81909c8a6797dbebdcc90699ba2790b603b94"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/mksh-59c-12.el10.aarch64.rpm;name=aarch64_mksh;unpack=0"
SRC_URI[aarch64_mksh.sha256sum] = "70039c1255249940d17c9f79f189cc266487d15e766f40eb61de2695554ab02b"

RDEPENDS:mksh = " \
 alternatives \
 bash \
 glibc \
 grep \
 sed \
 "
