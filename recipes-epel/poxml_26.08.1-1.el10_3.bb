# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "poxml"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 poxml \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/poxml-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6eb64881aee72e5bf972c6a7693a696db2bdafcd9993b75a77b9c99bb5f20e5f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/poxml-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_poxml;unpack=0"
SRC_URI[x86_64_v2_poxml.sha256sum] = "17086c8329964a9ebbbf246c7d4ef7d5f3722110cc647e679d339f8fd45d4ef1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/poxml-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_poxml;unpack=0"
SRC_URI[aarch64_poxml.sha256sum] = "2475c0dd3f5de3929c6d8a5e3bea1c43cec0553f77c71da2c23c83a83a5f76d4"

RDEPENDS:poxml = " \
 gettext-libs \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
