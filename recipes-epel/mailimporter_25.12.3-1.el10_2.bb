# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mailimporter"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 mailimporter \
 mailimporter-akonadi \
 mailimporter-devel \
 mailimporter-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mailimporter-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca097d0f99b3d94966e1128c0e56ce85ac2f092f3badd410984e73d76c2f2f3f"

URI_x86_64_v2_mailimporter = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter}"
SRC_URI[x86_64_v2_mailimporter.sha256sum] = "65dd98c0698c91c667f458fc8934682f51663b1df31f5f099fabb22c021e8683"

URI_x86_64_v2_mailimporter-akonadi = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-akonadi-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-akonadi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-akonadi}"
SRC_URI[x86_64_v2_mailimporter-akonadi.sha256sum] = "16461443219b1c83dec8eec57332777030cd5767fccb1b21f2591045fce63da8"

URI_x86_64_v2_mailimporter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mailimporter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-devel}"
SRC_URI[x86_64_v2_mailimporter-devel.sha256sum] = "c6bd5d27a07ef549ba244e2d4e34a8fc2b7050ce50c7c545bc3379aefdf0c155"

URI_x86_64_v2_mailimporter-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mailimporter-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mailimporter-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mailimporter-doc}"
SRC_URI[x86_64_v2_mailimporter-doc.sha256sum] = "c8cdcab7edb251aa0433f5906a4d1dee86079a7e3a330987b9d0c9d82e19152c"

URI_aarch64_mailimporter = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_mailimporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter}"
SRC_URI[aarch64_mailimporter.sha256sum] = "fed0db16c0a3af74ccc605de94f77adcbafc0327a507ead47282cbc717e100c7"

URI_aarch64_mailimporter-akonadi = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-akonadi-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_mailimporter-akonadi;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-akonadi}"
SRC_URI[aarch64_mailimporter-akonadi.sha256sum] = "089d5b58758a0fbdee0eb94d113ea03f07e5e201c9a7b36e9b363e96a99d092c"

URI_aarch64_mailimporter-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_mailimporter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-devel}"
SRC_URI[aarch64_mailimporter-devel.sha256sum] = "f1b12e670f8f3f5a2d04abc34114a7f548ed275d2191c7298e712c03794205f4"

URI_aarch64_mailimporter-doc = "${EPEL_MIRROR}/aarch64/Packages/m/mailimporter-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_mailimporter-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_mailimporter-doc}"
SRC_URI[aarch64_mailimporter-doc.sha256sum] = "5a5fa35747cbed206e528e7970907343462e71350229dfce07d0930aeb6f93c6"

RDEPENDS:mailimporter = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-ki18n \
 libstdc++ \
 pimcommon \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:mailimporter-akonadi = " \
 akonadi-mime \
 akonadi-server \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kmime \
 libgcc \
 libstdc++ \
 mailimporter \
 qt6-qtbase \
 "
RDEPENDS:mailimporter-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 mailimporter \
 mailimporter-akonadi \
 "
RDEPENDS:mailimporter-doc = " \
 "
