# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php-pecl-raphf"
PV = "2.0.2"
PR = "1.el10_2"
PACKAGES = " \
 php-pecl-raphf \
 php-pecl-raphf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/php-pecl-raphf-2.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43f31f3ef12c7658bfd88c84af33ac8b961fcba07740524c48486ca8db65be3d"

URI_x86_64_v2_php-pecl-raphf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-raphf-2.0.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-raphf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-raphf}"
SRC_URI[x86_64_v2_php-pecl-raphf.sha256sum] = "d66b6e01c5cbbb180cd223ecc6ca4ea64c79a3632bfe387315637fb67837b4a3"

URI_x86_64_v2_php-pecl-raphf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/php-pecl-raphf-devel-2.0.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_php-pecl-raphf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pecl-raphf-devel}"
SRC_URI[x86_64_v2_php-pecl-raphf-devel.sha256sum] = "f4d097991bef1d3ba95462a6d39140b44a9aaeafb3aef51ee8c0014b4c58f279"

URI_aarch64_php-pecl-raphf = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-raphf-2.0.2-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-raphf;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-raphf}"
SRC_URI[aarch64_php-pecl-raphf.sha256sum] = "24c8e72f97b9f2abbf9014c0c47aced1e858f058737332f2b17dd9d33f9c1f0d"

URI_aarch64_php-pecl-raphf-devel = "${EPEL_MIRROR}/aarch64/Packages/p/php-pecl-raphf-devel-2.0.2-1.el10_2.aarch64.rpm;name=aarch64_php-pecl-raphf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pecl-raphf-devel}"
SRC_URI[aarch64_php-pecl-raphf-devel.sha256sum] = "d1bcf8a334fe1d0bce2b77e73330c0eea2c66b1331960ee6431ca95e219cd414"

RDEPENDS:php-pecl-raphf = " \
 glibc \
 php-common \
 "
RDEPENDS:php-pecl-raphf-devel = " \
 php-devel \
 php-pecl-raphf \
 "
