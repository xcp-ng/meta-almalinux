# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "freerdp2"
PV = "2.11.7"
PR = "6.el10_0"
PACKAGES = " \
 freerdp2-devel \
 freerdp2-libs \
 libwinpr2 \
 libwinpr2-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/freerdp2-2.11.7-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7250cc74914fe3c1aa7cdc64dc75551702592094d4ccc1a1ccb3ae91b040dd3b"

URI_x86_64_v2_freerdp2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freerdp2-devel-2.11.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freerdp2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp2-devel}"
SRC_URI[x86_64_v2_freerdp2-devel.sha256sum] = "2a69c7b9d07b123d154c9b2b4d5295714f6c125bcf3b9e702dec69cafba58d67"

URI_x86_64_v2_freerdp2-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/freerdp2-libs-2.11.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_freerdp2-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_freerdp2-libs}"
SRC_URI[x86_64_v2_freerdp2-libs.sha256sum] = "8b6d72c00c9dadd95dd3dfa131fa6ac1188d048ecd826183f80fc9f400efead0"

URI_x86_64_v2_libwinpr2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwinpr2-2.11.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwinpr2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr2}"
SRC_URI[x86_64_v2_libwinpr2.sha256sum] = "78596cfbb3aba72ed5be4626aa5ec3ee509f6d055e182851e4184c11ee22fbc7"

URI_x86_64_v2_libwinpr2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libwinpr2-devel-2.11.7-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libwinpr2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwinpr2-devel}"
SRC_URI[x86_64_v2_libwinpr2-devel.sha256sum] = "aea0152b1ab0cb2ab9aba160e9dc2a30697fbc52d36f1e1bb92e0fbc340eae97"

URI_aarch64_freerdp2-devel = "${EPEL_MIRROR}/aarch64/Packages/f/freerdp2-devel-2.11.7-6.el10_0.aarch64.rpm;name=aarch64_freerdp2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp2-devel}"
SRC_URI[aarch64_freerdp2-devel.sha256sum] = "ef41f8cd205e3d5ec394b3dc53ff01e689bf3f6415cce2a908de16ba7d9f3fd7"

URI_aarch64_freerdp2-libs = "${EPEL_MIRROR}/aarch64/Packages/f/freerdp2-libs-2.11.7-6.el10_0.aarch64.rpm;name=aarch64_freerdp2-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_freerdp2-libs}"
SRC_URI[aarch64_freerdp2-libs.sha256sum] = "e1cd7171c42c6252001daa0320dcff548cad5be69822c81f02c348bd8a774f5e"

URI_aarch64_libwinpr2 = "${EPEL_MIRROR}/aarch64/Packages/l/libwinpr2-2.11.7-6.el10_0.aarch64.rpm;name=aarch64_libwinpr2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr2}"
SRC_URI[aarch64_libwinpr2.sha256sum] = "6f867c37b47f0bded142323dfec959ff90889fcb881c8e5682aea6edb5ba5b45"

URI_aarch64_libwinpr2-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libwinpr2-devel-2.11.7-6.el10_0.aarch64.rpm;name=aarch64_libwinpr2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwinpr2-devel}"
SRC_URI[aarch64_libwinpr2-devel.sha256sum] = "81d13fddaf73a0b433cb170b968aa04a16b29e2c76670b2b7f32e3ba74d95f20"

RDEPENDS:freerdp2-devel = " \
 cmake \
 cmake-filesystem \
 freerdp2-devel \
 freerdp2-libs \
 libwinpr2-devel \
 libxkbcommon-devel \
 openssl-devel \
 pkgconf-pkg-config \
 wayland-devel \
 "
RDEPENDS:freerdp2-libs = " \
 alsa-lib \
 cairo \
 cups-libs \
 glibc \
 gsm \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXinerama \
 libXtst \
 libjpeg-turbo \
 libusb1 \
 libwayland-client \
 libwayland-cursor \
 libwinpr2 \
 libxkbcommon \
 libxkbfile \
 noopenh264 \
 openssl-libs \
 pam-libs \
 pulseaudio-libs \
 "
RDEPENDS:libwinpr2 = " \
 glibc \
 libicu \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:libwinpr2-devel = " \
 cmake \
 cmake-filesystem \
 libwinpr2 \
 libwinpr2-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
