# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xq"
PV = "1.4.0"
PR = "2.el10_2"
PACKAGES = " \
 xq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/x/xq-1.4.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7ce053a9b7a04e1e890dd1d7d9acea831dd2afacc5d7145c9c37e9e8a4898955"

URI_x86_64_v2_xq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/xq-1.4.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_xq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xq}"
SRC_URI[x86_64_v2_xq.sha256sum] = "72917cfb4c3feb50ee605c009b33b605804aa9b5a7565bcd750da6e60155a40e"

URI_aarch64_xq = "${EPEL_MIRROR}/aarch64/Packages/x/xq-1.4.0-2.el10_2.aarch64.rpm;name=aarch64_xq;unpack=0"
SRC_URI:append = " ${URI_aarch64_xq}"
SRC_URI[aarch64_xq.sha256sum] = "677c994543383cbf7f8e663b7e017e4a26111570351aa2c8d0010bdc219059c3"

RDEPENDS:xq = " \
 glibc \
 "
