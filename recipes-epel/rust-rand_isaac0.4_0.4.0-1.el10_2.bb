# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_isaac0.4"
PV = "0.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_isaac0.4+default-devel \
 rust-rand_isaac0.4+serde-devel \
 rust-rand_isaac0.4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_isaac0.4-0.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b67ee2c56385bbd4a5f1b84da9f75139a10536bd02e94cb8a357d8852c79a94"

URI_x86_64_v2_rust-rand_isaac0.4+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac0.4+default-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac0.4+default-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac0.4+default-devel.sha256sum] = "2f091c0e0d58f1e6b8686bc52ba3dfed74af4a63e3c1912194b4f522efc64257"

URI_x86_64_v2_rust-rand_isaac0.4+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac0.4+serde-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac0.4+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac0.4+serde-devel.sha256sum] = "e72583f04bd821f615b12a0ff4bae8b4a5c2d43666d808d8ea0da4a10d60823a"

URI_x86_64_v2_rust-rand_isaac0.4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_isaac0.4-devel-0.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_isaac0.4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_isaac0.4-devel}"
SRC_URI[x86_64_v2_rust-rand_isaac0.4-devel.sha256sum] = "0d027ca886837a79ecfae231562880c94302436038aac95341ad17620c21ba54"

URI_aarch64_rust-rand_isaac0.4+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac0.4+default-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac0.4+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac0.4+default-devel}"
SRC_URI[aarch64_rust-rand_isaac0.4+default-devel.sha256sum] = "6adedb4d8764ebcc93866215851b84e37898f49eb3d586a8c34937df4c7b84ae"

URI_aarch64_rust-rand_isaac0.4+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac0.4+serde-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac0.4+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac0.4+serde-devel}"
SRC_URI[aarch64_rust-rand_isaac0.4+serde-devel.sha256sum] = "b759df75c16ce4cf39957c6bb24eb897555feff56e642e30264c98c09e0d0e0a"

URI_aarch64_rust-rand_isaac0.4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_isaac0.4-devel-0.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_isaac0.4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_isaac0.4-devel}"
SRC_URI[aarch64_rust-rand_isaac0.4-devel.sha256sum] = "5100bc5d676a7427f3390a071798d759fa52273193df3dcff76ccfcfdcf14c23"

RDEPENDS:rust-rand_isaac0.4+default-devel = " \
 cargo \
 rust-rand_isaac0.4-devel \
 "
RDEPENDS:rust-rand_isaac0.4+serde-devel = " \
 cargo \
 rust-rand_core0.9+serde-devel \
 rust-rand_isaac0.4-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_isaac0.4-devel = " \
 cargo \
 rust \
 rust-rand_core0.9+default-devel \
 "
