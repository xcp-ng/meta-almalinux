# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbackup"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kbackup \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kbackup-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "576af3a0555ab90a243640fbda3d552af338f34d838297dae2abb81995e5a36a"

URI_x86_64_v2_kbackup = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kbackup-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kbackup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbackup}"
SRC_URI[x86_64_v2_kbackup.sha256sum] = "d2a0210c712a7e72326170e097dd66864db864bef2e8916778ed8953f87206c5"

URI_aarch64_kbackup = "${EPEL_MIRROR}/aarch64/Packages/k/kbackup-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kbackup;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbackup}"
SRC_URI[aarch64_kbackup.sha256sum] = "f2770427f534e3705edd88e872e8f3b8ed163e9eed5394fba309d4fe61593673"

RDEPENDS:kbackup = " \
 glibc \
 hicolor-icon-theme \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libarchive \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
