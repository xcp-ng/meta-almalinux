# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ptyxis"
PV = "47.10"
PR = "1.el10"
PACKAGES = " \
 ptyxis \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ptyxis-47.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b53f378499954b04c68754e5aa468cb3fab76e3603ad76d573e13fc5f32b710c"

URI_x86_64_v2_ptyxis = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ptyxis-47.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_ptyxis;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ptyxis}"
SRC_URI[x86_64_v2_ptyxis.sha256sum] = "f7cd56c7ff521a244eca04a52abefb902258dc7c224767b5142e5bba008a6fdd"

URI_aarch64_ptyxis = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ptyxis-47.10-1.el10.aarch64.rpm;name=aarch64_ptyxis;unpack=0"
SRC_URI:append = " ${URI_aarch64_ptyxis}"
SRC_URI[aarch64_ptyxis.sha256sum] = "6bbddcde0b0e0325f0aa9630e5180fcf6bc61cb416c230b6cd932c2a2d439027"

RDEPENDS:ptyxis = " \
 glib2 \
 glibc \
 gtk4 \
 hicolor-icon-theme \
 json-glib \
 libadwaita \
 libgcc \
 libportal \
 libportal-gtk4 \
 pango \
 vte291-gtk4 \
 "
