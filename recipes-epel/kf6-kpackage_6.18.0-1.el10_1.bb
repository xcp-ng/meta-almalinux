# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kpackage"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kpackage \
 kf6-kpackage-devel \
 kf6-kpackage-doc \
 kf6-kpackage-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kpackage-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2de066c256276c50b6b093097cdf4d5e904e9f1835d8715fbb82cba3b3db13b"

URI_x86_64_v2_kf6-kpackage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage}"
SRC_URI[x86_64_v2_kf6-kpackage.sha256sum] = "86a36fa774690eff02020259235b8a4114a53c7a144f8908076f7a28ec0ab2b9"

URI_x86_64_v2_kf6-kpackage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kpackage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-devel}"
SRC_URI[x86_64_v2_kf6-kpackage-devel.sha256sum] = "6e435faa64185537ce2f5a043b9845dc91b47d0d53bf779f713c5a044aa2efd7"

URI_x86_64_v2_kf6-kpackage-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpackage-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-doc}"
SRC_URI[x86_64_v2_kf6-kpackage-doc.sha256sum] = "e487a911374dd9be07c895b528c5f56c01d51625fa0db659a5a87de8b0e540e1"

URI_x86_64_v2_kf6-kpackage-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kpackage-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kpackage-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kpackage-html}"
SRC_URI[x86_64_v2_kf6-kpackage-html.sha256sum] = "70e1c3f91fb08a12a2b1bff70118ae323387186db5c7cdc6e8f72105acd1d69b"

URI_aarch64_kf6-kpackage = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kpackage;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage}"
SRC_URI[aarch64_kf6-kpackage.sha256sum] = "f73ee9f016067b03a82af7d1b84fb8f570fdd23105034951bca651aeabd07f29"

URI_aarch64_kf6-kpackage-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kpackage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-devel}"
SRC_URI[aarch64_kf6-kpackage-devel.sha256sum] = "d725be779d1f943f33e4021df07f6975677d02e67852650e3f76b3841d7617ca"

URI_aarch64_kf6-kpackage-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kpackage-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-doc}"
SRC_URI[aarch64_kf6-kpackage-doc.sha256sum] = "e670f5b8822d002a0d4817bdb3cd04a05ea5a97aa3e996a80990888ed28a6c4a"

URI_aarch64_kf6-kpackage-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kpackage-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kpackage-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kpackage-html}"
SRC_URI[aarch64_kf6-kpackage-html.sha256sum] = "e5002791134df92964ae87146fa9eb4f55fac3dc6d41a15d7abfc8e1e2805e8f"

RDEPENDS:kf6-kpackage = " \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-kpackage-devel = " \
 cmake-filesystem \
 kf6-kpackage \
 "
RDEPENDS:kf6-kpackage-doc = " \
 "
RDEPENDS:kf6-kpackage-html = " \
 "
