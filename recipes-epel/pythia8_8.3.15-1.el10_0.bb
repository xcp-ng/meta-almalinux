# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pythia8"
PV = "8.3.15"
PR = "1.el10_0"
PACKAGES = " \
 pythia8 \
 pythia8-data \
 pythia8-devel \
 pythia8-doc \
 pythia8-examples \
 pythia8-lhapdf \
 python3-pythia8 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pythia8-8.3.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "687ba9e0f1f3213e5ce6f9ccadf67195edfec2f473835df433169966ae684a34"

URI_x86_64_v2_pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-8.3.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8}"
SRC_URI[x86_64_v2_pythia8.sha256sum] = "ebbd5e0cfc7b2878fb4f4ffa38dad17271e5b82655efb5f85b0c2edb6eec15d2"

URI_x86_64_v2_pythia8-data = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-data-8.3.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-data;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-data}"
SRC_URI[x86_64_v2_pythia8-data.sha256sum] = "acb1c8abaf9acafe962a7061f5c24a3a6820533f9aae61ca4ea9ebfdeca4f9b1"

URI_x86_64_v2_pythia8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-devel-8.3.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-devel}"
SRC_URI[x86_64_v2_pythia8-devel.sha256sum] = "c8ff09b2808f8d30e71a2877e03586e18c5c690fe1414580fb66166577213066"

URI_x86_64_v2_pythia8-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-doc-8.3.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-doc}"
SRC_URI[x86_64_v2_pythia8-doc.sha256sum] = "519854615685813257ec75b9eede824bc7f71bb2108b27dda272305ca1b76526"

URI_x86_64_v2_pythia8-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-examples-8.3.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pythia8-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-examples}"
SRC_URI[x86_64_v2_pythia8-examples.sha256sum] = "c84d0c9679e8a18893fb1318c84cc32190796d42ac21629deedd7a57e8580b6b"

URI_x86_64_v2_pythia8-lhapdf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythia8-lhapdf-8.3.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pythia8-lhapdf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythia8-lhapdf}"
SRC_URI[x86_64_v2_pythia8-lhapdf.sha256sum] = "704cc38c9e95782f4e4e230f8f7916deaaf0367deaa1943e83b80e044bb590ea"

URI_x86_64_v2_python3-pythia8 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pythia8-8.3.15-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pythia8;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pythia8}"
SRC_URI[x86_64_v2_python3-pythia8.sha256sum] = "65fef36007b5b0f3f885d50553636a0a55e14484b820673aeaa1c72414f22ec6"

URI_aarch64_pythia8 = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-8.3.15-1.el10_0.aarch64.rpm;name=aarch64_pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8}"
SRC_URI[aarch64_pythia8.sha256sum] = "8547fc2d1a218cfc652120782d98b49644af227af8a4110056f1476da695c232"

URI_aarch64_pythia8-data = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-data-8.3.15-1.el10_0.noarch.rpm;name=aarch64_pythia8-data;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-data}"
SRC_URI[aarch64_pythia8-data.sha256sum] = "d9db302f89dbed4cce4c33ec09896cb49e94cd818d2eb97edd6886e3b86ce366"

URI_aarch64_pythia8-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-devel-8.3.15-1.el10_0.aarch64.rpm;name=aarch64_pythia8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-devel}"
SRC_URI[aarch64_pythia8-devel.sha256sum] = "b4e72cc738bc2a6993b87a0670a311be3df40cf341bd5a9929ebd379bed5b44f"

URI_aarch64_pythia8-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-doc-8.3.15-1.el10_0.noarch.rpm;name=aarch64_pythia8-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-doc}"
SRC_URI[aarch64_pythia8-doc.sha256sum] = "2aa3019b130e5f420fcab07fbacfea4b2c87fd25a2af9cd7caec6744acf1dc27"

URI_aarch64_pythia8-examples = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-examples-8.3.15-1.el10_0.noarch.rpm;name=aarch64_pythia8-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-examples}"
SRC_URI[aarch64_pythia8-examples.sha256sum] = "f18c18166f31988a6a9c7ac84b7f25df37c72bc3b50836d4d60c4a1d11427243"

URI_aarch64_pythia8-lhapdf = "${EPEL_MIRROR}/aarch64/Packages/p/pythia8-lhapdf-8.3.15-1.el10_0.aarch64.rpm;name=aarch64_pythia8-lhapdf;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythia8-lhapdf}"
SRC_URI[aarch64_pythia8-lhapdf.sha256sum] = "8fbfd072727124103bb0814df88974d5e8bac7ed13f778d80a0056451fe0137c"

URI_aarch64_python3-pythia8 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pythia8-8.3.15-1.el10_0.aarch64.rpm;name=aarch64_python3-pythia8;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pythia8}"
SRC_URI[aarch64_python3-pythia8.sha256sum] = "e2035f40918819c0df00b1fed012dbe2168dc2ee17aa06bc8f79c22fbfa45f7c"

RDEPENDS:pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8-data \
 zlib-ng-compat \
 "
RDEPENDS:pythia8-data = " \
 "
RDEPENDS:pythia8-devel = " \
 pythia8 \
 "
RDEPENDS:pythia8-doc = " \
 "
RDEPENDS:pythia8-examples = " \
 "
RDEPENDS:pythia8-lhapdf = " \
 glibc \
 lhapdf \
 libgcc \
 libstdc++ \
 pythia8 \
 "
RDEPENDS:python3-pythia8 = " \
 glibc \
 libgcc \
 libstdc++ \
 pythia8 \
 python3 \
 "
