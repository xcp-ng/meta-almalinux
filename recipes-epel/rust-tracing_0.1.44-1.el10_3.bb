# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tracing"
PV = "0.1.44"
PR = "1.el10_3"
PACKAGES = " \
 rust-tracing+async-await-devel \
 rust-tracing+attributes-devel \
 rust-tracing+default-devel \
 rust-tracing+log-always-devel \
 rust-tracing+log-devel \
 rust-tracing+max_level_debug-devel \
 rust-tracing+max_level_error-devel \
 rust-tracing+max_level_info-devel \
 rust-tracing+max_level_off-devel \
 rust-tracing+max_level_trace-devel \
 rust-tracing+max_level_warn-devel \
 rust-tracing+release_max_level_debug-devel \
 rust-tracing+release_max_level_error-devel \
 rust-tracing+release_max_level_info-devel \
 rust-tracing+release_max_level_off-devel \
 rust-tracing+release_max_level_trace-devel \
 rust-tracing+release_max_level_warn-devel \
 rust-tracing+std-devel \
 rust-tracing+tracing-attributes-devel \
 rust-tracing-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tracing-0.1.44-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a093dcb09c9f0a64f79ddd2059735eb570735659b8f3261b56919c75baf6129"

URI_x86_64_v2_rust-tracing+async-await-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+async-await-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+async-await-devel}"
SRC_URI[x86_64_v2_rust-tracing+async-await-devel.sha256sum] = "e6719676f39f2e06243e8b725fe7a2febe5a163ebcb8ea6602650f046e6a6bbc"

URI_x86_64_v2_rust-tracing+attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+attributes-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing+attributes-devel.sha256sum] = "0c2a0b3f2aee154fce1b0b7bb12cb2218dde076ab432cc64c9380d558fe6960e"

URI_x86_64_v2_rust-tracing+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+default-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+default-devel}"
SRC_URI[x86_64_v2_rust-tracing+default-devel.sha256sum] = "bcb218b199ba2d0b5300de6167bbe4b38b950fe1680122a666294acc3c5795f3"

URI_x86_64_v2_rust-tracing+log-always-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+log-always-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+log-always-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+log-always-devel}"
SRC_URI[x86_64_v2_rust-tracing+log-always-devel.sha256sum] = "4f7dffed248af9f99060682bbac3d5ca95417a2f671e48f6d0a7bbfabf6522e1"

URI_x86_64_v2_rust-tracing+log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+log-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+log-devel}"
SRC_URI[x86_64_v2_rust-tracing+log-devel.sha256sum] = "cbb7d49f001113f2e9d9b161a95cf3747a30053df6a3fd88652599785393549c"

URI_x86_64_v2_rust-tracing+max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_debug-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_debug-devel.sha256sum] = "a1f5d5b8d56485c0292fcbd2f0c011bb9f69751373f4262c6efa63b4e2cd37f2"

URI_x86_64_v2_rust-tracing+max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_error-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_error-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_error-devel.sha256sum] = "1ad552d5190c13b6a6d5753bde7f22d16a80951577ddc67667321b4127e184ad"

URI_x86_64_v2_rust-tracing+max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_info-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_info-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_info-devel.sha256sum] = "7654c18cc83feba2dae134e62c7b029b3b34a92e07033f21557e9a269eec1510"

URI_x86_64_v2_rust-tracing+max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_off-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_off-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_off-devel.sha256sum] = "b5e2278f6a49c42b12629d3380adc4d8907e3b04759d2ef5e9e8a466e738c3cf"

URI_x86_64_v2_rust-tracing+max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_trace-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_trace-devel.sha256sum] = "3e29a3f71ad8aa148fdf8ac70a9930377c1ad56f68c1cfd18798db2cdfbd2e43"

URI_x86_64_v2_rust-tracing+max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+max_level_warn-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-tracing+max_level_warn-devel.sha256sum] = "bda3c1cd8b2468d4b08f76e9701574c21336e7c923b801b9271441cf88f33f9a"

URI_x86_64_v2_rust-tracing+release_max_level_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_debug-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_debug-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_debug-devel.sha256sum] = "5eb32700b63def19c29e58a4e3727146faccc5957b6e0a215a8e4c73aab52fe2"

URI_x86_64_v2_rust-tracing+release_max_level_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_error-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_error-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_error-devel.sha256sum] = "3a53b7cf27f859d9782d45e97a255faf4078136aeb0d91cced70ac31fe3884a1"

URI_x86_64_v2_rust-tracing+release_max_level_info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_info-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_info-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_info-devel.sha256sum] = "83f964c429c22351c011ecfae702e9472d116a9f14a196737880974cc33c7936"

URI_x86_64_v2_rust-tracing+release_max_level_off-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_off-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_off-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_off-devel.sha256sum] = "5fb8fffa182a5b2d812172902b3de1ce2108b5bbca65acdb957115efdbde9fe1"

URI_x86_64_v2_rust-tracing+release_max_level_trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_trace-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_trace-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_trace-devel.sha256sum] = "dac00eb3a7f063de6ebc625e9a8cae7aa5dfeb8ef2bdc7b66699eaad2c2aaf14"

URI_x86_64_v2_rust-tracing+release_max_level_warn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+release_max_level_warn-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+release_max_level_warn-devel}"
SRC_URI[x86_64_v2_rust-tracing+release_max_level_warn-devel.sha256sum] = "2d6afde0844541dcdf2658b61fc3544b22f8a8d7ba2ccc051254e92528859d6c"

URI_x86_64_v2_rust-tracing+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+std-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+std-devel}"
SRC_URI[x86_64_v2_rust-tracing+std-devel.sha256sum] = "46f2ebd964fa081b3c196952764e565deec328b3bb629757339dffe60b30e9cc"

URI_x86_64_v2_rust-tracing+tracing-attributes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing+tracing-attributes-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing+tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing+tracing-attributes-devel}"
SRC_URI[x86_64_v2_rust-tracing+tracing-attributes-devel.sha256sum] = "332897d8b8d6ea0c0f25c33025f7aa10b3abc4cf68906a15e560e8934939200e"

URI_x86_64_v2_rust-tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tracing-devel-0.1.44-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tracing-devel}"
SRC_URI[x86_64_v2_rust-tracing-devel.sha256sum] = "bf3b95f9fc4cb817621f9853ed62d4e53445f8d06f4946b150e81ebcc50c533e"

URI_aarch64_rust-tracing+async-await-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+async-await-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+async-await-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+async-await-devel}"
SRC_URI[aarch64_rust-tracing+async-await-devel.sha256sum] = "eb8c19d1158f88c42a199e2274708f0fdeae45648290a6e610152e58875495f1"

URI_aarch64_rust-tracing+attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+attributes-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+attributes-devel}"
SRC_URI[aarch64_rust-tracing+attributes-devel.sha256sum] = "49c432e2c46c975d5e8e459c24a08e0250043afd08b92c8a8737c24b60c3ca3d"

URI_aarch64_rust-tracing+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+default-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+default-devel}"
SRC_URI[aarch64_rust-tracing+default-devel.sha256sum] = "2fdf0a5221527944a31430c9e1bed9d6fac7cc4cd20b9a00f81b946f4688f7eb"

URI_aarch64_rust-tracing+log-always-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+log-always-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+log-always-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+log-always-devel}"
SRC_URI[aarch64_rust-tracing+log-always-devel.sha256sum] = "1e00bad21123f1cf432687f0887955a9636f89fa9e5e6b3101621360c74b433c"

URI_aarch64_rust-tracing+log-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+log-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+log-devel}"
SRC_URI[aarch64_rust-tracing+log-devel.sha256sum] = "66f0c95eba74e11f632932f4ab3fdec35f5cbef2fb591087b42d0e56ddc325a0"

URI_aarch64_rust-tracing+max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_debug-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_debug-devel}"
SRC_URI[aarch64_rust-tracing+max_level_debug-devel.sha256sum] = "495a14ff61f36664c50e39be438f501528b61c2d5524cfdefb664d34d5fe360d"

URI_aarch64_rust-tracing+max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_error-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_error-devel}"
SRC_URI[aarch64_rust-tracing+max_level_error-devel.sha256sum] = "7faed4b0b82230906313f5ad77c01a7cd36a9adca8301acfa3183bb42b82f2bb"

URI_aarch64_rust-tracing+max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_info-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_info-devel}"
SRC_URI[aarch64_rust-tracing+max_level_info-devel.sha256sum] = "242bd5417da75749fa9d7b65ee2bd3d85b511aa3ad9074acf5b9874f82e7e8da"

URI_aarch64_rust-tracing+max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_off-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_off-devel}"
SRC_URI[aarch64_rust-tracing+max_level_off-devel.sha256sum] = "e1a9ee1e6e2eb08dcab2d195834c77f0d10057a7949ac18b6b7f57b5c8238586"

URI_aarch64_rust-tracing+max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_trace-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_trace-devel}"
SRC_URI[aarch64_rust-tracing+max_level_trace-devel.sha256sum] = "02ac48125a19b243b6353d035dc418f3b61d329f24aed93d30f1761400449c4b"

URI_aarch64_rust-tracing+max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+max_level_warn-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+max_level_warn-devel}"
SRC_URI[aarch64_rust-tracing+max_level_warn-devel.sha256sum] = "ef051fdd2dcf7cfed99208b80fd14ad738143e0921fba7d4e29e177df66a436d"

URI_aarch64_rust-tracing+release_max_level_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_debug-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+release_max_level_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_debug-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_debug-devel.sha256sum] = "ff55f4f405884270d7645acf7d19826ec288320a0682adaec70d4e54d630be02"

URI_aarch64_rust-tracing+release_max_level_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_error-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+release_max_level_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_error-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_error-devel.sha256sum] = "a90e9d4bc6cb9100c1aad952b4a1d8613b26882d68102f38fd2c6b794ee216bd"

URI_aarch64_rust-tracing+release_max_level_info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_info-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+release_max_level_info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_info-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_info-devel.sha256sum] = "b48114deec5ee970658d36d8463056311b9f01da5355ad98278a5155e6cc6e05"

URI_aarch64_rust-tracing+release_max_level_off-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_off-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+release_max_level_off-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_off-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_off-devel.sha256sum] = "c334db671bfcf3958202ca558ae5a8ec91897d06c27247a8580b53ab64ca1689"

URI_aarch64_rust-tracing+release_max_level_trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_trace-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+release_max_level_trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_trace-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_trace-devel.sha256sum] = "e4590ce836f9e34f6f800755b5ba7bd28976748205dda60e3b37f8b728955809"

URI_aarch64_rust-tracing+release_max_level_warn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+release_max_level_warn-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+release_max_level_warn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+release_max_level_warn-devel}"
SRC_URI[aarch64_rust-tracing+release_max_level_warn-devel.sha256sum] = "e228eb0a3479a1a60db6603df2090b6655d9083818b2e8d0f3585128254b42d6"

URI_aarch64_rust-tracing+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+std-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+std-devel}"
SRC_URI[aarch64_rust-tracing+std-devel.sha256sum] = "75be9fb3ee2577c349ad04bb330c1124508d2063a501b125e7ba840fea4ebbfb"

URI_aarch64_rust-tracing+tracing-attributes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing+tracing-attributes-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing+tracing-attributes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing+tracing-attributes-devel}"
SRC_URI[aarch64_rust-tracing+tracing-attributes-devel.sha256sum] = "43a3c9a95512c3e3b086f45ff393131d8f5f3e22972c97976a572d48a93e8b22"

URI_aarch64_rust-tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tracing-devel-0.1.44-1.el10_3.noarch.rpm;name=aarch64_rust-tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tracing-devel}"
SRC_URI[aarch64_rust-tracing-devel.sha256sum] = "236065cba250561e2851bfed562b96ee7c155430bbc3c237f1763b0e0a85f194"

RDEPENDS:rust-tracing+async-await-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+attributes-devel = " \
 cargo \
 rust-tracing+tracing-attributes-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+default-devel = " \
 cargo \
 rust-tracing+attributes-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+log-always-devel = " \
 cargo \
 rust-tracing+log-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+log-devel = " \
 cargo \
 rust-log+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_debug-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_error-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_info-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_off-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_trace-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+max_level_warn-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_debug-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_error-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_info-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_off-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_trace-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+release_max_level_warn-devel = " \
 cargo \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+std-devel = " \
 cargo \
 rust-tracing-core+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing+tracing-attributes-devel = " \
 cargo \
 rust-tracing-attributes+default-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tracing-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 rust-tracing-core-devel \
 "
