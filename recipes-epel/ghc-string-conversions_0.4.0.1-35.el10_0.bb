# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-string-conversions"
PV = "0.4.0.1"
PR = "35.el10_0"
PACKAGES = " \
 ghc-string-conversions \
 ghc-string-conversions-devel \
 ghc-string-conversions-doc \
 ghc-string-conversions-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-string-conversions-0.4.0.1-35.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "02aea8cdc502efbad3633c29d067da1e624c79ea9aaf3b0121d196a83a1a9ae1"

URI_x86_64_v2_ghc-string-conversions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-string-conversions-0.4.0.1-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-string-conversions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-string-conversions}"
SRC_URI[x86_64_v2_ghc-string-conversions.sha256sum] = "15ba7ec79bf9ce175d441eb891a7d7654725413cd8e325de6d32c7c0539d7a3a"

URI_x86_64_v2_ghc-string-conversions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-string-conversions-devel-0.4.0.1-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-string-conversions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-string-conversions-devel}"
SRC_URI[x86_64_v2_ghc-string-conversions-devel.sha256sum] = "71d046af8001e1ca7bfb66f9ee9424c952837045121135bf32817e5bc0d43f44"

URI_x86_64_v2_ghc-string-conversions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-string-conversions-doc-0.4.0.1-35.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-string-conversions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-string-conversions-doc}"
SRC_URI[x86_64_v2_ghc-string-conversions-doc.sha256sum] = "f5f804b9f16845c3307a6fdfc91abc8bcde94d9db7d50f1da0f8cbadcba9d046"

URI_x86_64_v2_ghc-string-conversions-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-string-conversions-prof-0.4.0.1-35.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-string-conversions-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-string-conversions-prof}"
SRC_URI[x86_64_v2_ghc-string-conversions-prof.sha256sum] = "da8c2cb4722ad24c90901f513853a46a7ce70ac694231c39b121a5cb4a5cd3d9"

URI_aarch64_ghc-string-conversions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-string-conversions-0.4.0.1-35.el10_0.aarch64.rpm;name=aarch64_ghc-string-conversions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-string-conversions}"
SRC_URI[aarch64_ghc-string-conversions.sha256sum] = "00b95b36bff0849f9fa66410bebc5fe12f26b9115fef0f49c50e6f4ad5508864"

URI_aarch64_ghc-string-conversions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-string-conversions-devel-0.4.0.1-35.el10_0.aarch64.rpm;name=aarch64_ghc-string-conversions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-string-conversions-devel}"
SRC_URI[aarch64_ghc-string-conversions-devel.sha256sum] = "a3984197ab87176c4451fd789556b32f9431ced77c8f638d79aea6e69b0bd77b"

URI_aarch64_ghc-string-conversions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-string-conversions-doc-0.4.0.1-35.el10_0.noarch.rpm;name=aarch64_ghc-string-conversions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-string-conversions-doc}"
SRC_URI[aarch64_ghc-string-conversions-doc.sha256sum] = "bea10ecc22431840210580649c09953ece0fa5e1a2cd27c4df828269200a0c9b"

URI_aarch64_ghc-string-conversions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-string-conversions-prof-0.4.0.1-35.el10_0.aarch64.rpm;name=aarch64_ghc-string-conversions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-string-conversions-prof}"
SRC_URI[aarch64_ghc-string-conversions-prof.sha256sum] = "08219d8f2755c63a4f3fba054df5f22bfd261514b3ac6dc335dfbd6bb00be98b"

RDEPENDS:ghc-string-conversions = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 ghc-utf8-string \
 glibc \
 gmp \
 "
RDEPENDS:ghc-string-conversions-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-string-conversions \
 ghc-text-devel \
 ghc-utf8-string-devel \
 "
RDEPENDS:ghc-string-conversions-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-string-conversions-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-string-conversions-devel \
 ghc-text-prof \
 ghc-utf8-string-prof \
 "
