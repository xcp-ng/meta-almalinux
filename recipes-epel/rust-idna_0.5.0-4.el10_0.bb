# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-idna"
PV = "0.5.0"
PR = "4.el10_0"
PACKAGES = " \
 rust-idna+alloc-devel \
 rust-idna+default-devel \
 rust-idna+std-devel \
 rust-idna-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-idna-0.5.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c29d4599964c664bfcb672e6f43133c0ebfa7f2ac47e1ab944164b9df85be9af"

URI_x86_64_v2_rust-idna+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+alloc-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+alloc-devel}"
SRC_URI[x86_64_v2_rust-idna+alloc-devel.sha256sum] = "1e4f29c1998b38182894b5ccdcc5040b386e032da2ec3a3fa8822d93833789a0"

URI_x86_64_v2_rust-idna+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+default-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+default-devel}"
SRC_URI[x86_64_v2_rust-idna+default-devel.sha256sum] = "fa25935c816ce3cff771c460f86955a50ad37574d8a3abac54af2609907ffade"

URI_x86_64_v2_rust-idna+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna+std-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna+std-devel}"
SRC_URI[x86_64_v2_rust-idna+std-devel.sha256sum] = "ab9619d297ffe8eb3b684525398fd051b01d630ce6e9dc5d963a50ed1c2b839c"

URI_x86_64_v2_rust-idna-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-idna-devel-0.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-idna-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-idna-devel}"
SRC_URI[x86_64_v2_rust-idna-devel.sha256sum] = "2cf70430c31ebe35e6b72980414a775692d43b2bebc0425d2ee97b34a431d04e"

URI_aarch64_rust-idna+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+alloc-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-idna+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+alloc-devel}"
SRC_URI[aarch64_rust-idna+alloc-devel.sha256sum] = "b7de0e3eb0fadf0af7db750582801112bf61ce6acdff72cc30f268163f2913cf"

URI_aarch64_rust-idna+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+default-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-idna+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+default-devel}"
SRC_URI[aarch64_rust-idna+default-devel.sha256sum] = "c07823661f10866e2691ab8802c1c25dfcfce788aaad71a9234bea17beb81e6b"

URI_aarch64_rust-idna+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna+std-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-idna+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna+std-devel}"
SRC_URI[aarch64_rust-idna+std-devel.sha256sum] = "6ac89b2572245860709d37707e7821b7b19dcfe5078962e7cb9dd0dcea03ca80"

URI_aarch64_rust-idna-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-idna-devel-0.5.0-4.el10_0.noarch.rpm;name=aarch64_rust-idna-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-idna-devel}"
SRC_URI[aarch64_rust-idna-devel.sha256sum] = "8863a2c6ba95ce856ef3581eabc730625f3805fd8774b1c4e5b25b95efe3e27c"

RDEPENDS:rust-idna+alloc-devel = " \
 cargo \
 rust-idna-devel \
 "
RDEPENDS:rust-idna+default-devel = " \
 cargo \
 rust-idna+std-devel \
 rust-idna-devel \
 "
RDEPENDS:rust-idna+std-devel = " \
 cargo \
 rust-idna+alloc-devel \
 rust-idna-devel \
 rust-unicode-bidi+std-devel \
 rust-unicode-normalization+std-devel \
 "
RDEPENDS:rust-idna-devel = " \
 cargo \
 rust \
 rust-unicode-bidi+hardcoded-data-devel \
 rust-unicode-bidi-devel \
 rust-unicode-normalization-devel \
 "
