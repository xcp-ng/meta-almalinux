# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-channel"
PV = "0.5.17"
PR = "1.el10_3"
PACKAGES = " \
 rust-crossbeam-channel+default-devel \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-channel-0.5.17-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2d9c14c816e479c08d719efe72e8db85ec122cc7e30e766c420ca45f263cd7d5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+default-devel-0.5.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-channel+default-devel.sha256sum] = "06e3de05cdd6c033c357c0dd7d0848dd8ddc0bd8b08421937ff726402381cada"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+std-devel-0.5.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-channel+std-devel.sha256sum] = "fdcfef4e55652d29e7e44380f47defeaf452a33e5882800beefc9bf4f6695fa2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel-devel-0.5.17-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel-devel;unpack=0"
SRC_URI[x86_64_v2_rust-crossbeam-channel-devel.sha256sum] = "525ab09e9882f20fc2c9ac8c89ce0109a37b2988bc57725c91629c5e5460d66a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+default-devel-0.5.17-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-channel+default-devel.sha256sum] = "a4d2b45ce28da621d02c6e9f47836c34234d7b4cf0e38160a4946d3f84fc346c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+std-devel-0.5.17-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-channel+std-devel.sha256sum] = "aa5f597d83c648da61850e7df35b3572c97cf39f5ae6415fecc412334b043fae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel-devel-0.5.17-1.el10_3.noarch.rpm;name=aarch64_rust-crossbeam-channel-devel;unpack=0"
SRC_URI[aarch64_rust-crossbeam-channel-devel.sha256sum] = "baf27fff8005c017dd271335833d4eb3531e59ff4e76ac316e3c4f267beb8cff"

RDEPENDS:rust-crossbeam-channel+default-devel = " \
 cargo \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "
RDEPENDS:rust-crossbeam-channel+std-devel = " \
 cargo \
 rust-crossbeam-channel-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-channel-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
