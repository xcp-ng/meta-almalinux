# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_who"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_who+default-devel \
 rust-uu_who+feat_systemd_logind-devel \
 rust-uu_who-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_who-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "085dcd3bebc4022f18d6ab2d1f373b01fbbfb7becdbc61c22e38622694389b7b"

URI_x86_64_v2_rust-uu_who+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_who+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_who+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_who+default-devel}"
SRC_URI[x86_64_v2_rust-uu_who+default-devel.sha256sum] = "27a28910b73a34f003cfaf207f89aacaae808e519ad1688c362fdb08b205d507"

URI_x86_64_v2_rust-uu_who+feat_systemd_logind-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_who+feat_systemd_logind-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_who+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_who+feat_systemd_logind-devel}"
SRC_URI[x86_64_v2_rust-uu_who+feat_systemd_logind-devel.sha256sum] = "423f5f18fba0ff0c61d3ceb99787565406e051d7867be47586cd1a647a26ca80"

URI_x86_64_v2_rust-uu_who-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_who-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_who-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_who-devel}"
SRC_URI[x86_64_v2_rust-uu_who-devel.sha256sum] = "df777da7d9a806af443984d570a0c18dbecc29fe520ecaaf6935835a4d2ff76b"

URI_aarch64_rust-uu_who+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_who+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_who+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_who+default-devel}"
SRC_URI[aarch64_rust-uu_who+default-devel.sha256sum] = "30a3a45c61d717cbf885623c2fd43e1d687d5a0545a7bcc656d43bd9c539baf2"

URI_aarch64_rust-uu_who+feat_systemd_logind-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_who+feat_systemd_logind-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_who+feat_systemd_logind-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_who+feat_systemd_logind-devel}"
SRC_URI[aarch64_rust-uu_who+feat_systemd_logind-devel.sha256sum] = "a28c4eb9b7943b16e920fdbf5cd0daba358428342f91d17a6d9b0d4a3edc31b5"

URI_aarch64_rust-uu_who-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_who-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_who-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_who-devel}"
SRC_URI[aarch64_rust-uu_who-devel.sha256sum] = "e0a1541464de8de61370661843372cd09374c6f8af004d38dbe01790aa5aa84b"

RDEPENDS:rust-uu_who+default-devel = " \
 cargo \
 rust-uu_who-devel \
 "
RDEPENDS:rust-uu_who+feat_systemd_logind-devel = " \
 cargo \
 rust-uu_who-devel \
 rust-uucore+feat_systemd_logind-devel \
 "
RDEPENDS:rust-uu_who-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+utmpx-devel \
 "
