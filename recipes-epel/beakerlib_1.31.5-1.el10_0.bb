# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "beakerlib"
PV = "1.31.5"
PR = "1.el10_0"
PACKAGES = " \
 beakerlib \
 beakerlib-vim-syntax \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/beakerlib-1.31.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3506033b24f65d231bec30300ffb9beae5dbfec829e87157a574a605826fbb2b"

URI_x86_64_v2_beakerlib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beakerlib-1.31.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_beakerlib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beakerlib}"
SRC_URI[x86_64_v2_beakerlib.sha256sum] = "0540af6816491a2a37ea856765838dbc292e92d7819f0fcead60637459604aa4"

URI_x86_64_v2_beakerlib-vim-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/beakerlib-vim-syntax-1.31.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_beakerlib-vim-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_beakerlib-vim-syntax}"
SRC_URI[x86_64_v2_beakerlib-vim-syntax.sha256sum] = "9378512597c0668201ff84fd539ff175f5a7dcd3508db699f2fd5dbd5ff573af"

URI_aarch64_beakerlib = "${EPEL_MIRROR}/aarch64/Packages/b/beakerlib-1.31.5-1.el10_0.noarch.rpm;name=aarch64_beakerlib;unpack=0"
SRC_URI:append = " ${URI_aarch64_beakerlib}"
SRC_URI[aarch64_beakerlib.sha256sum] = "2628a75315f5568793070eaada1314ec583289eacb28f39353d527bb55de8e20"

URI_aarch64_beakerlib-vim-syntax = "${EPEL_MIRROR}/aarch64/Packages/b/beakerlib-vim-syntax-1.31.5-1.el10_0.noarch.rpm;name=aarch64_beakerlib-vim-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_beakerlib-vim-syntax}"
SRC_URI[aarch64_beakerlib-vim-syntax.sha256sum] = "36b3ea996e2863252ec5eb10ff483f6338204e4d0810d13dea906f7f95380c48"

RDEPENDS:beakerlib = " \
 bash \
 bc \
 grep \
 gzip \
 iproute \
 nfs-utils \
 sed \
 tar \
 time \
 util-linux \
 virtual/coreutils \
 virtual/wget_or_curl \
 which \
 yum-utils \
 "
RDEPENDS:beakerlib-vim-syntax = " \
 vim-common \
 "
