# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "calceph"
PV = "4.0.5"
PR = "1.el10_1"
PACKAGES = " \
 calceph \
 calceph-devel \
 calceph-fortran-devel \
 calceph-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/calceph-4.0.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "76b395228ae776ed25eccb2661e002be4b28299b21e7a7952c514e3362798f63"

URI_x86_64_v2_calceph = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calceph-4.0.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calceph;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calceph}"
SRC_URI[x86_64_v2_calceph.sha256sum] = "a3e121354c9d4328127b18a609a29c65a4c3a06d8c77295131b5f455904c9233"

URI_x86_64_v2_calceph-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calceph-devel-4.0.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calceph-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calceph-devel}"
SRC_URI[x86_64_v2_calceph-devel.sha256sum] = "e9274a0ff55396535c4e9f190c1808f727f81df216d38c2b14dd42a7a297c79a"

URI_x86_64_v2_calceph-fortran-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calceph-fortran-devel-4.0.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calceph-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calceph-fortran-devel}"
SRC_URI[x86_64_v2_calceph-fortran-devel.sha256sum] = "d0a816a684e4f2260bb3e0387c8bb411cb820540e7f1f17dfba8994a08ecbf17"

URI_x86_64_v2_calceph-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/calceph-libs-4.0.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_calceph-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_calceph-libs}"
SRC_URI[x86_64_v2_calceph-libs.sha256sum] = "6b92240ec29a409d7f9358cc40d2d1b8639a84fb6d3ea61917df90fa99a682d0"

URI_aarch64_calceph = "${EPEL_MIRROR}/aarch64/Packages/c/calceph-4.0.5-1.el10_1.aarch64.rpm;name=aarch64_calceph;unpack=0"
SRC_URI:append = " ${URI_aarch64_calceph}"
SRC_URI[aarch64_calceph.sha256sum] = "b58b00fe38f2caf64f520a92664eaa8df252c597c67897d0efd08f4a7d9422f7"

URI_aarch64_calceph-devel = "${EPEL_MIRROR}/aarch64/Packages/c/calceph-devel-4.0.5-1.el10_1.aarch64.rpm;name=aarch64_calceph-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_calceph-devel}"
SRC_URI[aarch64_calceph-devel.sha256sum] = "b0f79b0c7188b1909f3f01f23526b24e0f45eade898ef92765796d50c72a746f"

URI_aarch64_calceph-fortran-devel = "${EPEL_MIRROR}/aarch64/Packages/c/calceph-fortran-devel-4.0.5-1.el10_1.aarch64.rpm;name=aarch64_calceph-fortran-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_calceph-fortran-devel}"
SRC_URI[aarch64_calceph-fortran-devel.sha256sum] = "23f230b83bf445a9ec140d440f503721d6309b52b71b2176fdb2c5d7373321ff"

URI_aarch64_calceph-libs = "${EPEL_MIRROR}/aarch64/Packages/c/calceph-libs-4.0.5-1.el10_1.aarch64.rpm;name=aarch64_calceph-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_calceph-libs}"
SRC_URI[aarch64_calceph-libs.sha256sum] = "ab3ebf0fb772299f52aeebd14ce8048f6e93485d6a5f696df22ab472aae9c469"

RDEPENDS:calceph = " \
 calceph-libs \
 glibc \
 "
RDEPENDS:calceph-devel = " \
 calceph \
 calceph-libs \
 cmake-filesystem \
 "
RDEPENDS:calceph-fortran-devel = " \
 calceph \
 calceph-devel \
 gcc-gfortran \
 "
RDEPENDS:calceph-libs:x86_64_v2 = " \
 glibc \
 libgcc \
 libgfortran \
"
RDEPENDS:calceph-libs:aarch64 = " \
 glibc \
 libgfortran \
"
