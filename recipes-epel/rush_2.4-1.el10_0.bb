# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rush"
PV = "2.4"
PR = "1.el10_0"
PACKAGES = " \
 rush \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rush-2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "27aa5ba97f36aa47c2ddec4109e5565326a04986d5262cc13cc90cabaa03a138"

URI_x86_64_v2_rush = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rush-2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_rush;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rush}"
SRC_URI[x86_64_v2_rush.sha256sum] = "56b60bed84efe9cdb5ecccbddd7ba16a9acbd929d8faf5481fde871932a0b885"

URI_aarch64_rush = "${EPEL_MIRROR}/aarch64/Packages/r/rush-2.4-1.el10_0.aarch64.rpm;name=aarch64_rush;unpack=0"
SRC_URI:append = " ${URI_aarch64_rush}"
SRC_URI[aarch64_rush.sha256sum] = "73ab664489e72a4f69ae67d2810a061c860abc04d8d57034e743f5d4888e479b"

RDEPENDS:rush = " \
 bash \
 glibc \
 "
