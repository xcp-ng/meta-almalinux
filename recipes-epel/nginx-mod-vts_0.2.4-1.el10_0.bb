# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nginx-mod-vts"
PV = "0.2.4"
PR = "1.el10_0"
PACKAGES = " \
 nginx-mod-vts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nginx-mod-vts-0.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6028350fc45cada52cc0a9a828347a8005700f67b414bc40263f4f5b08d189c2"

URI_x86_64_v2_nginx-mod-vts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nginx-mod-vts-0.2.4-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nginx-mod-vts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nginx-mod-vts}"
SRC_URI[x86_64_v2_nginx-mod-vts.sha256sum] = "593bd51e9a4ec7a305899b312ea07f0023e7270c262e3fbd2b61bc5523228736"

URI_aarch64_nginx-mod-vts = "${EPEL_MIRROR}/aarch64/Packages/n/nginx-mod-vts-0.2.4-1.el10_0.aarch64.rpm;name=aarch64_nginx-mod-vts;unpack=0"
SRC_URI:append = " ${URI_aarch64_nginx-mod-vts}"
SRC_URI[aarch64_nginx-mod-vts.sha256sum] = "fe3f1068f8e2b1d5a257f99f02fb4422b087a2919c4f57c5116f59e98a403419"

RDEPENDS:nginx-mod-vts = " \
 glibc \
 nginx \
 "
