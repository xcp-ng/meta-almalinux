# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-azure-storage"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-azure-storage+default-devel \
 rust-reqsign-azure-storage-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-azure-storage-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "243a5fd7b2beeaca1a4beea75e40f9004fb122997fda8ea9cbdb8bab914b5471"

URI_x86_64_v2_rust-reqsign-azure-storage+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-azure-storage+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-azure-storage+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-azure-storage+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-azure-storage+default-devel.sha256sum] = "380767df382d72d7fc620d537051e9d7538b4b43b5c926beca6740c112495d9e"

URI_x86_64_v2_rust-reqsign-azure-storage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-azure-storage-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-azure-storage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-azure-storage-devel}"
SRC_URI[x86_64_v2_rust-reqsign-azure-storage-devel.sha256sum] = "1e478df7959f3b41d5b0c6d10f9403056cd953dc596ad9431042c03076b3250f"

URI_aarch64_rust-reqsign-azure-storage+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-azure-storage+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-azure-storage+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-azure-storage+default-devel}"
SRC_URI[aarch64_rust-reqsign-azure-storage+default-devel.sha256sum] = "adb210fc92fe486f6c72b86802f6247d3fbba09f67c5e9b5b374f1bce4666878"

URI_aarch64_rust-reqsign-azure-storage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-azure-storage-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-azure-storage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-azure-storage-devel}"
SRC_URI[aarch64_rust-reqsign-azure-storage-devel.sha256sum] = "9dd11fa18d9d0cbbb9321bfc3cf648b5aa2cc7b5c4dfc127db97f026719d3650"

RDEPENDS:rust-reqsign-azure-storage+default-devel = " \
 cargo \
 rust-reqsign-azure-storage-devel \
 "
RDEPENDS:rust-reqsign-azure-storage-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-jsonwebtoken+default-devel \
 rust-log+default-devel \
 rust-pem+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-sha1+default-devel \
 "
