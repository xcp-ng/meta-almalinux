# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter"
PV = "0.26.11"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter+default-devel \
 rust-tree-sitter+std-devel \
 rust-tree-sitter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-0.26.11-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "499699b2468d311d98dbf7349d18af127b4fad7e32f24b5085145140cb85a01d"

URI_x86_64_v2_rust-tree-sitter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter+default-devel-0.26.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter+default-devel.sha256sum] = "7b4d0d60e4b0c16eedd24f3c1a49548a0dbdb13719ee01012d6333d62ca9a16a"

URI_x86_64_v2_rust-tree-sitter+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter+std-devel-0.26.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter+std-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter+std-devel.sha256sum] = "d824356db71c890f0905e85a674daae86b8a8a9bbe60c41e3afb7a9c1ff3fb55"

URI_x86_64_v2_rust-tree-sitter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-devel-0.26.11-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-devel.sha256sum] = "c13d5527c3f926546763e9032fe2cf52bdff10416f51be8c108598fbd4042902"

URI_aarch64_rust-tree-sitter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter+default-devel-0.26.11-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter+default-devel}"
SRC_URI[aarch64_rust-tree-sitter+default-devel.sha256sum] = "4e0613583961d793d10412d454789de31b056e1d95afc71dfbbd472d2d5a1df3"

URI_aarch64_rust-tree-sitter+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter+std-devel-0.26.11-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter+std-devel}"
SRC_URI[aarch64_rust-tree-sitter+std-devel.sha256sum] = "b3a676fb87da0964038ef94558985376c8d38695f769a5a60081f377e597d2c3"

URI_aarch64_rust-tree-sitter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-devel-0.26.11-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-devel}"
SRC_URI[aarch64_rust-tree-sitter-devel.sha256sum] = "6e24beb4433929d328cce3240c4295273da1c0657953545a37d2b3ce6c9b8343"

RDEPENDS:rust-tree-sitter+default-devel = " \
 cargo \
 rust-tree-sitter+std-devel \
 rust-tree-sitter-devel \
 "
RDEPENDS:rust-tree-sitter+std-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-tree-sitter-devel \
 "
RDEPENDS:rust-tree-sitter-devel = " \
 cargo \
 rust \
 rust-bindgen+default-devel \
 rust-cc+default-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-streaming-iterator+default-devel \
 rust-tree-sitter-language+default-devel \
 "
