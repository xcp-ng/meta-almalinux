# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_spanned"
PV = "1.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-serde_spanned+std-devel \
 rust-serde_spanned-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_spanned-1.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72154a15f9c36f6b122b657f66b1f6e3d3b5fdb9ae202a8e6486faa1d6aea6a4"

URI_x86_64_v2_rust-serde_spanned+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+alloc-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+alloc-devel.sha256sum] = "82dff3bcda5418d0bcf58af824420bb5316363157c970c9746dd11f84ccb380c"

URI_x86_64_v2_rust-serde_spanned+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+default-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+default-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+default-devel.sha256sum] = "e08f5042b884d8ec7de4e0f4e2e3f6e65642c2f194c203cb4d8be963bd308d4e"

URI_x86_64_v2_rust-serde_spanned+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+serde-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+serde-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+serde-devel.sha256sum] = "66dcd42f1375c4bbb1bcb974019ca5aeb7278b694a8a9ae6aece81e206ba5237"

URI_x86_64_v2_rust-serde_spanned+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+std-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+std-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+std-devel.sha256sum] = "d04005f24e253508253cff031e5415870786d51c40673d616860b98a07ce7049"

URI_x86_64_v2_rust-serde_spanned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned-devel-1.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned-devel.sha256sum] = "4838d3752b7332cf02cc4a374538828b522f907b716fc2d2ae5e6399b9cd4ef5"

URI_aarch64_rust-serde_spanned+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+alloc-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-serde_spanned+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+alloc-devel}"
SRC_URI[aarch64_rust-serde_spanned+alloc-devel.sha256sum] = "26980f34870bcd28d8eaa812a41975956d99aed6586f0de0c5484fd3a3915f3b"

URI_aarch64_rust-serde_spanned+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+default-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-serde_spanned+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+default-devel}"
SRC_URI[aarch64_rust-serde_spanned+default-devel.sha256sum] = "dcf3b59d6d13ee51f6c2a5adc01ba563ec945f0572ea5df8737016b5c840f7c0"

URI_aarch64_rust-serde_spanned+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+serde-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-serde_spanned+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+serde-devel}"
SRC_URI[aarch64_rust-serde_spanned+serde-devel.sha256sum] = "46c9bd032e83a28e34a1c0e170f37a3c2ef3c875fe6dde5dcd0552c0874cef3b"

URI_aarch64_rust-serde_spanned+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+std-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-serde_spanned+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+std-devel}"
SRC_URI[aarch64_rust-serde_spanned+std-devel.sha256sum] = "faf26fa0e2d1745e0873025a9b5a7074ac9e1568d8a35eac14c0593a9208a1e9"

URI_aarch64_rust-serde_spanned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned-devel-1.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-serde_spanned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned-devel}"
SRC_URI[aarch64_rust-serde_spanned-devel.sha256sum] = "9117e49a4cbb9f76ae3e9ae363e34a88e5964464fe79968752596b655f9af312"

RDEPENDS:rust-serde_spanned+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+default-devel = " \
 cargo \
 rust-serde_spanned+serde-devel \
 rust-serde_spanned+std-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+std-devel = " \
 cargo \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned-devel = " \
 cargo \
 rust \
 "
