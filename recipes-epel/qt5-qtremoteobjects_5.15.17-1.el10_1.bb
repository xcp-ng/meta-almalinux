# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtremoteobjects"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtremoteobjects \
 qt5-qtremoteobjects-devel \
 qt5-qtremoteobjects-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtremoteobjects-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fe09b349133651bdf6b98ce3c974083d50840140db7ba46c389b3c03dcdac27"

URI_x86_64_v2_qt5-qtremoteobjects = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtremoteobjects;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects.sha256sum] = "cfa656a699bc0fc9ef1cfdcae6594ce629a1ea85054169e5e743b95fd5f5bd61"

URI_x86_64_v2_qt5-qtremoteobjects-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtremoteobjects-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects-devel}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects-devel.sha256sum] = "ba2e13461af57aaaa9b8bfca67cac55b744eb3dfad809f8489ab24e2a6ac61a5"

URI_x86_64_v2_qt5-qtremoteobjects-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtremoteobjects-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtremoteobjects-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtremoteobjects-examples}"
SRC_URI[x86_64_v2_qt5-qtremoteobjects-examples.sha256sum] = "fc9eae84fdd97b9df3bb3157864f3a3d82344cb6f71fca451f65d9fc7ccfa379"

URI_aarch64_qt5-qtremoteobjects = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtremoteobjects;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects}"
SRC_URI[aarch64_qt5-qtremoteobjects.sha256sum] = "dccc9ad50f7a4cab10bb1f3ac4cd7f5da8c26538f54f8357d6e5f41f68d1d435"

URI_aarch64_qt5-qtremoteobjects-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtremoteobjects-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects-devel}"
SRC_URI[aarch64_qt5-qtremoteobjects-devel.sha256sum] = "d291b611bea2c2eb21b7dff4a89be0e8978e8627d4e7c9c90b29bd139370b9f2"

URI_aarch64_qt5-qtremoteobjects-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtremoteobjects-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtremoteobjects-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtremoteobjects-examples}"
SRC_URI[aarch64_qt5-qtremoteobjects-examples.sha256sum] = "3777a1d9aaf0d8a9888602a91b5a3a270c4d03f5962337a259fc064fdeebb8e4"

RDEPENDS:qt5-qtremoteobjects = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtremoteobjects-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtremoteobjects \
 "
RDEPENDS:qt5-qtremoteobjects-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtremoteobjects \
 "
