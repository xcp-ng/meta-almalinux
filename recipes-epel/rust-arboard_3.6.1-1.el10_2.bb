# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-arboard"
PV = "3.6.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-arboard+default-devel \
 rust-arboard+image-data-devel \
 rust-arboard+image-devel \
 rust-arboard+wayland-data-control-devel \
 rust-arboard+wl-clipboard-rs-devel \
 rust-arboard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-arboard-3.6.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3471c2b2847cb694aa2aadc45191d0c580d8bcdda1f38db0b0da121441492367"

URI_x86_64_v2_rust-arboard+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+default-devel-3.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+default-devel}"
SRC_URI[x86_64_v2_rust-arboard+default-devel.sha256sum] = "ae98fd72eeb5f7f12316a292f5ffd4a791d9c2eaabe17ebb1d68ef87a92ffd0e"

URI_x86_64_v2_rust-arboard+image-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+image-data-devel-3.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+image-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+image-data-devel}"
SRC_URI[x86_64_v2_rust-arboard+image-data-devel.sha256sum] = "0902655d37ce9130d47a3a2659395969db1cdce8b2fc4f056cdfecbc12775256"

URI_x86_64_v2_rust-arboard+image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+image-devel-3.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+image-devel}"
SRC_URI[x86_64_v2_rust-arboard+image-devel.sha256sum] = "8d10f93b52ca945ee1c600630e6ccb7544e7b58df1e0bdacd92bf4994b25aff2"

URI_x86_64_v2_rust-arboard+wayland-data-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+wayland-data-control-devel-3.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+wayland-data-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+wayland-data-control-devel}"
SRC_URI[x86_64_v2_rust-arboard+wayland-data-control-devel.sha256sum] = "6cfe484566af6d62eab4ff282267865d3bb2f93890fec1be7b44cf9f8e9664cd"

URI_x86_64_v2_rust-arboard+wl-clipboard-rs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard+wl-clipboard-rs-devel-3.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard+wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard+wl-clipboard-rs-devel}"
SRC_URI[x86_64_v2_rust-arboard+wl-clipboard-rs-devel.sha256sum] = "f2807c99463cf855ef4edc8019c5ff7ba44cd1f6eb7c3affa875c920faf249e8"

URI_x86_64_v2_rust-arboard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-arboard-devel-3.6.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-arboard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-arboard-devel}"
SRC_URI[x86_64_v2_rust-arboard-devel.sha256sum] = "64d0f8944ea486f8e9771ff4d4266f18c148900842cba067b5e896db2dacf2f8"

URI_aarch64_rust-arboard+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+default-devel-3.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-arboard+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+default-devel}"
SRC_URI[aarch64_rust-arboard+default-devel.sha256sum] = "33a3c58838925a6dbd435c22ecece83ebb60686ce764fcd7585c0133500dca9d"

URI_aarch64_rust-arboard+image-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+image-data-devel-3.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-arboard+image-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+image-data-devel}"
SRC_URI[aarch64_rust-arboard+image-data-devel.sha256sum] = "773a886337c78e4687d36afeb2e82ec7e2dea8419998dfd752ca895bb4873796"

URI_aarch64_rust-arboard+image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+image-devel-3.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-arboard+image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+image-devel}"
SRC_URI[aarch64_rust-arboard+image-devel.sha256sum] = "21830fa6a7aacdf45ed405b6f3e02a1bb2e7d9ac3230f74618053f3337c0016f"

URI_aarch64_rust-arboard+wayland-data-control-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+wayland-data-control-devel-3.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-arboard+wayland-data-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+wayland-data-control-devel}"
SRC_URI[aarch64_rust-arboard+wayland-data-control-devel.sha256sum] = "5e78b9b0cd7dc776e3f4fa719270fca86dc1247463288309e83c82a39dce869e"

URI_aarch64_rust-arboard+wl-clipboard-rs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard+wl-clipboard-rs-devel-3.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-arboard+wl-clipboard-rs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard+wl-clipboard-rs-devel}"
SRC_URI[aarch64_rust-arboard+wl-clipboard-rs-devel.sha256sum] = "2b7d4254099baf514262fd3daf4783bbb46eab2cd0b3e462037ffb17f783cdba"

URI_aarch64_rust-arboard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-arboard-devel-3.6.1-1.el10_2.noarch.rpm;name=aarch64_rust-arboard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-arboard-devel}"
SRC_URI[aarch64_rust-arboard-devel.sha256sum] = "4b8b29a431b641a489d7dc16f72d86ee1acfa47250c8d0707d024dfe1e0eb719"

RDEPENDS:rust-arboard+default-devel = " \
 cargo \
 rust-arboard+image-data-devel \
 rust-arboard-devel \
 "
RDEPENDS:rust-arboard+image-data-devel = " \
 cargo \
 rust-arboard+image-devel \
 rust-arboard-devel \
 "
RDEPENDS:rust-arboard+image-devel = " \
 cargo \
 rust-arboard-devel \
 rust-image+png-devel \
 rust-image-devel \
 "
RDEPENDS:rust-arboard+wayland-data-control-devel = " \
 cargo \
 rust-arboard+wl-clipboard-rs-devel \
 rust-arboard-devel \
 "
RDEPENDS:rust-arboard+wl-clipboard-rs-devel = " \
 cargo \
 rust-arboard-devel \
 rust-wl-clipboard-rs+default-devel \
 "
RDEPENDS:rust-arboard-devel = " \
 bash \
 cargo \
 rust \
 rust-log+default-devel \
 rust-parking_lot+default-devel \
 rust-percent-encoding+default-devel \
 rust-x11rb+default-devel \
 "
