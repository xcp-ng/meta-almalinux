# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-gopkg-check-1"
PV = "1"
PR = "21.20210113git10cb982.el10_0"
PACKAGES = " \
 compat-golang-github-check-devel \
 golang-gopkg-check-1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-gopkg-check-1-1-21.20210113git10cb982.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c0fa0f6f616b97c3bb921c485855b952f79ff73fe055f843fb312cb21d62040"

URI_aarch64_compat-golang-github-check-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-check-devel-1-21.20210113git10cb982.el10_0.noarch.rpm;name=aarch64_compat-golang-github-check-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-check-devel}"
SRC_URI[aarch64_compat-golang-github-check-devel.sha256sum] = "4b11a4b3892b4eba4773a2fc5f2e84dc277976fb087d6fe39f971ac1fba108c5"

URI_aarch64_golang-gopkg-check-1-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-gopkg-check-1-devel-1-21.20210113git10cb982.el10_0.noarch.rpm;name=aarch64_golang-gopkg-check-1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-gopkg-check-1-devel}"
SRC_URI[aarch64_golang-gopkg-check-1-devel.sha256sum] = "6cc3ef55c0deac4d45662f54394fe1e3dcc93a0f7e6847d6e3e4ecdb787cb28a"

RDEPENDS:compat-golang-github-check-devel = " \
 go-filesystem \
 golang-gopkg-check-1-devel \
 "
RDEPENDS:golang-gopkg-check-1-devel = " \
 go-filesystem \
 golang-github-kr-pretty-devel \
 "
