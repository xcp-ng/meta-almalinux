# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vapoursynth"
PV = "68"
PR = "7.el10_1"
PACKAGES = " \
 python3-vapoursynth \
 vapoursynth-devel \
 vapoursynth-libs \
 vapoursynth-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vapoursynth-68-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cb5c37573b005622b42d7cab52ffca3fa6a241e2b636d0d73084cbe6552559c"

URI_x86_64_v2_python3-vapoursynth = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-vapoursynth-68-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-vapoursynth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-vapoursynth}"
SRC_URI[x86_64_v2_python3-vapoursynth.sha256sum] = "a6c7ab7067bb40fad283b51d1ab0e348eb70e3e0e43bbf2d9697a33e1eb31d50"

URI_x86_64_v2_vapoursynth-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vapoursynth-devel-68-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vapoursynth-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vapoursynth-devel}"
SRC_URI[x86_64_v2_vapoursynth-devel.sha256sum] = "7f22bc8bd12677f7791601b60d7d964ff339e386a7bf5f10def876d7aecd1a6d"

URI_x86_64_v2_vapoursynth-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vapoursynth-libs-68-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vapoursynth-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vapoursynth-libs}"
SRC_URI[x86_64_v2_vapoursynth-libs.sha256sum] = "0ca89fb9c968556ac3682aef2053a751a2463774feedcd42b63c96dc77459cee"

URI_x86_64_v2_vapoursynth-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vapoursynth-tools-68-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vapoursynth-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vapoursynth-tools}"
SRC_URI[x86_64_v2_vapoursynth-tools.sha256sum] = "5fb29bd81e5d04970d91378a47a660ff5b0a47355cbdc8172d9fc3ece2cf429c"

URI_aarch64_python3-vapoursynth = "${EPEL_MIRROR}/aarch64/Packages/p/python3-vapoursynth-68-7.el10_1.aarch64.rpm;name=aarch64_python3-vapoursynth;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-vapoursynth}"
SRC_URI[aarch64_python3-vapoursynth.sha256sum] = "30d232d61c7bfb3851998f8bf39bbb40db30aa9b38dfe2edc6125a874d8e7072"

URI_aarch64_vapoursynth-devel = "${EPEL_MIRROR}/aarch64/Packages/v/vapoursynth-devel-68-7.el10_1.aarch64.rpm;name=aarch64_vapoursynth-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_vapoursynth-devel}"
SRC_URI[aarch64_vapoursynth-devel.sha256sum] = "e695545f9ce3ccf0a24815eb4cabb25cea43c1b44062d1cc6ea824bc2e74c8df"

URI_aarch64_vapoursynth-libs = "${EPEL_MIRROR}/aarch64/Packages/v/vapoursynth-libs-68-7.el10_1.aarch64.rpm;name=aarch64_vapoursynth-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_vapoursynth-libs}"
SRC_URI[aarch64_vapoursynth-libs.sha256sum] = "1b0bd6ca4a4343b50792c679da85027abacdc625cd8d8ec003431523cbad27c2"

URI_aarch64_vapoursynth-tools = "${EPEL_MIRROR}/aarch64/Packages/v/vapoursynth-tools-68-7.el10_1.aarch64.rpm;name=aarch64_vapoursynth-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vapoursynth-tools}"
SRC_URI[aarch64_vapoursynth-tools.sha256sum] = "dae0bfd2a29a5d401f9d03bad4b8e966ad4aa0f203b8316850027ab199e3b40a"

RDEPENDS:python3-vapoursynth = " \
 glibc \
 python3 \
 vapoursynth-libs \
 zimg \
 "
RDEPENDS:vapoursynth-devel = " \
 pkgconf-pkg-config \
 python3-devel \
 vapoursynth-devel \
 vapoursynth-libs \
 zimg-devel \
 "
RDEPENDS:vapoursynth-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-libs \
 zimg \
 "
RDEPENDS:vapoursynth-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 python3-vapoursynth \
 vapoursynth-libs \
 "
