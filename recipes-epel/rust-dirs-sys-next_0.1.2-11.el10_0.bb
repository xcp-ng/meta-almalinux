# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-dirs-sys-next"
PV = "0.1.2"
PR = "11.el10_0"
PACKAGES = " \
 rust-dirs-sys-next+default-devel \
 rust-dirs-sys-next-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-dirs-sys-next-0.1.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66b5b3407ee0e35858088244513525404456cfd69152f1d52e189507a012d501"

URI_x86_64_v2_rust-dirs-sys-next+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-sys-next+default-devel-0.1.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-sys-next+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-sys-next+default-devel}"
SRC_URI[x86_64_v2_rust-dirs-sys-next+default-devel.sha256sum] = "cc1a7f9b37feb21f8728b0af17780082eadb35164e2796f7535ba8b2507af0ea"

URI_x86_64_v2_rust-dirs-sys-next-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-dirs-sys-next-devel-0.1.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-dirs-sys-next-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-dirs-sys-next-devel}"
SRC_URI[x86_64_v2_rust-dirs-sys-next-devel.sha256sum] = "5acf146ddde3d52276ab64c1a629023c3b5ca05cb5df0ef303bd26e23b6eb83f"

URI_aarch64_rust-dirs-sys-next+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-sys-next+default-devel-0.1.2-11.el10_0.noarch.rpm;name=aarch64_rust-dirs-sys-next+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-sys-next+default-devel}"
SRC_URI[aarch64_rust-dirs-sys-next+default-devel.sha256sum] = "b9dbede905765fb8633d6921867448ee5de189dd76e39b762399be970dbfbbec"

URI_aarch64_rust-dirs-sys-next-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-dirs-sys-next-devel-0.1.2-11.el10_0.noarch.rpm;name=aarch64_rust-dirs-sys-next-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-dirs-sys-next-devel}"
SRC_URI[aarch64_rust-dirs-sys-next-devel.sha256sum] = "4d19af02013105f8b69a347ee04636da05c9eb01309073333e5950b03be8b4d8"

RDEPENDS:rust-dirs-sys-next+default-devel = " \
 cargo \
 rust-dirs-sys-next-devel \
 "
RDEPENDS:rust-dirs-sys-next-devel = " \
 cargo \
 rust-libc+default-devel \
 "
