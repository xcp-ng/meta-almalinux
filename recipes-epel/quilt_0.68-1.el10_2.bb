# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "quilt"
PV = "0.68"
PR = "1.el10_2"
PACKAGES = " \
 quilt \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/quilt-0.68-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "304744399c512acdcfa75b4042b1dc0f8bdafa63d86a2c170531a2c840efbb42"

URI_x86_64_v2_quilt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/quilt-0.68-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_quilt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_quilt}"
SRC_URI[x86_64_v2_quilt.sha256sum] = "d920779780a05e37ea5466f52b5f75089d4346c1f8efe1fe1fdda5cb4958af13"

URI_aarch64_quilt = "${EPEL_MIRROR}/aarch64/Packages/q/quilt-0.68-1.el10_2.noarch.rpm;name=aarch64_quilt;unpack=0"
SRC_URI:append = " ${URI_aarch64_quilt}"
SRC_URI[aarch64_quilt.sha256sum] = "1fdd2257ddc3b5b7b0ae19b4219df4017943aa97833bc47ea37094fd977058a7"

RDEPENDS:quilt = " \
 7zip-standalone \
 bash \
 bzip2 \
 diffstat \
 diffutils \
 gawk \
 gzip \
 perl-File-Temp \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-constant \
 perl-interpreter \
 perl-libs \
 perl-vars \
 procmail \
 rpm-build \
 sed \
 tar \
 util-linux \
 virtual//usr/sbin/sendmail \
 virtual/coreutils \
 "
