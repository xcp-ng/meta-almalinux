# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rend"
PV = "0.5.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-rend+bytecheck-devel \
 rust-rend+default-devel \
 rust-rend-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rend-0.5.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bcd2a220bfdf90188090e4a3211400eaa33dda46bcdaeb8d5276fd324fddb045"

URI_x86_64_v2_rust-rend+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend+bytecheck-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rend+bytecheck-devel.sha256sum] = "45dc6396fd76cc1c151bef1bb0d036681699954398fbd278ae332cb1c346d62d"

URI_x86_64_v2_rust-rend+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend+default-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend+default-devel}"
SRC_URI[x86_64_v2_rust-rend+default-devel.sha256sum] = "49a77e3d9e890c4a58b895cb7ab4aedf93c247dbdf6e5a225326c8fa7894318c"

URI_x86_64_v2_rust-rend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rend-devel-0.5.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rend-devel}"
SRC_URI[x86_64_v2_rust-rend-devel.sha256sum] = "6a2b1c23915fa9af3c3f66482f5e995f842608438baa9d660ba81a8abd0be9c8"

URI_aarch64_rust-rend+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend+bytecheck-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-rend+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend+bytecheck-devel}"
SRC_URI[aarch64_rust-rend+bytecheck-devel.sha256sum] = "974161150142f4975f1cfc66fe4374120e30b50ae4e9a130b52a606a4add4972"

URI_aarch64_rust-rend+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend+default-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-rend+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend+default-devel}"
SRC_URI[aarch64_rust-rend+default-devel.sha256sum] = "faa9388908f6ed452ef828f0786e10d4a5c64f2dbcdd46ece54f09ac2db4f93f"

URI_aarch64_rust-rend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rend-devel-0.5.2-1.el10_0.noarch.rpm;name=aarch64_rust-rend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rend-devel}"
SRC_URI[aarch64_rust-rend-devel.sha256sum] = "6c08e2962f4e8e586ef6d362d6a299f052199e733ed68a072f7739793cae6851"

RDEPENDS:rust-rend+bytecheck-devel = " \
 cargo \
 rust-bytecheck-devel \
 rust-rend-devel \
 "
RDEPENDS:rust-rend+default-devel = " \
 cargo \
 rust-rend-devel \
 "
RDEPENDS:rust-rend-devel = " \
 cargo \
 "
