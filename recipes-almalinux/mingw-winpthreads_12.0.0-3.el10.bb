# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mingw-winpthreads"
PV = "12.0.0"
PR = "3.el10"
PACKAGES = " \
 mingw32-winpthreads \
 mingw32-winpthreads-static \
 mingw64-winpthreads \
 mingw64-winpthreads-static \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/mingw-winpthreads-12.0.0-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "29ee2aa1914da0c253a2eb7c58e21290418a92c426a71cc76dfa00b4887094e5"

URI_x86_64_v2_mingw32-winpthreads = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-winpthreads-12.0.0-3.el10.noarch.rpm;name=x86_64_v2_mingw32-winpthreads;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-winpthreads}"
SRC_URI[x86_64_v2_mingw32-winpthreads.sha256sum] = "99b6ffbf0e1a692e7ec469cd535d785df419b9da460b296c730badb4c4c669b7"

URI_x86_64_v2_mingw32-winpthreads-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw32-winpthreads-static-12.0.0-3.el10.noarch.rpm;name=x86_64_v2_mingw32-winpthreads-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw32-winpthreads-static}"
SRC_URI[x86_64_v2_mingw32-winpthreads-static.sha256sum] = "a6bf61f35806e3db3072230ae8fc02f9dc316f518eeb6330544c5b41400c483e"

URI_x86_64_v2_mingw64-winpthreads = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-winpthreads-12.0.0-3.el10.noarch.rpm;name=x86_64_v2_mingw64-winpthreads;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-winpthreads}"
SRC_URI[x86_64_v2_mingw64-winpthreads.sha256sum] = "3a66e157825ac7fbf8ddc319b0d5c15852738a26b6a25d43a418c4f7ddc4e5ad"

URI_x86_64_v2_mingw64-winpthreads-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mingw64-winpthreads-static-12.0.0-3.el10.noarch.rpm;name=x86_64_v2_mingw64-winpthreads-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mingw64-winpthreads-static}"
SRC_URI[x86_64_v2_mingw64-winpthreads-static.sha256sum] = "bc07f7a7d2356f8bf8eee989dda1755be696c2a6884824ef76a192876574bc34"

URI_aarch64_mingw32-winpthreads = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-winpthreads-12.0.0-3.el10.noarch.rpm;name=aarch64_mingw32-winpthreads;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-winpthreads}"
SRC_URI[aarch64_mingw32-winpthreads.sha256sum] = "99b6ffbf0e1a692e7ec469cd535d785df419b9da460b296c730badb4c4c669b7"

URI_aarch64_mingw32-winpthreads-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw32-winpthreads-static-12.0.0-3.el10.noarch.rpm;name=aarch64_mingw32-winpthreads-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw32-winpthreads-static}"
SRC_URI[aarch64_mingw32-winpthreads-static.sha256sum] = "a6bf61f35806e3db3072230ae8fc02f9dc316f518eeb6330544c5b41400c483e"

URI_aarch64_mingw64-winpthreads = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-winpthreads-12.0.0-3.el10.noarch.rpm;name=aarch64_mingw64-winpthreads;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-winpthreads}"
SRC_URI[aarch64_mingw64-winpthreads.sha256sum] = "3a66e157825ac7fbf8ddc319b0d5c15852738a26b6a25d43a418c4f7ddc4e5ad"

URI_aarch64_mingw64-winpthreads-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mingw64-winpthreads-static-12.0.0-3.el10.noarch.rpm;name=aarch64_mingw64-winpthreads-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_mingw64-winpthreads-static}"
SRC_URI[aarch64_mingw64-winpthreads-static.sha256sum] = "bc07f7a7d2356f8bf8eee989dda1755be696c2a6884824ef76a192876574bc34"

RDEPENDS:mingw32-winpthreads = " \
 mingw32-crt \
 mingw32-filesystem \
 "
RDEPENDS:mingw32-winpthreads-static = " \
 mingw32-winpthreads \
 "
RDEPENDS:mingw64-winpthreads = " \
 mingw64-crt \
 mingw64-filesystem \
 "
RDEPENDS:mingw64-winpthreads-static = " \
 mingw64-winpthreads \
 "
