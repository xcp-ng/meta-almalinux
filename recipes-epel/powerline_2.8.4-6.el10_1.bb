# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "powerline"
PV = "2.8.4"
PR = "6.el10_1"
PACKAGES = " \
 powerline \
 powerline-docs \
 powerline-fonts \
 tmux-powerline \
 vim-powerline \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/powerline-2.8.4-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a98b9a6383e9d0c2255c988b2b77e16750ed623db3c6a20d1421142d2824f475"

URI_x86_64_v2_powerline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerline-2.8.4-6.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_powerline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerline}"
SRC_URI[x86_64_v2_powerline.sha256sum] = "009f7ebfce1f4a4bfe622a83738222dbbe19f19c2021dbf25806987a9e3aa0ee"

URI_x86_64_v2_powerline-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerline-docs-2.8.4-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_powerline-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerline-docs}"
SRC_URI[x86_64_v2_powerline-docs.sha256sum] = "1bcad0023ab61fd39a4d95925069b20f3db5eb57886a5b40322b9529afd2b344"

URI_x86_64_v2_powerline-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/powerline-fonts-2.8.4-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_powerline-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_powerline-fonts}"
SRC_URI[x86_64_v2_powerline-fonts.sha256sum] = "3bccc140751e1539873bfbf6dfd9676126dbb4d3db5c23c10a36ccf6d2927dd4"

URI_x86_64_v2_tmux-powerline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tmux-powerline-2.8.4-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_tmux-powerline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tmux-powerline}"
SRC_URI[x86_64_v2_tmux-powerline.sha256sum] = "9bb96e70ac058c862efcb8755a44c302379b6a8e77a1dff08d6b62ada9978147"

URI_x86_64_v2_vim-powerline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vim-powerline-2.8.4-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_vim-powerline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-powerline}"
SRC_URI[x86_64_v2_vim-powerline.sha256sum] = "79d4d07a866f816e47e9027d18640b1a94f4465b14bb4d9106aae93ca3dfe88e"

URI_aarch64_powerline = "${EPEL_MIRROR}/aarch64/Packages/p/powerline-2.8.4-6.el10_1.aarch64.rpm;name=aarch64_powerline;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerline}"
SRC_URI[aarch64_powerline.sha256sum] = "99403ee4fb37bf61371367fa3526269a1b4578523e18eac31be4614c3d9c8bc9"

URI_aarch64_powerline-docs = "${EPEL_MIRROR}/aarch64/Packages/p/powerline-docs-2.8.4-6.el10_1.noarch.rpm;name=aarch64_powerline-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerline-docs}"
SRC_URI[aarch64_powerline-docs.sha256sum] = "638da48717a5d728b4c7adb20d9c26949ad6ba5c8549573861444ec40fd96458"

URI_aarch64_powerline-fonts = "${EPEL_MIRROR}/aarch64/Packages/p/powerline-fonts-2.8.4-6.el10_1.noarch.rpm;name=aarch64_powerline-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_powerline-fonts}"
SRC_URI[aarch64_powerline-fonts.sha256sum] = "5a6504fb88a6e7fb6322c49eb45f711e6f62a57044c4a74852e14ca2eb92b96c"

URI_aarch64_tmux-powerline = "${EPEL_MIRROR}/aarch64/Packages/t/tmux-powerline-2.8.4-6.el10_1.noarch.rpm;name=aarch64_tmux-powerline;unpack=0"
SRC_URI:append = " ${URI_aarch64_tmux-powerline}"
SRC_URI[aarch64_tmux-powerline.sha256sum] = "21fac5576fc6c6b687a5173fa36ac21cbd95468a127518343531b0e9ea8ca639"

URI_aarch64_vim-powerline = "${EPEL_MIRROR}/aarch64/Packages/v/vim-powerline-2.8.4-6.el10_1.noarch.rpm;name=aarch64_vim-powerline;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-powerline}"
SRC_URI[aarch64_vim-powerline.sha256sum] = "419226641641b89982bff405f98af1581066ea737f72f6c0b18592e15fce0a47"

RDEPENDS:powerline = " \
 bash \
 glibc \
 powerline-fonts \
 python3 \
 systemd \
 "
RDEPENDS:powerline-docs = " \
 "
RDEPENDS:powerline-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:tmux-powerline = " \
 powerline \
 tmux \
 "
RDEPENDS:vim-powerline = " \
 powerline \
 vim-enhanced \
 "
