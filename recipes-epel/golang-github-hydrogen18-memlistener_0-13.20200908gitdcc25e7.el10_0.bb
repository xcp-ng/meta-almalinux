# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-hydrogen18-memlistener"
PV = "0"
PR = "13.20200908gitdcc25e7.el10_0"
PACKAGES = " \
 golang-github-hydrogen18-memlistener-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-hydrogen18-memlistener-0-13.20200908gitdcc25e7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34c311ac1a43b76f2b237056810cdecddd1dc2300a73546dc356643441788059"

URI_aarch64_golang-github-hydrogen18-memlistener-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-hydrogen18-memlistener-devel-0-13.20200908gitdcc25e7.el10_0.noarch.rpm;name=aarch64_golang-github-hydrogen18-memlistener-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-hydrogen18-memlistener-devel}"
SRC_URI[aarch64_golang-github-hydrogen18-memlistener-devel.sha256sum] = "578992b68d0838ff62beba1003cf808570a03fd5fda3ce1d7e49108b0050406a"

RDEPENDS:golang-github-hydrogen18-memlistener-devel = " \
 go-filesystem \
 "
