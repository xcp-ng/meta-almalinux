# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyxdameraulevenshtein"
PV = "1.9.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-pyxdameraulevenshtein \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyxdameraulevenshtein-1.9.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "309738dcd99f3540bec313ffb15d0b0209a5439b74d480f8365cfe773219dcee"

URI_x86_64_v2_python3-pyxdameraulevenshtein = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyxdameraulevenshtein-1.9.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyxdameraulevenshtein;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyxdameraulevenshtein}"
SRC_URI[x86_64_v2_python3-pyxdameraulevenshtein.sha256sum] = "b7d50e6465b69ca2f919c186c4355831f50fab8dfed52931a82d410fff119896"

URI_aarch64_python3-pyxdameraulevenshtein = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyxdameraulevenshtein-1.9.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pyxdameraulevenshtein;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyxdameraulevenshtein}"
SRC_URI[aarch64_python3-pyxdameraulevenshtein.sha256sum] = "7acb0ef1a5d16b9ae922ded399b3940ec341479f879a48d99643ddadcc732df2"

RDEPENDS:python3-pyxdameraulevenshtein = " \
 glibc \
 python3 \
 "
