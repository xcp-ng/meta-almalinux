# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libaiff"
PV = "6.0"
PR = "11.el10_0"
PACKAGES = " \
 libaiff \
 libaiff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libaiff-6.0-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d963effff38281bd21ed1a0f422ca6c4e84a053dbb1069ace506cb0658f147d5"

URI_x86_64_v2_libaiff = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaiff-6.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaiff;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaiff}"
SRC_URI[x86_64_v2_libaiff.sha256sum] = "711e25c95239b7eec7212a0f9e2d0064cf6fa674dfb32e0c24f9f2f141ff79f0"

URI_x86_64_v2_libaiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libaiff-devel-6.0-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libaiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libaiff-devel}"
SRC_URI[x86_64_v2_libaiff-devel.sha256sum] = "db918b55db2ab011c9fb1e4f37836c1c84a9f558a4c21432d813c553b018b427"

URI_aarch64_libaiff = "${EPEL_MIRROR}/aarch64/Packages/l/libaiff-6.0-11.el10_0.aarch64.rpm;name=aarch64_libaiff;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaiff}"
SRC_URI[aarch64_libaiff.sha256sum] = "cccfa7fa5326f1e7193ead720874a7b8b946f7bbd8c29f9a2fd5a18382fd9c21"

URI_aarch64_libaiff-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libaiff-devel-6.0-11.el10_0.aarch64.rpm;name=aarch64_libaiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libaiff-devel}"
SRC_URI[aarch64_libaiff-devel.sha256sum] = "bfb09220ac48ca60828dcb679ee8fad7f294c8ff3d4d15c873a02cf79d88b8e0"

RDEPENDS:libaiff = " \
 glibc \
 "
RDEPENDS:libaiff-devel = " \
 libaiff \
 "
