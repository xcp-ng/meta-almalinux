# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Filesys-Df"
PV = "0.92"
PR = "55.el10_1"
PACKAGES = " \
 perl-Filesys-Df \
 perl-Filesys-Df-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Filesys-Df-0.92-55.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c065df82c3fd211e4b70b22d17008c1ee76eae96e6e5b0497ac39189b8a67755"

URI_x86_64_v2_perl-Filesys-Df = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Filesys-Df-0.92-55.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Filesys-Df;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Filesys-Df}"
SRC_URI[x86_64_v2_perl-Filesys-Df.sha256sum] = "b567f94726cd7342c5f0cee93ce2676a9c988c786cc4b755f4b12310ec67832f"

URI_x86_64_v2_perl-Filesys-Df-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Filesys-Df-tests-0.92-55.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Filesys-Df-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Filesys-Df-tests}"
SRC_URI[x86_64_v2_perl-Filesys-Df-tests.sha256sum] = "5f568446328adab014cd66c134cdadd3514653bb792b9c7159dbfb456077fd2b"

URI_aarch64_perl-Filesys-Df = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Filesys-Df-0.92-55.el10_1.aarch64.rpm;name=aarch64_perl-Filesys-Df;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Filesys-Df}"
SRC_URI[aarch64_perl-Filesys-Df.sha256sum] = "fa70b7384c9f5e5e3ae4baca4e6bb7ed489dd6c1ab445710951e84a0a721dd5d"

URI_aarch64_perl-Filesys-Df-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Filesys-Df-tests-0.92-55.el10_1.noarch.rpm;name=aarch64_perl-Filesys-Df-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Filesys-Df-tests}"
SRC_URI[aarch64_perl-Filesys-Df-tests.sha256sum] = "6c96209ffbe8f6ed4b66a696c96db47e3c13d69a731e62f488e144d44e9e5b36"

RDEPENDS:perl-Filesys-Df = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Filesys-Df-tests = " \
 bash \
 perl-Filesys-Df \
 perl-Test-Harness \
 perl-libs \
 "
