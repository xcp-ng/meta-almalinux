# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-job-manager-scripts"
PV = "7.3"
PR = "9.el10_0"
PACKAGES = " \
 globus-gram-job-manager-scripts \
 globus-gram-job-manager-scripts-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-job-manager-scripts-7.3-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cea3ee4e1d59b215a1b3652d050fdaf3ab5b2a876b413ee5013109e13e939939"

URI_x86_64_v2_globus-gram-job-manager-scripts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-scripts-7.3-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-scripts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-scripts}"
SRC_URI[x86_64_v2_globus-gram-job-manager-scripts.sha256sum] = "8cdbc78f819f3bded9428d09835b46efe9eaaed68a1469a0da420b62dd99e563"

URI_x86_64_v2_globus-gram-job-manager-scripts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-job-manager-scripts-doc-7.3-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-job-manager-scripts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-job-manager-scripts-doc}"
SRC_URI[x86_64_v2_globus-gram-job-manager-scripts-doc.sha256sum] = "ca79dc27fcbdf3ff1d830fa808a672b590bac39c318c086bf36b8810b587c48e"

URI_aarch64_globus-gram-job-manager-scripts = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-scripts-7.3-9.el10_0.noarch.rpm;name=aarch64_globus-gram-job-manager-scripts;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-scripts}"
SRC_URI[aarch64_globus-gram-job-manager-scripts.sha256sum] = "ea0c92a9affe4278d61dbd2d5c182e6f0480dda851ec3ec82a1a11282da846f3"

URI_aarch64_globus-gram-job-manager-scripts-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-job-manager-scripts-doc-7.3-9.el10_0.noarch.rpm;name=aarch64_globus-gram-job-manager-scripts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-job-manager-scripts-doc}"
SRC_URI[aarch64_globus-gram-job-manager-scripts-doc.sha256sum] = "8f100690babc510952c84463ca558c000f598e6dace9f99a667fb4850d18318c"

RDEPENDS:globus-gram-job-manager-scripts = " \
 bash \
 globus-common \
 globus-gram-protocol \
 perl-Errno \
 perl-File-Copy \
 perl-File-Path \
 perl-Getopt-Long \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:globus-gram-job-manager-scripts-doc = " \
 "
