# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "awesome-vim-colorschemes"
PV = "0"
PR = "15.20240722gitae5e022.25.el10_1"
PACKAGES = " \
 awesome-vim-colorschemes \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/awesome-vim-colorschemes-0-15.20240722gitae5e022.25.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4542721ff0b1ce24b8478eb220d358900e0b8919c1368c9c5800f55a7dd5b3b"

URI_x86_64_v2_awesome-vim-colorschemes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/awesome-vim-colorschemes-0-15.20240722gitae5e022.25.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_awesome-vim-colorschemes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_awesome-vim-colorschemes}"
SRC_URI[x86_64_v2_awesome-vim-colorschemes.sha256sum] = "2b99671f065dbbee6ba1aacdb91acf9a2273877445dbcf66596b065ddf3787f9"

URI_aarch64_awesome-vim-colorschemes = "${EPEL_MIRROR}/aarch64/Packages/a/awesome-vim-colorschemes-0-15.20240722gitae5e022.25.el10_1.noarch.rpm;name=aarch64_awesome-vim-colorschemes;unpack=0"
SRC_URI:append = " ${URI_aarch64_awesome-vim-colorschemes}"
SRC_URI[aarch64_awesome-vim-colorschemes.sha256sum] = "3397d5fa5a344db6891c04bc4ea43a790cb1bfef07ad0758a360d9d0a02ad5d3"

RDEPENDS:awesome-vim-colorschemes = " \
 vim-enhanced \
 vim-jellybeans \
 "
