# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-onefetch-ascii"
PV = "2.27.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-onefetch-ascii+default-devel \
 rust-onefetch-ascii-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-onefetch-ascii-2.27.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e960693540cb99f98046d61092c7cce2bc74376428ab3f4c603159efa7c09123"

URI_x86_64_v2_rust-onefetch-ascii+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-ascii+default-devel-2.27.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-ascii+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-ascii+default-devel}"
SRC_URI[x86_64_v2_rust-onefetch-ascii+default-devel.sha256sum] = "0561c449065d565470679e33b0c7cc54d7f2473c3121e6fc762250d65adeeb8d"

URI_x86_64_v2_rust-onefetch-ascii-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-onefetch-ascii-devel-2.27.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-onefetch-ascii-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-onefetch-ascii-devel}"
SRC_URI[x86_64_v2_rust-onefetch-ascii-devel.sha256sum] = "f6760a07489e037e830502774e4b889e796d04dd9816d8f3d18550119bef5fdb"

URI_aarch64_rust-onefetch-ascii+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-ascii+default-devel-2.27.1-1.el10_2.noarch.rpm;name=aarch64_rust-onefetch-ascii+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-ascii+default-devel}"
SRC_URI[aarch64_rust-onefetch-ascii+default-devel.sha256sum] = "aa94f82c80a5b7d6fc12484fe8c4f5ead321b41beac68aeb75cc22fd11971cc7"

URI_aarch64_rust-onefetch-ascii-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-onefetch-ascii-devel-2.27.1-1.el10_2.noarch.rpm;name=aarch64_rust-onefetch-ascii-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-onefetch-ascii-devel}"
SRC_URI[aarch64_rust-onefetch-ascii-devel.sha256sum] = "659e11806b8110e82fc7bbcab6e965ab10b63a978a71bc2d1d9678dd87576d40"

RDEPENDS:rust-onefetch-ascii+default-devel = " \
 cargo \
 rust-onefetch-ascii-devel \
 "
RDEPENDS:rust-onefetch-ascii-devel = " \
 cargo \
 rust-owo-colors+default-devel \
 "
