# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtxmlpatterns"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtxmlpatterns \
 qt5-qtxmlpatterns-devel \
 qt5-qtxmlpatterns-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtxmlpatterns-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53d236f26ecd62d9f87e289c2b55ebc1baf9b455a0f07b2d307746c8487e2f1d"

URI_x86_64_v2_qt5-qtxmlpatterns = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtxmlpatterns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns.sha256sum] = "add7c7a84ad54773586886b894c6925328e353a80e383e4dcf447dc45e60ef47"

URI_x86_64_v2_qt5-qtxmlpatterns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtxmlpatterns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns-devel}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns-devel.sha256sum] = "e6d080a42e9fdaabb967063e896f8460655782ed372f4d9c94abb4db4f74eb6c"

URI_x86_64_v2_qt5-qtxmlpatterns-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtxmlpatterns-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtxmlpatterns-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtxmlpatterns-examples}"
SRC_URI[x86_64_v2_qt5-qtxmlpatterns-examples.sha256sum] = "23922c4b1d592664c9e892e8436e1f9ff4c9ddd44a43df60cde959d0a29f5726"

URI_aarch64_qt5-qtxmlpatterns = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtxmlpatterns;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns}"
SRC_URI[aarch64_qt5-qtxmlpatterns.sha256sum] = "0b92b26af71da082166085c60f12516e7773694a48006e0797a9f98ee02aae3f"

URI_aarch64_qt5-qtxmlpatterns-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtxmlpatterns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns-devel}"
SRC_URI[aarch64_qt5-qtxmlpatterns-devel.sha256sum] = "92d4d65e53c97fe2a51738a43ffbe523691196d7028adaf5f42c8a25144a1ecc"

URI_aarch64_qt5-qtxmlpatterns-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtxmlpatterns-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtxmlpatterns-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtxmlpatterns-examples}"
SRC_URI[aarch64_qt5-qtxmlpatterns-examples.sha256sum] = "1e5955e4e6e127da046de98be723ea32093f69f92c1761f0787e288409277ccf"

RDEPENDS:qt5-qtxmlpatterns = " \
 glibc \
 libgcc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtdeclarative \
 "
RDEPENDS:qt5-qtxmlpatterns-devel = " \
 cmake-filesystem \
 glibc \
 libstdc++ \
 pkgconf-pkg-config \
 qt5-qtbase \
 qt5-qtbase-devel \
 qt5-qtxmlpatterns \
 "
RDEPENDS:qt5-qtxmlpatterns-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtxmlpatterns \
 "
