# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ff"
PV = "0.14.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-ff+alloc-devel \
 rust-ff+bits-devel \
 rust-ff+bitvec-devel \
 rust-ff+byteorder-devel \
 rust-ff+default-devel \
 rust-ff+std-devel \
 rust-ff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ff-0.14.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "df005203ee442252ef4c09a6ffd3359ef219af38d30d9df456d729b5a48099c8"

URI_x86_64_v2_rust-ff+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+alloc-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+alloc-devel}"
SRC_URI[x86_64_v2_rust-ff+alloc-devel.sha256sum] = "df7f0d6865320f8c6eea5dd61e5f569dec1145d3e9e6f99d94bea12181d126dc"

URI_x86_64_v2_rust-ff+bits-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+bits-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+bits-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+bits-devel}"
SRC_URI[x86_64_v2_rust-ff+bits-devel.sha256sum] = "d01be6476fa3604805b9590e80e2539c79ab8e3f8936886593480cce86a4cc02"

URI_x86_64_v2_rust-ff+bitvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+bitvec-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+bitvec-devel}"
SRC_URI[x86_64_v2_rust-ff+bitvec-devel.sha256sum] = "1266f1300eef00214db0870b82f3cfb98a157f9dc4d8788c567d951546eb2b95"

URI_x86_64_v2_rust-ff+byteorder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+byteorder-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+byteorder-devel}"
SRC_URI[x86_64_v2_rust-ff+byteorder-devel.sha256sum] = "6d374171f7afbd64498bf8d3ae635a5659dc606c726e0b018102ed619ce5c9ee"

URI_x86_64_v2_rust-ff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+default-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+default-devel}"
SRC_URI[x86_64_v2_rust-ff+default-devel.sha256sum] = "a00c0106e8df84565150bf6fe31018c52de63d8e23bc3eacd9e36bc1d34c91d0"

URI_x86_64_v2_rust-ff+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff+std-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff+std-devel}"
SRC_URI[x86_64_v2_rust-ff+std-devel.sha256sum] = "e84ad2c01a002006de67712fd4f931c85f39e46471f92b9049b17d0334db9181"

URI_x86_64_v2_rust-ff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ff-devel-0.14.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ff-devel}"
SRC_URI[x86_64_v2_rust-ff-devel.sha256sum] = "26d288870955f7863ae2abcd5e80fadf5d5bbb4bbb6bef231ab099564dd0566d"

URI_aarch64_rust-ff+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+alloc-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-ff+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+alloc-devel}"
SRC_URI[aarch64_rust-ff+alloc-devel.sha256sum] = "e3547aecb331ea507fa39a5f6436a57098940cc6f1e8aae9edb6d94bb302fe2e"

URI_aarch64_rust-ff+bits-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+bits-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-ff+bits-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+bits-devel}"
SRC_URI[aarch64_rust-ff+bits-devel.sha256sum] = "5e14a5d308dbdeff3b0271f1a8678fbcaeeec0f2f935a73f999454fa26619775"

URI_aarch64_rust-ff+bitvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+bitvec-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-ff+bitvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+bitvec-devel}"
SRC_URI[aarch64_rust-ff+bitvec-devel.sha256sum] = "85b98ff7c892c082ab0833d9dacd7a00cc305d6567917cb7751744e4e6eac6ad"

URI_aarch64_rust-ff+byteorder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+byteorder-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-ff+byteorder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+byteorder-devel}"
SRC_URI[aarch64_rust-ff+byteorder-devel.sha256sum] = "704b5017f054dd10f94046e8bc82bd723618fdc5f0fad5d290ae850d9b0c88e3"

URI_aarch64_rust-ff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+default-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-ff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+default-devel}"
SRC_URI[aarch64_rust-ff+default-devel.sha256sum] = "6e3fd775384472714df9bdfe79529df69fdfb59e26bdef8971f5f8ba1e6f701c"

URI_aarch64_rust-ff+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff+std-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-ff+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff+std-devel}"
SRC_URI[aarch64_rust-ff+std-devel.sha256sum] = "8fcd2d4c9cc594f578a0b3fb0cc6770310728f4681496a439b9519cd464bc64f"

URI_aarch64_rust-ff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ff-devel-0.14.0-1.el10_3.noarch.rpm;name=aarch64_rust-ff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ff-devel}"
SRC_URI[aarch64_rust-ff-devel.sha256sum] = "8b254448062685669806fbd08f5b1ddf22fa6cea824e1a59882098225e40e9f7"

RDEPENDS:rust-ff+alloc-devel = " \
 cargo \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+bits-devel = " \
 cargo \
 rust-ff+bitvec-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+bitvec-devel = " \
 cargo \
 rust-bitvec-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+byteorder-devel = " \
 cargo \
 rust-byteorder-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+default-devel = " \
 cargo \
 rust-ff+bits-devel \
 rust-ff+std-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff+std-devel = " \
 cargo \
 rust-ff+alloc-devel \
 rust-ff-devel \
 "
RDEPENDS:rust-ff-devel = " \
 cargo \
 rust \
 rust-rand_core-devel \
 rust-subtle+i128-devel \
 rust-subtle-devel \
 "
