# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemd-extras"
PV = "257.9"
PR = "2.el10_1"
PACKAGES = " \
 systemd-networkd \
 systemd-networkd-defaults \
 systemd-timesyncd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/systemd-extras-257.9-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4d1c886764d3ebfbe18daeb136d387e5a59b871c7a2a26b2b9af9602cbedc3e9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/systemd-networkd-257.9-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_systemd-networkd;unpack=0"
SRC_URI[x86_64_v2_systemd-networkd.sha256sum] = "61428e9b41e670590b6024f55332c31679946c8b1d771dedaf58c79443314919"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/systemd-networkd-defaults-257.9-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_systemd-networkd-defaults;unpack=0"
SRC_URI[x86_64_v2_systemd-networkd-defaults.sha256sum] = "c819bcc5840ec0f31793ad5b6a2d70bce123b3a65e040a5feb28f621bb177893"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/systemd-timesyncd-257.9-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_systemd-timesyncd;unpack=0"
SRC_URI[x86_64_v2_systemd-timesyncd.sha256sum] = "9c2eb6ba90607e05c3f50eddd4a0c229c1b1df74f597aea81f0bc81a8231865e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/systemd-networkd-257.9-2.el10_1.aarch64.rpm;name=aarch64_systemd-networkd;unpack=0"
SRC_URI[aarch64_systemd-networkd.sha256sum] = "6532d1e394da884f22881469ccce7fa3b0d3a2087a442a6794d32c26534d5161"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/systemd-networkd-defaults-257.9-2.el10_1.noarch.rpm;name=aarch64_systemd-networkd-defaults;unpack=0"
SRC_URI[aarch64_systemd-networkd-defaults.sha256sum] = "53d411f1f976fe8460a9141e6f08fc63b2e86ada5cbcb661944224814541c8d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/systemd-timesyncd-257.9-2.el10_1.aarch64.rpm;name=aarch64_systemd-timesyncd;unpack=0"
SRC_URI[aarch64_systemd-timesyncd.sha256sum] = "84c7f51dda06584905c4698374b0b6075e56a059aa3c60ce7cd6c99617f22c04"

RDEPENDS:systemd-networkd = " \
 bash \
 dbus \
 glibc \
 libcap \
 libgcc \
 libmount \
 libselinux \
 shadow-utils \
 systemd \
 virtual/util-linux-core_or_util-linux \
 "
RDEPENDS:systemd-networkd-defaults = " \
 systemd-networkd \
 "
RDEPENDS:systemd-timesyncd = " \
 bash \
 dbus \
 glibc \
 libcap \
 libgcc \
 libselinux \
 shadow-utils \
 systemd \
 virtual/util-linux-core_or_util-linux \
 "
