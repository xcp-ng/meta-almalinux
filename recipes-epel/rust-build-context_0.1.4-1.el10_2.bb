# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-build-context"
PV = "0.1.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-build-context+default-devel \
 rust-build-context-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-build-context-0.1.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5bf83b5baeeee102d5fc8baefb331137f640a6aee0e718229ea4a612e204a9cd"

URI_x86_64_v2_rust-build-context+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-build-context+default-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-build-context+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-build-context+default-devel}"
SRC_URI[x86_64_v2_rust-build-context+default-devel.sha256sum] = "52c03ad527edf8a280456b5bc59c999ac0c8a46c7bef08316d1e23eed3c7c989"

URI_x86_64_v2_rust-build-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-build-context-devel-0.1.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-build-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-build-context-devel}"
SRC_URI[x86_64_v2_rust-build-context-devel.sha256sum] = "7fc667c6860b50aaf89b9bf946fb3ffe944d1309db46b18e0bcbc24210ca9f58"

URI_aarch64_rust-build-context+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-build-context+default-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-build-context+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-build-context+default-devel}"
SRC_URI[aarch64_rust-build-context+default-devel.sha256sum] = "a58319c68e99d2e1b124697891c740f2a9d7d7de228a0da15824229bb5e4c884"

URI_aarch64_rust-build-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-build-context-devel-0.1.4-1.el10_2.noarch.rpm;name=aarch64_rust-build-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-build-context-devel}"
SRC_URI[aarch64_rust-build-context-devel.sha256sum] = "f1cd0fcbb3f67b012fae0ef2ddffe499563b27a77a78c4f452e2ce19b52144fc"

RDEPENDS:rust-build-context+default-devel = " \
 cargo \
 rust-build-context-devel \
 "
RDEPENDS:rust-build-context-devel = " \
 cargo \
 rust \
 "
