# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-beef"
PV = "0.5.2"
PR = "10.el10_3"
PACKAGES = " \
 rust-beef+const_fn-devel \
 rust-beef+default-devel \
 rust-beef+impl_serde-devel \
 rust-beef+serde-devel \
 rust-beef-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-beef-0.5.2-10.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c86ef3637b798156daa7ae40a1ee0c900ad92010d99d884271640a1537333975"

URI_x86_64_v2_rust-beef+const_fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-beef+const_fn-devel-0.5.2-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-beef+const_fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-beef+const_fn-devel}"
SRC_URI[x86_64_v2_rust-beef+const_fn-devel.sha256sum] = "8021b06c5caf45aec1e4440b026b96b88160247b735c96cbfdc45b2d7730c879"

URI_x86_64_v2_rust-beef+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-beef+default-devel-0.5.2-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-beef+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-beef+default-devel}"
SRC_URI[x86_64_v2_rust-beef+default-devel.sha256sum] = "765ec77cbc562acf0a02e843c4076b107e8654f8bf258c0fed5dd0f9f46bf218"

URI_x86_64_v2_rust-beef+impl_serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-beef+impl_serde-devel-0.5.2-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-beef+impl_serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-beef+impl_serde-devel}"
SRC_URI[x86_64_v2_rust-beef+impl_serde-devel.sha256sum] = "9412aab0b8265cd7c020eb32ffc20f8b6eb2592a5482294e6370b3636621c781"

URI_x86_64_v2_rust-beef+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-beef+serde-devel-0.5.2-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-beef+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-beef+serde-devel}"
SRC_URI[x86_64_v2_rust-beef+serde-devel.sha256sum] = "2e188fc46e04bccefa3237ed0a3399904cadc40e2bdaab11523d50847a20217c"

URI_x86_64_v2_rust-beef-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-beef-devel-0.5.2-10.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-beef-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-beef-devel}"
SRC_URI[x86_64_v2_rust-beef-devel.sha256sum] = "98d7a223bd849652d87747d0bb4d5cc253d96b6d4e4ad24a8fde6936bf1d8065"

URI_aarch64_rust-beef+const_fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-beef+const_fn-devel-0.5.2-10.el10_3.noarch.rpm;name=aarch64_rust-beef+const_fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-beef+const_fn-devel}"
SRC_URI[aarch64_rust-beef+const_fn-devel.sha256sum] = "b43a18b6d0ff319f72239b1e860b2a71ed6f93d851d8f1c463ff86b0266d3e79"

URI_aarch64_rust-beef+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-beef+default-devel-0.5.2-10.el10_3.noarch.rpm;name=aarch64_rust-beef+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-beef+default-devel}"
SRC_URI[aarch64_rust-beef+default-devel.sha256sum] = "04a646323493f0dcde91c92904a810c64c7472e7690053d084aa1219f2c60029"

URI_aarch64_rust-beef+impl_serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-beef+impl_serde-devel-0.5.2-10.el10_3.noarch.rpm;name=aarch64_rust-beef+impl_serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-beef+impl_serde-devel}"
SRC_URI[aarch64_rust-beef+impl_serde-devel.sha256sum] = "b2d1141ed3c698c61acb95d4f8628e55908fb655f11fd679688a96f6e861bbef"

URI_aarch64_rust-beef+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-beef+serde-devel-0.5.2-10.el10_3.noarch.rpm;name=aarch64_rust-beef+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-beef+serde-devel}"
SRC_URI[aarch64_rust-beef+serde-devel.sha256sum] = "c7e9b804114ad5a3a89b3e5f1d49a376f7680f151b7b4a9de0f0f84268f45d6c"

URI_aarch64_rust-beef-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-beef-devel-0.5.2-10.el10_3.noarch.rpm;name=aarch64_rust-beef-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-beef-devel}"
SRC_URI[aarch64_rust-beef-devel.sha256sum] = "afb3113b67db2e356745432bdda47cfa4c46737aefe0b7eadc0ff031a0356d07"

RDEPENDS:rust-beef+const_fn-devel = " \
 cargo \
 rust-beef-devel \
 "
RDEPENDS:rust-beef+default-devel = " \
 cargo \
 rust-beef-devel \
 "
RDEPENDS:rust-beef+impl_serde-devel = " \
 cargo \
 rust-beef+serde-devel \
 rust-beef-devel \
 "
RDEPENDS:rust-beef+serde-devel = " \
 cargo \
 rust-beef-devel \
 rust-serde+alloc-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-beef-devel = " \
 bash \
 cargo \
 "
