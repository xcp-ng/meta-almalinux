# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Data-Binary"
PV = "0.01"
PR = "14.el10_0"
PACKAGES = " \
 perl-Data-Binary \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Data-Binary-0.01-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "423a8729c35bba6b18a3fa76ab0e34445d807bfd01d58466dc777e3fcc8c9bc9"

URI_x86_64_v2_perl-Data-Binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Data-Binary-0.01-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Data-Binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Data-Binary}"
SRC_URI[x86_64_v2_perl-Data-Binary.sha256sum] = "2435383be0a2510b730f573148f19be3ab0935f0b0ac2345a4faface79333d03"

URI_aarch64_perl-Data-Binary = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Data-Binary-0.01-14.el10_0.noarch.rpm;name=aarch64_perl-Data-Binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Data-Binary}"
SRC_URI[aarch64_perl-Data-Binary.sha256sum] = "63f8f51483b22ef53e39a21759a39261fbeff5bc79e95dc13031a078d33aacf1"

RDEPENDS:perl-Data-Binary = " \
 perl-Encode \
 perl-Exporter \
 perl-base \
 perl-libs \
 "
