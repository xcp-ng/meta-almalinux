# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-sonnet"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-sonnet \
 kf6-sonnet-aspell \
 kf6-sonnet-devel \
 kf6-sonnet-doc \
 kf6-sonnet-hspell \
 kf6-sonnet-html \
 kf6-sonnet-hunspell \
 kf6-sonnet-voikko \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-sonnet-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "552c3826ecf79c8d85aa3f94ef9bcac5139c63af45d1d79066c62054c06bc150"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet;unpack=0"
SRC_URI[x86_64_v2_kf6-sonnet.sha256sum] = "d75ea180df3621919593396555a84fb8c8d285bbc19e950096468f08b12ea759"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-aspell-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-aspell;unpack=0"
SRC_URI[x86_64_v2_kf6-sonnet-aspell.sha256sum] = "b92969361a336fac051d5bb049ce387b91e82603a52957975565d337101efb88"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-sonnet-devel.sha256sum] = "6d69a8fd3193ee92476f64161c5fd4092450d24b1f605a2296711f87f0f4faab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-sonnet-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-sonnet-doc.sha256sum] = "23c6c4de3f00845207a662fabc1f03c839822fdbec1746325910b260ca0cb455"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hspell-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hspell;unpack=0"
SRC_URI[x86_64_v2_kf6-sonnet-hspell.sha256sum] = "ee6a53aa3a27fad0593fe99ace9863ed41c88339118678fac6570ba06ebb54ba"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-sonnet-html;unpack=0"
SRC_URI[x86_64_v2_kf6-sonnet-html.sha256sum] = "5ebb12dfbb3078bb83eed729c4afa7cab2e5b5ce8f9f315afe178a477acad32a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-hunspell-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-hunspell;unpack=0"
SRC_URI[x86_64_v2_kf6-sonnet-hunspell.sha256sum] = "ab06377e0eea0fd64f7066c5bbe82292baaaa5749cba6dcb0d27a9133494787b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-sonnet-voikko-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-sonnet-voikko;unpack=0"
SRC_URI[x86_64_v2_kf6-sonnet-voikko.sha256sum] = "9ea5c3fae1e8318077fbff05d05a861907bad3eddf499dfe00e3699df0b34113"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet;unpack=0"
SRC_URI[aarch64_kf6-sonnet.sha256sum] = "422e926473d8b002b8d795d9d5d665dd4b3992273e285967a2ee6b573f5e8e45"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-aspell-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-aspell;unpack=0"
SRC_URI[aarch64_kf6-sonnet-aspell.sha256sum] = "1e3488d7759eb8a49765ab412ec6359475dce22e2eed31a6e46f2e0845994bd3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-devel;unpack=0"
SRC_URI[aarch64_kf6-sonnet-devel.sha256sum] = "a34ac781203b9c13987eba2cd1121ddc8bbfc96502bdfc1097425f9390e82910"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-sonnet-doc;unpack=0"
SRC_URI[aarch64_kf6-sonnet-doc.sha256sum] = "288f087cc3d5e71d6b83a069f3529731de73eab33ce60270a84532b1589f1050"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hspell-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-hspell;unpack=0"
SRC_URI[aarch64_kf6-sonnet-hspell.sha256sum] = "7eecf2bc57a8bf2abcdc9cb8e60af1d9d547f5cbb908cdbe6a9c4225fc89520c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-sonnet-html;unpack=0"
SRC_URI[aarch64_kf6-sonnet-html.sha256sum] = "26ffc16b6ca081d3bf2afe9d71d8f78066423ce07ad4521cf9f3d81f8cffeda8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-hunspell-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-hunspell;unpack=0"
SRC_URI[aarch64_kf6-sonnet-hunspell.sha256sum] = "3ab5a3add89016ca12f2f19ac5ac30bb30966e53619ac19202e82122138a96ef"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-sonnet-voikko-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-sonnet-voikko;unpack=0"
SRC_URI[aarch64_kf6-sonnet-voikko.sha256sum] = "1ad50ed8529cff07cb66f8c324e673cf12bafe8a50166c4566e9cdb09b9a1616"

RDEPENDS:kf6-sonnet = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-sonnet-aspell = " \
 aspell \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-devel = " \
 cmake-filesystem \
 glibc \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-sonnet-doc = " \
 "
RDEPENDS:kf6-sonnet-hspell = " \
 glibc \
 hspell \
 hunspell-he \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-html = " \
 "
RDEPENDS:kf6-sonnet-hunspell = " \
 glibc \
 hunspell \
 kf6-sonnet \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-sonnet-voikko = " \
 glibc \
 kf6-sonnet \
 libstdc++ \
 libvoikko \
 qt6-qtbase \
 "
