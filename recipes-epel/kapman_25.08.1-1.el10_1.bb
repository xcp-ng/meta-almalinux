# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kapman"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kapman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kapman-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "316f8d99b1cca74ace8f695c74987a7ebfca076ce74881b88c9f932b35db14ce"

URI_x86_64_v2_kapman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kapman-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kapman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kapman}"
SRC_URI[x86_64_v2_kapman.sha256sum] = "1cc7fa7c57745db0923612cf406388b82f0d33101abb759aae4be4c73d4dc391"

URI_aarch64_kapman = "${EPEL_MIRROR}/aarch64/Packages/k/kapman-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kapman;unpack=0"
SRC_URI:append = " ${URI_aarch64_kapman}"
SRC_URI[aarch64_kapman.sha256sum] = "6fa5a8c8cf5893b3ba6b070a07a2fff114ddae5e5e5b02b779fad8f4a645d593"

RDEPENDS:kapman = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
