# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-MemoTrie"
PV = "0.6.11"
PR = "3.el10_0"
PACKAGES = " \
 ghc-MemoTrie \
 ghc-MemoTrie-devel \
 ghc-MemoTrie-doc \
 ghc-MemoTrie-prof \
 ghc-newtype-generics \
 ghc-newtype-generics-devel \
 ghc-newtype-generics-doc \
 ghc-newtype-generics-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-MemoTrie-0.6.11-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18d26a38d455b806f0b42f947d2315e5980ec195e0684145cedd7a5e16494a58"

URI_x86_64_v2_ghc-MemoTrie = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-MemoTrie-0.6.11-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-MemoTrie;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-MemoTrie}"
SRC_URI[x86_64_v2_ghc-MemoTrie.sha256sum] = "07b933fbd720b4f8aac63decdf0118b1cc82a7474c3d6fb1a9d926cd8cfe806f"

URI_x86_64_v2_ghc-MemoTrie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-MemoTrie-devel-0.6.11-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-MemoTrie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-MemoTrie-devel}"
SRC_URI[x86_64_v2_ghc-MemoTrie-devel.sha256sum] = "52b97cb504e26b98bad6798e1aa5cdde40f54ea2f4476a4262d17dc4b6c4766f"

URI_x86_64_v2_ghc-MemoTrie-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-MemoTrie-doc-0.6.11-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-MemoTrie-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-MemoTrie-doc}"
SRC_URI[x86_64_v2_ghc-MemoTrie-doc.sha256sum] = "736408d5a9c81bcdaac9ae8abeed6883a705216739b387d89c9907b9e61a5436"

URI_x86_64_v2_ghc-MemoTrie-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-MemoTrie-prof-0.6.11-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-MemoTrie-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-MemoTrie-prof}"
SRC_URI[x86_64_v2_ghc-MemoTrie-prof.sha256sum] = "6dfea1c57d27a837f7349234b8a62a4712b83dd1237ecd1aa76b5a508b3c6af6"

URI_x86_64_v2_ghc-newtype-generics = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-newtype-generics-0.6.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-newtype-generics;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-newtype-generics}"
SRC_URI[x86_64_v2_ghc-newtype-generics.sha256sum] = "422992fca8d7b6715de3ec043ad0efb2ea0d1e5c2936dbf778a6c347e7a06388"

URI_x86_64_v2_ghc-newtype-generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-newtype-generics-devel-0.6.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-newtype-generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-newtype-generics-devel}"
SRC_URI[x86_64_v2_ghc-newtype-generics-devel.sha256sum] = "a69575a48505fa584d0b26e25b8549d42f16f8ab059bbcb2fa31c331b67911e1"

URI_x86_64_v2_ghc-newtype-generics-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-newtype-generics-doc-0.6.2-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-newtype-generics-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-newtype-generics-doc}"
SRC_URI[x86_64_v2_ghc-newtype-generics-doc.sha256sum] = "9e844298ba8b8aa825b19f89c35a6d059e97639abd066d04165e77ea5865f687"

URI_x86_64_v2_ghc-newtype-generics-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-newtype-generics-prof-0.6.2-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-newtype-generics-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-newtype-generics-prof}"
SRC_URI[x86_64_v2_ghc-newtype-generics-prof.sha256sum] = "dc5652629dc9bd1f9f00c78b95174c1486536050899362c0dfba3fff880ace75"

URI_aarch64_ghc-MemoTrie = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-MemoTrie-0.6.11-3.el10_0.aarch64.rpm;name=aarch64_ghc-MemoTrie;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-MemoTrie}"
SRC_URI[aarch64_ghc-MemoTrie.sha256sum] = "16bedf21ce696fb40d23a90a793be3d7cc1b2e335fdf33ac448b25966cbbd6d8"

URI_aarch64_ghc-MemoTrie-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-MemoTrie-devel-0.6.11-3.el10_0.aarch64.rpm;name=aarch64_ghc-MemoTrie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-MemoTrie-devel}"
SRC_URI[aarch64_ghc-MemoTrie-devel.sha256sum] = "220c702d7b6d277c802d8631a71dad91aa2913e1331874567936e0bd9acf6397"

URI_aarch64_ghc-MemoTrie-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-MemoTrie-doc-0.6.11-3.el10_0.noarch.rpm;name=aarch64_ghc-MemoTrie-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-MemoTrie-doc}"
SRC_URI[aarch64_ghc-MemoTrie-doc.sha256sum] = "c73c9a7240c06a8989f7c140ec582750215ada25021445475bb1100c3b456086"

URI_aarch64_ghc-MemoTrie-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-MemoTrie-prof-0.6.11-3.el10_0.aarch64.rpm;name=aarch64_ghc-MemoTrie-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-MemoTrie-prof}"
SRC_URI[aarch64_ghc-MemoTrie-prof.sha256sum] = "171b61359ada46d0e6c19d2e1e2729346ecdbe7526feccf38f2310bf1bce3d45"

URI_aarch64_ghc-newtype-generics = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-newtype-generics-0.6.2-3.el10_0.aarch64.rpm;name=aarch64_ghc-newtype-generics;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-newtype-generics}"
SRC_URI[aarch64_ghc-newtype-generics.sha256sum] = "af160a71e4aa3d7238f9f5147e713a738d6be15ecd26c7bd38bd9f7fd485a517"

URI_aarch64_ghc-newtype-generics-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-newtype-generics-devel-0.6.2-3.el10_0.aarch64.rpm;name=aarch64_ghc-newtype-generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-newtype-generics-devel}"
SRC_URI[aarch64_ghc-newtype-generics-devel.sha256sum] = "a74a2dc213adb8e94d46269b2f12a7cf4667fd21f28c16badf0e2c65ad4984c5"

URI_aarch64_ghc-newtype-generics-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-newtype-generics-doc-0.6.2-3.el10_0.noarch.rpm;name=aarch64_ghc-newtype-generics-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-newtype-generics-doc}"
SRC_URI[aarch64_ghc-newtype-generics-doc.sha256sum] = "618545f2df0f513ea93a33765175c91b815612e0fe961e90ceffa1c926812d80"

URI_aarch64_ghc-newtype-generics-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-newtype-generics-prof-0.6.2-3.el10_0.aarch64.rpm;name=aarch64_ghc-newtype-generics-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-newtype-generics-prof}"
SRC_URI[aarch64_ghc-newtype-generics-prof.sha256sum] = "ef7258f1836ad50812ec535088e0b5fee9046afac3834101bda074cc549f6910"

RDEPENDS:ghc-MemoTrie = " \
 ghc-base \
 ghc-ghc-bignum \
 ghc-newtype-generics \
 glibc \
 gmp \
 "
RDEPENDS:ghc-MemoTrie-devel = " \
 ghc-MemoTrie \
 ghc-base-devel \
 ghc-compiler \
 ghc-newtype-generics-devel \
 "
RDEPENDS:ghc-MemoTrie-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-MemoTrie-prof = " \
 ghc-MemoTrie-devel \
 ghc-base-prof \
 ghc-newtype-generics-prof \
 "
RDEPENDS:ghc-newtype-generics = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-newtype-generics-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-newtype-generics \
 "
RDEPENDS:ghc-newtype-generics-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-newtype-generics-prof = " \
 ghc-base-prof \
 ghc-newtype-generics-devel \
 "
