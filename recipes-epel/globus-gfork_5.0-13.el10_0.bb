# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gfork"
PV = "5.0"
PR = "13.el10_0"
PACKAGES = " \
 globus-gfork \
 globus-gfork-devel \
 globus-gfork-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gfork-5.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc992ddd53057209c747c62bd60ffd3ca6bf3311b744cf23f32dac5c6bcaf806"

URI_x86_64_v2_globus-gfork = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gfork-5.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gfork;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gfork}"
SRC_URI[x86_64_v2_globus-gfork.sha256sum] = "ea97c9a01cb35b974d28d9f855ab76569f13342cb13bc970cdd74b74a43c1302"

URI_x86_64_v2_globus-gfork-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gfork-devel-5.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gfork-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gfork-devel}"
SRC_URI[x86_64_v2_globus-gfork-devel.sha256sum] = "e8677ed36a7bf1109e035071aeeddb76b9d11100b1e07621586880e36cdafbee"

URI_x86_64_v2_globus-gfork-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gfork-progs-5.0-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gfork-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gfork-progs}"
SRC_URI[x86_64_v2_globus-gfork-progs.sha256sum] = "27f36dcf1f92301102ca25dd5dc5f9beba90020c3f6203daf6a0f67b53be97eb"

URI_aarch64_globus-gfork = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gfork-5.0-13.el10_0.aarch64.rpm;name=aarch64_globus-gfork;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gfork}"
SRC_URI[aarch64_globus-gfork.sha256sum] = "ae9e7719c7e943b5bd3f2355f879e9ed94ca1f291b089ce77d52d03e3e03ed6a"

URI_aarch64_globus-gfork-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gfork-devel-5.0-13.el10_0.aarch64.rpm;name=aarch64_globus-gfork-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gfork-devel}"
SRC_URI[aarch64_globus-gfork-devel.sha256sum] = "a5705361e8e80bc371a86f8cb2129c7e19d8f529cb15e24115ecc6d6b487ca0f"

URI_aarch64_globus-gfork-progs = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gfork-progs-5.0-13.el10_0.aarch64.rpm;name=aarch64_globus-gfork-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gfork-progs}"
SRC_URI[aarch64_globus-gfork-progs.sha256sum] = "eb263282ecf2e9fc0cf10b447b307b1a54056e36f97991f73a59eb3a29012c76"

RDEPENDS:globus-gfork = " \
 glibc \
 globus-common \
 globus-xio \
 "
RDEPENDS:globus-gfork-devel = " \
 globus-common-devel \
 globus-gfork \
 globus-xio-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gfork-progs = " \
 glibc \
 globus-common \
 globus-gfork \
 globus-xio \
 "
