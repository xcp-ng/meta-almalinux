# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-wxpython4"
PV = "4.2.2"
PR = "2.el10_1"
PACKAGES = " \
 python-wxpython4-doc \
 python3-wxpython4 \
 python3-wxpython4-media \
 python3-wxpython4-webview \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-wxpython4-4.2.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "90c2860c740a82e97b50b8cc7dd5e90e63c6d621ac9b030e7760401fdf976cb8"

URI_x86_64_v2_python-wxpython4-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-wxpython4-doc-4.2.2-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-wxpython4-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-wxpython4-doc}"
SRC_URI[x86_64_v2_python-wxpython4-doc.sha256sum] = "13528ef60edf8c092ae12fd12b08d825011175aa676bae7ebbb306c67839a1af"

URI_x86_64_v2_python3-wxpython4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wxpython4-4.2.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-wxpython4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wxpython4}"
SRC_URI[x86_64_v2_python3-wxpython4.sha256sum] = "875372983dd5cfeea76688f6efa88cc2a620c20d2d421b12f4e14db80182a97b"

URI_x86_64_v2_python3-wxpython4-media = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wxpython4-media-4.2.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-wxpython4-media;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wxpython4-media}"
SRC_URI[x86_64_v2_python3-wxpython4-media.sha256sum] = "e4c9469f6274264e849d9d7713bd98de2f1d902dc6441740096e5de52cec01eb"

URI_x86_64_v2_python3-wxpython4-webview = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-wxpython4-webview-4.2.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-wxpython4-webview;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-wxpython4-webview}"
SRC_URI[x86_64_v2_python3-wxpython4-webview.sha256sum] = "bb63565181199e770ffacf971124b9e581a791f578a0b553158464e37660eb6b"

URI_aarch64_python-wxpython4-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-wxpython4-doc-4.2.2-2.el10_1.noarch.rpm;name=aarch64_python-wxpython4-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-wxpython4-doc}"
SRC_URI[aarch64_python-wxpython4-doc.sha256sum] = "9349669c82e11112b1b346d87345b1f8921223100633f4f5bfb8bfe6eb08e4b6"

URI_aarch64_python3-wxpython4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wxpython4-4.2.2-2.el10_1.aarch64.rpm;name=aarch64_python3-wxpython4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wxpython4}"
SRC_URI[aarch64_python3-wxpython4.sha256sum] = "01858a1a39e2072b40f48515139ca5064db097d66b53dbd0da011977e7daef6f"

URI_aarch64_python3-wxpython4-media = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wxpython4-media-4.2.2-2.el10_1.aarch64.rpm;name=aarch64_python3-wxpython4-media;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wxpython4-media}"
SRC_URI[aarch64_python3-wxpython4-media.sha256sum] = "faab063f9e4cbcb283cef2b5fcf987e99867d2aa46338100f09462a6f65b0938"

URI_aarch64_python3-wxpython4-webview = "${EPEL_MIRROR}/aarch64/Packages/p/python3-wxpython4-webview-4.2.2-2.el10_1.aarch64.rpm;name=aarch64_python3-wxpython4-webview;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-wxpython4-webview}"
SRC_URI[aarch64_python3-wxpython4-webview.sha256sum] = "ffa7dc0b97594f9d529c83809854aa811b513a32800e337d44afedd37857acee"

RDEPENDS:python-wxpython4-doc = " \
 "
RDEPENDS:python3-wxpython4 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-pillow \
 python3-six \
 wxBase \
 wxGTK \
 wxGTK-gl \
 "
RDEPENDS:python3-wxpython4-media = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-wxpython4 \
 wxBase \
 wxGTK \
 wxGTK-media \
 "
RDEPENDS:python3-wxpython4-webview = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-wxpython4 \
 wxBase \
 wxGTK \
 wxGTK-webview \
 "
