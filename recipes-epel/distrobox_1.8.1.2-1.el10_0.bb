# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "distrobox"
PV = "1.8.1.2"
PR = "1.el10_0"
PACKAGES = " \
 distrobox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/distrobox-1.8.1.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ed69705f081a54da9639d4728396af46d0e254a15d000b4376a759f89c5739b"

URI_x86_64_v2_distrobox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/distrobox-1.8.1.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_distrobox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_distrobox}"
SRC_URI[x86_64_v2_distrobox.sha256sum] = "8e77d3f1cc8b515413cf0cdf57f1ddd529912431b7e9167d9242096805362448"

URI_aarch64_distrobox = "${EPEL_MIRROR}/aarch64/Packages/d/distrobox-1.8.1.2-1.el10_0.noarch.rpm;name=aarch64_distrobox;unpack=0"
SRC_URI:append = " ${URI_aarch64_distrobox}"
SRC_URI[aarch64_distrobox.sha256sum] = "6cb5fe88bb2c2f587f42d3f60b353bf2b63429bca22182e95115351647f6c3f4"

RDEPENDS:distrobox = " \
 bash \
 findutils \
 grep \
 hicolor-icon-theme \
 sed \
 virtual//usr/bin/basename \
 virtual/podman_or_/usr/bin/docker \
 "
