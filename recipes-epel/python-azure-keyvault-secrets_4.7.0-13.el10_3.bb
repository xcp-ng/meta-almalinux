# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-azure-keyvault-secrets"
PV = "4.7.0"
PR = "13.el10_3"
PACKAGES = " \
 python3-azure-keyvault-secrets \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-azure-keyvault-secrets-4.7.0-13.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f8881129638112be635d4bbcf7b6e9651551d289e0a12f9baf83b20855419804"

URI_x86_64_v2_python3-azure-keyvault-secrets = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-azure-keyvault-secrets-4.7.0-13.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-azure-keyvault-secrets;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-azure-keyvault-secrets}"
SRC_URI[x86_64_v2_python3-azure-keyvault-secrets.sha256sum] = "98d87496f4e4270f8a0939988251c6def521a86e1922f43c77f88c3b04c8cdd4"

URI_aarch64_python3-azure-keyvault-secrets = "${EPEL_MIRROR}/aarch64/Packages/p/python3-azure-keyvault-secrets-4.7.0-13.el10_3.noarch.rpm;name=aarch64_python3-azure-keyvault-secrets;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-azure-keyvault-secrets}"
SRC_URI[aarch64_python3-azure-keyvault-secrets.sha256sum] = "b77f6ace00a6d4fd6168fb5336b851a70332350f030a544414153f9fa0bdca14"

RDEPENDS:python3-azure-keyvault-secrets = " \
 python3 \
 python3-azure-common \
 python3-azure-core \
 python3-isodate \
 python3-typing-extensions \
 "
