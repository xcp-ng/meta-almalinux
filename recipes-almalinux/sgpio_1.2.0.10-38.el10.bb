# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sgpio"
PV = "1.2.0.10"
PR = "38.el10"
PACKAGES = " \
 sgpio \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/sgpio-1.2.0.10-38.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cdad3447b5823b1a4a8faea1601560f5869063f2a031fc13d5311690887b4ec"

URI_x86_64_v2_sgpio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sgpio-1.2.0.10-38.el10.x86_64_v2.rpm;name=x86_64_v2_sgpio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sgpio}"
SRC_URI[x86_64_v2_sgpio.sha256sum] = "a37a24735f6077a156c53e3af9cad607b6a7a11aaacdaeb866ecc142bb7e53af"

URI_aarch64_sgpio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sgpio-1.2.0.10-38.el10.aarch64.rpm;name=aarch64_sgpio;unpack=0"
SRC_URI:append = " ${URI_aarch64_sgpio}"
SRC_URI[aarch64_sgpio.sha256sum] = "ae2e282b4861c74e50270021810e868f75223b5471372a7b64fee5d263ec94f6"

RDEPENDS:sgpio = " \
 glibc \
 "
