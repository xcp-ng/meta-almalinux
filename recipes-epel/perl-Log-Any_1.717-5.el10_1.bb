# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Log-Any"
PV = "1.717"
PR = "5.el10_1"
PACKAGES = " \
 perl-Log-Any \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Log-Any-1.717-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f5eaf04043c547d92a125a72e9a9bef3c7d36644ad6a8cdd02a71c170819e361"

URI_x86_64_v2_perl-Log-Any = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Log-Any-1.717-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Log-Any;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Log-Any}"
SRC_URI[x86_64_v2_perl-Log-Any.sha256sum] = "1c424433f23ba48de2f026ad16c7ffd3d61c077d9ef7e0fb96f5b503f0137885"

URI_aarch64_perl-Log-Any = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Log-Any-1.717-5.el10_1.noarch.rpm;name=aarch64_perl-Log-Any;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Log-Any}"
SRC_URI[aarch64_perl-Log-Any.sha256sum] = "2bbfeb71270007644ce6a4a7639f0e7d6270d0699437d796024b2af57806caf2"

RDEPENDS:perl-Log-Any = " \
 perl-B \
 perl-Carp \
 perl-Data-Dumper \
 perl-Devel-StackTrace \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-IO \
 perl-Log-Any \
 perl-Scalar-List-Utils \
 perl-Sys-Syslog \
 perl-Test-Simple \
 perl-base \
 perl-constant \
 perl-libs \
 perl-overload \
 "
