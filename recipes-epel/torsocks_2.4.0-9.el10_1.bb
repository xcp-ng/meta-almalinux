# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "torsocks"
PV = "2.4.0"
PR = "9.el10_1"
PACKAGES = " \
 torsocks \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/torsocks-2.4.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "439ed44ef32253cf13e89a927d1093a01f7e2bd533def513ee514830647fe3e6"

URI_x86_64_v2_torsocks = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/torsocks-2.4.0-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_torsocks;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_torsocks}"
SRC_URI[x86_64_v2_torsocks.sha256sum] = "65127ff72ac25e57da6a8b31c4335628e32e441ec4fa2ee836a974d33609f812"

URI_aarch64_torsocks = "${EPEL_MIRROR}/aarch64/Packages/t/torsocks-2.4.0-9.el10_1.aarch64.rpm;name=aarch64_torsocks;unpack=0"
SRC_URI:append = " ${URI_aarch64_torsocks}"
SRC_URI[aarch64_torsocks.sha256sum] = "a73870f5c49841b7b94406554722c45463a09723d18f0518b2ffb18f9d5610bf"

RDEPENDS:torsocks = " \
 bash \
 glibc \
 "
