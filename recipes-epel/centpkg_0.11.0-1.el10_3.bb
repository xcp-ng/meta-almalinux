# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "centpkg"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 centpkg \
 centpkg-sig \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/centpkg-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3f43800d88b5925619550d100760fdc3abb568644078aafd1a964320111c870"

URI_x86_64_v2_centpkg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centpkg-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_centpkg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_centpkg}"
SRC_URI[x86_64_v2_centpkg.sha256sum] = "e42fbdf922a6663d4c50d4c8744e911fa8587fd38dccb2472d705f356b5f4815"

URI_x86_64_v2_centpkg-sig = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/centpkg-sig-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_centpkg-sig;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_centpkg-sig}"
SRC_URI[x86_64_v2_centpkg-sig.sha256sum] = "4202604f1a5883bf1a44c9fa203dde2e6e44af9469dd3cc475345f2f2a95ede4"

URI_aarch64_centpkg = "${EPEL_MIRROR}/aarch64/Packages/c/centpkg-0.11.0-1.el10_3.noarch.rpm;name=aarch64_centpkg;unpack=0"
SRC_URI:append = " ${URI_aarch64_centpkg}"
SRC_URI[aarch64_centpkg.sha256sum] = "d67a5e2a94fcb9d7794bfec9794299d0c378887b11fecb9d321f3b6727552522"

URI_aarch64_centpkg-sig = "${EPEL_MIRROR}/aarch64/Packages/c/centpkg-sig-0.11.0-1.el10_3.noarch.rpm;name=aarch64_centpkg-sig;unpack=0"
SRC_URI:append = " ${URI_aarch64_centpkg-sig}"
SRC_URI[aarch64_centpkg-sig.sha256sum] = "805cae4f7b6e3ee052fd2b7acf245314bf057ac8710fd7d59f217d57922d6d51"

RDEPENDS:centpkg = " \
 python3 \
 python3-GitPython \
 python3-cryptography \
 python3-gitlab \
 python3-pycurl \
 python3-pyyaml \
 python3-rpkg \
 "
RDEPENDS:centpkg-sig = " \
 centpkg \
 python3 \
 "
