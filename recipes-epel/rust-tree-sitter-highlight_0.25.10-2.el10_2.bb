# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-highlight"
PV = "0.25.10"
PR = "2.el10_2"
PACKAGES = " \
 rust-tree-sitter-highlight+default-devel \
 rust-tree-sitter-highlight-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-highlight-0.25.10-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43da6872769d5b0bec5d8e04beb2ac4f011fa2407a1bd143794a82d60138c9b8"

URI_x86_64_v2_rust-tree-sitter-highlight+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-highlight+default-devel-0.25.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-highlight+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-highlight+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-highlight+default-devel.sha256sum] = "9d7d31ff234f93bc4de659340f9f4c00849dcd4c8a96e73b453d5537a1855b7d"

URI_x86_64_v2_rust-tree-sitter-highlight-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-highlight-devel-0.25.10-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-highlight-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-highlight-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-highlight-devel.sha256sum] = "2b7ffc18351dc767d1a14c4f2af8a2cc893d4fb93a72eb934e710eb02d4f63de"

URI_aarch64_rust-tree-sitter-highlight+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-highlight+default-devel-0.25.10-2.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-highlight+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-highlight+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-highlight+default-devel.sha256sum] = "99166347f75cb79acfc6605b1c2692e23f5952c8e9fcb503804d519357b604a0"

URI_aarch64_rust-tree-sitter-highlight-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-highlight-devel-0.25.10-2.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-highlight-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-highlight-devel}"
SRC_URI[aarch64_rust-tree-sitter-highlight-devel.sha256sum] = "e4a32d74511d0976ba98cca9939f36f0a91834d7592e751aaf00b21246a064dd"

RDEPENDS:rust-tree-sitter-highlight+default-devel = " \
 cargo \
 rust-tree-sitter-highlight-devel \
 "
RDEPENDS:rust-tree-sitter-highlight-devel = " \
 cargo \
 rust \
 rust-regex+default-devel \
 rust-streaming-iterator+default-devel \
 rust-thiserror+default-devel \
 rust-tree-sitter0.25+default-devel \
 "
