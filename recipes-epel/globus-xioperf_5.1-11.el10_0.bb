# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xioperf"
PV = "5.1"
PR = "11.el10_0"
PACKAGES = " \
 globus-xioperf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-xioperf-5.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0c9641acc9e8a2a0b898a24c1ebd0b8f048ddc32ff1c05418c80ca627ebceb1"

URI_x86_64_v2_globus-xioperf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xioperf-5.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xioperf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xioperf}"
SRC_URI[x86_64_v2_globus-xioperf.sha256sum] = "1cd97c82f07aac33afb263abe49a040ccd7f0e2ee472928535e791ddcade92d7"

URI_aarch64_globus-xioperf = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xioperf-5.1-11.el10_0.aarch64.rpm;name=aarch64_globus-xioperf;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xioperf}"
SRC_URI[aarch64_globus-xioperf.sha256sum] = "6cc61aad0bcb3c1706746a2711b434b22f5c8be81bea9379207480eef056e803"

RDEPENDS:globus-xioperf = " \
 glibc \
 globus-common \
 globus-xio \
 "
