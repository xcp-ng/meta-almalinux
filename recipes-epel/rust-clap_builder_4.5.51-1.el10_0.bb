# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_builder"
PV = "4.5.51"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+color-devel \
 rust-clap_builder+debug-devel \
 rust-clap_builder+default-devel \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-doc-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+unstable-styles-devel \
 rust-clap_builder+unstable-v5-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_builder-4.5.51-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fee1a991ed032f79534ac05f0133f1bf0e1660dc7216111640e3f4097af5861e"

URI_x86_64_v2_rust-clap_builder+cargo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+cargo-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+cargo-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+cargo-devel.sha256sum] = "a5c290bd5b5f62ef8adeee1d8ea19f818c89157a908838b4f2a147246bb00ea5"

URI_x86_64_v2_rust-clap_builder+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+color-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+color-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+color-devel.sha256sum] = "fdc8b24603f75cddfc681677447e5811d9f7621d7f6ac6cb56be63c491d4bf15"

URI_x86_64_v2_rust-clap_builder+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+debug-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+debug-devel.sha256sum] = "97dc70d8e77b6621aff690c7a3648262f6d18e3a88c164cfad20da68213bdfbc"

URI_x86_64_v2_rust-clap_builder+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+default-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+default-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+default-devel.sha256sum] = "f8d5587af0722a473e17c21ccc823a1210998c37a5b83dc355a459ee9ebb7cad"

URI_x86_64_v2_rust-clap_builder+deprecated-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+deprecated-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+deprecated-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+deprecated-devel.sha256sum] = "f470808c0ad1c0609fd35fb9601762df740aa433ce67ef803fb60309c72b0d3f"

URI_x86_64_v2_rust-clap_builder+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+env-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+env-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+env-devel.sha256sum] = "68c3138ae1064395823149ac0010115a12d1405ba370e8c563eea03a761f4b25"

URI_x86_64_v2_rust-clap_builder+error-context-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+error-context-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+error-context-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+error-context-devel.sha256sum] = "146528fd0e1a94597c4e9b54a0ff67ca9111279d95cf400d707506cd572c165d"

URI_x86_64_v2_rust-clap_builder+help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+help-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+help-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+help-devel.sha256sum] = "6bbe89bfcadd1e4e5a608b52118b7c898b6fea127c3782a6c43ad2c71e61d5bf"

URI_x86_64_v2_rust-clap_builder+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+std-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+std-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+std-devel.sha256sum] = "83d9b81bca04b8adca763ba58af6307f05e738d4e1764946f9311326d432f3c2"

URI_x86_64_v2_rust-clap_builder+string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+string-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+string-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+string-devel.sha256sum] = "64b96c1a3984fbc5669288b35a018dc9508405e610496eae33d294d4034cd0f1"

URI_x86_64_v2_rust-clap_builder+suggestions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+suggestions-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+suggestions-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+suggestions-devel.sha256sum] = "42c07c9c7db8d8b9e6062cbfc7b8327e25c95be3f8b16f1a3b1884c4724027cf"

URI_x86_64_v2_rust-clap_builder+unicode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unicode-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unicode-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unicode-devel.sha256sum] = "af76a8e293919ab05af3cd64bb3405f142751274f6b2a40cba34c420dd8ea6d2"

URI_x86_64_v2_rust-clap_builder+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-doc-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-doc-devel.sha256sum] = "d4c8e604796c96aeb39877a4f537fbf78614f2428bf78647c9048649b318ba9f"

URI_x86_64_v2_rust-clap_builder+unstable-ext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-ext-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-ext-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-ext-devel.sha256sum] = "65243b65d2d3cd8b0fa600a42f1bb5ee9058e6126a5e9a21290bc41833d24e1c"

URI_x86_64_v2_rust-clap_builder+unstable-styles-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-styles-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-styles-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-styles-devel.sha256sum] = "014560a855e271593a5b720819b6a21889b4468c647aa950bf9ff7a3993954c7"

URI_x86_64_v2_rust-clap_builder+unstable-v5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+unstable-v5-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+unstable-v5-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+unstable-v5-devel.sha256sum] = "b449d0bc3f00a821aec1b51ed3b53883cf9a202d629c64088f421aba4fd4aa00"

URI_x86_64_v2_rust-clap_builder+usage-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+usage-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+usage-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+usage-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+usage-devel.sha256sum] = "d128e3c4451dd6cc9b68c1b377c24fbf70506d9645c72acdb8ec6ee991958829"

URI_x86_64_v2_rust-clap_builder+wrap_help-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder+wrap_help-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder+wrap_help-devel}"
SRC_URI[x86_64_v2_rust-clap_builder+wrap_help-devel.sha256sum] = "799670ca908bd04a445b8cadaf67548b1be1743c3e95f6df17e867e8148b5ba4"

URI_x86_64_v2_rust-clap_builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_builder-devel-4.5.51-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_builder-devel}"
SRC_URI[x86_64_v2_rust-clap_builder-devel.sha256sum] = "eeebe77b4704b782dc4e4a9ede2fada8091ddff646cee62d33567006d85298b9"

URI_aarch64_rust-clap_builder+cargo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+cargo-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+cargo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+cargo-devel}"
SRC_URI[aarch64_rust-clap_builder+cargo-devel.sha256sum] = "f1ce80b2a502c4f148dfa037e28d215696401f28c867da3dd6cf804a96977161"

URI_aarch64_rust-clap_builder+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+color-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+color-devel}"
SRC_URI[aarch64_rust-clap_builder+color-devel.sha256sum] = "77aa5cff0b2febe4a58f8ab54ac4d3bbfdaf682ff93e16827e1ed04a26067a3e"

URI_aarch64_rust-clap_builder+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+debug-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+debug-devel}"
SRC_URI[aarch64_rust-clap_builder+debug-devel.sha256sum] = "0463d9ad896675e2e074f30ff732cb8a0ff9e9648c73f2586dd111dc5bf1619c"

URI_aarch64_rust-clap_builder+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+default-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+default-devel}"
SRC_URI[aarch64_rust-clap_builder+default-devel.sha256sum] = "3b54809a53e19f26d909173ca11071334a60645eabb2a4cefdef2ca62b1408dc"

URI_aarch64_rust-clap_builder+deprecated-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+deprecated-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+deprecated-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+deprecated-devel}"
SRC_URI[aarch64_rust-clap_builder+deprecated-devel.sha256sum] = "d2140675d2c49b2d58ce94f3bd9d26c1211e49a259c1158b1e97b93e8e3c97ee"

URI_aarch64_rust-clap_builder+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+env-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+env-devel}"
SRC_URI[aarch64_rust-clap_builder+env-devel.sha256sum] = "3ba5cedca25688fafd42ea8da23604aba6fb3263da4eb8ea05e3f6638103d850"

URI_aarch64_rust-clap_builder+error-context-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+error-context-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+error-context-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+error-context-devel}"
SRC_URI[aarch64_rust-clap_builder+error-context-devel.sha256sum] = "c7be0693c893ecc15ab8c894eb0adb9cd9465db28508e27e8501db6229d2c908"

URI_aarch64_rust-clap_builder+help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+help-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+help-devel}"
SRC_URI[aarch64_rust-clap_builder+help-devel.sha256sum] = "58abd5db7097a34ce7e3042c92cc29292492a990885c7d09f9f7ff15ed8a67dc"

URI_aarch64_rust-clap_builder+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+std-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+std-devel}"
SRC_URI[aarch64_rust-clap_builder+std-devel.sha256sum] = "a3562e4709446f61b8014a289c79661f8176480c15fcbd55b03c57014f1cf31c"

URI_aarch64_rust-clap_builder+string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+string-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+string-devel}"
SRC_URI[aarch64_rust-clap_builder+string-devel.sha256sum] = "7b69360da76b3f8133e8b3388933f79b047b54a6dfedb13b96f821110b127a90"

URI_aarch64_rust-clap_builder+suggestions-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+suggestions-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+suggestions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+suggestions-devel}"
SRC_URI[aarch64_rust-clap_builder+suggestions-devel.sha256sum] = "4680e5f4052e6f23797c8a30c0e364ebce0bd577f24a77c170585a680b14c63a"

URI_aarch64_rust-clap_builder+unicode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unicode-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+unicode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unicode-devel}"
SRC_URI[aarch64_rust-clap_builder+unicode-devel.sha256sum] = "878201520a63a663a5edb6e050a9ff37a869a8ad95a085719c164bfbfb73114e"

URI_aarch64_rust-clap_builder+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-doc-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-doc-devel.sha256sum] = "02f490db5daad351528f4754ef3dc50fc846171714df2b832c2ca9bdb07d6831"

URI_aarch64_rust-clap_builder+unstable-ext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-ext-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+unstable-ext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-ext-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-ext-devel.sha256sum] = "d445e4f9b51e9c7f66b160d5f76b04c4393705d9b978561766d5eb54c7ab31bd"

URI_aarch64_rust-clap_builder+unstable-styles-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-styles-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+unstable-styles-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-styles-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-styles-devel.sha256sum] = "8c8b8c70fa677874f347236e8b1d424ba35e536c8967666c047fa1622bf2046f"

URI_aarch64_rust-clap_builder+unstable-v5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+unstable-v5-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+unstable-v5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+unstable-v5-devel}"
SRC_URI[aarch64_rust-clap_builder+unstable-v5-devel.sha256sum] = "b72f32926c2f4070a7309d17ce58b6a7826abd7a5c1f90a799d9f413d588f500"

URI_aarch64_rust-clap_builder+usage-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+usage-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+usage-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+usage-devel}"
SRC_URI[aarch64_rust-clap_builder+usage-devel.sha256sum] = "8cfe9dae9c571a692c1e82e0b8266401fac9b3902573992c7322a30388bdeb85"

URI_aarch64_rust-clap_builder+wrap_help-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder+wrap_help-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder+wrap_help-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder+wrap_help-devel}"
SRC_URI[aarch64_rust-clap_builder+wrap_help-devel.sha256sum] = "78fa20fcc88eb1819904f0a8b623ea1770793ee0d162e370fa019a2dde5074d0"

URI_aarch64_rust-clap_builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_builder-devel-4.5.51-1.el10_0.noarch.rpm;name=aarch64_rust-clap_builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_builder-devel}"
SRC_URI[aarch64_rust-clap_builder-devel.sha256sum] = "a35713f51e9762424db0fd6dec494cfbbbfee8b1f7c7f0c537a5b9b898db557e"

RDEPENDS:rust-clap_builder+cargo-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+debug-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+default-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder+error-context-devel \
 rust-clap_builder+help-devel \
 rust-clap_builder+std-devel \
 rust-clap_builder+suggestions-devel \
 rust-clap_builder+usage-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+deprecated-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+env-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+error-context-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+help-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+std-devel = " \
 cargo \
 rust-anstyle+std-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+string-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+suggestions-devel = " \
 cargo \
 rust-clap_builder+error-context-devel \
 rust-clap_builder-devel \
 rust-strsim+default-devel \
 "
RDEPENDS:rust-clap_builder+unicode-devel = " \
 cargo \
 rust-clap_builder-devel \
 rust-unicase+default-devel \
 rust-unicode-width+default-devel \
 "
RDEPENDS:rust-clap_builder+unstable-doc-devel = " \
 cargo \
 rust-clap_builder+cargo-devel \
 rust-clap_builder+env-devel \
 rust-clap_builder+string-devel \
 rust-clap_builder+unicode-devel \
 rust-clap_builder+unstable-ext-devel \
 rust-clap_builder+wrap_help-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-ext-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-styles-devel = " \
 cargo \
 rust-clap_builder+color-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+unstable-v5-devel = " \
 cargo \
 rust-clap_builder+deprecated-devel \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+usage-devel = " \
 cargo \
 rust-clap_builder-devel \
 "
RDEPENDS:rust-clap_builder+wrap_help-devel = " \
 cargo \
 rust-clap_builder+help-devel \
 rust-clap_builder-devel \
 rust-terminal_size+default-devel \
 "
RDEPENDS:rust-clap_builder-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 rust-clap_lex+default-devel \
 "
