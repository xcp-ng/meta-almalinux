# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kparts"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kparts \
 kf6-kparts-devel \
 kf6-kparts-doc \
 kf6-kparts-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kparts-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f3af489671d44f61dd4cafea2571c467f629f03fd39a7a8225b5ec6e532deab"

URI_x86_64_v2_kf6-kparts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts}"
SRC_URI[x86_64_v2_kf6-kparts.sha256sum] = "cde327dbc0222dff3d92856d5e5d930498054fd44eea685d45b6cfc4a7982bc9"

URI_x86_64_v2_kf6-kparts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kparts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-devel}"
SRC_URI[x86_64_v2_kf6-kparts-devel.sha256sum] = "966aea58b490e79bcdbaeb585db2e33561d111e35813f1b2a0aaa04a9952cbf2"

URI_x86_64_v2_kf6-kparts-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kparts-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-doc}"
SRC_URI[x86_64_v2_kf6-kparts-doc.sha256sum] = "0e1507f8982738988621f60631df59ec3571834491c28d25e22a87532fdfaf2b"

URI_x86_64_v2_kf6-kparts-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kparts-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kparts-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kparts-html}"
SRC_URI[x86_64_v2_kf6-kparts-html.sha256sum] = "69817d7c759836db28089acafef0ebc53bf7efd0465305ac28fb6234f0bfe33a"

URI_aarch64_kf6-kparts = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kparts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts}"
SRC_URI[aarch64_kf6-kparts.sha256sum] = "d13e9889ca6b97c0f2b059de4eac1ca048befe591e434f6d5faf41cc184a7be2"

URI_aarch64_kf6-kparts-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kparts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-devel}"
SRC_URI[aarch64_kf6-kparts-devel.sha256sum] = "f79568f9c60846a126e2ae98b3f57d4235d86fe6b59c2f83271211c9eaaa7db5"

URI_aarch64_kf6-kparts-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kparts-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-doc}"
SRC_URI[aarch64_kf6-kparts-doc.sha256sum] = "b8bcb250382bb66b25d2108478c05c438cf0f193a78ab1b04c8bb9e195f6ec64"

URI_aarch64_kf6-kparts-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kparts-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kparts-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kparts-html}"
SRC_URI[aarch64_kf6-kparts-html.sha256sum] = "1c312dfd8b3448d4a184b88cc0c09201b5ed0c7d6bfa97d6a960c2e2add31516"

RDEPENDS:kf6-kparts = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kparts-devel = " \
 cmake-filesystem \
 kf6-kio-devel \
 kf6-kparts \
 kf6-ktextwidgets-devel \
 kf6-kxmlgui-devel \
 "
RDEPENDS:kf6-kparts-doc = " \
 "
RDEPENDS:kf6-kparts-html = " \
 "
