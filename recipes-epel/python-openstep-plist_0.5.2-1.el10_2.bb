# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-openstep-plist"
PV = "0.5.2"
PR = "1.el10_2"
PACKAGES = " \
 python3-openstep-plist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-openstep-plist-0.5.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d594f77cbdfba5d08a6cc0dbaa98ddb2f246987deddc7e154e906d28192b7ca1"

URI_x86_64_v2_python3-openstep-plist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openstep-plist-0.5.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-openstep-plist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openstep-plist}"
SRC_URI[x86_64_v2_python3-openstep-plist.sha256sum] = "a69bc40328566191dfb602ad85917a19b98fba29c1c51c0bd98e512b09909cb9"

URI_aarch64_python3-openstep-plist = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openstep-plist-0.5.2-1.el10_2.aarch64.rpm;name=aarch64_python3-openstep-plist;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openstep-plist}"
SRC_URI[aarch64_python3-openstep-plist.sha256sum] = "e9d8c735cecf5478d8ca8dec330799d77bd7cceb1fcd065a87737c63c4ab2536"

RDEPENDS:python3-openstep-plist = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
