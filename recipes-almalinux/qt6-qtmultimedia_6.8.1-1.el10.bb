# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtmultimedia"
PV = "6.8.1"
PR = "1.el10"
PACKAGES = " \
 qt6-qtmultimedia \
 qt6-qtmultimedia-devel \
 qt6-qtmultimedia-examples \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/qt6-qtmultimedia-6.8.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b202c1d8a1331701e4e1be9e590327365b41c2a4c4780b98e1a54eda71e023e"

URI_x86_64_v2_qt6-qtmultimedia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtmultimedia-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmultimedia}"
SRC_URI[x86_64_v2_qt6-qtmultimedia.sha256sum] = "08d492b8a398b29cdf3eafc453170fa92a737352defefad65a5e263f341ca74a"

URI_x86_64_v2_qt6-qtmultimedia-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/qt6-qtmultimedia-devel-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmultimedia-devel}"
SRC_URI[x86_64_v2_qt6-qtmultimedia-devel.sha256sum] = "38339932cfdfd980daaf78bb3f1d5e19cc988e7f61ccc680aaffb48b5aa737eb"

URI_x86_64_v2_qt6-qtmultimedia-examples = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/qt6-qtmultimedia-examples-6.8.1-1.el10.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmultimedia-examples}"
SRC_URI[x86_64_v2_qt6-qtmultimedia-examples.sha256sum] = "00a46700c67f219ae668b8cdebdb6c19c5266085cf0882ac35eff8bbc5ef703c"

URI_aarch64_qt6-qtmultimedia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtmultimedia-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtmultimedia;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmultimedia}"
SRC_URI[aarch64_qt6-qtmultimedia.sha256sum] = "809fc5b033ef89b3c6e2405c86596e38ec0d5007de80ba1df7fe24c2e20efb5c"

URI_aarch64_qt6-qtmultimedia-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/qt6-qtmultimedia-devel-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtmultimedia-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmultimedia-devel}"
SRC_URI[aarch64_qt6-qtmultimedia-devel.sha256sum] = "51c3dc84ca68f934b72497e12534ca6cf989a8a871fd9a52e4be998810b52d25"

URI_aarch64_qt6-qtmultimedia-examples = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/qt6-qtmultimedia-examples-6.8.1-1.el10.aarch64.rpm;name=aarch64_qt6-qtmultimedia-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmultimedia-examples}"
SRC_URI[aarch64_qt6-qtmultimedia-examples.sha256sum] = "0b893206343e5078c8c91845c562f02dfc03890d14b66c67e3e5f4a2d52739a6"

RDEPENDS:qt6-qtmultimedia = " \
 alsa-lib \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 libglvnd-egl \
 libstdc++ \
 pulseaudio-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtquick3d \
 "
RDEPENDS:qt6-qtmultimedia-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 qt6-qtmultimedia \
 qt6-qtmultimedia-devel \
 "
RDEPENDS:qt6-qtmultimedia-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
