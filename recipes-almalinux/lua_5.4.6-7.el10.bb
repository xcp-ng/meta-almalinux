# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lua"
PV = "5.4.6"
PR = "7.el10"
PACKAGES = " \
 lua \
 lua-devel \
 lua-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/lua-5.4.6-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a1dcfcad7f371256f2f79ce4760e483fa1522d134cf898441302a13e8bcde9d"

URI_x86_64_v2_lua = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/lua-5.4.6-7.el10.x86_64_v2.rpm;name=x86_64_v2_lua;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua}"
SRC_URI[x86_64_v2_lua.sha256sum] = "3bb22b4928f4361b335191e3f492696867b8943d8a9b94e120fcd152c784c53b"
RPROVIDES:lua:append:x86_64_v2 = " virtual/lua"

URI_x86_64_v2_lua-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/lua-devel-5.4.6-7.el10.x86_64_v2.rpm;name=x86_64_v2_lua-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-devel}"
SRC_URI[x86_64_v2_lua-devel.sha256sum] = "1ffc5144829f971b2818caffdd958e8496c010e29847fef0710191a5e632b086"

URI_x86_64_v2_lua-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/lua-libs-5.4.6-7.el10.x86_64_v2.rpm;name=x86_64_v2_lua-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lua-libs}"
SRC_URI[x86_64_v2_lua-libs.sha256sum] = "30d7e104d9990207bd6b279a47ad2d4d1bc6edf3f557916c18d40a6f50789cb8"

URI_aarch64_lua = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/lua-5.4.6-7.el10.aarch64.rpm;name=aarch64_lua;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua}"
SRC_URI[aarch64_lua.sha256sum] = "0448fc9e42debb48cde6afa9eaf9034d3db27227e7fcee7db1c741cb77d3eab1"
RPROVIDES:lua:append:aarch64 = " virtual/lua"

URI_aarch64_lua-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/lua-devel-5.4.6-7.el10.aarch64.rpm;name=aarch64_lua-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-devel}"
SRC_URI[aarch64_lua-devel.sha256sum] = "30b581898841feb62756337529756c8a9d16b48de3b5767c61c58be2bda2c956"

URI_aarch64_lua-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/lua-libs-5.4.6-7.el10.aarch64.rpm;name=aarch64_lua-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lua-libs}"
SRC_URI[aarch64_lua-libs.sha256sum] = "ee9a1529698207ebf3ac39bd478afeedc40678691284b4209d7186bdf9afde62"

RDEPENDS:lua = " \
 glibc \
 lua-libs \
 readline \
 "
RDEPENDS:lua-devel = " \
 lua \
 lua-rpm-macros \
 pkgconf-pkg-config \
 "
RDEPENDS:lua-libs = " \
 glibc \
 "
