# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rsync"
PV = "3.4.1"
PR = "2.el10"
PACKAGES = " \
 rsync \
 rsync-daemon \
 rsync-rrsync \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/rsync-3.4.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cab405943a766f9490b0fc555323cbd55db26cef50ca85db3240391229a78155"

URI_x86_64_v2_rsync = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/rsync-3.4.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_rsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync}"
SRC_URI[x86_64_v2_rsync.sha256sum] = "442035d84d6b4dee87c781ace0710c676f66903a18183f29f9e9dcb3defea5f2"

URI_x86_64_v2_rsync-daemon = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsync-daemon-3.4.1-2.el10.noarch.rpm;name=x86_64_v2_rsync-daemon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync-daemon}"
SRC_URI[x86_64_v2_rsync-daemon.sha256sum] = "c70129ad90ad8d013703e86fbb1e19e4c709c64b0c8bc33ce8e2581eb41aa7fb"

URI_x86_64_v2_rsync-rrsync = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rsync-rrsync-3.4.1-2.el10.noarch.rpm;name=x86_64_v2_rsync-rrsync;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rsync-rrsync}"
SRC_URI[x86_64_v2_rsync-rrsync.sha256sum] = "57e8d6fb49d61a6ad78a96628799532df853557c7b3d049d906fe09ce97c3665"

URI_aarch64_rsync = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/rsync-3.4.1-2.el10.aarch64.rpm;name=aarch64_rsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync}"
SRC_URI[aarch64_rsync.sha256sum] = "d798331ea5c9acb999af71daf8e6295b7ee29dd8e703b24f1db48c3526d4d110"

URI_aarch64_rsync-daemon = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsync-daemon-3.4.1-2.el10.noarch.rpm;name=aarch64_rsync-daemon;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync-daemon}"
SRC_URI[aarch64_rsync-daemon.sha256sum] = "c70129ad90ad8d013703e86fbb1e19e4c709c64b0c8bc33ce8e2581eb41aa7fb"

URI_aarch64_rsync-rrsync = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rsync-rrsync-3.4.1-2.el10.noarch.rpm;name=aarch64_rsync-rrsync;unpack=0"
SRC_URI:append = " ${URI_aarch64_rsync-rrsync}"
SRC_URI[aarch64_rsync-rrsync.sha256sum] = "57e8d6fb49d61a6ad78a96628799532df853557c7b3d049d906fe09ce97c3665"

RDEPENDS:rsync = " \
 bash \
 glibc \
 libacl \
 libzstd \
 lz4-libs \
 openssl-libs \
 popt \
 "
RDEPENDS:rsync-daemon = " \
 bash \
 rsync \
 systemd \
 "
RDEPENDS:rsync-rrsync = " \
 python3 \
 rsync \
 "
