# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gridftp-server-control"
PV = "9.3"
PR = "8.el10_0"
PACKAGES = " \
 globus-gridftp-server-control \
 globus-gridftp-server-control-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/globus-gridftp-server-control-9.3-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "ac8cd97ef0c7ed0b611399d93c1080273c6f8a45976109d1018508d660a735b4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-control-9.3-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-control;unpack=0"
SRC_URI[x86_64_v2_globus-gridftp-server-control.sha256sum] = "af8b775c74766eb59c1013ea202071c7378e29c28beec0498fa40d8d233dfef5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-control-devel-9.3-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-control-devel;unpack=0"
SRC_URI[x86_64_v2_globus-gridftp-server-control-devel.sha256sum] = "a880a0aef4e729da43af03d3c7518178df2f8a5a57360b4a3f7391a727f6d51a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-control-9.3-8.el10_0.aarch64.rpm;name=aarch64_globus-gridftp-server-control;unpack=0"
SRC_URI[aarch64_globus-gridftp-server-control.sha256sum] = "50c719767f1839a802c9350629da1d794d18a84430737b1422021211d0d22a4b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-control-devel-9.3-8.el10_0.aarch64.rpm;name=aarch64_globus-gridftp-server-control-devel;unpack=0"
SRC_URI[aarch64_globus-gridftp-server-control-devel.sha256sum] = "430a2a045349c351c4f2078227179f30680d46f2d39e3497e4e2ad69871c57e8"

RDEPENDS:globus-gridftp-server-control = " \
 glibc \
 globus-common \
 globus-gsi-openssl-error \
 globus-gss-assist \
 globus-gssapi-error \
 globus-gssapi-gsi \
 globus-xio \
 globus-xio-gsi-driver \
 globus-xio-pipe-driver \
 "
RDEPENDS:globus-gridftp-server-control-devel = " \
 globus-common-devel \
 globus-gridftp-server-control \
 globus-gsi-openssl-error-devel \
 globus-gss-assist-devel \
 globus-gssapi-error-devel \
 globus-gssapi-gsi-devel \
 globus-xio-devel \
 globus-xio-gsi-driver-devel \
 globus-xio-pipe-driver-devel \
 pkgconf-pkg-config \
 "
