# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-filepattern"
PV = "0.1.3"
PR = "7.el10_0"
PACKAGES = " \
 ghc-filepattern \
 ghc-filepattern-devel \
 ghc-filepattern-doc \
 ghc-filepattern-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-filepattern-0.1.3-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7f934a2578571c0cd1fb019b419cc99cfbcc9cfeaaffecec6de1439dbdd4c1b8"

URI_x86_64_v2_ghc-filepattern = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepattern-0.1.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filepattern;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepattern}"
SRC_URI[x86_64_v2_ghc-filepattern.sha256sum] = "364a3420521a6a5cc998622a16bdf63cd994662f5dc76155c33c31530f2d2a6f"

URI_x86_64_v2_ghc-filepattern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepattern-devel-0.1.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filepattern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepattern-devel}"
SRC_URI[x86_64_v2_ghc-filepattern-devel.sha256sum] = "1e9c9ef19d74f646f506efb015fb96d177b57bcfa9ebd82d7c07b7e4d0dbb258"

URI_x86_64_v2_ghc-filepattern-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepattern-doc-0.1.3-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-filepattern-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepattern-doc}"
SRC_URI[x86_64_v2_ghc-filepattern-doc.sha256sum] = "4bc6fc7d3ae00f7ec4c7a70c7a2a9d46f0b804627f8a599069acee1ba7d04b95"

URI_x86_64_v2_ghc-filepattern-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-filepattern-prof-0.1.3-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-filepattern-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-filepattern-prof}"
SRC_URI[x86_64_v2_ghc-filepattern-prof.sha256sum] = "b440fd109de9562e29569e8e8d764c426fd05d65b47cc9905e4e6b8bfcf48ae7"

URI_aarch64_ghc-filepattern = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepattern-0.1.3-7.el10_0.aarch64.rpm;name=aarch64_ghc-filepattern;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepattern}"
SRC_URI[aarch64_ghc-filepattern.sha256sum] = "ce629a472d6fe67352b96af8b63b0be71eac1658a077f49cc8ba5bd179b63122"

URI_aarch64_ghc-filepattern-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepattern-devel-0.1.3-7.el10_0.aarch64.rpm;name=aarch64_ghc-filepattern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepattern-devel}"
SRC_URI[aarch64_ghc-filepattern-devel.sha256sum] = "374319d4cc168cbbb5ef998753344c45fb06db071b81eca686377a8efe72e463"

URI_aarch64_ghc-filepattern-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepattern-doc-0.1.3-7.el10_0.noarch.rpm;name=aarch64_ghc-filepattern-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepattern-doc}"
SRC_URI[aarch64_ghc-filepattern-doc.sha256sum] = "43d408077210b552338fef1e100c818130cd82cf0de9b9333e6e6215d74df590"

URI_aarch64_ghc-filepattern-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-filepattern-prof-0.1.3-7.el10_0.aarch64.rpm;name=aarch64_ghc-filepattern-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-filepattern-prof}"
SRC_URI[aarch64_ghc-filepattern-prof.sha256sum] = "d829ca82f749b6206a640f241cf5df8c4a0d16177a879b20e19bdf163e79e148"

RDEPENDS:ghc-filepattern = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-clock \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-extra \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-process \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-filepattern-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-directory-devel \
 ghc-extra-devel \
 ghc-filepath-devel \
 ghc-filepattern \
 "
RDEPENDS:ghc-filepattern-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-filepattern-prof = " \
 ghc-base-prof \
 ghc-directory-prof \
 ghc-extra-prof \
 ghc-filepath-prof \
 ghc-filepattern-devel \
 "
