# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-html-escape"
PV = "0.2.14"
PR = "1.el10_3"
PACKAGES = " \
 rust-html-escape+default-devel \
 rust-html-escape+std-devel \
 rust-html-escape-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-html-escape-0.2.14-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e54c6073e00965bd987ab47e4b7a4e6fb733c81425e4cd4f02c4cec5891fd353"

URI_x86_64_v2_rust-html-escape+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html-escape+default-devel-0.2.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html-escape+default-devel}"
SRC_URI[x86_64_v2_rust-html-escape+default-devel.sha256sum] = "5ae2e7f78e90651041299a4f421e6e049cd006f3237230482dff98ab4dae1757"

URI_x86_64_v2_rust-html-escape+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html-escape+std-devel-0.2.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html-escape+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html-escape+std-devel}"
SRC_URI[x86_64_v2_rust-html-escape+std-devel.sha256sum] = "cd979f1b4f3fb3bde5f060cf8045cc5bb4929d03acbe069c255417199cf09226"

URI_x86_64_v2_rust-html-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-html-escape-devel-0.2.14-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-html-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-html-escape-devel}"
SRC_URI[x86_64_v2_rust-html-escape-devel.sha256sum] = "2a04646dcf1605a1043d7c174d0412f45bb43c1e9d4d40ab50e9bbfdaa26466d"

URI_aarch64_rust-html-escape+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html-escape+default-devel-0.2.14-1.el10_3.noarch.rpm;name=aarch64_rust-html-escape+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html-escape+default-devel}"
SRC_URI[aarch64_rust-html-escape+default-devel.sha256sum] = "f128cb50445817f163887a69fc22f5179af06011c6b26238010fc60237de433e"

URI_aarch64_rust-html-escape+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html-escape+std-devel-0.2.14-1.el10_3.noarch.rpm;name=aarch64_rust-html-escape+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html-escape+std-devel}"
SRC_URI[aarch64_rust-html-escape+std-devel.sha256sum] = "028fc27f25b64c8ddfac5184c9084febed98ae712ea66d2759c96b943eb19dcf"

URI_aarch64_rust-html-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-html-escape-devel-0.2.14-1.el10_3.noarch.rpm;name=aarch64_rust-html-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-html-escape-devel}"
SRC_URI[aarch64_rust-html-escape-devel.sha256sum] = "f50d83e519be03a4cddaf3b2ba1470ceb0cb1f650f053e5d22e87678512b8e83"

RDEPENDS:rust-html-escape+default-devel = " \
 cargo \
 rust-html-escape+std-devel \
 rust-html-escape-devel \
 "
RDEPENDS:rust-html-escape+std-devel = " \
 cargo \
 rust-html-escape-devel \
 "
RDEPENDS:rust-html-escape-devel = " \
 cargo \
 rust \
 "
