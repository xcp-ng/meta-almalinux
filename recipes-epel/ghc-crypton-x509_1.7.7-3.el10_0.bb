# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-crypton-x509"
PV = "1.7.7"
PR = "3.el10_0"
PACKAGES = " \
 ghc-crypton-x509 \
 ghc-crypton-x509-devel \
 ghc-crypton-x509-doc \
 ghc-crypton-x509-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-crypton-x509-1.7.7-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f1bc8bd973f38f2174f798056b44944c8344981cdce774c4158fe070ed12cb8"

URI_x86_64_v2_ghc-crypton-x509 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-1.7.7-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-x509;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509}"
SRC_URI[x86_64_v2_ghc-crypton-x509.sha256sum] = "22f1fcee69fa01aa993703ef1edf6bf13c768896962e0905907d4799a8eb1427"

URI_x86_64_v2_ghc-crypton-x509-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-devel-1.7.7-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-x509-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-devel}"
SRC_URI[x86_64_v2_ghc-crypton-x509-devel.sha256sum] = "69dfbf33a589b1bb6105f687d18ca7ddb0775f37347f4b1ae8826b6593167019"

URI_x86_64_v2_ghc-crypton-x509-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-doc-1.7.7-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-crypton-x509-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-doc}"
SRC_URI[x86_64_v2_ghc-crypton-x509-doc.sha256sum] = "f0731268ceeb19fd3f451bf2c02228b3f2a5c145917c41ae4dbe4d202c3f1995"

URI_x86_64_v2_ghc-crypton-x509-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-crypton-x509-prof-1.7.7-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-crypton-x509-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-crypton-x509-prof}"
SRC_URI[x86_64_v2_ghc-crypton-x509-prof.sha256sum] = "709e8c5df77fd71509ad52fecaa4fcd574fd9fc25d9503c530be22d04142fc76"

URI_aarch64_ghc-crypton-x509 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-1.7.7-3.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-x509;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509}"
SRC_URI[aarch64_ghc-crypton-x509.sha256sum] = "86b00c3a4ce9eacd3954f2c2972484f14d0c902bcee803758ea1ea90df1c9a34"

URI_aarch64_ghc-crypton-x509-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-devel-1.7.7-3.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-x509-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-devel}"
SRC_URI[aarch64_ghc-crypton-x509-devel.sha256sum] = "9ef15a17c1d01c95043a2f664175dc3ebf8eb3dedc02e98a3b94311dad0ae499"

URI_aarch64_ghc-crypton-x509-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-doc-1.7.7-3.el10_0.noarch.rpm;name=aarch64_ghc-crypton-x509-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-doc}"
SRC_URI[aarch64_ghc-crypton-x509-doc.sha256sum] = "4005b2c9cfbdd0e0f53357dddb105f6ae4395c313b476abaf901daaca2360d77"

URI_aarch64_ghc-crypton-x509-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-crypton-x509-prof-1.7.7-3.el10_0.aarch64.rpm;name=aarch64_ghc-crypton-x509-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-crypton-x509-prof}"
SRC_URI[aarch64_ghc-crypton-x509-prof.sha256sum] = "f880161d14a0590d0be6a378f3b2daf24af466f37a1c3c8b34e84d21c7b43719"

RDEPENDS:ghc-crypton-x509 = " \
 ghc-array \
 ghc-asn1-encoding \
 ghc-asn1-parse \
 ghc-asn1-types \
 ghc-base \
 ghc-basement \
 ghc-bytestring \
 ghc-containers \
 ghc-crypton \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hourglass \
 ghc-memory \
 ghc-pem \
 ghc-pretty \
 ghc-template-haskell \
 ghc-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc-crypton-x509-devel = " \
 ghc-asn1-encoding-devel \
 ghc-asn1-parse-devel \
 ghc-asn1-types-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-crypton-devel \
 ghc-crypton-x509 \
 ghc-hourglass-devel \
 ghc-memory-devel \
 ghc-pem-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-crypton-x509-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-crypton-x509-prof = " \
 ghc-asn1-encoding-prof \
 ghc-asn1-parse-prof \
 ghc-asn1-types-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-containers-prof \
 ghc-crypton-prof \
 ghc-crypton-x509-devel \
 ghc-hourglass-prof \
 ghc-memory-prof \
 ghc-pem-prof \
 ghc-transformers-prof \
 "
