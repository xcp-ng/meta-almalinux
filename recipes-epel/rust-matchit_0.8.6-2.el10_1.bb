# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-matchit"
PV = "0.8.6"
PR = "2.el10_1"
PACKAGES = " \
 rust-matchit+default-devel \
 rust-matchit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-matchit-0.8.6-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03c2321c5ef8b48c01755c18ab03286e80283caebc9fe532e7b7f937ce0c39d8"

URI_x86_64_v2_rust-matchit+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit+default-devel-0.8.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit+default-devel}"
SRC_URI[x86_64_v2_rust-matchit+default-devel.sha256sum] = "76095eba10aecafd6199f068bab25a57f9fa6aa3dbaaabe8ce16327d22427737"

URI_x86_64_v2_rust-matchit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-matchit-devel-0.8.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-matchit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-matchit-devel}"
SRC_URI[x86_64_v2_rust-matchit-devel.sha256sum] = "21b1a7eddd66c409ddac6d40e14badb3bc5d80086f6d1365feda8803b2e79a40"

URI_aarch64_rust-matchit+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit+default-devel-0.8.6-2.el10_1.noarch.rpm;name=aarch64_rust-matchit+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit+default-devel}"
SRC_URI[aarch64_rust-matchit+default-devel.sha256sum] = "b380122f20d50d8dd8c99e42b3ee216887a2a6dcb2b41b3cb61937f38338c1e5"

URI_aarch64_rust-matchit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-matchit-devel-0.8.6-2.el10_1.noarch.rpm;name=aarch64_rust-matchit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-matchit-devel}"
SRC_URI[aarch64_rust-matchit-devel.sha256sum] = "2a7875a6a7098f5ff28b479d8bf5063e863d8e09647346f6b052a27b0d5ba978"

RDEPENDS:rust-matchit+default-devel = " \
 cargo \
 rust-matchit-devel \
 "
RDEPENDS:rust-matchit-devel = " \
 cargo \
 "
