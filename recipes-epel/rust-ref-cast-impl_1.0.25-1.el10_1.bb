# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ref-cast-impl"
PV = "1.0.25"
PR = "1.el10_1"
PACKAGES = " \
 rust-ref-cast-impl+default-devel \
 rust-ref-cast-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ref-cast-impl-1.0.25-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9a81eecdc2625b060456d3f2643855573fdae72410cde136f3a750c66198aebe"

URI_x86_64_v2_rust-ref-cast-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-impl+default-devel-1.0.25-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast-impl+default-devel}"
SRC_URI[x86_64_v2_rust-ref-cast-impl+default-devel.sha256sum] = "a9f8fa60a2192c3dcb99405cc863cb58817d67282b2901472fee182cb271735f"

URI_x86_64_v2_rust-ref-cast-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-impl-devel-1.0.25-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast-impl-devel}"
SRC_URI[x86_64_v2_rust-ref-cast-impl-devel.sha256sum] = "db359a4c0b65ad99ecdbe670010f33b825863315ecbc3347e9458a2b2fbdbc47"

URI_aarch64_rust-ref-cast-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-impl+default-devel-1.0.25-1.el10_1.noarch.rpm;name=aarch64_rust-ref-cast-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast-impl+default-devel}"
SRC_URI[aarch64_rust-ref-cast-impl+default-devel.sha256sum] = "780aa0c86521663ead8c886b4f6a5159c00343b50391615578fae1bb41d6cf3e"

URI_aarch64_rust-ref-cast-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-impl-devel-1.0.25-1.el10_1.noarch.rpm;name=aarch64_rust-ref-cast-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast-impl-devel}"
SRC_URI[aarch64_rust-ref-cast-impl-devel.sha256sum] = "378d7073a9f249c448458c6db497b66be88a280b7580067f74ffc00c75845c6c"

RDEPENDS:rust-ref-cast-impl+default-devel = " \
 cargo \
 rust-ref-cast-impl-devel \
 "
RDEPENDS:rust-ref-cast-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
