# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rkyv0.7"
PV = "0.7.46"
PR = "1.el10_2"
PACKAGES = " \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7+arbitrary_enum_discriminant-devel \
 rust-rkyv0.7+archive_be-devel \
 rust-rkyv0.7+archive_le-devel \
 rust-rkyv0.7+arrayvec-devel \
 rust-rkyv0.7+bytecheck-devel \
 rust-rkyv0.7+copy-devel \
 rust-rkyv0.7+copy_unsafe-devel \
 rust-rkyv0.7+default-devel \
 rust-rkyv0.7+hashbrown-devel \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7+size_16-devel \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+size_64-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7+strict-devel \
 rust-rkyv0.7+validation-devel \
 rust-rkyv0.7-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rkyv0.7-0.7.46-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4a34b691f60c6665f56fa663cbf34a274f176c53fbf0db1f30a42f5f61c466df"

URI_x86_64_v2_rust-rkyv0.7+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+alloc-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+alloc-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+alloc-devel.sha256sum] = "f4e7800b5d15efd47fdea7ddf7dd3d2e965727ab5899acbde0db983b4cdcc71a"

URI_x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+arbitrary_enum_discriminant-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+arbitrary_enum_discriminant-devel.sha256sum] = "626e7a315c3b08b6417665d99258d0d9dc1c86cf90f5d9577344f4ec8ff033c2"

URI_x86_64_v2_rust-rkyv0.7+archive_be-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+archive_be-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+archive_be-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+archive_be-devel.sha256sum] = "363c7b086985a6a6c5f2e7953220cb800110db01e1c719ad406fc4d7ddf91c04"

URI_x86_64_v2_rust-rkyv0.7+archive_le-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+archive_le-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+archive_le-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+archive_le-devel.sha256sum] = "625ad45b1c48cd912a582422f04f44abb4d46093b010c93ae414244e2109d57a"

URI_x86_64_v2_rust-rkyv0.7+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+arrayvec-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+arrayvec-devel.sha256sum] = "6d2cd5fb71084b3dad40b75b0380dcadf9de9b88d62d68cd34072bb89160f449"

URI_x86_64_v2_rust-rkyv0.7+bytecheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+bytecheck-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+bytecheck-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+bytecheck-devel.sha256sum] = "2bab55b9d881cc17d6ca05afc58b840ae136cd1b4d5c19de74f22664bd5d078c"

URI_x86_64_v2_rust-rkyv0.7+copy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+copy-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+copy-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+copy-devel.sha256sum] = "5c534cb0a00fee7758d49a4b1b98a7b14d2b6f39ed03cc0f0a29c4fa4f13cfb3"

URI_x86_64_v2_rust-rkyv0.7+copy_unsafe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+copy_unsafe-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+copy_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+copy_unsafe-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+copy_unsafe-devel.sha256sum] = "cc6433d1bfad15d6989af8e4cee3516ddbf548937b3ff8498a48e41dfa5eae60"

URI_x86_64_v2_rust-rkyv0.7+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+default-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+default-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+default-devel.sha256sum] = "d4d18ef4f48e335ef959815d0afd0505761c8a7c5517a725637c10d506a7d5f9"

URI_x86_64_v2_rust-rkyv0.7+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+hashbrown-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+hashbrown-devel.sha256sum] = "3dc5dea9e7c989123c387aa3a0740e0e87d0770c8e88ac475e1920e275e06d08"

URI_x86_64_v2_rust-rkyv0.7+rend-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+rend-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+rend-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+rend-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+rend-devel.sha256sum] = "6b6fc385c97c39c6f1dbf32ce53cf3d5ad0174b97ffaf14c904b1b6c665aca9e"

URI_x86_64_v2_rust-rkyv0.7+size_16-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+size_16-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+size_16-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+size_16-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+size_16-devel.sha256sum] = "282b980ae08c9f8abed0c052fcb80dcaa7e52ee0619d3ef4dcc9f6b45217f5f0"

URI_x86_64_v2_rust-rkyv0.7+size_32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+size_32-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+size_32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+size_32-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+size_32-devel.sha256sum] = "45e79d4fa34b85eaa293a00cfb8a41877ef229d1f827064d4d23f69f9bed318a"

URI_x86_64_v2_rust-rkyv0.7+size_64-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+size_64-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+size_64-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+size_64-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+size_64-devel.sha256sum] = "75af88e07d673ddd81c81830b254b3e6fd4a7213fe275d2fae7a686d01fcfbf1"

URI_x86_64_v2_rust-rkyv0.7+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+std-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+std-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+std-devel.sha256sum] = "721d85c62ad593c9aef74e28903cc55ecf96fd72fe0fe0bc8b3c9b03a99f5848"

URI_x86_64_v2_rust-rkyv0.7+strict-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+strict-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+strict-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+strict-devel.sha256sum] = "2bb190d3d67e2772773c360b7d1e2c7ed7372e4b528e4ea13cf9de50634319ae"

URI_x86_64_v2_rust-rkyv0.7+validation-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7+validation-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7+validation-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7+validation-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7+validation-devel.sha256sum] = "73338bd73823561995fa07f71f441a3dd58f6e312b81f5a0bd63eeb05586b098"

URI_x86_64_v2_rust-rkyv0.7-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rkyv0.7-devel-0.7.46-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rkyv0.7-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rkyv0.7-devel}"
SRC_URI[x86_64_v2_rust-rkyv0.7-devel.sha256sum] = "ddbe72ee7732a91b366953388729d0a3ad7a6184c04fbc5706a1c77f3dd40a4b"

URI_aarch64_rust-rkyv0.7+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+alloc-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+alloc-devel}"
SRC_URI[aarch64_rust-rkyv0.7+alloc-devel.sha256sum] = "a181cf4bdc31087f23bb467d8e6f6b0022160933582a002f804367d988daa82c"

URI_aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+arbitrary_enum_discriminant-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel}"
SRC_URI[aarch64_rust-rkyv0.7+arbitrary_enum_discriminant-devel.sha256sum] = "b3420c6fc5a198c0c113c259c985353f41b00c08eb6bf9c1e47eb78584287d05"

URI_aarch64_rust-rkyv0.7+archive_be-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+archive_be-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+archive_be-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+archive_be-devel}"
SRC_URI[aarch64_rust-rkyv0.7+archive_be-devel.sha256sum] = "be6b51c6e698cf92a1357a3f320bb786e37f52e658fe7be7d768abb8e5c0d7c5"

URI_aarch64_rust-rkyv0.7+archive_le-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+archive_le-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+archive_le-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+archive_le-devel}"
SRC_URI[aarch64_rust-rkyv0.7+archive_le-devel.sha256sum] = "2ce4fe140aa9cc0fc66f93c7a4468cebf150ba96fc7216b80eda3867e52e24e2"

URI_aarch64_rust-rkyv0.7+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+arrayvec-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+arrayvec-devel}"
SRC_URI[aarch64_rust-rkyv0.7+arrayvec-devel.sha256sum] = "5bae68a5eeeaccb01aabe71220e2395d5a282b44c117e0e5818ea9deed9aeb91"

URI_aarch64_rust-rkyv0.7+bytecheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+bytecheck-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+bytecheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+bytecheck-devel}"
SRC_URI[aarch64_rust-rkyv0.7+bytecheck-devel.sha256sum] = "ce6d4fa204cb4a48b31f0f31a114551d1e36d3b4f51d1e3f84d6fd8154ea7426"

URI_aarch64_rust-rkyv0.7+copy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+copy-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+copy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+copy-devel}"
SRC_URI[aarch64_rust-rkyv0.7+copy-devel.sha256sum] = "f7b6ff773549079cfbd0870b78cdea427d15f448f6dd123e84db7887e2ce0440"

URI_aarch64_rust-rkyv0.7+copy_unsafe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+copy_unsafe-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+copy_unsafe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+copy_unsafe-devel}"
SRC_URI[aarch64_rust-rkyv0.7+copy_unsafe-devel.sha256sum] = "3f4c6b3f94055648a183605bfc60668c0ceb75887e730f781e37283c3fc91cb6"

URI_aarch64_rust-rkyv0.7+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+default-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+default-devel}"
SRC_URI[aarch64_rust-rkyv0.7+default-devel.sha256sum] = "798b606e8049df73afc57e11ad17f608cd163a5a1329ccd588fdd127012d609b"

URI_aarch64_rust-rkyv0.7+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+hashbrown-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+hashbrown-devel}"
SRC_URI[aarch64_rust-rkyv0.7+hashbrown-devel.sha256sum] = "735d4f722205c0ba0f8554a266dbc1b872e01a730927f33d43d79113ed543e27"

URI_aarch64_rust-rkyv0.7+rend-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+rend-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+rend-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+rend-devel}"
SRC_URI[aarch64_rust-rkyv0.7+rend-devel.sha256sum] = "11300af951c8d8592da6c10891f92ba8666112a8da592a8e678278c6485cbcc2"

URI_aarch64_rust-rkyv0.7+size_16-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+size_16-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+size_16-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+size_16-devel}"
SRC_URI[aarch64_rust-rkyv0.7+size_16-devel.sha256sum] = "3f7bba51a0b68429edea13acf01c26501b16fe8b007a884fd2aed1a6d14de5d2"

URI_aarch64_rust-rkyv0.7+size_32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+size_32-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+size_32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+size_32-devel}"
SRC_URI[aarch64_rust-rkyv0.7+size_32-devel.sha256sum] = "39702a38e4a0fd2bf8b3c14a2c2a030c50404be2e25d322e7e9b68a2f00f21ac"

URI_aarch64_rust-rkyv0.7+size_64-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+size_64-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+size_64-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+size_64-devel}"
SRC_URI[aarch64_rust-rkyv0.7+size_64-devel.sha256sum] = "27b6347ceec19ba83caf5b031d847461317142bd6fd06e77760085211dfbc570"

URI_aarch64_rust-rkyv0.7+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+std-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+std-devel}"
SRC_URI[aarch64_rust-rkyv0.7+std-devel.sha256sum] = "5b23483dc11064254880156df3cf08184f177a13acc8e678c5204777076236c1"

URI_aarch64_rust-rkyv0.7+strict-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+strict-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+strict-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+strict-devel}"
SRC_URI[aarch64_rust-rkyv0.7+strict-devel.sha256sum] = "e86ddc722dcb96419be909ceba6d09aa73de28306a4189d0b737ea6daaba50e5"

URI_aarch64_rust-rkyv0.7+validation-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7+validation-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7+validation-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7+validation-devel}"
SRC_URI[aarch64_rust-rkyv0.7+validation-devel.sha256sum] = "e6f167fe4b0cca39b0c24b5bca99f8da9a7b6dce9353391c8937a7367a28fabe"

URI_aarch64_rust-rkyv0.7-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rkyv0.7-devel-0.7.46-1.el10_2.noarch.rpm;name=aarch64_rust-rkyv0.7-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rkyv0.7-devel}"
SRC_URI[aarch64_rust-rkyv0.7-devel.sha256sum] = "c06fdf6c2ed9486af451738095a2df936e62f669b3545b23d22306f7dbcadcfa"

RDEPENDS:rust-rkyv0.7+alloc-devel = " \
 cargo \
 rust-rkyv0.7+hashbrown-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+arbitrary_enum_discriminant-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+arbitrary_enum_discriminant-devel \
 "
RDEPENDS:rust-rkyv0.7+archive_be-devel = " \
 cargo \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+archive_be-devel \
 "
RDEPENDS:rust-rkyv0.7+archive_le-devel = " \
 cargo \
 rust-rkyv0.7+rend-devel \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+archive_le-devel \
 "
RDEPENDS:rust-rkyv0.7+arrayvec-devel = " \
 cargo \
 rust-arrayvec-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+bytecheck-devel = " \
 cargo \
 rust-bytecheck0.6-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+copy-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+copy-devel \
 "
RDEPENDS:rust-rkyv0.7+copy_unsafe-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+default-devel = " \
 cargo \
 rust-rkyv0.7+size_32-devel \
 rust-rkyv0.7+std-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.14+default-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+rend-devel = " \
 cargo \
 rust-rend0.4-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+size_16-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+size_32-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+size_64-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+std-devel = " \
 cargo \
 rust-bytecheck0.6+std-devel \
 rust-bytecheck0.6-devel \
 rust-ptr_meta0.1+std-devel \
 rust-rend0.4+std-devel \
 rust-rend0.4-devel \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7+strict-devel = " \
 cargo \
 rust-rkyv0.7-devel \
 rust-rkyv_derive0.7+strict-devel \
 "
RDEPENDS:rust-rkyv0.7+validation-devel = " \
 cargo \
 rust-rend0.4+validation-devel \
 rust-rend0.4-devel \
 rust-rkyv0.7+alloc-devel \
 rust-rkyv0.7+bytecheck-devel \
 rust-rkyv0.7-devel \
 "
RDEPENDS:rust-rkyv0.7-devel = " \
 cargo \
 rust-ptr_meta0.1-devel \
 rust-rkyv_derive0.7+default-devel \
 rust-seahash+default-devel \
 "
