# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zune-inflate"
PV = "0.2.54"
PR = "2.el10_0"
PACKAGES = " \
 rust-zune-inflate+default-devel \
 rust-zune-inflate+gzip-devel \
 rust-zune-inflate+simd-adler32-devel \
 rust-zune-inflate+std-devel \
 rust-zune-inflate+zlib-devel \
 rust-zune-inflate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zune-inflate-0.2.54-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0c07b40865a093ac5f99cb73ea0a722b626c85681ebc82456d99864ad146667"

URI_x86_64_v2_rust-zune-inflate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-inflate+default-devel-0.2.54-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-inflate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-inflate+default-devel}"
SRC_URI[x86_64_v2_rust-zune-inflate+default-devel.sha256sum] = "9316483b95a46d615ab759a9337e9b35c08ba62fce538b8253e8ccb58549a602"

URI_x86_64_v2_rust-zune-inflate+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-inflate+gzip-devel-0.2.54-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-inflate+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-inflate+gzip-devel}"
SRC_URI[x86_64_v2_rust-zune-inflate+gzip-devel.sha256sum] = "e452bf29596f70c611ac67da29ff04122428285c051067bb501af14d73fd8a0d"

URI_x86_64_v2_rust-zune-inflate+simd-adler32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-inflate+simd-adler32-devel-0.2.54-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-inflate+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-inflate+simd-adler32-devel}"
SRC_URI[x86_64_v2_rust-zune-inflate+simd-adler32-devel.sha256sum] = "164b863ad8d1d4b10dc34b8c921bc7a8a8f58d40a6efa45c6ab77366a32daeaa"

URI_x86_64_v2_rust-zune-inflate+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-inflate+std-devel-0.2.54-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-inflate+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-inflate+std-devel}"
SRC_URI[x86_64_v2_rust-zune-inflate+std-devel.sha256sum] = "487b46865cb0e42eabe076de29a5abae589d4716f4b597fb4abdd79f3243d8ce"

URI_x86_64_v2_rust-zune-inflate+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-inflate+zlib-devel-0.2.54-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-inflate+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-inflate+zlib-devel}"
SRC_URI[x86_64_v2_rust-zune-inflate+zlib-devel.sha256sum] = "8ccdb4139c7298be694a85695d3672053b958604c559831cc0fb58678723708e"

URI_x86_64_v2_rust-zune-inflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zune-inflate-devel-0.2.54-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zune-inflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zune-inflate-devel}"
SRC_URI[x86_64_v2_rust-zune-inflate-devel.sha256sum] = "cdd59224c293ab15fba49aef374d93f1328f1b658d6c4ea93c1ca541a6eb3609"

URI_aarch64_rust-zune-inflate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-inflate+default-devel-0.2.54-2.el10_0.noarch.rpm;name=aarch64_rust-zune-inflate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-inflate+default-devel}"
SRC_URI[aarch64_rust-zune-inflate+default-devel.sha256sum] = "2d51abeb5b6fa5664925c08763e6072061148ce378729c6eab430df340088dca"

URI_aarch64_rust-zune-inflate+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-inflate+gzip-devel-0.2.54-2.el10_0.noarch.rpm;name=aarch64_rust-zune-inflate+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-inflate+gzip-devel}"
SRC_URI[aarch64_rust-zune-inflate+gzip-devel.sha256sum] = "518786be83c85c404aebac23f68ac119eb68e4b8162d3e3d21ae321e3f41d42b"

URI_aarch64_rust-zune-inflate+simd-adler32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-inflate+simd-adler32-devel-0.2.54-2.el10_0.noarch.rpm;name=aarch64_rust-zune-inflate+simd-adler32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-inflate+simd-adler32-devel}"
SRC_URI[aarch64_rust-zune-inflate+simd-adler32-devel.sha256sum] = "cbee6cbf17a18a6e143b78c7a21384cb2dda3ce46ddc4d4262167d009df9d49a"

URI_aarch64_rust-zune-inflate+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-inflate+std-devel-0.2.54-2.el10_0.noarch.rpm;name=aarch64_rust-zune-inflate+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-inflate+std-devel}"
SRC_URI[aarch64_rust-zune-inflate+std-devel.sha256sum] = "ef2a03e22c9a1b7efc83b3f1e240fdc57866726184a8a8ef19187c62610b4af3"

URI_aarch64_rust-zune-inflate+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-inflate+zlib-devel-0.2.54-2.el10_0.noarch.rpm;name=aarch64_rust-zune-inflate+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-inflate+zlib-devel}"
SRC_URI[aarch64_rust-zune-inflate+zlib-devel.sha256sum] = "751bb54cc40475cc786433994bfb3e61eb404772ed631e4898bb9c4a1d6b54f9"

URI_aarch64_rust-zune-inflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zune-inflate-devel-0.2.54-2.el10_0.noarch.rpm;name=aarch64_rust-zune-inflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zune-inflate-devel}"
SRC_URI[aarch64_rust-zune-inflate-devel.sha256sum] = "734c5a540100a4966eafd0bbdfe1e566dbddc277c4991dbe94c17bcef9914cea"

RDEPENDS:rust-zune-inflate+default-devel = " \
 cargo \
 rust-zune-inflate+gzip-devel \
 rust-zune-inflate+std-devel \
 rust-zune-inflate+zlib-devel \
 rust-zune-inflate-devel \
 "
RDEPENDS:rust-zune-inflate+gzip-devel = " \
 cargo \
 rust-zune-inflate-devel \
 "
RDEPENDS:rust-zune-inflate+simd-adler32-devel = " \
 cargo \
 rust-simd-adler32-devel \
 rust-zune-inflate-devel \
 "
RDEPENDS:rust-zune-inflate+std-devel = " \
 cargo \
 rust-simd-adler32+std-devel \
 rust-simd-adler32-devel \
 rust-zune-inflate-devel \
 "
RDEPENDS:rust-zune-inflate+zlib-devel = " \
 cargo \
 rust-zune-inflate+simd-adler32-devel \
 rust-zune-inflate-devel \
 "
RDEPENDS:rust-zune-inflate-devel = " \
 cargo \
 "
