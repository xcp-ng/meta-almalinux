# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "protobuf"
PV = "3.19.6"
PR = "15.el10_1"
PACKAGES = " \
 protobuf \
 protobuf-compiler \
 protobuf-devel \
 protobuf-lite \
 protobuf-lite-devel \
 python3-protobuf \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/protobuf-3.19.6-15.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7877059707ec34221163b79b2306febd02ac579f9a8c363ccd27f1e0926df9a0"

URI_x86_64_v2_protobuf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/protobuf-3.19.6-15.el10_1.x86_64_v2.rpm;name=x86_64_v2_protobuf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf}"
SRC_URI[x86_64_v2_protobuf.sha256sum] = "c835046b9266c2c2ad5e91d7f98386337de8ebfc07c8dc33a8cc8d737688fe58"

URI_x86_64_v2_protobuf-compiler = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/protobuf-compiler-3.19.6-15.el10_1.x86_64_v2.rpm;name=x86_64_v2_protobuf-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf-compiler}"
SRC_URI[x86_64_v2_protobuf-compiler.sha256sum] = "42d9f7195287d284329664522f136f3f7f4519d9456a76ca865f45197006432f"

URI_x86_64_v2_protobuf-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/protobuf-devel-3.19.6-15.el10_1.x86_64_v2.rpm;name=x86_64_v2_protobuf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf-devel}"
SRC_URI[x86_64_v2_protobuf-devel.sha256sum] = "8af71ef697124ad13b08a4e429255d192ee47f9002c5c3ab3f5abb91a9dca75c"

URI_x86_64_v2_protobuf-lite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/protobuf-lite-3.19.6-15.el10_1.x86_64_v2.rpm;name=x86_64_v2_protobuf-lite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf-lite}"
SRC_URI[x86_64_v2_protobuf-lite.sha256sum] = "e0462cfdd83b59cb10c3fa33714d00d068f38c06818f911f11ade986f9d1f580"

URI_x86_64_v2_protobuf-lite-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/protobuf-lite-devel-3.19.6-15.el10_1.x86_64_v2.rpm;name=x86_64_v2_protobuf-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_protobuf-lite-devel}"
SRC_URI[x86_64_v2_protobuf-lite-devel.sha256sum] = "a1c8e09147703eb93f7c571b9fbc10b5b90c3f89169422ec6ef46f4728a7cb1e"

URI_x86_64_v2_python3-protobuf = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-protobuf-3.19.6-15.el10_1.x86_64_v2.rpm;name=x86_64_v2_python3-protobuf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-protobuf}"
SRC_URI[x86_64_v2_python3-protobuf.sha256sum] = "35733245df065a974ab212e48d199f2ba2105df649d179f98b9e719e1815ca42"

URI_aarch64_protobuf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/protobuf-3.19.6-15.el10_1.aarch64.rpm;name=aarch64_protobuf;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf}"
SRC_URI[aarch64_protobuf.sha256sum] = "9a4b6f502ae4987e937ca5ab6734c347876c85ffeab60281aa0787ba680cd49d"

URI_aarch64_protobuf-compiler = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/protobuf-compiler-3.19.6-15.el10_1.aarch64.rpm;name=aarch64_protobuf-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf-compiler}"
SRC_URI[aarch64_protobuf-compiler.sha256sum] = "c39e61a05c3512c1b6a4d020e82a8e782e192df3ee4befc5ae389047f9a10d10"

URI_aarch64_protobuf-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/protobuf-devel-3.19.6-15.el10_1.aarch64.rpm;name=aarch64_protobuf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf-devel}"
SRC_URI[aarch64_protobuf-devel.sha256sum] = "ce0385d492c4adc946228fed6a95e8eaa88387d23a1ea6f85491657be3bb1552"

URI_aarch64_protobuf-lite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/protobuf-lite-3.19.6-15.el10_1.aarch64.rpm;name=aarch64_protobuf-lite;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf-lite}"
SRC_URI[aarch64_protobuf-lite.sha256sum] = "f0e30e5531bede8fe387d10a752ea8a8c7f0e65deebb7c30a27d2853e32c8cfe"

URI_aarch64_protobuf-lite-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/protobuf-lite-devel-3.19.6-15.el10_1.aarch64.rpm;name=aarch64_protobuf-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_protobuf-lite-devel}"
SRC_URI[aarch64_protobuf-lite-devel.sha256sum] = "436898af7df4d30a1c5264ed4fd5db86634b3bd639d33355d046f25a408dc922"

URI_aarch64_python3-protobuf = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-protobuf-3.19.6-15.el10_1.aarch64.rpm;name=aarch64_python3-protobuf;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-protobuf}"
SRC_URI[aarch64_python3-protobuf.sha256sum] = "4501d9892661503b617796d4d7054f215382a696959f6e55aaa18fca95f3f0f5"

RDEPENDS:protobuf = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:protobuf-compiler = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 zlib-ng-compat \
 "
RDEPENDS:protobuf-devel = " \
 pkgconf-pkg-config \
 protobuf \
 protobuf-compiler \
 zlib-ng-compat-devel \
 "
RDEPENDS:protobuf-lite = " \
 glibc \
 libgcc \
 libstdc++ \
 zlib-ng-compat \
 "
RDEPENDS:protobuf-lite-devel = " \
 pkgconf-pkg-config \
 protobuf-devel \
 protobuf-lite \
 "
RDEPENDS:python3-protobuf = " \
 glibc \
 libgcc \
 libstdc++ \
 protobuf \
 python3 \
 "
