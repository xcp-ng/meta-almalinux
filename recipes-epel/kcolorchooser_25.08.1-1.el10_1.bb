# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kcolorchooser"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kcolorchooser \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kcolorchooser-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae58315492e5d266d604267ae878af824193992dfe3899cc7e7e584ee8f64842"

URI_x86_64_v2_kcolorchooser = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kcolorchooser-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kcolorchooser;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kcolorchooser}"
SRC_URI[x86_64_v2_kcolorchooser.sha256sum] = "006dea89345dd1e67c05c537c7a87db80eef40cd2bf2b73e371d88054d2364a0"

URI_aarch64_kcolorchooser = "${EPEL_MIRROR}/aarch64/Packages/k/kcolorchooser-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kcolorchooser;unpack=0"
SRC_URI:append = " ${URI_aarch64_kcolorchooser}"
SRC_URI[aarch64_kcolorchooser.sha256sum] = "90255e77fe4d38bae5597d603ea35102317c53e1dc5b064befa019b4f8cb2686"

RDEPENDS:kcolorchooser = " \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
