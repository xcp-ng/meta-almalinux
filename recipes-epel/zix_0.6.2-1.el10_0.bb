# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zix"
PV = "0.6.2"
PR = "1.el10_0"
PACKAGES = " \
 zix \
 zix-devel \
 zix-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zix-0.6.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04bbec42c7c3bf10f25ce4aaef9d0c95b65aee0c7447c6b2479672378c6a5c98"

URI_x86_64_v2_zix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zix-0.6.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zix}"
SRC_URI[x86_64_v2_zix.sha256sum] = "7de1e445f351b514b5e64be60639c0b610344063ae17a396cdb243e5010c6170"

URI_x86_64_v2_zix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zix-devel-0.6.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zix-devel}"
SRC_URI[x86_64_v2_zix-devel.sha256sum] = "d487845abfb3e96020ce33160eeb42320b7aa8c121c4b883527e542894ec996f"

URI_x86_64_v2_zix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zix-doc-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_zix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zix-doc}"
SRC_URI[x86_64_v2_zix-doc.sha256sum] = "8a252204ad5d329f794cf34a573c2b5bf9f19172df86b12cb21d40d525f952a8"

URI_aarch64_zix = "${EPEL_MIRROR}/aarch64/Packages/z/zix-0.6.2-1.el10_0.aarch64.rpm;name=aarch64_zix;unpack=0"
SRC_URI:append = " ${URI_aarch64_zix}"
SRC_URI[aarch64_zix.sha256sum] = "e9d073668d2f9e0cb3e5e97b7ed849582c0f5ce6222a145ea5f8697b5774fce7"

URI_aarch64_zix-devel = "${EPEL_MIRROR}/aarch64/Packages/z/zix-devel-0.6.2-1.el10_0.aarch64.rpm;name=aarch64_zix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_zix-devel}"
SRC_URI[aarch64_zix-devel.sha256sum] = "69ef934f0e19b2f4a0421cbc2e073b644a091b9f7f386518caeff7f7e54bbedd"

URI_aarch64_zix-doc = "${EPEL_MIRROR}/aarch64/Packages/z/zix-doc-0.6.2-1.el10_0.noarch.rpm;name=aarch64_zix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_zix-doc}"
SRC_URI[aarch64_zix-doc.sha256sum] = "45dd77fb6a1d9310c9794c0a98d2ce5f822ded3dbf0dfb7e6688b7cb9b308b22"

RDEPENDS:zix = " \
 glibc \
 "
RDEPENDS:zix-devel = " \
 pkgconf-pkg-config \
 zix \
 "
RDEPENDS:zix-doc = " \
 "
