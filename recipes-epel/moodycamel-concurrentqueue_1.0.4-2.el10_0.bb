# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "moodycamel-concurrentqueue"
PV = "1.0.4"
PR = "2.el10_0"
PACKAGES = " \
 moodycamel-concurrentqueue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/moodycamel-concurrentqueue-1.0.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b443bcd00305323b4672a1445f24e74e2da25c28a4e4f4d4dee1a67486f8c6cb"

URI_x86_64_v2_moodycamel-concurrentqueue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/moodycamel-concurrentqueue-devel-1.0.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_moodycamel-concurrentqueue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_moodycamel-concurrentqueue-devel}"
SRC_URI[x86_64_v2_moodycamel-concurrentqueue-devel.sha256sum] = "6769edce75702d4e9ab2887723f69ec49bf4987eb4b9edfe8bfee5c19c49c763"

URI_aarch64_moodycamel-concurrentqueue-devel = "${EPEL_MIRROR}/aarch64/Packages/m/moodycamel-concurrentqueue-devel-1.0.4-2.el10_0.noarch.rpm;name=aarch64_moodycamel-concurrentqueue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_moodycamel-concurrentqueue-devel}"
SRC_URI[aarch64_moodycamel-concurrentqueue-devel.sha256sum] = "7dd7ab46537de066b101578ffc54883409c364f18609e4bf52b35128b0d55edf"

RDEPENDS:moodycamel-concurrentqueue-devel = " \
 cmake-filesystem \
 "
