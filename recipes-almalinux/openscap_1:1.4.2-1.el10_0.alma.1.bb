# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openscap"
PE = "1"
PV = "1.4.2"
PR = "1.el10_0.alma.1"
PACKAGES = " \
 openscap \
 openscap-engine-sce \
 openscap-scanner \
 openscap-utils \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openscap-1.4.2-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0f51930bc05075606b47e4ccb42efb85e93f8d079205de15932f1dd908fda7d"

URI_x86_64_v2_openscap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-1.4.2-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap}"
SRC_URI[x86_64_v2_openscap.sha256sum] = "7e2f52df7719d268bc2255f55868fb0715ef279153a9952f3d47782f16e6488e"

URI_x86_64_v2_openscap-engine-sce = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-engine-sce-1.4.2-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-engine-sce;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-engine-sce}"
SRC_URI[x86_64_v2_openscap-engine-sce.sha256sum] = "105015534b699caad6aefb683c6c8e850b5d90798d8dc51b72b83ba34a7bcc34"

URI_x86_64_v2_openscap-scanner = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-scanner-1.4.2-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-scanner;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-scanner}"
SRC_URI[x86_64_v2_openscap-scanner.sha256sum] = "cffa63359f27b9d6dab5bad3339fd39e1cd984212f327816fc4b421a3011ccc3"

URI_x86_64_v2_openscap-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openscap-utils-1.4.2-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_openscap-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openscap-utils}"
SRC_URI[x86_64_v2_openscap-utils.sha256sum] = "dd63a1f3250916497c0794acbbc9fafd8b035fe5fcbc592d56f6b0fca31270ae"

URI_aarch64_openscap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-1.4.2-1.el10_0.alma.1.aarch64.rpm;name=aarch64_openscap;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap}"
SRC_URI[aarch64_openscap.sha256sum] = "eb817362f0db8df35ff3f164a1cde3e0207043479e4f0a1575b5cc6771b48950"

URI_aarch64_openscap-engine-sce = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-engine-sce-1.4.2-1.el10_0.alma.1.aarch64.rpm;name=aarch64_openscap-engine-sce;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-engine-sce}"
SRC_URI[aarch64_openscap-engine-sce.sha256sum] = "2f7521e393567a8ec9d29c443660b4be8879ea2629d5b3d811232066c579faea"

URI_aarch64_openscap-scanner = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-scanner-1.4.2-1.el10_0.alma.1.aarch64.rpm;name=aarch64_openscap-scanner;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-scanner}"
SRC_URI[aarch64_openscap-scanner.sha256sum] = "872343a1e9aabda41ff43793d5bd6a573cd3c4b6f0d0d62dccaa69f9255560e9"

URI_aarch64_openscap-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openscap-utils-1.4.2-1.el10_0.alma.1.aarch64.rpm;name=aarch64_openscap-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_openscap-utils}"
SRC_URI[aarch64_openscap-utils.sha256sum] = "fed2815d2ac9ba3b4f7550f2105cdea4f507f0562e0c0ad578301b23e8638c33"

RDEPENDS:openscap = " \
 bash \
 bzip2-libs \
 dbus \
 dbus-libs \
 glib2 \
 glibc \
 libacl \
 libblkid \
 libcap \
 libgcc \
 libselinux \
 libxml2 \
 libxslt \
 libyaml \
 nss \
 openldap \
 pcre2 \
 popt \
 procps-ng \
 rpm-libs \
 virtual/libcurl.so.4___64bit_ \
 xmlsec1 \
 xmlsec1-openssl \
 "
RDEPENDS:openscap-engine-sce = " \
 glibc \
 openscap \
 "
RDEPENDS:openscap-scanner = " \
 bash \
 glibc \
 openscap \
 virtual/libcurl_ge_7.12.0 \
 "
RDEPENDS:openscap-utils = " \
 bash \
 openscap \
 openscap-scanner \
 python3 \
 rpm-build \
 rpmdevtools \
 "
