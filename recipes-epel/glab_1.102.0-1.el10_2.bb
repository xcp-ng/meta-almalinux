# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glab"
PV = "1.102.0"
PR = "1.el10_2"
PACKAGES = " \
 glab \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glab-1.102.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e8bc35f1f288344c4739231ebdd69cfb4a2f69b3218ab63cfa6772d6442c440e"

URI_x86_64_v2_glab = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glab-1.102.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glab;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glab}"
SRC_URI[x86_64_v2_glab.sha256sum] = "16c957ac3cb350528e2b0761c5cdaaa58f810f62ff45cd9fbc8378d4911225fa"

URI_aarch64_glab = "${EPEL_MIRROR}/aarch64/Packages/g/glab-1.102.0-1.el10_2.aarch64.rpm;name=aarch64_glab;unpack=0"
SRC_URI:append = " ${URI_aarch64_glab}"
SRC_URI[aarch64_glab.sha256sum] = "641b2596c0d5fc8beb3da079788e3addb9562036a9babe158a5089fc875f786e"

RDEPENDS:glab = " \
 git-core \
 glibc \
 "
