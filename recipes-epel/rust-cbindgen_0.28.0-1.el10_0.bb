# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cbindgen"
PV = "0.28.0"
PR = "1.el10_0"
PACKAGES = " \
 cbindgen \
 rust-cbindgen+clap-devel \
 rust-cbindgen+default-devel \
 rust-cbindgen+unstable_ir-devel \
 rust-cbindgen-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cbindgen-0.28.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c8ec389cf3d4be8b1c02087479c19e0e1e64c0295ad97e9feb6da4ed240e0cd4"

URI_x86_64_v2_cbindgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/cbindgen-0.28.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_cbindgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cbindgen}"
SRC_URI[x86_64_v2_cbindgen.sha256sum] = "daff7b4480feca72e456873eaaafdbd19cbebb3f9048d7d5ee2c2b641dd59ed3"

URI_x86_64_v2_rust-cbindgen+clap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen+clap-devel-0.28.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen+clap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen+clap-devel}"
SRC_URI[x86_64_v2_rust-cbindgen+clap-devel.sha256sum] = "44500c40be4799a35ac7bda5cbee54c9c4d1dd40bb23eda8fdeff9b178e9132e"

URI_x86_64_v2_rust-cbindgen+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen+default-devel-0.28.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen+default-devel}"
SRC_URI[x86_64_v2_rust-cbindgen+default-devel.sha256sum] = "5ca08b97090b3075d70cdd115cd50dde8a59138c47d5f5a5d9bd56b2dd0e5a17"

URI_x86_64_v2_rust-cbindgen+unstable_ir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen+unstable_ir-devel-0.28.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen+unstable_ir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen+unstable_ir-devel}"
SRC_URI[x86_64_v2_rust-cbindgen+unstable_ir-devel.sha256sum] = "e1833eefeb2836b8d15b75b02e02ec37caed0b2299627678f5b1c59620c99d38"

URI_x86_64_v2_rust-cbindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cbindgen-devel-0.28.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cbindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cbindgen-devel}"
SRC_URI[x86_64_v2_rust-cbindgen-devel.sha256sum] = "9e526626c6b3454537af97b59e1faa5464a85ac578ce50e000877f6f265e7345"

URI_aarch64_cbindgen = "${EPEL_MIRROR}/aarch64/Packages/c/cbindgen-0.28.0-1.el10_0.aarch64.rpm;name=aarch64_cbindgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_cbindgen}"
SRC_URI[aarch64_cbindgen.sha256sum] = "5befa5ad31989b8c1a0710a1be57270fe6435bb57687fff72b323f3586d50744"

URI_aarch64_rust-cbindgen+clap-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen+clap-devel-0.28.0-1.el10_0.noarch.rpm;name=aarch64_rust-cbindgen+clap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen+clap-devel}"
SRC_URI[aarch64_rust-cbindgen+clap-devel.sha256sum] = "b9792710523e3c4af0515a0aa8bc441a6c1f053bd453dd8d045446c0d866b025"

URI_aarch64_rust-cbindgen+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen+default-devel-0.28.0-1.el10_0.noarch.rpm;name=aarch64_rust-cbindgen+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen+default-devel}"
SRC_URI[aarch64_rust-cbindgen+default-devel.sha256sum] = "7e9fc7891d4c85c0797fb0fbfb6ca10831f6b30349b2b2c8b74841fa1933aac5"

URI_aarch64_rust-cbindgen+unstable_ir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen+unstable_ir-devel-0.28.0-1.el10_0.noarch.rpm;name=aarch64_rust-cbindgen+unstable_ir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen+unstable_ir-devel}"
SRC_URI[aarch64_rust-cbindgen+unstable_ir-devel.sha256sum] = "012466f1f5c8b91ed81e24747f6842363e6c35fa617954d894d5a5fcdb35849a"

URI_aarch64_rust-cbindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cbindgen-devel-0.28.0-1.el10_0.noarch.rpm;name=aarch64_rust-cbindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cbindgen-devel}"
SRC_URI[aarch64_rust-cbindgen-devel.sha256sum] = "be22731e7f82f6ac4471cafe3131496d84b702ea4a6a74aacbf0123a03df542e"

RDEPENDS:cbindgen = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-cbindgen+clap-devel = " \
 cargo \
 rust-cbindgen-devel \
 rust-clap+default-devel \
 "
RDEPENDS:rust-cbindgen+default-devel = " \
 cargo \
 rust-cbindgen+clap-devel \
 rust-cbindgen-devel \
 "
RDEPENDS:rust-cbindgen+unstable_ir-devel = " \
 cargo \
 rust-cbindgen-devel \
 "
RDEPENDS:rust-cbindgen-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-indexmap+default-devel \
 rust-log+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-serde_json+default-devel \
 rust-syn+clone-impls-devel \
 rust-syn+extra-traits-devel \
 rust-syn+fold-devel \
 rust-syn+full-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn-devel \
 rust-tempfile+default-devel \
 rust-toml+default-devel \
 "
