# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt6-qtmqtt"
PV = "6.10.1"
PR = "1.el10_2"
PACKAGES = " \
 qt6-qtmqtt \
 qt6-qtmqtt-devel \
 qt6-qtmqtt-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt6-qtmqtt-6.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "18bb2937bc681e0a3676d665e8618c4b9a8ec3684e3f0147db61e58e557de37b"

URI_x86_64_v2_qt6-qtmqtt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtmqtt-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmqtt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmqtt}"
SRC_URI[x86_64_v2_qt6-qtmqtt.sha256sum] = "8ccfdcb6c00eb6995e5691fce49477d42b2f660032e9e7fd39f17a8b5fcb7540"

URI_x86_64_v2_qt6-qtmqtt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtmqtt-devel-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmqtt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmqtt-devel}"
SRC_URI[x86_64_v2_qt6-qtmqtt-devel.sha256sum] = "8204d0197f54668e62d75c48f459e888b54a0d16e762a07f7e9607667bf7b77a"

URI_x86_64_v2_qt6-qtmqtt-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt6-qtmqtt-examples-6.10.1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt6-qtmqtt-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt6-qtmqtt-examples}"
SRC_URI[x86_64_v2_qt6-qtmqtt-examples.sha256sum] = "53ae87dd16b760464e0b2908013ff0f3e9bea54f687677b0db02191d730f93bd"

URI_aarch64_qt6-qtmqtt = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtmqtt-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtmqtt;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmqtt}"
SRC_URI[aarch64_qt6-qtmqtt.sha256sum] = "b23fcffa76255cdeeddc64cc6bc0a34dbb72884115ac64903882a0d6aef1929e"

URI_aarch64_qt6-qtmqtt-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtmqtt-devel-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtmqtt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmqtt-devel}"
SRC_URI[aarch64_qt6-qtmqtt-devel.sha256sum] = "e144ccb932509be7cd8fa7954b25ada80a87c4ea1823607aa2d9d4a2d4b00eb3"

URI_aarch64_qt6-qtmqtt-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt6-qtmqtt-examples-6.10.1-1.el10_2.aarch64.rpm;name=aarch64_qt6-qtmqtt-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt6-qtmqtt-examples}"
SRC_URI[aarch64_qt6-qtmqtt-examples.sha256sum] = "a20edcf319e958ba884fe280ac10b26c0a91dd1007331df0f166ed5abc66b1b9"

RDEPENDS:qt6-qtmqtt = " \
 glibc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:qt6-qtmqtt-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 qt6-qtmqtt \
 "
RDEPENDS:qt6-qtmqtt-examples = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmqtt \
 "
