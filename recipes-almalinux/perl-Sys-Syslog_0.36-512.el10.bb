# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Sys-Syslog"
PV = "0.36"
PR = "512.el10"
PACKAGES = " \
 perl-Sys-Syslog \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Sys-Syslog-0.36-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "44618afd0e07d4aabe897036b1fc1cae592f3a4ac424c49b5ff874715c4f9a25"

URI_x86_64_v2_perl-Sys-Syslog = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Sys-Syslog-0.36-512.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Sys-Syslog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Sys-Syslog}"
SRC_URI[x86_64_v2_perl-Sys-Syslog.sha256sum] = "71f1ab6575a812434095ab2f3d81685eaa7eef7a32d588b6134233fd612b0b97"

URI_aarch64_perl-Sys-Syslog = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Sys-Syslog-0.36-512.el10.aarch64.rpm;name=aarch64_perl-Sys-Syslog;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Sys-Syslog}"
SRC_URI[aarch64_perl-Sys-Syslog.sha256sum] = "eab87f1e197e10dd2a11c1bff2759c39fe8f18f8ca37d988e55bccae26ffd68a"

RDEPENDS:perl-Sys-Syslog = " \
 glibc \
 perl-Carp \
 perl-Exporter \
 perl-Fcntl \
 perl-File-Basename \
 perl-POSIX \
 perl-Socket \
 perl-constant \
 perl-libs \
 perl-vars \
 "
