# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Object-Remote"
PV = "0.005001"
PR = "2.el10_2"
PACKAGES = " \
 perl-Object-Remote \
 perl-Object-Remote-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Object-Remote-0.005001-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2089d9cc08fc5c7265dcb4d0f92105e336ebcacf7f49ad77ebe7a358908824b9"

URI_x86_64_v2_perl-Object-Remote = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Object-Remote-0.005001-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Object-Remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Object-Remote}"
SRC_URI[x86_64_v2_perl-Object-Remote.sha256sum] = "121dd4b081e398352e7ff9b6fcbe93abe5aef3428a31e7a2c031e39b82d4a4f6"

URI_x86_64_v2_perl-Object-Remote-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Object-Remote-tests-0.005001-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Object-Remote-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Object-Remote-tests}"
SRC_URI[x86_64_v2_perl-Object-Remote-tests.sha256sum] = "9b3f6713fef0a95a429f23d471dd063a2e728ccc5638299066690b4725fcabf7"

URI_aarch64_perl-Object-Remote = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Object-Remote-0.005001-2.el10_2.noarch.rpm;name=aarch64_perl-Object-Remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Object-Remote}"
SRC_URI[aarch64_perl-Object-Remote.sha256sum] = "b3d669afa42c6daa573651841a43c4500bcba2e09831cc83bd9ca59a9031c6d3"

URI_aarch64_perl-Object-Remote-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Object-Remote-tests-0.005001-2.el10_2.noarch.rpm;name=aarch64_perl-Object-Remote-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Object-Remote-tests}"
SRC_URI[aarch64_perl-Object-Remote-tests.sha256sum] = "04046c84cf3841f3b098def067970f902056f04fd36ea9c930437581657553a6"

RDEPENDS:perl-Object-Remote = " \
 openssh-clients \
 perl-Algorithm-C3 \
 perl-B \
 perl-Carp \
 perl-Class-C3 \
 perl-Data-Dumper \
 perl-Devel-GlobalDestruction \
 perl-Eval-WithLexicals \
 perl-Exporter \
 perl-FileHandle \
 perl-Future \
 perl-IO \
 perl-IPC-Open3 \
 perl-JSON-PP \
 perl-Log-Contextual \
 perl-MRO-Compat \
 perl-Module-Runtime \
 perl-Moo \
 perl-Object-Remote \
 perl-POSIX \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-String-ShellQuote \
 perl-Symbol \
 perl-Sys-Hostname \
 perl-Term-ReadLine \
 perl-Tie \
 perl-Time-HiRes \
 perl-base \
 perl-interpreter \
 perl-libs \
 perl-strictures \
 sudo \
 "
RDEPENDS:perl-Object-Remote-tests = " \
 bash \
 perl-Errno \
 perl-FindBin \
 perl-Object-Remote \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-Test-Fatal \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tie \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-overload \
 "
