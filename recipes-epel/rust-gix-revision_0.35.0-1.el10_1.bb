# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-revision"
PV = "0.35.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-revision+default-devel \
 rust-gix-revision+describe-devel \
 rust-gix-revision+document-features-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision+serde-devel \
 rust-gix-revision-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-revision-0.35.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "587dfd90266bf9fe2ef6225886f27b5800122a1d33094cbb56421799022c3ee7"

URI_x86_64_v2_rust-gix-revision+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+default-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+default-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+default-devel.sha256sum] = "86d8fd5d6b71408e4b0856e927d7a0cb9a4031603a2241f4e94da59178d252bb"

URI_x86_64_v2_rust-gix-revision+describe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+describe-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+describe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+describe-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+describe-devel.sha256sum] = "d6c37947e5f83efe91d03dbc3247bc17f466e4229e7b64497f6183a91e9f0464"

URI_x86_64_v2_rust-gix-revision+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+document-features-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+document-features-devel.sha256sum] = "7d938cbb66476ef37cec8e57a68ba8657fd918bdc1a341746a534986ed66799b"

URI_x86_64_v2_rust-gix-revision+merge_base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+merge_base-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+merge_base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+merge_base-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+merge_base-devel.sha256sum] = "a9bc0530078e9b19c72e5c5fd9d7639f1deba1176174a3ee1fdc4b658a5c96af"

URI_x86_64_v2_rust-gix-revision+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+serde-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+serde-devel.sha256sum] = "3db66642b95f8d222be19e0d44fc7de2f3df24dc9344413190c85ac925bc0d78"

URI_x86_64_v2_rust-gix-revision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision-devel-0.35.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision-devel}"
SRC_URI[x86_64_v2_rust-gix-revision-devel.sha256sum] = "f73d9544c68b06eff89e90d0106392b562898394ccf94b9d4782ce9c2897fba1"

URI_aarch64_rust-gix-revision+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+default-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-revision+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+default-devel}"
SRC_URI[aarch64_rust-gix-revision+default-devel.sha256sum] = "314f75f28649023d5a042bf3a9a181c85f86367b11c1a6f6b7795674f5a16586"

URI_aarch64_rust-gix-revision+describe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+describe-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-revision+describe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+describe-devel}"
SRC_URI[aarch64_rust-gix-revision+describe-devel.sha256sum] = "40b2be9a4ce55c8ba3864cb33e7807c1bc264f4d01a93782925ea2dd41337969"

URI_aarch64_rust-gix-revision+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+document-features-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-revision+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+document-features-devel}"
SRC_URI[aarch64_rust-gix-revision+document-features-devel.sha256sum] = "be91a18d12d8600096e8bb1952e9a113e92603a7a7200c1e1a366a29fc3c4331"

URI_aarch64_rust-gix-revision+merge_base-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+merge_base-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-revision+merge_base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+merge_base-devel}"
SRC_URI[aarch64_rust-gix-revision+merge_base-devel.sha256sum] = "5aeed9b9a7f2755d6d0e0255dca1ff448cd4c92eba2740a00fa7b4c45290ba85"

URI_aarch64_rust-gix-revision+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+serde-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-revision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+serde-devel}"
SRC_URI[aarch64_rust-gix-revision+serde-devel.sha256sum] = "4408dc788a64ec9ca1c250bd54b696878c1d602a6bec55dae3d7593aa4718da5"

URI_aarch64_rust-gix-revision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision-devel-0.35.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-revision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision-devel}"
SRC_URI[aarch64_rust-gix-revision-devel.sha256sum] = "096452663c053cff64d857624e75558c68326b85e0a8da82dbcd6bb759823d53"

RDEPENDS:rust-gix-revision+default-devel = " \
 cargo \
 rust-gix-revision+describe-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision+describe-devel = " \
 cargo \
 rust-gix-hashtable+default-devel \
 rust-gix-revision-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-revision+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision+merge_base-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-gix-revision-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-revision+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-revision-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-revision-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-thiserror+default-devel \
 "
