# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-resolv-conf"
PV = "0.7.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 rust-resolv-conf-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-resolv-conf-0.7.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a58f44ed5978955de5678512df8720aabad2003e683861ff21c95b75dddb7ab"

URI_x86_64_v2_rust-resolv-conf+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resolv-conf+default-devel-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resolv-conf+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-resolv-conf+default-devel}"
SRC_URI[x86_64_v2_rust-resolv-conf+default-devel.sha256sum] = "d09da1de7ee2482563b9b8aa3efb9ba306558255e4e2dc9b1d1084ffffe90223"

URI_x86_64_v2_rust-resolv-conf+system-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resolv-conf+system-devel-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resolv-conf+system-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-resolv-conf+system-devel}"
SRC_URI[x86_64_v2_rust-resolv-conf+system-devel.sha256sum] = "66f74baef1c6df3f496fa9a05617f36f1ea186ea9a7aba9997f92468ca11e4b2"

URI_x86_64_v2_rust-resolv-conf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-resolv-conf-devel-0.7.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-resolv-conf-devel}"
SRC_URI[x86_64_v2_rust-resolv-conf-devel.sha256sum] = "ed561afe8c9d0182ca7c5f1fc6d2206304bbc45e1a228d2681a83410abdeb2ff"

URI_aarch64_rust-resolv-conf+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-resolv-conf+default-devel-0.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-resolv-conf+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-resolv-conf+default-devel}"
SRC_URI[aarch64_rust-resolv-conf+default-devel.sha256sum] = "7b4a48740c11534093c919060b756514dd9b2b10c19ae056e4ccfcb74ae4064e"

URI_aarch64_rust-resolv-conf+system-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-resolv-conf+system-devel-0.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-resolv-conf+system-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-resolv-conf+system-devel}"
SRC_URI[aarch64_rust-resolv-conf+system-devel.sha256sum] = "4a651030bd2086140e70e03d861801b31992537027f04046806debb98c57aeed"

URI_aarch64_rust-resolv-conf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-resolv-conf-devel-0.7.4-1.el10_0.noarch.rpm;name=aarch64_rust-resolv-conf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-resolv-conf-devel}"
SRC_URI[aarch64_rust-resolv-conf-devel.sha256sum] = "455c8e21d553a3f4c4c87a3fae1360d458d49983cc258f11cb4d12df093d8151"

RDEPENDS:rust-resolv-conf+default-devel = " \
 cargo \
 rust-resolv-conf-devel \
 "
RDEPENDS:rust-resolv-conf+system-devel = " \
 cargo \
 rust-resolv-conf-devel \
 "
RDEPENDS:rust-resolv-conf-devel = " \
 cargo \
 rust \
 "
