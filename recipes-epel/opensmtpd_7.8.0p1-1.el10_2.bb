# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "opensmtpd"
PV = "7.8.0p1"
PR = "1.el10_2"
PACKAGES = " \
 opensmtpd \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/opensmtpd-7.8.0p1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "662fe2f459065b5ddf8a9215da3491829b35025994417263b220038cdf595767"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/opensmtpd-7.8.0p1-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_opensmtpd;unpack=0"
SRC_URI[x86_64_v2_opensmtpd.sha256sum] = "4c25b165fdf02d2b71453ac88fd09b127dbeff0c5bcc44448b0ddc270f344cb2"
RPROVIDES:opensmtpd:append:x86_64_v2 = " virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/opensmtpd-7.8.0p1-1.el10_2.aarch64.rpm;name=aarch64_opensmtpd;unpack=0"
SRC_URI[aarch64_opensmtpd.sha256sum] = "c6cc1523cdeba6c70a856e505140e62a17db3cfe15486b3a7f752b294a4c0894"
RPROVIDES:opensmtpd:append:aarch64 = " virtual//usr/bin/mailq virtual//usr/sbin/sendmail virtual/smtpdaemon"

RDEPENDS:opensmtpd = " \
 bash \
 glibc \
 libdb \
 libevent \
 libxcrypt \
 openssl-libs \
 pam-libs \
 shadow-utils \
 systemd \
 zlib-ng-compat \
 "
