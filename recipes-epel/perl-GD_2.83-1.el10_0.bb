# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-GD"
PV = "2.83"
PR = "1.el10_0"
PACKAGES = " \
 perl-GD \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-GD-2.83-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "36d5c00b30b7375610016909139f07ac0c79ff77270da81485c970a4af2f7c7c"

URI_x86_64_v2_perl-GD = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-GD-2.83-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-GD;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-GD}"
SRC_URI[x86_64_v2_perl-GD.sha256sum] = "8692f6ee25dc1291737b3ba8dab71cc0363f33826bfb4cdd4d40d3fbac859791"

URI_aarch64_perl-GD = "${EPEL_MIRROR}/aarch64/Packages/p/perl-GD-2.83-1.el10_0.aarch64.rpm;name=aarch64_perl-GD;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-GD}"
SRC_URI[aarch64_perl-GD.sha256sum] = "b3628fa983af8a310ea12cca35663a4200f40909641b333bb0281dd77c324efe"

RDEPENDS:perl-GD = " \
 gd \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-FileHandle \
 perl-GD \
 perl-Math-Complex \
 perl-Symbol \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
