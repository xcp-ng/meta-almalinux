# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman-compose"
PV = "1.5.0"
PR = "1.el10_1"
PACKAGES = " \
 podman-compose \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/podman-compose-1.5.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9cdfd8673c76cf807a1ff8493ddd09a0c198c6bccee89cb03e6e6ea026646d40"

URI_x86_64_v2_podman-compose = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/podman-compose-1.5.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_podman-compose;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_podman-compose}"
SRC_URI[x86_64_v2_podman-compose.sha256sum] = "3864b6512ef89d8541bd371f5a3f3d2874ee092d5c54254e96876eb733df9143"

URI_aarch64_podman-compose = "${EPEL_MIRROR}/aarch64/Packages/p/podman-compose-1.5.0-1.el10_1.noarch.rpm;name=aarch64_podman-compose;unpack=0"
SRC_URI:append = " ${URI_aarch64_podman-compose}"
SRC_URI[aarch64_podman-compose.sha256sum] = "b38bc39dfdef6710326a204f56bc8b44d130474b6985c2008a29b722ccfee044"

RDEPENDS:podman-compose = " \
 podman \
 python3 \
 python3-dotenv \
 python3-pyyaml \
 "
