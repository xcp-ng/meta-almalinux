# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Math-Int128"
PV = "0.22"
PR = "16.el10_0"
PACKAGES = " \
 perl-Math-Int128 \
 perl-Math-Int128-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Math-Int128-0.22-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d6eb348d7f8758e16b3a16ffc556ca228c0435f0d52897bfe3ac81ffed33da82"

URI_x86_64_v2_perl-Math-Int128 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-Int128-0.22-16.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Math-Int128;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-Int128}"
SRC_URI[x86_64_v2_perl-Math-Int128.sha256sum] = "6e89bec5f25410f8ee77e38cc47bc89a1dca0a91f534947cf08b14370bfc1a78"

URI_x86_64_v2_perl-Math-Int128-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Math-Int128-tests-0.22-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Math-Int128-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Math-Int128-tests}"
SRC_URI[x86_64_v2_perl-Math-Int128-tests.sha256sum] = "5983a42aabaa6bb564bda041ced941128da63f117d258fe8ff079fe74c675d31"

URI_aarch64_perl-Math-Int128 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-Int128-0.22-16.el10_0.aarch64.rpm;name=aarch64_perl-Math-Int128;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-Int128}"
SRC_URI[aarch64_perl-Math-Int128.sha256sum] = "364c09532f141e734324cbd7794b1a4da09094c19046dae925749dba94a9e1e0"

URI_aarch64_perl-Math-Int128-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Math-Int128-tests-0.22-16.el10_0.noarch.rpm;name=aarch64_perl-Math-Int128-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Math-Int128-tests}"
SRC_URI[aarch64_perl-Math-Int128-tests.sha256sum] = "a0945b35740bd4baa0e30358ea6b32252395fa66e580195be431263b7c6759d7"

RDEPENDS:perl-Math-Int128 = " \
 glibc \
 perl-Exporter \
 perl-Math-Int64 \
 perl-constant \
 perl-libs \
 perl-overload \
 "
RDEPENDS:perl-Math-Int128-tests = " \
 bash \
 perl-ExtUtils-MakeMaker \
 perl-IO \
 perl-IPC-Open3 \
 perl-Math-BigInt \
 perl-Math-Int128 \
 perl-PathTools \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-interpreter \
 perl-libs \
 "
