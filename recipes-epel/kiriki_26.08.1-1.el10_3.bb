# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kiriki"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kiriki \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kiriki-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4f7a999cf4162a62a7aa68b4c9f91314128e01176390f596dc82cacaac303d2e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kiriki-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kiriki;unpack=0"
SRC_URI[x86_64_v2_kiriki.sha256sum] = "43ecb52838f23bfbad2175bbdd72f44fae6455bd46ebd9ee4e04c5dcff364230"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kiriki-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kiriki;unpack=0"
SRC_URI[aarch64_kiriki.sha256sum] = "d95bd2adf4f0446ee374779f2a14c10058818cb3ab863be12cfc831fda1d078a"

RDEPENDS:kiriki = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
