# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fast-cdr"
PV = "2.3.0"
PR = "1.el10_1"
PACKAGES = " \
 fast-cdr \
 fast-cdr-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fast-cdr-2.3.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82a087ea792475c389250aee051643a89c901b5152d25cd41236ef2641d97ddc"

URI_x86_64_v2_fast-cdr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fast-cdr-2.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fast-cdr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fast-cdr}"
SRC_URI[x86_64_v2_fast-cdr.sha256sum] = "b62b04e6c84a6689952b1319390e656bd6b3f3300837eb969d94c2bdcd7b7999"

URI_x86_64_v2_fast-cdr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fast-cdr-devel-2.3.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fast-cdr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fast-cdr-devel}"
SRC_URI[x86_64_v2_fast-cdr-devel.sha256sum] = "f705d1ac5cee3328dd8719b4b123158c3f4d5d0c6f7f3adf3a61ab6edf24636d"

URI_aarch64_fast-cdr = "${EPEL_MIRROR}/aarch64/Packages/f/fast-cdr-2.3.0-1.el10_1.aarch64.rpm;name=aarch64_fast-cdr;unpack=0"
SRC_URI:append = " ${URI_aarch64_fast-cdr}"
SRC_URI[aarch64_fast-cdr.sha256sum] = "7f19dc2aaae9c739ff7bcdb76d6e92f4100a3466ddb60e5481c0be8970973ef3"

URI_aarch64_fast-cdr-devel = "${EPEL_MIRROR}/aarch64/Packages/f/fast-cdr-devel-2.3.0-1.el10_1.aarch64.rpm;name=aarch64_fast-cdr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_fast-cdr-devel}"
SRC_URI[aarch64_fast-cdr-devel.sha256sum] = "221f613aeb7d00ee72946ad00bb9447a50a5641a680e010a7a2c01d29764e91f"

RDEPENDS:fast-cdr = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:fast-cdr-devel = " \
 cmake-filesystem \
 fast-cdr \
 "
