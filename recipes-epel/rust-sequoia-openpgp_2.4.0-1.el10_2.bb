# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sequoia-openpgp"
PV = "2.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel \
 rust-sequoia-openpgp+compression-bzip2-devel \
 rust-sequoia-openpgp+compression-deflate-devel \
 rust-sequoia-openpgp+compression-devel \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-openpgp+crypto-openssl-devel \
 rust-sequoia-openpgp+default-devel \
 rust-sequoia-openpgp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sequoia-openpgp-2.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e6ea25bc008f9ecb4a433be0c88495cbf5c81c579234c22b22c01c8637ee3172"

URI_x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel.sha256sum] = "d3ce249ab32488e6cf33994b2b28c427a78f4b0bf39b22b196ee54b595506c83"

URI_x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-bzip2-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-bzip2-devel.sha256sum] = "d93ba783e1a9dcb0161d6f418aebae54541d7e0993a4edf848fcd23bc191ad93"

URI_x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-deflate-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-deflate-devel.sha256sum] = "ebe6d86a9324ff70a06b816a584eb59c26d07fb9f4103d5972ed3dad21ba95e6"

URI_x86_64_v2_rust-sequoia-openpgp+compression-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+compression-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+compression-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+compression-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+compression-devel.sha256sum] = "2d2934f8de5ab8c1bdacda7e7cfb2d7524982f5de26aa227b6997e69c83cf337"

URI_x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+crypto-nettle-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+crypto-nettle-devel.sha256sum] = "bf66f501e9c2c6e259207b046930f11b53d3958de1ee3a5e671e037df597f32c"

URI_x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+crypto-openssl-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+crypto-openssl-devel.sha256sum] = "17c2d334f2c91ab6c6ac9a58b46db916d139ab4d7995e56da48f4f30d9b31635"

URI_x86_64_v2_rust-sequoia-openpgp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp+default-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp+default-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp+default-devel.sha256sum] = "0e1c6ae67a3ce733e388b0be0d34004c3f4373917211c33a0c9355d0c4ee9e13"

URI_x86_64_v2_rust-sequoia-openpgp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sequoia-openpgp-devel-2.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sequoia-openpgp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sequoia-openpgp-devel}"
SRC_URI[x86_64_v2_rust-sequoia-openpgp-devel.sha256sum] = "4cf31014b57edd79362278403c630153fce38cbca399e924173eb7d9d4843709"

URI_aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel.sha256sum] = "0218a6283bda0acc17b21acd28a8c47d86f39d55863984e953f509d9470ff4d1"

URI_aarch64_rust-sequoia-openpgp+compression-bzip2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-bzip2-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-bzip2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+compression-bzip2-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-bzip2-devel.sha256sum] = "2ac7c5886159e95b676ac49cfcc8ec2ef6ffebdace9077e701c667e58ddaf30d"

URI_aarch64_rust-sequoia-openpgp+compression-deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-deflate-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+compression-deflate-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-deflate-devel.sha256sum] = "2bbb7a5363b67181ecb045babc7fa8f423ff0dde36fc46b045d21fcf68d9557a"

URI_aarch64_rust-sequoia-openpgp+compression-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+compression-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-sequoia-openpgp+compression-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+compression-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+compression-devel.sha256sum] = "e3c5d55a07403ec4ee6d0b82143c93ebf25cb2fb7a525b68cce047d158514cfd"

URI_aarch64_rust-sequoia-openpgp+crypto-nettle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+crypto-nettle-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-sequoia-openpgp+crypto-nettle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+crypto-nettle-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+crypto-nettle-devel.sha256sum] = "bb7286b7b13987d897098bccad1bb10855d0d29187688d11a8071bd5ade29642"

URI_aarch64_rust-sequoia-openpgp+crypto-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+crypto-openssl-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-sequoia-openpgp+crypto-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+crypto-openssl-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+crypto-openssl-devel.sha256sum] = "22a6d075cc82a9f066ddc48d6d08b41cfa94e8ced7d498ede4d20243318e0151"

URI_aarch64_rust-sequoia-openpgp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp+default-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-sequoia-openpgp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp+default-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp+default-devel.sha256sum] = "a76ca756983d96ee85104ab355e2f6502dabe23071cfa7019a50c5fa21fc71f2"

URI_aarch64_rust-sequoia-openpgp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sequoia-openpgp-devel-2.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-sequoia-openpgp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sequoia-openpgp-devel}"
SRC_URI[aarch64_rust-sequoia-openpgp-devel.sha256sum] = "2fa56d326c52deac5d38b9ea12fbb6a49c16d94c1945e32c94b2f5f27242ff5b"

RDEPENDS:rust-sequoia-openpgp+__implicit-crypto-backend-for-tests-devel = " \
 cargo \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-bzip2-devel = " \
 cargo \
 rust-buffered-reader+compression-bzip2-devel \
 rust-bzip2+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-deflate-devel = " \
 cargo \
 rust-buffered-reader+compression-deflate-devel \
 rust-flate2+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+compression-devel = " \
 cargo \
 rust-sequoia-openpgp+compression-bzip2-devel \
 rust-sequoia-openpgp+compression-deflate-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+crypto-nettle-devel = " \
 cargo \
 rust-nettle+default-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+crypto-openssl-devel = " \
 cargo \
 rust-ossl+openssl-sys-devel \
 rust-ossl+rfc9580-devel \
 rust-ossl-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp+default-devel = " \
 cargo \
 rust-sequoia-openpgp+compression-devel \
 rust-sequoia-openpgp+crypto-nettle-devel \
 rust-sequoia-openpgp-devel \
 "
RDEPENDS:rust-sequoia-openpgp-devel = " \
 bash \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-argon2+default-devel \
 rust-base64+default-devel \
 rust-buffered-reader-devel \
 rust-dyn-clone+default-devel \
 rust-idna+default-devel \
 rust-lalrpop-devel \
 rust-lalrpop-util+default-devel \
 rust-libc+default-devel \
 rust-memsec-devel \
 rust-regex+default-devel \
 rust-regex-syntax+default-devel \
 rust-sha1collisiondetection+std-devel \
 rust-sha1collisiondetection-devel \
 rust-xxhash-rust+default-devel \
 rust-xxhash-rust+xxh3-devel \
 virtual/crate_thiserror/default__ge_1.0.0_with_crate_thiserror/default__lt_3.0.0~ \
 "
