# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-channel"
PV = "0.5.15"
PR = "1.el10_0"
PACKAGES = " \
 rust-crossbeam-channel+default-devel \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-channel-0.5.15-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fc13cccbdd6b42ef78d76a633c5a04b692d674ce33b5a674af4f28a0dbbc7b7"

URI_x86_64_v2_rust-crossbeam-channel+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+default-devel-0.5.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel+default-devel.sha256sum] = "df056706327af1c19556f4e1d8fafc5c29cb028e2849cda6cf5899fb5dd70736"

URI_x86_64_v2_rust-crossbeam-channel+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel+std-devel-0.5.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel+std-devel.sha256sum] = "0eef8e23a97f55249db4f2a753c8ccb112c803e8bc85e1435ceac7a5358e5e4f"

URI_x86_64_v2_rust-crossbeam-channel-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-channel-devel-0.5.15-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-channel-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-channel-devel.sha256sum] = "9870d91ab2d82a9fa8cb32d969296ab27b6c74230cd792ccc12873b783d4db04"

URI_aarch64_rust-crossbeam-channel+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+default-devel-0.5.15-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-channel+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel+default-devel}"
SRC_URI[aarch64_rust-crossbeam-channel+default-devel.sha256sum] = "67588e320347b96d972fd539dc735e139a94de597cf449a3fd385c79f02f1d94"

URI_aarch64_rust-crossbeam-channel+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel+std-devel-0.5.15-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-channel+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel+std-devel}"
SRC_URI[aarch64_rust-crossbeam-channel+std-devel.sha256sum] = "ec1761eae4c4588a1327ea865cc4029c7eb55dd94d3b5c403845c13fb9370643"

URI_aarch64_rust-crossbeam-channel-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-channel-devel-0.5.15-1.el10_0.noarch.rpm;name=aarch64_rust-crossbeam-channel-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-channel-devel}"
SRC_URI[aarch64_rust-crossbeam-channel-devel.sha256sum] = "537fb6cf84298a61a2323493f0f9b17aa769772ca89a48570c208115a3f9f15e"

RDEPENDS:rust-crossbeam-channel+default-devel = " \
 cargo \
 rust-crossbeam-channel+std-devel \
 rust-crossbeam-channel-devel \
 "
RDEPENDS:rust-crossbeam-channel+std-devel = " \
 cargo \
 rust-crossbeam-channel-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-channel-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
