# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_xoshiro"
PV = "0.8.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_xoshiro+default-devel \
 rust-rand_xoshiro+serde-devel \
 rust-rand_xoshiro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_xoshiro-0.8.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcacb27411e4b934db7b6cdec905edd5b30499c078d808a8e618e4f52b52f8e2"

URI_x86_64_v2_rust-rand_xoshiro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro+default-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro+default-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro+default-devel.sha256sum] = "9d63a6ac69406437020badecf4c7316011f534768f440ece8f23549e9e031416"

URI_x86_64_v2_rust-rand_xoshiro+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro+serde-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro+serde-devel.sha256sum] = "c0d0298e5b291d473ff4f0296de4bbb09806876815ead7e940bcb803bae6efc4"

URI_x86_64_v2_rust-rand_xoshiro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_xoshiro-devel-0.8.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_xoshiro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_xoshiro-devel}"
SRC_URI[x86_64_v2_rust-rand_xoshiro-devel.sha256sum] = "3c4d806ce61fdff296927d5f09db36ebab3265c62e91d91613a0c3b504a1760b"

URI_aarch64_rust-rand_xoshiro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro+default-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro+default-devel}"
SRC_URI[aarch64_rust-rand_xoshiro+default-devel.sha256sum] = "d181659f71df328920c3dd13015faf3cd6b3ddb93ca2f2183a6513864eb07d56"

URI_aarch64_rust-rand_xoshiro+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro+serde-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro+serde-devel}"
SRC_URI[aarch64_rust-rand_xoshiro+serde-devel.sha256sum] = "7274a92a97d510a7c51961f0a16b63ceaec55a123691a5fe336a4e107a99cb5d"

URI_aarch64_rust-rand_xoshiro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_xoshiro-devel-0.8.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_xoshiro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_xoshiro-devel}"
SRC_URI[aarch64_rust-rand_xoshiro-devel.sha256sum] = "16a521ac1300a947b5dd2adec75ebdebb8704b707d9f325f89d1392af1257b5c"

RDEPENDS:rust-rand_xoshiro+default-devel = " \
 cargo \
 rust-rand_xoshiro-devel \
 "
RDEPENDS:rust-rand_xoshiro+serde-devel = " \
 cargo \
 rust-rand_xoshiro-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_xoshiro-devel = " \
 cargo \
 rust \
 rust-rand_core+default-devel \
 "
