# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bovo"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 bovo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/b/bovo-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63908d0d459e33843c2d1071f3f29ca97e4503ee2a84c9563866c977fd315b37"

URI_x86_64_v2_bovo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bovo-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bovo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_bovo}"
SRC_URI[x86_64_v2_bovo.sha256sum] = "58b92be99bbfc63db6a884e5c0f6a14c346da0c898e862e77f19b77c3276bb38"

URI_aarch64_bovo = "${EPEL_MIRROR}/aarch64/Packages/b/bovo-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_bovo;unpack=0"
SRC_URI:append = " ${URI_aarch64_bovo}"
SRC_URI[aarch64_bovo.sha256sum] = "7836023914b548a078c6b3b828510ef3b1b251e8b6df382f1224ff76c9d8086c"

RDEPENDS:bovo = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
