# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-core"
PV = "0.21.3"
PR = "1.el10_2"
PACKAGES = " \
 python3-colcon-core \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-core-0.21.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f0d05509105979658dcc5020eb97054038916eff2f88becbffe43a5f114293f5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-core-0.21.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-core;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-core.sha256sum] = "e4289bef4746821abab4c7994fa09f4f6c72348fd0e06c252f7b3afa25f205ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-core-0.21.3-1.el10_2.noarch.rpm;name=aarch64_python3-colcon-core;unpack=0"
SRC_URI[aarch64_python3-colcon-core.sha256sum] = "4adbc97cfbaa38bebe07258ccde20d8c417d0037f3135ed9593531f6b8c9e186"

RDEPENDS:python3-colcon-core = " \
 python3 \
 python3-distlib \
 python3-empy \
 python3-packaging \
 python3-setuptools \
 "
