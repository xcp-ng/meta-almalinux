# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-siphasher"
PV = "1.0.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-siphasher+default-devel \
 rust-siphasher+serde-devel \
 rust-siphasher+serde_json-devel \
 rust-siphasher+serde_no_std-devel \
 rust-siphasher+serde_std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-siphasher-1.0.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c36b97b1f4ce52e1f2db812e8b268c27f4ae2256ca2275ec1d136c0830cdef31"

URI_x86_64_v2_rust-siphasher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+default-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+default-devel}"
SRC_URI[x86_64_v2_rust-siphasher+default-devel.sha256sum] = "14db49c30d4bb26935f7e92145fafd010edf6e12ac7b69491312141c94895fad"

URI_x86_64_v2_rust-siphasher+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde-devel.sha256sum] = "e1ec47ad6bd06361b62c7ece2962ecefc6d06b29e25e959ee62e4e02a910c70b"

URI_x86_64_v2_rust-siphasher+serde_json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_json-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde_json-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde_json-devel.sha256sum] = "86661f45dbf92f99a897cb4170ceb1c403f83cf4e38aa348e6e607100ee6e142"

URI_x86_64_v2_rust-siphasher+serde_no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_no_std-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde_no_std-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde_no_std-devel.sha256sum] = "63c3e95fd65c271030ad98aa284e1c3e3c111b9f95db4069fdab0d243495e0db"

URI_x86_64_v2_rust-siphasher+serde_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+serde_std-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+serde_std-devel}"
SRC_URI[x86_64_v2_rust-siphasher+serde_std-devel.sha256sum] = "e2352265dda4332498ea0e890f6cd272a12c6a5ea21b88aced159c28bf63046f"

URI_x86_64_v2_rust-siphasher+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher+std-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher+std-devel}"
SRC_URI[x86_64_v2_rust-siphasher+std-devel.sha256sum] = "51b4550dcf2049a364603b88247d364dec743893fd6cc573222c4e36aa13b86a"

URI_x86_64_v2_rust-siphasher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-siphasher-devel-1.0.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-siphasher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-siphasher-devel}"
SRC_URI[x86_64_v2_rust-siphasher-devel.sha256sum] = "afbbaeed83038c97fa45d88801b0d653b13e9e7e3498edf59346a0316095d444"

URI_aarch64_rust-siphasher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+default-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-siphasher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+default-devel}"
SRC_URI[aarch64_rust-siphasher+default-devel.sha256sum] = "2c0f585e86d4f6edb5990c0717ead7eb55ea672ce73404c18d7cb771e65dd3b1"

URI_aarch64_rust-siphasher+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-siphasher+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde-devel}"
SRC_URI[aarch64_rust-siphasher+serde-devel.sha256sum] = "08c3c5c4cd2a5a180b95add57974f8326c2c94435defd97cfb4604479e87fc55"

URI_aarch64_rust-siphasher+serde_json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_json-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-siphasher+serde_json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde_json-devel}"
SRC_URI[aarch64_rust-siphasher+serde_json-devel.sha256sum] = "1d9c5681219c14aea7cd83d8b14bc2eec8a987c6e5cb498a107a0a35c4865abc"

URI_aarch64_rust-siphasher+serde_no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_no_std-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-siphasher+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde_no_std-devel}"
SRC_URI[aarch64_rust-siphasher+serde_no_std-devel.sha256sum] = "c3b1718559ebf2ccc829ba257fbb7334faad5f8f435ee15a3d89bcdc7406ffd9"

URI_aarch64_rust-siphasher+serde_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+serde_std-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-siphasher+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+serde_std-devel}"
SRC_URI[aarch64_rust-siphasher+serde_std-devel.sha256sum] = "ae87a3482a8d9c87ad91986526662b95d0bc3bebd65c68ded785ee1ef72bc31e"

URI_aarch64_rust-siphasher+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher+std-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-siphasher+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher+std-devel}"
SRC_URI[aarch64_rust-siphasher+std-devel.sha256sum] = "9155ae2bf41f99ee64020720c82f67fed67ed66ca810207984651e8eb2c49d5b"

URI_aarch64_rust-siphasher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-siphasher-devel-1.0.2-1.el10_1.noarch.rpm;name=aarch64_rust-siphasher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-siphasher-devel}"
SRC_URI[aarch64_rust-siphasher-devel.sha256sum] = "7f6d34199c082bbcbd99c7562322b545bea43aced03e69ca9e24bbe03db3420f"

RDEPENDS:rust-siphasher+default-devel = " \
 cargo \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_json-devel = " \
 cargo \
 rust-serde_json+default-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_no_std-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+serde_std-devel = " \
 cargo \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-siphasher+std-devel \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher+std-devel = " \
 cargo \
 rust-siphasher-devel \
 "
RDEPENDS:rust-siphasher-devel = " \
 cargo \
 "
