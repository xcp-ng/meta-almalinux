# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-good"
PV = "1.24.11"
PR = "1.el10"
PACKAGES = " \
 gstreamer1-plugins-good \
 gstreamer1-plugins-good-gtk \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-good-1.24.11-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5044c866248ea4836873362eb47d6dedee7b80aa8b7cfad61219a6f77676af41"

URI_x86_64_v2_gstreamer1-plugins-good = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-1.24.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-good}"
SRC_URI[x86_64_v2_gstreamer1-plugins-good.sha256sum] = "1c998be6349c471760365b31870f98d29538be9f751fcb92ebc3e7f5364d6832"

URI_x86_64_v2_gstreamer1-plugins-good-gtk = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-gtk-1.24.11-1.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-good-gtk}"
SRC_URI[x86_64_v2_gstreamer1-plugins-good-gtk.sha256sum] = "18fd45284d6f62728ab2c68818623760832afa0bad7c9159a18242d71a20b460"

URI_aarch64_gstreamer1-plugins-good = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-1.24.11-1.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-good;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-good}"
SRC_URI[aarch64_gstreamer1-plugins-good.sha256sum] = "b696dc40b135fdccb8961690e7fdeacaf76bce1219efb3c0d852ca1779337808"

URI_aarch64_gstreamer1-plugins-good-gtk = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-gtk-1.24.11-1.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-good-gtk}"
SRC_URI[aarch64_gstreamer1-plugins-good-gtk.sha256sum] = "7724f6fdadd5ddb8d1f9e6a7734fbd92383198261ec68909a610fe6940d8ec5a"

RDEPENDS:gstreamer1-plugins-good = " \
 bzip2-libs \
 cairo \
 cairo-gobject \
 flac-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXtst \
 libgcc \
 libgudev \
 libjpeg-turbo \
 libpng \
 libshout \
 libstdc++ \
 libv4l \
 libvpx \
 libxml2 \
 mpg123-libs \
 openssl-libs \
 orc \
 pulseaudio-libs \
 speex \
 taglib \
 twolame-libs \
 wavpack \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-good-gtk = " \
 cairo \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 gtk3 \
 "
