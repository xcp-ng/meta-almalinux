# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcalendarcore"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kcalendarcore \
 kf6-kcalendarcore-devel \
 kf6-kcalendarcore-doc \
 kf6-kcalendarcore-html \
 python3-kf6-kcalendarcore \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcalendarcore-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e9277936751821d60bbafdfc804567a113c5b67b6921ec7340fa250b928ea08"

URI_x86_64_v2_kf6-kcalendarcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore}"
SRC_URI[x86_64_v2_kf6-kcalendarcore.sha256sum] = "829ac0849982fb2967034e6b9ee56c3bc311420746112e95781724eb8db3b325"

URI_x86_64_v2_kf6-kcalendarcore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-devel}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-devel.sha256sum] = "6aaa872a86439686f08e7beae96d3333f0c62b374e750296768d2b51c2e04514"

URI_x86_64_v2_kf6-kcalendarcore-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcalendarcore-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-doc}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-doc.sha256sum] = "8a9f4d8d329e73d9a69cde2c9ccc1c05b6f8f1e879753e424801914f32aa524b"

URI_x86_64_v2_kf6-kcalendarcore-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcalendarcore-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-html}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-html.sha256sum] = "dc24f113f9aebb8195a776c9de414700df0ca03d8aef3082a6cff5ec4e131d20"

URI_x86_64_v2_python3-kf6-kcalendarcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kcalendarcore-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kcalendarcore}"
SRC_URI[x86_64_v2_python3-kf6-kcalendarcore.sha256sum] = "9c44149b7c344e84afe8731c5392c048052924693f278fd3417bebf1c468b1b7"

URI_aarch64_kf6-kcalendarcore = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore}"
SRC_URI[aarch64_kf6-kcalendarcore.sha256sum] = "e3a837ddd8fc0b1058f082832f533ffb10d0d6990785bdde58d5059c55827365"

URI_aarch64_kf6-kcalendarcore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kcalendarcore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-devel}"
SRC_URI[aarch64_kf6-kcalendarcore-devel.sha256sum] = "aa0583040f533a2d5839cf84ea6bfe591f26a897510d0945a0ca2629bcbeadf3"

URI_aarch64_kf6-kcalendarcore-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcalendarcore-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-doc}"
SRC_URI[aarch64_kf6-kcalendarcore-doc.sha256sum] = "3a6bf41a38dfbe2109f1f087b78c9c18c404607aa089690657fb413b8eba0064"

URI_aarch64_kf6-kcalendarcore-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kcalendarcore-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-html}"
SRC_URI[aarch64_kf6-kcalendarcore-html.sha256sum] = "be333a53abeef881e80bdfc4e10a5cb803f5bb6cb50aef9534222753801011ec"

URI_aarch64_python3-kf6-kcalendarcore = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kcalendarcore-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kcalendarcore}"
SRC_URI[aarch64_python3-kf6-kcalendarcore.sha256sum] = "6d4077b1be61810e6e5d6ab26ab24e274d7fdd5fd4db1a384b758a9be0d1f6df"

RDEPENDS:kf6-kcalendarcore = " \
 glibc \
 libical \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcalendarcore-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore \
 libical-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcalendarcore-doc = " \
 "
RDEPENDS:kf6-kcalendarcore-html = " \
 "
RDEPENDS:python3-kf6-kcalendarcore = " \
 glibc \
 kf6-kcalendarcore \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
