# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-click-log"
PV = "0.4.0"
PR = "16.el10_2"
PACKAGES = " \
 python3-click-log \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-click-log-0.4.0-16.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05f0567ff34f1949b31b2bc109d650ff8e87fbf5e491747c6fddd0129a2e8e8a"

URI_x86_64_v2_python3-click-log = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-click-log-0.4.0-16.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-click-log;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-click-log}"
SRC_URI[x86_64_v2_python3-click-log.sha256sum] = "be848cb9a0f8400ffce938955f65f61d17845948f7c26d7f422ab6d9eaf29d89"

URI_aarch64_python3-click-log = "${EPEL_MIRROR}/aarch64/Packages/p/python3-click-log-0.4.0-16.el10_2.noarch.rpm;name=aarch64_python3-click-log;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-click-log}"
SRC_URI[aarch64_python3-click-log.sha256sum] = "ccd3737a935316f49778e3fee78b2987006532f1de6c85218e59b864fd8261a6"

RDEPENDS:python3-click-log = " \
 python3 \
 python3-click \
 "
