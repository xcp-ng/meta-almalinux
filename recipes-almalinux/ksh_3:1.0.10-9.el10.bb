# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksh"
PE = "3"
PV = "1.0.10"
PR = "9.el10"
PACKAGES = " \
 ksh \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ksh-1.0.10-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3b5ddbe8142e642c3b9fc89099e39348e410644f0a262bae57f9646486f6782a"

URI_x86_64_v2_ksh = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ksh-1.0.10-9.el10.x86_64_v2.rpm;name=x86_64_v2_ksh;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksh}"
SRC_URI[x86_64_v2_ksh.sha256sum] = "ef40d5a6359a2ae3897e273231386ec74db68ca64521ffbde695a5a9eeb6133d"

URI_aarch64_ksh = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ksh-1.0.10-9.el10.aarch64.rpm;name=aarch64_ksh;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksh}"
SRC_URI[aarch64_ksh.sha256sum] = "26126f21330397c032efbd3c3caadcaaa623907ab39de82076bfeb092cfd679b"

RDEPENDS:ksh = " \
 bash \
 diffutils \
 glibc \
 grep \
 sed \
 systemd \
 virtual/coreutils \
 "
