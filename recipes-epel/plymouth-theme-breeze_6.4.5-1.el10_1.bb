# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-theme-breeze"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plymouth-theme-breeze \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plymouth-theme-breeze-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3602edb78f8d181ce778fa73922736dfc1f0b92befe0e0ebda66aec11c3290c1"

URI_x86_64_v2_plymouth-theme-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-theme-breeze-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-breeze}"
SRC_URI[x86_64_v2_plymouth-theme-breeze.sha256sum] = "2b2a3eae5dd34e317703c7a7b2568d5b9d8a5ec165b7807ab7cbbca44f60fa17"

URI_aarch64_plymouth-theme-breeze = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-theme-breeze-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plymouth-theme-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-breeze}"
SRC_URI[aarch64_plymouth-theme-breeze.sha256sum] = "15c04a992b5eb24d3743f5113042f1daa86dcca7dac47bf9e3486d1af3276398"

RDEPENDS:plymouth-theme-breeze = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-plugin-script \
 "
