# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-buf-min"
PV = "0.7.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-buf-min+bytes-devel \
 rust-buf-min+default-devel \
 rust-buf-min-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-buf-min-0.7.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81a24a541318f9dc70869f5329c4d54db37161ed36f57c16a0cf505b6d9e0488"

URI_x86_64_v2_rust-buf-min+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buf-min+bytes-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buf-min+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buf-min+bytes-devel}"
SRC_URI[x86_64_v2_rust-buf-min+bytes-devel.sha256sum] = "7032eb7ba7dcc01c6bbe9035b24dadb2c7c3ce091e6b494d0f098597095e7d7d"

URI_x86_64_v2_rust-buf-min+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buf-min+default-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buf-min+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buf-min+default-devel}"
SRC_URI[x86_64_v2_rust-buf-min+default-devel.sha256sum] = "a510497877a8e8e96bde6a663dc04b80aceef08aa0724246fd445cdb468bb754"

URI_x86_64_v2_rust-buf-min-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-buf-min-devel-0.7.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-buf-min-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-buf-min-devel}"
SRC_URI[x86_64_v2_rust-buf-min-devel.sha256sum] = "d6ab97032e83fe4cce43b0e3248d4b79d09f75cd0e8299c8e49e2a4bfaa6e2fa"

URI_aarch64_rust-buf-min+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buf-min+bytes-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-buf-min+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buf-min+bytes-devel}"
SRC_URI[aarch64_rust-buf-min+bytes-devel.sha256sum] = "5a6128e5aaa2971e9b591c4b8ddfa5c7e2672fcc2b369601091980a37aa21490"

URI_aarch64_rust-buf-min+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buf-min+default-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-buf-min+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buf-min+default-devel}"
SRC_URI[aarch64_rust-buf-min+default-devel.sha256sum] = "b8c004a03fdf44da0cf2b01f1a2aa7e5456a27cf2ef18cc7c1213b84a7ec09db"

URI_aarch64_rust-buf-min-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-buf-min-devel-0.7.1-3.el10_0.noarch.rpm;name=aarch64_rust-buf-min-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-buf-min-devel}"
SRC_URI[aarch64_rust-buf-min-devel.sha256sum] = "ed754e7230d05ec12b92d47156e13cd6a4f3b08ac625a2acb0a88df8f6b8c463"

RDEPENDS:rust-buf-min+bytes-devel = " \
 cargo \
 rust-buf-min-devel \
 rust-bytes+default-devel \
 "
RDEPENDS:rust-buf-min+default-devel = " \
 cargo \
 rust-buf-min-devel \
 "
RDEPENDS:rust-buf-min-devel = " \
 cargo \
 "
