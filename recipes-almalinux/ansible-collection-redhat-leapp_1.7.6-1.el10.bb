# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ansible-collection-redhat-leapp"
PV = "1.7.6"
PR = "1.el10"
PACKAGES = " \
 ansible-collection-redhat-leapp \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ansible-collection-redhat-leapp-1.7.6-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a6f5a37697be86b8d0adace734f4845ba5f710d47df36bad12c0fe0f2bf2d8ec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ansible-collection-redhat-leapp-1.7.6-1.el10.noarch.rpm;name=x86_64_v2_ansible-collection-redhat-leapp;unpack=0"
SRC_URI[x86_64_v2_ansible-collection-redhat-leapp.sha256sum] = "726fec3aa5d2d222f4b562604cbf44b95b324c1ea6a556cb88b1f41fe4ae5e42"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ansible-collection-redhat-leapp-1.7.6-1.el10.noarch.rpm;name=aarch64_ansible-collection-redhat-leapp;unpack=0"
SRC_URI[aarch64_ansible-collection-redhat-leapp.sha256sum] = "726fec3aa5d2d222f4b562604cbf44b95b324c1ea6a556cb88b1f41fe4ae5e42"

RDEPENDS:ansible-collection-redhat-leapp = " \
 ansible-core \
 bash \
 rhel-system-roles \
 "
