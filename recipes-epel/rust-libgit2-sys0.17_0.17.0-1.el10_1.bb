# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libgit2-sys0.17"
PV = "0.17.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-libgit2-sys0.17+default-devel \
 rust-libgit2-sys0.17+https-devel \
 rust-libgit2-sys0.17+libssh2-sys-devel \
 rust-libgit2-sys0.17+openssl-sys-devel \
 rust-libgit2-sys0.17+ssh-devel \
 rust-libgit2-sys0.17+ssh_key_from_memory-devel \
 rust-libgit2-sys0.17+vendored-devel \
 rust-libgit2-sys0.17-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libgit2-sys0.17-0.17.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "314b600af3a866a33ee49514d27af64dfb379b92dbff8ce0e6b8b54d0465850b"

URI_x86_64_v2_rust-libgit2-sys0.17+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys0.17+default-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys0.17+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys0.17+default-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys0.17+default-devel.sha256sum] = "dbc64093968221bd70d4b25f569c3b5e444d8a35b9528cb2591ccfa5a6858532"

URI_x86_64_v2_rust-libgit2-sys0.17+https-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys0.17+https-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys0.17+https-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys0.17+https-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys0.17+https-devel.sha256sum] = "d993d5544a822f9e700a96d34cebbc3b4c1dd5f8bd0e570574df2df43e526ead"

URI_x86_64_v2_rust-libgit2-sys0.17+libssh2-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys0.17+libssh2-sys-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys0.17+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys0.17+libssh2-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys0.17+libssh2-sys-devel.sha256sum] = "377436eea008a62ef838e6b11eff6a7f406f8a8e4dc56a1782bdfb6fac2a5ba1"

URI_x86_64_v2_rust-libgit2-sys0.17+openssl-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys0.17+openssl-sys-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys0.17+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys0.17+openssl-sys-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys0.17+openssl-sys-devel.sha256sum] = "c774979cd84beb9dd8c9b8c010a842dc19d0bcf7908d2214d415f152aed85027"

URI_x86_64_v2_rust-libgit2-sys0.17+ssh-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys0.17+ssh-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys0.17+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys0.17+ssh-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys0.17+ssh-devel.sha256sum] = "4658488b14e168896b7f3b49f67f0bab90db9ca0e971eb341a89e29b10d1129f"

URI_x86_64_v2_rust-libgit2-sys0.17+ssh_key_from_memory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys0.17+ssh_key_from_memory-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys0.17+ssh_key_from_memory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys0.17+ssh_key_from_memory-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys0.17+ssh_key_from_memory-devel.sha256sum] = "7b0ab0608dc3078d7ccbaed701d8f84c35b56709de2b60e7662e3cb2e18c6555"

URI_x86_64_v2_rust-libgit2-sys0.17+vendored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys0.17+vendored-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys0.17+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys0.17+vendored-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys0.17+vendored-devel.sha256sum] = "69a4773c1a8b347b893edb5cd5db3f274afb8af5732d38c7b5a651efdeba11d2"

URI_x86_64_v2_rust-libgit2-sys0.17-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys0.17-devel-0.17.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys0.17-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libgit2-sys0.17-devel}"
SRC_URI[x86_64_v2_rust-libgit2-sys0.17-devel.sha256sum] = "eaf45da83e6323497e701c8218f2d0b41f04b1ce5769001b1828b21ba0294ef2"

URI_aarch64_rust-libgit2-sys0.17+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys0.17+default-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys0.17+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys0.17+default-devel}"
SRC_URI[aarch64_rust-libgit2-sys0.17+default-devel.sha256sum] = "fe297650f78cb564b74077a7b9c7c4895e24f79da1a1782c78dc203424f236fc"

URI_aarch64_rust-libgit2-sys0.17+https-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys0.17+https-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys0.17+https-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys0.17+https-devel}"
SRC_URI[aarch64_rust-libgit2-sys0.17+https-devel.sha256sum] = "df9dd6e9eea0d5aaa5a0f2aaa25e003d011d3e2578b3c531cceb2997689dac16"

URI_aarch64_rust-libgit2-sys0.17+libssh2-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys0.17+libssh2-sys-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys0.17+libssh2-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys0.17+libssh2-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys0.17+libssh2-sys-devel.sha256sum] = "fba4fdef4a682bad7e46bb6ef5de56ab0e315a761d3cce51e30e9afb582b13fd"

URI_aarch64_rust-libgit2-sys0.17+openssl-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys0.17+openssl-sys-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys0.17+openssl-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys0.17+openssl-sys-devel}"
SRC_URI[aarch64_rust-libgit2-sys0.17+openssl-sys-devel.sha256sum] = "23d18d811bdb919af134258c829205c918b9ab3d76d8597441ad3993b5e22ed1"

URI_aarch64_rust-libgit2-sys0.17+ssh-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys0.17+ssh-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys0.17+ssh-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys0.17+ssh-devel}"
SRC_URI[aarch64_rust-libgit2-sys0.17+ssh-devel.sha256sum] = "e39174cd10452986eb1e00dfbd650809d138a4b0bf1dc2e67ffb205d070daf02"

URI_aarch64_rust-libgit2-sys0.17+ssh_key_from_memory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys0.17+ssh_key_from_memory-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys0.17+ssh_key_from_memory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys0.17+ssh_key_from_memory-devel}"
SRC_URI[aarch64_rust-libgit2-sys0.17+ssh_key_from_memory-devel.sha256sum] = "3a6c4c2bf07c1263c9f55c1a092d23473574c83ba77036c09b923c0a41b32c2a"

URI_aarch64_rust-libgit2-sys0.17+vendored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys0.17+vendored-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys0.17+vendored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys0.17+vendored-devel}"
SRC_URI[aarch64_rust-libgit2-sys0.17+vendored-devel.sha256sum] = "7e68e2a9dfcf193784a964418941cff4b183125a9dfaa85b8e053165aa1828bd"

URI_aarch64_rust-libgit2-sys0.17-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys0.17-devel-0.17.0-1.el10_1.noarch.rpm;name=aarch64_rust-libgit2-sys0.17-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libgit2-sys0.17-devel}"
SRC_URI[aarch64_rust-libgit2-sys0.17-devel.sha256sum] = "557a2ae74f7419a8502db8fd52138b6767e9ce8f8767b22dae5a0fbc5d28c073"

RDEPENDS:rust-libgit2-sys0.17+default-devel = " \
 cargo \
 rust-libgit2-sys0.17-devel \
 "
RDEPENDS:rust-libgit2-sys0.17+https-devel = " \
 cargo \
 rust-libgit2-sys0.17+openssl-sys-devel \
 rust-libgit2-sys0.17-devel \
 "
RDEPENDS:rust-libgit2-sys0.17+libssh2-sys-devel = " \
 cargo \
 rust-libgit2-sys0.17-devel \
 rust-libssh2-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys0.17+openssl-sys-devel = " \
 cargo \
 rust-libgit2-sys0.17-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys0.17+ssh-devel = " \
 cargo \
 rust-libgit2-sys0.17+libssh2-sys-devel \
 rust-libgit2-sys0.17-devel \
 "
RDEPENDS:rust-libgit2-sys0.17+ssh_key_from_memory-devel = " \
 cargo \
 rust-libgit2-sys0.17-devel \
 "
RDEPENDS:rust-libgit2-sys0.17+vendored-devel = " \
 cargo \
 rust-libgit2-sys0.17-devel \
 "
RDEPENDS:rust-libgit2-sys0.17-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-pkg-config+default-devel \
 "
