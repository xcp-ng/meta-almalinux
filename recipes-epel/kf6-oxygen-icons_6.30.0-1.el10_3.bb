# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-oxygen-icons"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 oxygen-icon-theme \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-oxygen-icons-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "11da7db295124a7350750f75e938aa285e68f06db7477d833b74856e250af475"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-icon-theme-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-icon-theme;unpack=0"
SRC_URI[x86_64_v2_oxygen-icon-theme.sha256sum] = "f4d73e8a1938bdea1f7e4b2b1ea617605d861259515f165ea1db70f9aa3eaff2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oxygen-icon-theme-6.30.0-1.el10_3.noarch.rpm;name=aarch64_oxygen-icon-theme;unpack=0"
SRC_URI[aarch64_oxygen-icon-theme.sha256sum] = "4b32c765177e4b2e43ca6e1c0c2be38f0c7b358a0f777345da4a728b32dc383b"

RDEPENDS:oxygen-icon-theme = " \
 almalinux-logos \
 bash \
 hicolor-icon-theme \
 "
