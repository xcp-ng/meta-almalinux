# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-uber-atomic"
PV = "1.11.0"
PR = "5.el10_0"
PACKAGES = " \
 golang-uber-atomic-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-uber-atomic-1.11.0-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "885887fd30f2f0039f151de8a1683c687a2e4239ce4b295c47db9fa1a5a0855d"

URI_x86_64_v2_golang-uber-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-uber-atomic-devel-1.11.0-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-uber-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-uber-atomic-devel}"
SRC_URI[x86_64_v2_golang-uber-atomic-devel.sha256sum] = "45a22051290d0324671f9baca0d09c41d3fcb25f5cf936f6f8e0c178dd3e1f05"

URI_aarch64_golang-uber-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-uber-atomic-devel-1.11.0-5.el10_0.noarch.rpm;name=aarch64_golang-uber-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-uber-atomic-devel}"
SRC_URI[aarch64_golang-uber-atomic-devel.sha256sum] = "3a683f2461ec38ed90e9c397e6646991cdfbce19e4bbae6b854ac9f64572eb97"

RDEPENDS:golang-uber-atomic-devel = " \
 go-filesystem \
 "
