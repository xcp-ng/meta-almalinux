# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kgeography"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kgeography \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kgeography-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9318761dcdc07697c76c75c79a612b342d1b58b72bbc693099611f8921975056"

URI_x86_64_v2_kgeography = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kgeography-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kgeography;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kgeography}"
SRC_URI[x86_64_v2_kgeography.sha256sum] = "0517db51ab83302949569558d1c451fe4b357423a211a5ed1182762fa720e936"

URI_aarch64_kgeography = "${EPEL_MIRROR}/aarch64/Packages/k/kgeography-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kgeography;unpack=0"
SRC_URI:append = " ${URI_aarch64_kgeography}"
SRC_URI[aarch64_kgeography.sha256sum] = "c94f733581e6938b8dfc46ce60f5c60f421b79e38ce31785d0a0f76ad4d03700"

RDEPENDS:kgeography = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
