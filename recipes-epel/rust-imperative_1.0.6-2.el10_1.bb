# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imperative"
PV = "1.0.6"
PR = "2.el10_1"
PACKAGES = " \
 rust-imperative+default-devel \
 rust-imperative-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-imperative-1.0.6-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0812c5142a41c65da5c176a32f5a1027a2d08dbec99534262a248e880e2b3901"

URI_x86_64_v2_rust-imperative+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imperative+default-devel-1.0.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imperative+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imperative+default-devel}"
SRC_URI[x86_64_v2_rust-imperative+default-devel.sha256sum] = "830171ff76dbdf17eb5b2631ed11af5bda90d7af5b2e294cf5261e2411a5cc41"

URI_x86_64_v2_rust-imperative-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imperative-devel-1.0.6-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imperative-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-imperative-devel}"
SRC_URI[x86_64_v2_rust-imperative-devel.sha256sum] = "e6cd995e7e3bd2913b3db22912b025cf1d44b1019f000c2240b3e275d3c4312b"

URI_aarch64_rust-imperative+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imperative+default-devel-1.0.6-2.el10_1.noarch.rpm;name=aarch64_rust-imperative+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imperative+default-devel}"
SRC_URI[aarch64_rust-imperative+default-devel.sha256sum] = "2f0dd2c27b527c329c1312f43d339df3ecf75d4b1f6ce7f39128a1f394a10ce0"

URI_aarch64_rust-imperative-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-imperative-devel-1.0.6-2.el10_1.noarch.rpm;name=aarch64_rust-imperative-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-imperative-devel}"
SRC_URI[aarch64_rust-imperative-devel.sha256sum] = "291843be17edb1488013ca661353166793f739034a3877d2b8e8a2412897cdaf"

RDEPENDS:rust-imperative+default-devel = " \
 cargo \
 rust-imperative-devel \
 "
RDEPENDS:rust-imperative-devel = " \
 cargo \
 rust \
 rust-phf+default-devel \
 rust-rust-stemmers+default-devel \
 "
