# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-Find-Rule"
PV = "0.35"
PR = "1.el10_1"
PACKAGES = " \
 perl-File-Find-Rule \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-Find-Rule-0.35-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fc86820e4e80fc1309d07c6ea0c312149869cc990a55d389192105c64758159"

URI_x86_64_v2_perl-File-Find-Rule = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-Find-Rule-0.35-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-Find-Rule;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-Find-Rule}"
SRC_URI[x86_64_v2_perl-File-Find-Rule.sha256sum] = "6fd1126804b38d59ec2560d255a65dfb73b545c15bed07cf737b6e400668bfa5"

URI_aarch64_perl-File-Find-Rule = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-Find-Rule-0.35-1.el10_1.noarch.rpm;name=aarch64_perl-File-Find-Rule;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-Find-Rule}"
SRC_URI[aarch64_perl-File-Find-Rule.sha256sum] = "7667a8c36d4b83b6134eb619760f7062efe9bcb68d4a3ee73fb660de924aa363"

RDEPENDS:perl-File-Find-Rule = " \
 perl-Carp \
 perl-File-Find \
 perl-File-Find-Rule \
 perl-Number-Compare \
 perl-PathTools \
 perl-Text-Glob \
 perl-interpreter \
 perl-libs \
 perl-vars \
 "
