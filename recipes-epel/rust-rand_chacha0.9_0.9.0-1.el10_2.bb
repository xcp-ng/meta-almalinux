# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_chacha0.9"
PV = "0.9.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_chacha0.9+default-devel \
 rust-rand_chacha0.9+os_rng-devel \
 rust-rand_chacha0.9+serde-devel \
 rust-rand_chacha0.9+std-devel \
 rust-rand_chacha0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_chacha0.9-0.9.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "629d8a79b3f0d8e8dea537062855e7352758eb3e3f224cef4b7cd9d2a85da06d"

URI_x86_64_v2_rust-rand_chacha0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.9+default-devel-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.9+default-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.9+default-devel.sha256sum] = "d5b3ea78c821afc73916a6e43a2838d9dcf11d51f0e578876dd1e6d9e7772f52"

URI_x86_64_v2_rust-rand_chacha0.9+os_rng-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.9+os_rng-devel-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.9+os_rng-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.9+os_rng-devel.sha256sum] = "016bc97511abba831819a024ea084843188c8d05c2fe2ee107679abf1967b91b"

URI_x86_64_v2_rust-rand_chacha0.9+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.9+serde-devel-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.9+serde-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.9+serde-devel.sha256sum] = "a270db40326ea74eda2e268449edcada24d9fb712795dd5fbaddacb4ea6ad502"

URI_x86_64_v2_rust-rand_chacha0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.9+std-devel-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.9+std-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.9+std-devel.sha256sum] = "3c173d5a8e9e18a620a38c66c3961da981716836af6dd7fe46444ca9e3229502"

URI_x86_64_v2_rust-rand_chacha0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_chacha0.9-devel-0.9.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_chacha0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_chacha0.9-devel}"
SRC_URI[x86_64_v2_rust-rand_chacha0.9-devel.sha256sum] = "da9636110ab406914096bbafc0340e2f5d4fd1d1247d2b5cc6767f8168e4262b"

URI_aarch64_rust-rand_chacha0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.9+default-devel-0.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_chacha0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.9+default-devel}"
SRC_URI[aarch64_rust-rand_chacha0.9+default-devel.sha256sum] = "57051f93fa40a28b6e3c3bc5b66b7f2493731b3384a8f0eb94d555587694dc4d"

URI_aarch64_rust-rand_chacha0.9+os_rng-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.9+os_rng-devel-0.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_chacha0.9+os_rng-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.9+os_rng-devel}"
SRC_URI[aarch64_rust-rand_chacha0.9+os_rng-devel.sha256sum] = "d5e29c90950873004e3f6695c3ebc806da2afd2323faebe58b1fa78fe3d8be99"

URI_aarch64_rust-rand_chacha0.9+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.9+serde-devel-0.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_chacha0.9+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.9+serde-devel}"
SRC_URI[aarch64_rust-rand_chacha0.9+serde-devel.sha256sum] = "56a85db2145c581a90e0ab20692997bd014f3fadfe8582dcaab2811ad2e99670"

URI_aarch64_rust-rand_chacha0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.9+std-devel-0.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_chacha0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.9+std-devel}"
SRC_URI[aarch64_rust-rand_chacha0.9+std-devel.sha256sum] = "34f65586b2e5cc2b43786f4ccd51f9ca58a9f8ca62beb37ea9bc466683646d2f"

URI_aarch64_rust-rand_chacha0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_chacha0.9-devel-0.9.0-1.el10_2.noarch.rpm;name=aarch64_rust-rand_chacha0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_chacha0.9-devel}"
SRC_URI[aarch64_rust-rand_chacha0.9-devel.sha256sum] = "ca5e71d20a84644fd7b8ff2d3b87d3bcfe31205852880c876226e7740addc911"

RDEPENDS:rust-rand_chacha0.9+default-devel = " \
 cargo \
 rust-rand_chacha0.9+std-devel \
 rust-rand_chacha0.9-devel \
 "
RDEPENDS:rust-rand_chacha0.9+os_rng-devel = " \
 cargo \
 rust-rand_chacha0.9-devel \
 rust-rand_core0.9+os_rng-devel \
 "
RDEPENDS:rust-rand_chacha0.9+serde-devel = " \
 cargo \
 rust-rand_chacha0.9-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand_chacha0.9+std-devel = " \
 cargo \
 rust-ppv-lite86+std-devel \
 rust-rand_chacha0.9-devel \
 rust-rand_core0.9+std-devel \
 "
RDEPENDS:rust-rand_chacha0.9-devel = " \
 cargo \
 rust \
 rust-ppv-lite86+simd-devel \
 rust-ppv-lite86-devel \
 rust-rand_core0.9+default-devel \
 "
