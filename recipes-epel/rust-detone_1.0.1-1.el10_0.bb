# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-detone"
PV = "1.0.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-detone+default-devel \
 rust-detone-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-detone-1.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "37286e587e423d2b898fe55dda1cad2a36e1b50591dee789d9581e7726fd7aaf"

URI_x86_64_v2_rust-detone+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-detone+default-devel-1.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-detone+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-detone+default-devel}"
SRC_URI[x86_64_v2_rust-detone+default-devel.sha256sum] = "ea50535a29a8669af4c117769c6a60a2fc22b2b3497133016190b5533de2d932"

URI_x86_64_v2_rust-detone-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-detone-devel-1.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-detone-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-detone-devel}"
SRC_URI[x86_64_v2_rust-detone-devel.sha256sum] = "cac3ee75c56084e69be5edfd9429610f42724d2c6d0571ffebfadb8ad0e31a63"

URI_aarch64_rust-detone+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-detone+default-devel-1.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-detone+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-detone+default-devel}"
SRC_URI[aarch64_rust-detone+default-devel.sha256sum] = "3f228491a9970dee75fde98f421e10b70d74c95fe52e80e7c7807371f905d2d7"

URI_aarch64_rust-detone-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-detone-devel-1.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-detone-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-detone-devel}"
SRC_URI[aarch64_rust-detone-devel.sha256sum] = "1b7af4d6b919ff7cc48799fe05e0495b112b06cde53d0999f70d8c3c8a901102"

RDEPENDS:rust-detone+default-devel = " \
 cargo \
 rust-detone-devel \
 "
RDEPENDS:rust-detone-devel = " \
 cargo \
 rust \
 "
