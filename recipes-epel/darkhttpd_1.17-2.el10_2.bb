# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "darkhttpd"
PV = "1.17"
PR = "2.el10_2"
PACKAGES = " \
 darkhttpd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/darkhttpd-1.17-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28b3c098a6664ca815f284af1e17b8fb58e178341e5516764a3de8963ba04852"

URI_x86_64_v2_darkhttpd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/darkhttpd-1.17-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_darkhttpd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_darkhttpd}"
SRC_URI[x86_64_v2_darkhttpd.sha256sum] = "1d50b79c28a087068ed1e02129cd0048aed00acd3dede37f0be00a364b988529"

URI_aarch64_darkhttpd = "${EPEL_MIRROR}/aarch64/Packages/d/darkhttpd-1.17-2.el10_2.aarch64.rpm;name=aarch64_darkhttpd;unpack=0"
SRC_URI:append = " ${URI_aarch64_darkhttpd}"
SRC_URI[aarch64_darkhttpd.sha256sum] = "3cf16fe6bef773ea5fce690eae5812e738b9bfc63e1094a612c843f28e08253a"

RDEPENDS:darkhttpd = " \
 bash \
 glibc \
 mailcap \
 "
