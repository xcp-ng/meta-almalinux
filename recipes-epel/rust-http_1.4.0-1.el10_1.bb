# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-http"
PV = "1.4.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-http+default-devel \
 rust-http+std-devel \
 rust-http-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-http-1.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfcfba64687e13050196e50a07f923ff112f1c0695c26552d3e5f0c5146de5b1"

URI_x86_64_v2_rust-http+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+default-devel-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http+default-devel}"
SRC_URI[x86_64_v2_rust-http+default-devel.sha256sum] = "7f62d7d890ca1a9ead1afcfb1e72662ae8ec53022129df3f8c21b63d9ca3090c"

URI_x86_64_v2_rust-http+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http+std-devel-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http+std-devel}"
SRC_URI[x86_64_v2_rust-http+std-devel.sha256sum] = "b718e7f295dfcd25c201e8a59b880f9dc698e77f17193dc167f4bdfdf758b0e6"

URI_x86_64_v2_rust-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-http-devel-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-http-devel}"
SRC_URI[x86_64_v2_rust-http-devel.sha256sum] = "9d1bbafdcc9ea9de761744117a912a6f289a4c6029fe76bf6d1eb9e27e711b82"

URI_aarch64_rust-http+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http+default-devel-1.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-http+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http+default-devel}"
SRC_URI[aarch64_rust-http+default-devel.sha256sum] = "2fc6b5b616c9c3dc4b594cdc3b287b92cfae45b286168788b90abc866fb27024"

URI_aarch64_rust-http+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http+std-devel-1.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-http+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http+std-devel}"
SRC_URI[aarch64_rust-http+std-devel.sha256sum] = "c32e656029d60e746d70a14467fd4a9075e895d15daa71021f239ddbdee6389d"

URI_aarch64_rust-http-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-http-devel-1.4.0-1.el10_1.noarch.rpm;name=aarch64_rust-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-http-devel}"
SRC_URI[aarch64_rust-http-devel.sha256sum] = "db866a196f7b54138dbae6ab26d8a8047585e6aa5d56812cfcef08ddd8031f38"

RDEPENDS:rust-http+default-devel = " \
 cargo \
 rust-http+std-devel \
 rust-http-devel \
 "
RDEPENDS:rust-http+std-devel = " \
 cargo \
 rust-http-devel \
 "
RDEPENDS:rust-http-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-itoa+default-devel \
 "
