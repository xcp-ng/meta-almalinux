# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sdubby"
PV = "1.0"
PR = "12.el10_2"
PACKAGES = " \
 sdubby \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/s/sdubby-1.0-12.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "4dfa79fe85222eac1180473637d31a7f356084c8bf57f6a5e58fd90eeb5258b2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sdubby-1.0-12.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sdubby;unpack=0"
SRC_URI[x86_64_v2_sdubby.sha256sum] = "fa1373b0f0e233730caa36f3e5a987ae7877bba533ee9108856e68e3e62efd16"
RPROVIDES:sdubby:append:x86_64_v2 = " virtual/grubby_or_sdubby"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/s/sdubby-1.0-12.el10_2.noarch.rpm;name=aarch64_sdubby;unpack=0"
SRC_URI[aarch64_sdubby.sha256sum] = "d63059364e54d3d64a1bad8cc03f6305e07c088ec3198f0d1e1c48df9171a151"
RPROVIDES:sdubby:append:aarch64 = " virtual/grubby_or_sdubby"

RDEPENDS:sdubby = " \
 bash \
 findutils \
 gawk \
 systemd-boot-unsigned \
 util-linux \
 virtual/coreutils \
 "
