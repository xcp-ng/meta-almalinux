# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-credential-libsecret"
PV = "0.5.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-cargo-credential-libsecret+default-devel \
 rust-cargo-credential-libsecret-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-credential-libsecret-0.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2bc483286e0512aa58539a693dcd689dd3666d10a354c0ac7014c30958180b25"

URI_x86_64_v2_rust-cargo-credential-libsecret+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret+default-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-libsecret+default-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret+default-devel.sha256sum] = "c74ed48867993493b53d8e74fe7fa4ba4e8a655acbaea12d6fdc1e1ce66997c7"

URI_x86_64_v2_rust-cargo-credential-libsecret-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-credential-libsecret-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cargo-credential-libsecret-devel}"
SRC_URI[x86_64_v2_rust-cargo-credential-libsecret-devel.sha256sum] = "3b5c236cd5e6bf277515145d2ba4777dad252f332a58e872acd61b465d56c20d"

URI_aarch64_rust-cargo-credential-libsecret+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret+default-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-libsecret+default-devel}"
SRC_URI[aarch64_rust-cargo-credential-libsecret+default-devel.sha256sum] = "53588e2902a4b5c34ca83b68dab743c03a807024801e822ecd6deef08324a234"

URI_aarch64_rust-cargo-credential-libsecret-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-credential-libsecret-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-cargo-credential-libsecret-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cargo-credential-libsecret-devel}"
SRC_URI[aarch64_rust-cargo-credential-libsecret-devel.sha256sum] = "7d50d984b7dea2cc351bca851cc83c816af2d13f5e1f79b1e5452ec9864a5358"

RDEPENDS:rust-cargo-credential-libsecret+default-devel = " \
 cargo \
 rust-cargo-credential-libsecret-devel \
 "
RDEPENDS:rust-cargo-credential-libsecret-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-cargo-credential+default-devel \
 rust-libloading+default-devel \
 "
