# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kwindowsystem"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kwindowsystem \
 kf6-kwindowsystem-devel \
 kf6-kwindowsystem-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kwindowsystem-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b0b98d423be243a0abefcb7b403427a1a8de633f5665ced2cb02ac4fe990dca4"

URI_x86_64_v2_kf6-kwindowsystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem}"
SRC_URI[x86_64_v2_kf6-kwindowsystem.sha256sum] = "afd1096443a6beca14a0552f0b0ed4bce57d5af51fda57d23267b2088744309e"

URI_x86_64_v2_kf6-kwindowsystem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kwindowsystem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-devel}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-devel.sha256sum] = "2482b2da63f759fd5998c525ba13c27e3fe4139d66513c0e45486d5a3082e16d"

URI_x86_64_v2_kf6-kwindowsystem-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kwindowsystem-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kwindowsystem-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kwindowsystem-doc}"
SRC_URI[x86_64_v2_kf6-kwindowsystem-doc.sha256sum] = "fb9ed9890538cd86df86bb7e9f8ac84c36d9c8fdab9aa88e9240e4760ad2127d"

URI_aarch64_kf6-kwindowsystem = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kwindowsystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem}"
SRC_URI[aarch64_kf6-kwindowsystem.sha256sum] = "4b4f80479b3dbf1d491a5ff5e6fb2354c184b9c025dfc7fabfd057cabad33b76"

URI_aarch64_kf6-kwindowsystem-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kwindowsystem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-devel}"
SRC_URI[aarch64_kf6-kwindowsystem-devel.sha256sum] = "a286b5bcbb898c77fc73a213b922b155c3fde9974ce38298704dc753c3cf42dc"

URI_aarch64_kf6-kwindowsystem-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kwindowsystem-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kwindowsystem-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kwindowsystem-doc}"
SRC_URI[aarch64_kf6-kwindowsystem-doc.sha256sum] = "d88d437f69956d4ee69e1114d23d542a28f13313f68c4ee34a56bc53f84c08c3"

RDEPENDS:kf6-kwindowsystem = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libXfixes \
 libstdc++ \
 libwayland-client \
 libxcb \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 xcb-util-keysyms \
 "
RDEPENDS:kf6-kwindowsystem-devel = " \
 cmake-filesystem \
 kf6-kwindowsystem \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kwindowsystem-doc = " \
 "
