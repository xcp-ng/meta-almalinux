# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "almalinux-release"
PV = "10.1"
PR = "16.el10"
PACKAGES = " \
 almalinux-gpg-keys \
 almalinux-release \
 almalinux-repos \
 almalinux-sb-certs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/almalinux-release-10.1-16.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1629f9a3e5f54d0b9958972cd41130fb8bb76c02ff65f52e57b1c03736d4b25"

URI_x86_64_v2_almalinux-gpg-keys = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/almalinux-gpg-keys-10.1-16.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-gpg-keys}"
SRC_URI[x86_64_v2_almalinux-gpg-keys.sha256sum] = "c0da87de23eabc3edc9704b7d3319ef046562f8994a4ef5750e61673b4fdc796"

URI_x86_64_v2_almalinux-release = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/almalinux-release-10.1-16.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-release;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-release}"
SRC_URI[x86_64_v2_almalinux-release.sha256sum] = "2f788fe84ca320be57b8d388dcdb53697781dc4dc2bd319fb61005f25ae2e1be"

URI_x86_64_v2_almalinux-repos = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/almalinux-repos-10.1-16.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-repos;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-repos}"
SRC_URI[x86_64_v2_almalinux-repos.sha256sum] = "642dd545c1db11d7b6ce45e4aac2efaed3e26fc7905f3e1855d9f1d621d18eae"

URI_x86_64_v2_almalinux-sb-certs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/almalinux-sb-certs-10.1-16.el10.x86_64_v2.rpm;name=x86_64_v2_almalinux-sb-certs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_almalinux-sb-certs}"
SRC_URI[x86_64_v2_almalinux-sb-certs.sha256sum] = "317dd8d57e1a24ec7993b1267747a272b14899e72420bac5c590dea1d3e4f341"

URI_aarch64_almalinux-gpg-keys = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/almalinux-gpg-keys-10.1-16.el10.aarch64.rpm;name=aarch64_almalinux-gpg-keys;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-gpg-keys}"
SRC_URI[aarch64_almalinux-gpg-keys.sha256sum] = "5594c2a97b76ca33b18cbf4d0f92add632d82eeba516846ed286d9eb0c4a8888"

URI_aarch64_almalinux-release = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/almalinux-release-10.1-16.el10.aarch64.rpm;name=aarch64_almalinux-release;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-release}"
SRC_URI[aarch64_almalinux-release.sha256sum] = "c5fb05712fb1a728507b3af0943a3cd30dc3a827cb877e465bce775e3decbefc"

URI_aarch64_almalinux-repos = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/almalinux-repos-10.1-16.el10.aarch64.rpm;name=aarch64_almalinux-repos;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-repos}"
SRC_URI[aarch64_almalinux-repos.sha256sum] = "af8f337d273236b1055fb1f5be218880c7e50dfc7aa188a9087ce6b67a083189"

URI_aarch64_almalinux-sb-certs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/almalinux-sb-certs-10.1-16.el10.aarch64.rpm;name=aarch64_almalinux-sb-certs;unpack=0"
SRC_URI:append = " ${URI_aarch64_almalinux-sb-certs}"
SRC_URI[aarch64_almalinux-sb-certs.sha256sum] = "8aaced7abb08cfaed8c85c1fbb449b134a5bd5a4c4a5bc6b3603d42a4573cff5"

RDEPENDS:almalinux-gpg-keys = " \
 "
RDEPENDS:almalinux-release = " \
 almalinux-repos \
 "
RDEPENDS:almalinux-repos = " \
 almalinux-gpg-keys \
 almalinux-release \
 "
RDEPENDS:almalinux-sb-certs = " \
 "
