# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fedrq"
PV = "1.7.0"
PR = "1.el10_3"
PACKAGES = " \
 fedrq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fedrq-1.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4b80c05e352e3985a0e93a018c7337eba990ec0a73c2298dd8e2842e9f14d7e0"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - fedrq: (python3-libdnf5 >= 5.2.0 if python3-libdnf5)

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - fedrq: (python3-libdnf5 >= 5.2.0 if python3-libdnf5)

URI_x86_64_v2_fedrq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fedrq-1.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_fedrq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_fedrq}"
SRC_URI[x86_64_v2_fedrq.sha256sum] = "c1c79bfaacf9368105a58c49f74ba5cba19c25d104297f51883373430f44c621"

URI_aarch64_fedrq = "${EPEL_MIRROR}/aarch64/Packages/f/fedrq-1.7.0-1.el10_3.noarch.rpm;name=aarch64_fedrq;unpack=0"
SRC_URI:append = " ${URI_aarch64_fedrq}"
SRC_URI[aarch64_fedrq.sha256sum] = "f9365b5cc1eefef13f4c615c43658de64546da4dac08655b8a6910d7d07f60f5"

RDEPENDS:fedrq = " \
 distribution-gpg-keys \
 python3 \
 python3-dnf \
 python3-pydantic \
 python3-requests \
 python3-rpm \
 python3-typing-extensions \
 "
