# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fragile"
PV = "2.0.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-fragile+default-devel \
 rust-fragile+slab-devel \
 rust-fragile-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fragile-2.0.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80805e794cb56e72f2655febdca9b930b2aeda4dabe8a3ae649f9c79446d45b1"

URI_x86_64_v2_rust-fragile+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+default-devel-2.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fragile+default-devel}"
SRC_URI[x86_64_v2_rust-fragile+default-devel.sha256sum] = "924c40baab49b5d39dfd2de35cfb3a859e3147afef8b5be34fbd72bf121d9180"

URI_x86_64_v2_rust-fragile+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile+slab-devel-2.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fragile+slab-devel}"
SRC_URI[x86_64_v2_rust-fragile+slab-devel.sha256sum] = "462ce4d50baea6d531de56bbd44d70ed3e6019594595f7991c0d76d08624e03e"

URI_x86_64_v2_rust-fragile-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fragile-devel-2.0.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fragile-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fragile-devel}"
SRC_URI[x86_64_v2_rust-fragile-devel.sha256sum] = "1b81c3971498c2839784a4f9089e76ab948683bab7059424ff240d9d28f440f2"

URI_aarch64_rust-fragile+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+default-devel-2.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-fragile+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fragile+default-devel}"
SRC_URI[aarch64_rust-fragile+default-devel.sha256sum] = "37866d4489785e973d4aa3231f09ad541884c00129f20975cf6502e4393c0ae9"

URI_aarch64_rust-fragile+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile+slab-devel-2.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-fragile+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fragile+slab-devel}"
SRC_URI[aarch64_rust-fragile+slab-devel.sha256sum] = "a89508630f78c7a38e6f73f6a83d8307fa14f56ec63d82e9f30051f3c6f19169"

URI_aarch64_rust-fragile-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fragile-devel-2.0.1-1.el10_0.noarch.rpm;name=aarch64_rust-fragile-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fragile-devel}"
SRC_URI[aarch64_rust-fragile-devel.sha256sum] = "0af8f283beb5109b6e7d052edd8aa57e1f8d35fae405971929a5f50d30a0c45f"

RDEPENDS:rust-fragile+default-devel = " \
 cargo \
 rust-fragile-devel \
 "
RDEPENDS:rust-fragile+slab-devel = " \
 cargo \
 rust-fragile-devel \
 rust-slab+default-devel \
 "
RDEPENDS:rust-fragile-devel = " \
 cargo \
 "
