# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "chrony"
PV = "4.6.1"
PR = "2.el10"
PACKAGES = " \
 chrony \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/chrony-4.6.1-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a5c1a001b95d5ff2710fe148686870a29828eb72e00bf70bc956664e4536fc77"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/chrony-4.6.1-2.el10.x86_64_v2.rpm;name=x86_64_v2_chrony;unpack=0"
SRC_URI[x86_64_v2_chrony.sha256sum] = "e7b5f8f5697cef9287a19c53cfd24f1ba11a700691c9df0ea6d6a7b63a80e466"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/chrony-4.6.1-2.el10.aarch64.rpm;name=aarch64_chrony;unpack=0"
SRC_URI[aarch64_chrony.sha256sum] = "4fe8b3c9d992ae3951b0a8c5e2c3d2f0c9d3873eb72f779f865ef180ae6fd233"

RDEPENDS:chrony = " \
 bash \
 glibc \
 gnutls \
 libcap \
 libedit \
 libseccomp \
 shadow-utils \
 systemd \
 tzdata \
 "
