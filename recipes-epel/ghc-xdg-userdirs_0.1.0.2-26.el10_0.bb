# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-xdg-userdirs"
PV = "0.1.0.2"
PR = "26.el10_0"
PACKAGES = " \
 ghc-xdg-userdirs \
 ghc-xdg-userdirs-devel \
 ghc-xdg-userdirs-doc \
 ghc-xdg-userdirs-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-xdg-userdirs-0.1.0.2-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a3de89760722701c95ecef690d89d7190ee35f742bfddbc773e0217f176de650"

URI_x86_64_v2_ghc-xdg-userdirs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xdg-userdirs-0.1.0.2-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xdg-userdirs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xdg-userdirs}"
SRC_URI[x86_64_v2_ghc-xdg-userdirs.sha256sum] = "c647f4a99b4c4a3ece01559e15406a7b056386186bed58f63d489b2dba9a3a6e"

URI_x86_64_v2_ghc-xdg-userdirs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xdg-userdirs-devel-0.1.0.2-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xdg-userdirs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xdg-userdirs-devel}"
SRC_URI[x86_64_v2_ghc-xdg-userdirs-devel.sha256sum] = "d1b70f038f7475745c399b2c679b2fdd9cf3372fe17e68b15ac0937f9aa83614"

URI_x86_64_v2_ghc-xdg-userdirs-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xdg-userdirs-doc-0.1.0.2-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-xdg-userdirs-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xdg-userdirs-doc}"
SRC_URI[x86_64_v2_ghc-xdg-userdirs-doc.sha256sum] = "682ca317e643ea77bf048cc4fde6498647f265e2f4c1370960d9496eb6e78a1f"

URI_x86_64_v2_ghc-xdg-userdirs-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xdg-userdirs-prof-0.1.0.2-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xdg-userdirs-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xdg-userdirs-prof}"
SRC_URI[x86_64_v2_ghc-xdg-userdirs-prof.sha256sum] = "8e683c0a3d59e8f5aa8b14fe7bcd3465541277d3e74a673001151377d930fc6d"

URI_aarch64_ghc-xdg-userdirs = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xdg-userdirs-0.1.0.2-26.el10_0.aarch64.rpm;name=aarch64_ghc-xdg-userdirs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xdg-userdirs}"
SRC_URI[aarch64_ghc-xdg-userdirs.sha256sum] = "baade161ef23b71df2d524680d2d9988a48f1250129a7dc79727b0b4abd82cf8"

URI_aarch64_ghc-xdg-userdirs-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xdg-userdirs-devel-0.1.0.2-26.el10_0.aarch64.rpm;name=aarch64_ghc-xdg-userdirs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xdg-userdirs-devel}"
SRC_URI[aarch64_ghc-xdg-userdirs-devel.sha256sum] = "8d65782a50d48a0aa9ea4e6799ebf02b348e7cd7268e674424adf6123d724548"

URI_aarch64_ghc-xdg-userdirs-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xdg-userdirs-doc-0.1.0.2-26.el10_0.noarch.rpm;name=aarch64_ghc-xdg-userdirs-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xdg-userdirs-doc}"
SRC_URI[aarch64_ghc-xdg-userdirs-doc.sha256sum] = "5677bebba6e379c2b36883e4a4a622626592a0ad71af6b20505daae5377cd5e5"

URI_aarch64_ghc-xdg-userdirs-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xdg-userdirs-prof-0.1.0.2-26.el10_0.aarch64.rpm;name=aarch64_ghc-xdg-userdirs-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xdg-userdirs-prof}"
SRC_URI[aarch64_ghc-xdg-userdirs-prof.sha256sum] = "8827ac0725b409a452a6187b3b31bbddd4d7554f3b3e7d1b06c4521493bf318b"

RDEPENDS:ghc-xdg-userdirs = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 ghc-xdg-basedir \
 glibc \
 gmp \
 "
RDEPENDS:ghc-xdg-userdirs-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-directory-devel \
 ghc-filepath-devel \
 ghc-xdg-basedir-devel \
 ghc-xdg-userdirs \
 "
RDEPENDS:ghc-xdg-userdirs-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-xdg-userdirs-prof = " \
 ghc-base-prof \
 ghc-containers-prof \
 ghc-directory-prof \
 ghc-filepath-prof \
 ghc-xdg-basedir-prof \
 ghc-xdg-userdirs-devel \
 "
