# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pulldown-cmark"
PV = "0.13.4"
PR = "1.el10_2"
PACKAGES = " \
 pulldown-cmark \
 rust-pulldown-cmark+default-devel \
 rust-pulldown-cmark+gen-tests-devel \
 rust-pulldown-cmark+getopts-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark+pulldown-cmark-escape-devel \
 rust-pulldown-cmark+serde-devel \
 rust-pulldown-cmark+simd-devel \
 rust-pulldown-cmark-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pulldown-cmark-0.13.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4e43219d2b2f5200a51f4605ace9043f0465694a2ab3dd513910ff55ce0c953"

URI_x86_64_v2_pulldown-cmark = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulldown-cmark-0.13.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pulldown-cmark;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulldown-cmark}"
SRC_URI[x86_64_v2_pulldown-cmark.sha256sum] = "f1d58ee0ec57969c05b8cef61a3091628cd0c7ffc2856802d65ce28ebd3fda92"

URI_x86_64_v2_rust-pulldown-cmark+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+default-devel-0.13.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+default-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+default-devel.sha256sum] = "8654eebe36b11317fba4ed15027c170b8f5d7b7eb3c7c8e1ae1c1d3788cdddb3"

URI_x86_64_v2_rust-pulldown-cmark+gen-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+gen-tests-devel-0.13.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+gen-tests-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+gen-tests-devel.sha256sum] = "bedb0a381116d4f79aaca2d1f70de11a79067cb175418923b9c69da9c659e4db"

URI_x86_64_v2_rust-pulldown-cmark+getopts-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+getopts-devel-0.13.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+getopts-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+getopts-devel.sha256sum] = "8d082b1090d05fef8d2d8d35984e6692e053ca51702bb40d7cc68fd80ed89459"

URI_x86_64_v2_rust-pulldown-cmark+html-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+html-devel-0.13.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+html-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+html-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+html-devel.sha256sum] = "bfd3e2efa12b36a26efa92b99512399e5b024e9dbb448b1dbe8b9edfe5fc7d99"

URI_x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+pulldown-cmark-escape-devel-0.13.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+pulldown-cmark-escape-devel.sha256sum] = "b7f68f06face8d349ac9df3f925e1e964d234f7b1f4c01f579f87498b9d9493b"

URI_x86_64_v2_rust-pulldown-cmark+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+serde-devel-0.13.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+serde-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+serde-devel.sha256sum] = "efe101340b5a7f5db595bbe76cbdf8f68991a8eb0c1840b5bc8fab4db6aa420e"

URI_x86_64_v2_rust-pulldown-cmark+simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark+simd-devel-0.13.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark+simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark+simd-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark+simd-devel.sha256sum] = "bd588f1ab1e480af77614a870f1289b61b0f34fd9301b6f3d1f3b5d5a438c40c"

URI_x86_64_v2_rust-pulldown-cmark-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pulldown-cmark-devel-0.13.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pulldown-cmark-devel}"
SRC_URI[x86_64_v2_rust-pulldown-cmark-devel.sha256sum] = "92146e075e082e2013a423ab31ae57c1f34061db30e0f8aed51def7c228f2087"

URI_aarch64_pulldown-cmark = "${EPEL_MIRROR}/aarch64/Packages/p/pulldown-cmark-0.13.4-1.el10_2.aarch64.rpm;name=aarch64_pulldown-cmark;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulldown-cmark}"
SRC_URI[aarch64_pulldown-cmark.sha256sum] = "b9b1266e1d8e2b2b97f22cc8ef80aec8a9c18e3197bb8f981183b402604c9aaa"

URI_aarch64_rust-pulldown-cmark+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+default-devel-0.13.4-1.el10_2.noarch.rpm;name=aarch64_rust-pulldown-cmark+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+default-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+default-devel.sha256sum] = "f0aa7080e894495728a55cdac797230f3b379dacbfb37e4ae9e2c2d0179858ac"

URI_aarch64_rust-pulldown-cmark+gen-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+gen-tests-devel-0.13.4-1.el10_2.noarch.rpm;name=aarch64_rust-pulldown-cmark+gen-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+gen-tests-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+gen-tests-devel.sha256sum] = "c4af86b4a6eae3c1e12514679f2740e68f894b50da09da438bf391265c44cf6a"

URI_aarch64_rust-pulldown-cmark+getopts-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+getopts-devel-0.13.4-1.el10_2.noarch.rpm;name=aarch64_rust-pulldown-cmark+getopts-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+getopts-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+getopts-devel.sha256sum] = "c5808140394e7de69d2f5f9249008692098dff78416c8ae7b2d05437840cfb2a"

URI_aarch64_rust-pulldown-cmark+html-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+html-devel-0.13.4-1.el10_2.noarch.rpm;name=aarch64_rust-pulldown-cmark+html-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+html-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+html-devel.sha256sum] = "e0ef79ad482bab28adc58e64e85739bd0a8165bf98da13be4444ed2eb63a42e7"

URI_aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+pulldown-cmark-escape-devel-0.13.4-1.el10_2.noarch.rpm;name=aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+pulldown-cmark-escape-devel.sha256sum] = "b8c7856a0658ee19ab954ddbc382f99cd20bd9645fa203ba30d9e8d77eee3adb"

URI_aarch64_rust-pulldown-cmark+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+serde-devel-0.13.4-1.el10_2.noarch.rpm;name=aarch64_rust-pulldown-cmark+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+serde-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+serde-devel.sha256sum] = "56508b4e058ec7ea058a1ca19769e220d224ad878f30044f29bc34e25044e384"

URI_aarch64_rust-pulldown-cmark+simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark+simd-devel-0.13.4-1.el10_2.noarch.rpm;name=aarch64_rust-pulldown-cmark+simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark+simd-devel}"
SRC_URI[aarch64_rust-pulldown-cmark+simd-devel.sha256sum] = "1c5a0da6eb57bd81b8c47843a90437bbe3d76242eb2ef35f273c93058c2761ee"

URI_aarch64_rust-pulldown-cmark-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pulldown-cmark-devel-0.13.4-1.el10_2.noarch.rpm;name=aarch64_rust-pulldown-cmark-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pulldown-cmark-devel}"
SRC_URI[aarch64_rust-pulldown-cmark-devel.sha256sum] = "d39fa36018398508156fba2861dc7bf3c36d246eac2f0be0583f90d9a597e7d6"

RDEPENDS:pulldown-cmark = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-pulldown-cmark+default-devel = " \
 cargo \
 rust-pulldown-cmark+getopts-devel \
 rust-pulldown-cmark+html-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+gen-tests-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+getopts-devel = " \
 cargo \
 rust-getopts+default-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+html-devel = " \
 cargo \
 rust-pulldown-cmark+pulldown-cmark-escape-devel \
 rust-pulldown-cmark-devel \
 "
RDEPENDS:rust-pulldown-cmark+pulldown-cmark-escape-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-pulldown-cmark-escape+default-devel \
 "
RDEPENDS:rust-pulldown-cmark+serde-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-pulldown-cmark+simd-devel = " \
 cargo \
 rust-pulldown-cmark-devel \
 rust-pulldown-cmark-escape+default-devel \
 rust-pulldown-cmark-escape+simd-devel \
 "
RDEPENDS:rust-pulldown-cmark-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-memchr+default-devel \
 rust-unicase+default-devel \
 "
