# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtimageformats"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtimageformats \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/q/qt5-qtimageformats-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa0ff74064606b696f2a68d8a923c43ff9c7cfafe0bf4c36d25fa4725bdb8c64"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtimageformats-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtimageformats;unpack=0"
SRC_URI[x86_64_v2_qt5-qtimageformats.sha256sum] = "a557058ce71edebb0e58cd9448c9896f7b6559a676ee35e08c840d47ff9900ea"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtimageformats-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtimageformats;unpack=0"
SRC_URI[aarch64_qt5-qtimageformats.sha256sum] = "85405c788a57454183eeaa940f605cf96ea9a52d7901bf7da716e95923269859"

RDEPENDS:qt5-qtimageformats = " \
 glibc \
 jasper-libs \
 libmng \
 libstdc++ \
 libtiff \
 libwebp \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
