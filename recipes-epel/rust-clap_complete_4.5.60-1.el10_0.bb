# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-clap_complete"
PV = "4.5.60"
PR = "1.el10_0"
PACKAGES = " \
 rust-clap_complete+debug-devel \
 rust-clap_complete+default-devel \
 rust-clap_complete+unstable-doc-devel \
 rust-clap_complete+unstable-dynamic-devel \
 rust-clap_complete-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-clap_complete-4.5.60-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cc5fc2704503259fe9ee6593cba704567b936081f1c23cd9ae8520ad26b0b353"

URI_x86_64_v2_rust-clap_complete+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+debug-devel-4.5.60-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+debug-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+debug-devel.sha256sum] = "f5c28f940d40f8eb1087cb1567074f84903b8a6ed343e1b94b5a787721cc293e"

URI_x86_64_v2_rust-clap_complete+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+default-devel-4.5.60-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+default-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+default-devel.sha256sum] = "e6b05e7cb0b8744622f91238dcbb7a5988b9451d1afbdc75c339145fdcfc0fa8"

URI_x86_64_v2_rust-clap_complete+unstable-doc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+unstable-doc-devel-4.5.60-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+unstable-doc-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+unstable-doc-devel.sha256sum] = "d98fb073d6482be2b75604f7db31ee0c2746453e70a876e496a8ecdf6fa5efbf"

URI_x86_64_v2_rust-clap_complete+unstable-dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete+unstable-dynamic-devel-4.5.60-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete+unstable-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete+unstable-dynamic-devel}"
SRC_URI[x86_64_v2_rust-clap_complete+unstable-dynamic-devel.sha256sum] = "0fd94ef1a6dc6564add2f86ecae55fdc6b805b966ff20b4338d9626029135176"

URI_x86_64_v2_rust-clap_complete-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-clap_complete-devel-4.5.60-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-clap_complete-devel}"
SRC_URI[x86_64_v2_rust-clap_complete-devel.sha256sum] = "dc0b50f43e23d9ec04af3aa402acb1c61d1ff67e7aa2c5d0e41c6a4a6a375e6a"

URI_aarch64_rust-clap_complete+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+debug-devel-4.5.60-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+debug-devel}"
SRC_URI[aarch64_rust-clap_complete+debug-devel.sha256sum] = "3b9f7ac39d9a3cb4bdd83d1d517903c628be51c2ce5d24f5a253d2697edb8573"

URI_aarch64_rust-clap_complete+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+default-devel-4.5.60-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+default-devel}"
SRC_URI[aarch64_rust-clap_complete+default-devel.sha256sum] = "e8916ab191698f34669de69d5602cfe46c3f5521c8e4c06d2bfc5891dfdbb8e3"

URI_aarch64_rust-clap_complete+unstable-doc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+unstable-doc-devel-4.5.60-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete+unstable-doc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+unstable-doc-devel}"
SRC_URI[aarch64_rust-clap_complete+unstable-doc-devel.sha256sum] = "5d39c508971d4291c673e65516a3586baad3de617cf51c11cad7776bbc64d95e"

URI_aarch64_rust-clap_complete+unstable-dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete+unstable-dynamic-devel-4.5.60-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete+unstable-dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete+unstable-dynamic-devel}"
SRC_URI[aarch64_rust-clap_complete+unstable-dynamic-devel.sha256sum] = "57fb9490288edd71923dbd5e9219077bd61dffa026771ce019513843e35fc215"

URI_aarch64_rust-clap_complete-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-clap_complete-devel-4.5.60-1.el10_0.noarch.rpm;name=aarch64_rust-clap_complete-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-clap_complete-devel}"
SRC_URI[aarch64_rust-clap_complete-devel.sha256sum] = "75d14ae6080481d49ea8575be80437329c2ab1993905bd0a34a3f171c4ce1345"

RDEPENDS:rust-clap_complete+debug-devel = " \
 cargo \
 rust-clap+debug-devel \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+default-devel = " \
 cargo \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+unstable-doc-devel = " \
 cargo \
 rust-clap_complete+unstable-dynamic-devel \
 rust-clap_complete-devel \
 "
RDEPENDS:rust-clap_complete+unstable-dynamic-devel = " \
 cargo \
 rust-clap+unstable-ext-devel \
 rust-clap_complete-devel \
 rust-clap_lex+default-devel \
 rust-is_executable+default-devel \
 rust-shlex+default-devel \
 "
RDEPENDS:rust-clap_complete-devel = " \
 cargo \
 rust \
 rust-clap+std-devel \
 rust-clap-devel \
 "
