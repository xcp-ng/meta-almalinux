# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipv6calc"
PV = "4.4.0"
PR = "1.el10_2"
PACKAGES = " \
 ipv6calc \
 ipv6calc-ipv6calcweb \
 ipv6calc-mod_ipv6calc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ipv6calc-4.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b74286c5be0eca0a9ef50257907d7e6675dac255e3c35f8f976a58178f784785"

URI_x86_64_v2_ipv6calc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ipv6calc-4.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ipv6calc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipv6calc}"
SRC_URI[x86_64_v2_ipv6calc.sha256sum] = "98589d2da3ece3133027e26a3949e835e78c526a0593d3d21a44e1df7aefa497"

URI_x86_64_v2_ipv6calc-ipv6calcweb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ipv6calc-ipv6calcweb-4.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ipv6calc-ipv6calcweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipv6calc-ipv6calcweb}"
SRC_URI[x86_64_v2_ipv6calc-ipv6calcweb.sha256sum] = "9e89929393e18425761b7301ed5aa54fcb5d2498fd73531b6c6bba58b5e0fb90"

URI_x86_64_v2_ipv6calc-mod_ipv6calc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ipv6calc-mod_ipv6calc-4.4.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ipv6calc-mod_ipv6calc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipv6calc-mod_ipv6calc}"
SRC_URI[x86_64_v2_ipv6calc-mod_ipv6calc.sha256sum] = "26ff7ecf24ccaefd4061cfefd89abe1d3288508eff337b08352ac8fbf140ca02"

URI_aarch64_ipv6calc = "${EPEL_MIRROR}/aarch64/Packages/i/ipv6calc-4.4.0-1.el10_2.aarch64.rpm;name=aarch64_ipv6calc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipv6calc}"
SRC_URI[aarch64_ipv6calc.sha256sum] = "f92df91c204d18504b1cf87383b7d614dfdfce15894c85b49109c282c5478f8a"

URI_aarch64_ipv6calc-ipv6calcweb = "${EPEL_MIRROR}/aarch64/Packages/i/ipv6calc-ipv6calcweb-4.4.0-1.el10_2.aarch64.rpm;name=aarch64_ipv6calc-ipv6calcweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipv6calc-ipv6calcweb}"
SRC_URI[aarch64_ipv6calc-ipv6calcweb.sha256sum] = "39ea46eb77aaa71ecabc10612207f524ebb72c57ee1956bab090dd499d3c7c89"

URI_aarch64_ipv6calc-mod_ipv6calc = "${EPEL_MIRROR}/aarch64/Packages/i/ipv6calc-mod_ipv6calc-4.4.0-1.el10_2.aarch64.rpm;name=aarch64_ipv6calc-mod_ipv6calc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipv6calc-mod_ipv6calc}"
SRC_URI[aarch64_ipv6calc-mod_ipv6calc.sha256sum] = "848a0dfbaf912c188fdec252a925ad5898b63d0735cfcc51611b3a9e8bb487ac"

RDEPENDS:ipv6calc = " \
 bash \
 glibc \
 libdb \
 openssl-libs \
 perl-BerkeleyDB \
 perl-Getopt-Std \
 perl-IPC-Open3 \
 perl-Math-BigInt \
 perl-Net-IP \
 perl-POSIX \
 perl-XML-Simple \
 perl-interpreter \
 perl-libs \
 unzip \
 "
RDEPENDS:ipv6calc-ipv6calcweb = " \
 httpd \
 ipv6calc \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Digest-SHA1 \
 perl-HTML-Parser \
 perl-POSIX \
 perl-URI \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:ipv6calc-mod_ipv6calc = " \
 glibc \
 httpd \
 ipv6calc \
 libdb \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 "
