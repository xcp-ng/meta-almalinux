# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ref-cast"
PV = "1.0.25"
PR = "1.el10_1"
PACKAGES = " \
 rust-ref-cast+default-devel \
 rust-ref-cast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ref-cast-1.0.25-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "84f6a3342a1c43b7bbbcc4b852c27b84df1b81b2305e561c5280ee22bc7c626d"

URI_x86_64_v2_rust-ref-cast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast+default-devel-1.0.25-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast+default-devel}"
SRC_URI[x86_64_v2_rust-ref-cast+default-devel.sha256sum] = "fe48dd4dba9a334d90b02c9a44d0f6cead10c8d4a3d5a2093d15360560ffc552"

URI_x86_64_v2_rust-ref-cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ref-cast-devel-1.0.25-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ref-cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ref-cast-devel}"
SRC_URI[x86_64_v2_rust-ref-cast-devel.sha256sum] = "5c8119f8d53114569d9d10f07d414331bda4857744d92fc270213867db1db5db"

URI_aarch64_rust-ref-cast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast+default-devel-1.0.25-1.el10_1.noarch.rpm;name=aarch64_rust-ref-cast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast+default-devel}"
SRC_URI[aarch64_rust-ref-cast+default-devel.sha256sum] = "4fdaa93d8cc08f33b395377b09edab655846a4304bf6125a76b86ab5cda1ea21"

URI_aarch64_rust-ref-cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ref-cast-devel-1.0.25-1.el10_1.noarch.rpm;name=aarch64_rust-ref-cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ref-cast-devel}"
SRC_URI[aarch64_rust-ref-cast-devel.sha256sum] = "632ec2a26a5c2abc4f753d5414295919efbdb574ccb86b169df66c78eef00e55"

RDEPENDS:rust-ref-cast+default-devel = " \
 cargo \
 rust-ref-cast-devel \
 "
RDEPENDS:rust-ref-cast-devel = " \
 cargo \
 rust \
 rust-ref-cast-impl+default-devel \
 "
