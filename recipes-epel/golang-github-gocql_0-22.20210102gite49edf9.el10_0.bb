# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-gocql"
PV = "0"
PR = "22.20210102gite49edf9.el10_0"
PACKAGES = " \
 golang-github-gocql-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-gocql-0-22.20210102gite49edf9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "402d44a0b44aadb617b25f9b3a92bb059165868f61a06a21b74ab1f9766305d8"

URI_aarch64_golang-github-gocql-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-gocql-devel-0-22.20210102gite49edf9.el10_0.noarch.rpm;name=aarch64_golang-github-gocql-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-gocql-devel}"
SRC_URI[aarch64_golang-github-gocql-devel.sha256sum] = "73fb7bc78e91f65f63173c65fba8f76e10105b43ce41aa110014ed71a7b12a33"

RDEPENDS:golang-github-gocql-devel = " \
 go-filesystem \
 golang-github-hailocab-hostpool-devel \
 golang-github-snappy-devel \
 golang-gopkg-inf-0-devel \
 "
