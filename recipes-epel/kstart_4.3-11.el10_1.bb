# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kstart"
PV = "4.3"
PR = "11.el10_1"
PACKAGES = " \
 kstart \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kstart-4.3-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b56525dc64ded9ee68e2cabb6862523ab6419affdac628e567e80d59d4a203e5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kstart-4.3-11.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kstart;unpack=0"
SRC_URI[x86_64_v2_kstart.sha256sum] = "a1f6da3c91d0a26af981ccbde3aa92ea516f6992b0f2558011a8d5192c8f7a0e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kstart-4.3-11.el10_1.aarch64.rpm;name=aarch64_kstart;unpack=0"
SRC_URI[aarch64_kstart.sha256sum] = "f44ae6464f957ec016f7b180977125d1c7e57e0b64a640e5ac7db47f19893c97"

RDEPENDS:kstart = " \
 bash \
 glibc \
 keyutils-libs \
 krb5-libs \
 "
