# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtdoc"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtdoc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtdoc-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94c0ecbc71f206c32b142fccdfa1aed7f997e6f5331e57b2e55ad9cb46f82900"

URI_x86_64_v2_qt5-qtdoc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtdoc-5.15.18-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_qt5-qtdoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtdoc}"
SRC_URI[x86_64_v2_qt5-qtdoc.sha256sum] = "76503c2837aa065c066fb313559a66fb8a52f1bad00b2e4f64fde1a0932610bf"

URI_aarch64_qt5-qtdoc = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtdoc-5.15.18-1.el10_2.noarch.rpm;name=aarch64_qt5-qtdoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtdoc}"
SRC_URI[aarch64_qt5-qtdoc.sha256sum] = "610ff6e5ca7ce90f0e2ae4fe59fae11bc14979c73708c148a4432cd5be9cfc99"

RDEPENDS:qt5-qtdoc = " \
 "
