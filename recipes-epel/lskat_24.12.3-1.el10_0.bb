# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lskat"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 lskat \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/lskat-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d5be9d9f9a5040b228112c32193c0818b217dd3170b9781936314b29c27a2dd8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lskat-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lskat;unpack=0"
SRC_URI[x86_64_v2_lskat.sha256sum] = "a631a272ed86133ea85a144d266bf3568cecd125637ae3b0a31ddc34bb2b4371"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/lskat-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_lskat;unpack=0"
SRC_URI[aarch64_lskat.sha256sum] = "6d9a90572cd5f9ad0e3631e0091be85e4ffe48f9247f0fc388e4a38a1212a83c"

RDEPENDS:lskat = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
