# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "phpMyAdmin"
PV = "5.2.3"
PR = "1.el10_1"
PACKAGES = " \
 phpMyAdmin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/phpMyAdmin-5.2.3-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ce1b25f2a57143106404ebc18f0239bd4ab80456c5aa13d77e37f3c702b7837"

URI_x86_64_v2_phpMyAdmin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phpMyAdmin-5.2.3-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_phpMyAdmin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_phpMyAdmin}"
SRC_URI[x86_64_v2_phpMyAdmin.sha256sum] = "a4e9ce1c42aee5e923d7c8784c94642fa7c57c8a008028a57d0ff0189c8fc2a0"

URI_aarch64_phpMyAdmin = "${EPEL_MIRROR}/aarch64/Packages/p/phpMyAdmin-5.2.3-1.el10_1.noarch.rpm;name=aarch64_phpMyAdmin;unpack=0"
SRC_URI:append = " ${URI_aarch64_phpMyAdmin}"
SRC_URI[aarch64_phpMyAdmin.sha256sum] = "9d8a79ab1bd1bbf7383b67470e87881965920c1e04e9b5fddb65d477255d4e9a"

RDEPENDS:phpMyAdmin = " \
 bash \
 ca-certificates \
 httpd-filesystem \
 nginx-filesystem \
 php-common \
 php-fpm \
 php-gd \
 php-intl \
 php-mbstring \
 php-mysqlnd \
 php-pecl-zip \
 php-process \
 php-xml \
 sed \
 virtual/coreutils \
 virtual/webserver \
 "
