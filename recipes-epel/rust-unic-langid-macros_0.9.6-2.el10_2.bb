# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-unic-langid-macros"
PV = "0.9.6"
PR = "2.el10_2"
PACKAGES = " \
 rust-unic-langid-macros+default-devel \
 rust-unic-langid-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-unic-langid-macros-0.9.6-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f9999e20e6cbd726582ba61c58030ded007a04d64e9119f902735f75bd929afd"

URI_x86_64_v2_rust-unic-langid-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-macros+default-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-macros+default-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-macros+default-devel.sha256sum] = "7474c4ca5bd4def388dd651a48bd0898b1bff92d9533ce97a2d9c92175a2d5d1"

URI_x86_64_v2_rust-unic-langid-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-unic-langid-macros-devel-0.9.6-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-unic-langid-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-unic-langid-macros-devel}"
SRC_URI[x86_64_v2_rust-unic-langid-macros-devel.sha256sum] = "f8e071ed3537df3c2f6e9e74573c1364ceee034a4032b59dc22e0d7c5d227cba"

URI_aarch64_rust-unic-langid-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-macros+default-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-macros+default-devel}"
SRC_URI[aarch64_rust-unic-langid-macros+default-devel.sha256sum] = "cd10587b0d667da5dfb99fa917420d048a9457f92556ea37381083e242119234"

URI_aarch64_rust-unic-langid-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-unic-langid-macros-devel-0.9.6-2.el10_2.noarch.rpm;name=aarch64_rust-unic-langid-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-unic-langid-macros-devel}"
SRC_URI[aarch64_rust-unic-langid-macros-devel.sha256sum] = "5de97ec08fbf40e3e22ebf86fb887e62107007b952d8d367732b0a1d28aa05ae"

RDEPENDS:rust-unic-langid-macros+default-devel = " \
 cargo \
 rust-unic-langid-macros-devel \
 "
RDEPENDS:rust-unic-langid-macros-devel = " \
 cargo \
 rust-proc-macro-hack+default-devel \
 rust-tinystr+default-devel \
 rust-unic-langid-impl+default-devel \
 rust-unic-langid-macros-impl+default-devel \
 "
