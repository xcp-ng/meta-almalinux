# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nsd"
PV = "4.15.0"
PR = "1.el10_2"
PACKAGES = " \
 nsd \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nsd-4.15.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c6ca8465823bd5db5c258b47a9b2641226fd84d579f0f66d3455cf951f51656"

URI_x86_64_v2_nsd = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nsd-4.15.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nsd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nsd}"
SRC_URI[x86_64_v2_nsd.sha256sum] = "61e8fad6472f23c8dcfcd2927ccd1adf0027d385c2b1730aa46426174d3af8e2"

URI_aarch64_nsd = "${EPEL_MIRROR}/aarch64/Packages/n/nsd-4.15.0-1.el10_2.aarch64.rpm;name=aarch64_nsd;unpack=0"
SRC_URI:append = " ${URI_aarch64_nsd}"
SRC_URI[aarch64_nsd.sha256sum] = "81f411801d9acf5f766fa1f26c22f6f5c6abed362679f81c53799e8bd7779420"

RDEPENDS:nsd = " \
 bash \
 fstrm \
 glibc \
 libevent \
 openssl-libs \
 protobuf-c \
 systemd-libs \
 "
