# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ka"
PV = "0.1"
PR = "3.1.el10"
PACKAGES = " \
 hunspell-ka \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ka-0.1-3.1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d6e3613af00ae224147bcfaf9769f05823839251e7e50bc6c2105a750f182ba"

URI_x86_64_v2_hunspell-ka = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ka-0.1-3.1.el10.noarch.rpm;name=x86_64_v2_hunspell-ka;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ka}"
SRC_URI[x86_64_v2_hunspell-ka.sha256sum] = "ea20b9b8b0a09e63c58f2c6851b2721f72d0a5d3eb6ba744d6eb27615e29f291"

URI_aarch64_hunspell-ka = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ka-0.1-3.1.el10.noarch.rpm;name=aarch64_hunspell-ka;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ka}"
SRC_URI[aarch64_hunspell-ka.sha256sum] = "ea20b9b8b0a09e63c58f2c6851b2721f72d0a5d3eb6ba744d6eb27615e29f291"

RDEPENDS:hunspell-ka = " \
 hunspell-filesystem \
 "
