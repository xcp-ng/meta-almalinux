# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-embed"
PV = "8.7.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-rust-embed+debug-embed-devel \
 rust-rust-embed+default-devel \
 rust-rust-embed+deterministic-timestamps-devel \
 rust-rust-embed+hex-devel \
 rust-rust-embed+include-exclude-devel \
 rust-rust-embed+interpolate-folder-path-devel \
 rust-rust-embed-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-embed-8.7.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e0fad47b138712853e27f3028dd3f375ebdc9166fc24b51e171a7c1a42689ea"

URI_x86_64_v2_rust-rust-embed+debug-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+debug-embed-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+debug-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+debug-embed-devel.sha256sum] = "efda9b2632038e43526eb4cce85f5f491671bb0b231a383cc2caf44e2c743be1"

URI_x86_64_v2_rust-rust-embed+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+default-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+default-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+default-devel.sha256sum] = "aeaeb481a25bea82b061d102adff62438ebc3aecd04a7a6096271a7f762cd69e"

URI_x86_64_v2_rust-rust-embed+deterministic-timestamps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+deterministic-timestamps-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+deterministic-timestamps-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+deterministic-timestamps-devel.sha256sum] = "e557d017828e298f39704015dcb72534fa0abaab7db27eb171de957498bcb7d4"

URI_x86_64_v2_rust-rust-embed+hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+hex-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+hex-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+hex-devel.sha256sum] = "e5a95d5978987b73273d31e80979a5b768c8335af125e874c585b6e46d1f9f62"

URI_x86_64_v2_rust-rust-embed+include-exclude-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+include-exclude-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+include-exclude-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+include-exclude-devel.sha256sum] = "5dafa59a926422b79821fe3b0631e3bc82734605bc48ae68ecaf2b3382c9301f"

URI_x86_64_v2_rust-rust-embed+interpolate-folder-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+interpolate-folder-path-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+interpolate-folder-path-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+interpolate-folder-path-devel.sha256sum] = "791ca2f1bc8ea2e1cf79b67007678e9722c6ae646647eedf67396783e72ba102"

URI_x86_64_v2_rust-rust-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-devel.sha256sum] = "70091fdcd6a3c6ea42c6f725adea830bf904907ee1d04d0c37dbc1969a46fee2"

URI_aarch64_rust-rust-embed+debug-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+debug-embed-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+debug-embed-devel}"
SRC_URI[aarch64_rust-rust-embed+debug-embed-devel.sha256sum] = "3f7a65d977a871a4477626371d53f9468aa9f3e5a9e301fd05138cddb7fda3fe"

URI_aarch64_rust-rust-embed+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+default-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+default-devel}"
SRC_URI[aarch64_rust-rust-embed+default-devel.sha256sum] = "f9a2fca32797374f0d982ed1b217239232d598483f9edc23fe10612bffb8b279"

URI_aarch64_rust-rust-embed+deterministic-timestamps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+deterministic-timestamps-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+deterministic-timestamps-devel}"
SRC_URI[aarch64_rust-rust-embed+deterministic-timestamps-devel.sha256sum] = "262f4d3265b09c60568641401423f725be20ee3a72c3e5237af6ecc98cb57208"

URI_aarch64_rust-rust-embed+hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+hex-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed+hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+hex-devel}"
SRC_URI[aarch64_rust-rust-embed+hex-devel.sha256sum] = "b8135211eed17a85b169954b7d2827e9524d72f713163a3bd356f9b240c4b8f0"

URI_aarch64_rust-rust-embed+include-exclude-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+include-exclude-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+include-exclude-devel}"
SRC_URI[aarch64_rust-rust-embed+include-exclude-devel.sha256sum] = "512b741e13b002ad0393cc49e9993090046857fc19bc0816d604e4d474d7f2fb"

URI_aarch64_rust-rust-embed+interpolate-folder-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+interpolate-folder-path-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+interpolate-folder-path-devel}"
SRC_URI[aarch64_rust-rust-embed+interpolate-folder-path-devel.sha256sum] = "c7c460942c0ffedfc2368bc81c89cd575959c5a93923191da784f4848947924c"

URI_aarch64_rust-rust-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-devel}"
SRC_URI[aarch64_rust-rust-embed-devel.sha256sum] = "946cb078c7008e1bb9644dcd8af81e9403ac4d328d9bcd2ca0e970d4839ca30d"

RDEPENDS:rust-rust-embed+debug-embed-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+debug-embed-devel \
 rust-rust-embed-utils+debug-embed-devel \
 "
RDEPENDS:rust-rust-embed+default-devel = " \
 cargo \
 rust-rust-embed-devel \
 "
RDEPENDS:rust-rust-embed+deterministic-timestamps-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+deterministic-timestamps-devel \
 "
RDEPENDS:rust-rust-embed+hex-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-rust-embed-devel \
 "
RDEPENDS:rust-rust-embed+include-exclude-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+include-exclude-devel \
 rust-rust-embed-utils+include-exclude-devel \
 "
RDEPENDS:rust-rust-embed+interpolate-folder-path-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+interpolate-folder-path-devel \
 "
RDEPENDS:rust-rust-embed-devel = " \
 cargo \
 rust \
 rust-rust-embed-impl+default-devel \
 rust-rust-embed-utils+default-devel \
 rust-walkdir+default-devel \
 "
