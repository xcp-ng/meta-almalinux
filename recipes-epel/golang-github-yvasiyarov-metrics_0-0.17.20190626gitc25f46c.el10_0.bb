# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-yvasiyarov-metrics"
PV = "0"
PR = "0.17.20190626gitc25f46c.el10_0"
PACKAGES = " \
 golang-github-yvasiyarov-metrics-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-yvasiyarov-metrics-0-0.17.20190626gitc25f46c.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "16059069e1f59460269c5709eab5969666729eab87dadfa74f67a6955cd766c3"

URI_aarch64_golang-github-yvasiyarov-metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-yvasiyarov-metrics-devel-0-0.17.20190626gitc25f46c.el10_0.noarch.rpm;name=aarch64_golang-github-yvasiyarov-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-yvasiyarov-metrics-devel}"
SRC_URI[aarch64_golang-github-yvasiyarov-metrics-devel.sha256sum] = "eee0b6e43d2533d0bf39f9236cb30fd5c058367f8d15f9b0eb2a488a6b8d6113"

RDEPENDS:golang-github-yvasiyarov-metrics-devel = " \
 go-filesystem \
 "
