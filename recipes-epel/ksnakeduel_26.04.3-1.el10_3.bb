# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksnakeduel"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 ksnakeduel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksnakeduel-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0c8c5cf7c3705a8a4f5d2f90a5f3ad4fe93c4a9f2448328ab60411ed1fd6fc79"

URI_x86_64_v2_ksnakeduel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksnakeduel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksnakeduel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksnakeduel}"
SRC_URI[x86_64_v2_ksnakeduel.sha256sum] = "d5d420e26bc4a556e7ac372afadc0adeb5f61cf7430aa0585984fc0f4d3e0989"

URI_aarch64_ksnakeduel = "${EPEL_MIRROR}/aarch64/Packages/k/ksnakeduel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_ksnakeduel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksnakeduel}"
SRC_URI[aarch64_ksnakeduel.sha256sum] = "043858c4675866cda5a0102c1629df223336a5950a533d706245946645a25322"

RDEPENDS:ksnakeduel = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
