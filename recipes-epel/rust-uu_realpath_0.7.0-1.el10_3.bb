# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_realpath"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_realpath+default-devel \
 rust-uu_realpath-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_realpath-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "99d7df6f80d32693288db9bf807e9fff88d86b84fa70af8087d9559a83aef79a"

URI_x86_64_v2_rust-uu_realpath+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_realpath+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_realpath+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_realpath+default-devel}"
SRC_URI[x86_64_v2_rust-uu_realpath+default-devel.sha256sum] = "2b253d20f394c945e688d824983f68b8c09300175670970adfcb676be464d215"

URI_x86_64_v2_rust-uu_realpath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_realpath-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_realpath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_realpath-devel}"
SRC_URI[x86_64_v2_rust-uu_realpath-devel.sha256sum] = "6e1415aa630ad33c278a8ee1e989cb45f687629b1b00f02e625f9c85275eb472"

URI_aarch64_rust-uu_realpath+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_realpath+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_realpath+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_realpath+default-devel}"
SRC_URI[aarch64_rust-uu_realpath+default-devel.sha256sum] = "9ad69736b2094d3c865c077f0783e698e362e1801b62e3e6eec858ba607ab714"

URI_aarch64_rust-uu_realpath-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_realpath-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_realpath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_realpath-devel}"
SRC_URI[aarch64_rust-uu_realpath-devel.sha256sum] = "26c58ecc815ce61a87605b32461fdb769eb1e2f9169e7ec724f729aba2a6f25d"

RDEPENDS:rust-uu_realpath+default-devel = " \
 cargo \
 rust-uu_realpath-devel \
 "
RDEPENDS:rust-uu_realpath-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-uucore+default-devel \
 rust-uucore+fs-devel \
 "
