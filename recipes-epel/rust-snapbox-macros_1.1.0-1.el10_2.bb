# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-snapbox-macros"
PV = "1.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-snapbox-macros+color-devel \
 rust-snapbox-macros+debug-devel \
 rust-snapbox-macros+default-devel \
 rust-snapbox-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-snapbox-macros-1.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17d46f87ade383a13ea01a6bf943b624292d8e91a93fc207fd2f298d81abad89"

URI_x86_64_v2_rust-snapbox-macros+color-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros+color-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros+color-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros+color-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros+color-devel.sha256sum] = "4dbd77f00e4aeae006ab7c2d469db9094de88718caccf1ce3990d78bc70c36ff"

URI_x86_64_v2_rust-snapbox-macros+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros+debug-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros+debug-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros+debug-devel.sha256sum] = "6fc7fae78b679cc1c0e63b691c3acffa6b8d6ff5afdb8d9e93cc9100086f6064"

URI_x86_64_v2_rust-snapbox-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros+default-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros+default-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros+default-devel.sha256sum] = "0d402e967af2659669ebbe53117fbc573e35e3082ca86a504feb0753d6e8ea6f"

URI_x86_64_v2_rust-snapbox-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-snapbox-macros-devel-1.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-snapbox-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-snapbox-macros-devel}"
SRC_URI[x86_64_v2_rust-snapbox-macros-devel.sha256sum] = "fc9ff84a98ad91c39c5703476b7036ff0a6b2dd802d5f77a274e3417d5ebadcb"

URI_aarch64_rust-snapbox-macros+color-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros+color-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox-macros+color-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros+color-devel}"
SRC_URI[aarch64_rust-snapbox-macros+color-devel.sha256sum] = "b2529bb443182fe199e68699c5583a731aa5b344a6961577f02273ee33156a45"

URI_aarch64_rust-snapbox-macros+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros+debug-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox-macros+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros+debug-devel}"
SRC_URI[aarch64_rust-snapbox-macros+debug-devel.sha256sum] = "f8d223b6f80115287c1ca0d6514f86a942c6df3153d6343eee9e9338bd3dac6b"

URI_aarch64_rust-snapbox-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros+default-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros+default-devel}"
SRC_URI[aarch64_rust-snapbox-macros+default-devel.sha256sum] = "5af12ff8156d54be5fc2792897cbec1daded4462d5e7cf5fbcb262d1a0d25297"

URI_aarch64_rust-snapbox-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-snapbox-macros-devel-1.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-snapbox-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-snapbox-macros-devel}"
SRC_URI[aarch64_rust-snapbox-macros-devel.sha256sum] = "3dc87037bc03fca2d3aee70f4f231fa12b3b212419274dab4c8d6bc228b5162d"

RDEPENDS:rust-snapbox-macros+color-devel = " \
 cargo \
 rust-anstream+default-devel \
 rust-snapbox-macros-devel \
 "
RDEPENDS:rust-snapbox-macros+debug-devel = " \
 cargo \
 rust-snapbox-macros-devel \
 "
RDEPENDS:rust-snapbox-macros+default-devel = " \
 cargo \
 rust-snapbox-macros-devel \
 "
RDEPENDS:rust-snapbox-macros-devel = " \
 cargo \
 rust \
 "
