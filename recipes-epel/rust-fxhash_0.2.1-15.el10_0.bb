# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fxhash"
PV = "0.2.1"
PR = "15.el10_0"
PACKAGES = " \
 rust-fxhash+default-devel \
 rust-fxhash-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fxhash-0.2.1-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6396c9433e67883bc4649eb3a1321a5dfbb5e6651d697f002f21aca1f8ca0e6e"

URI_x86_64_v2_rust-fxhash+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fxhash+default-devel-0.2.1-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fxhash+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fxhash+default-devel}"
SRC_URI[x86_64_v2_rust-fxhash+default-devel.sha256sum] = "e6326e561c6ff705cc57d582af90da28f6a70b9bceb60dfdf7a02448e5080559"

URI_x86_64_v2_rust-fxhash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fxhash-devel-0.2.1-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fxhash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fxhash-devel}"
SRC_URI[x86_64_v2_rust-fxhash-devel.sha256sum] = "fce66fa6761569d2d62ba5be6287a7108ce726142e8d5d2a517744c72ccac10c"

URI_aarch64_rust-fxhash+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fxhash+default-devel-0.2.1-15.el10_0.noarch.rpm;name=aarch64_rust-fxhash+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fxhash+default-devel}"
SRC_URI[aarch64_rust-fxhash+default-devel.sha256sum] = "80c6426c683ee85ef53ed8aaa8cfe959c47fad4a0b9e40ff22477eb55fac3f83"

URI_aarch64_rust-fxhash-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fxhash-devel-0.2.1-15.el10_0.noarch.rpm;name=aarch64_rust-fxhash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fxhash-devel}"
SRC_URI[aarch64_rust-fxhash-devel.sha256sum] = "2d79456ac82466cc5cfe8b691d29ec365f4a4970cafed85c67220085c62e9a6d"

RDEPENDS:rust-fxhash+default-devel = " \
 cargo \
 rust-fxhash-devel \
 "
RDEPENDS:rust-fxhash-devel = " \
 cargo \
 rust-byteorder+default-devel \
 "
