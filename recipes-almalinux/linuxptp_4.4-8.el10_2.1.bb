# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linuxptp"
PV = "4.4"
PR = "8.el10_2.1"
PACKAGES = " \
 linuxptp \
 linuxptp-selinux \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/linuxptp-4.4-8.el10_2.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cf7fd4b3a4d9f7f1675f895a16829abecf8626994ab2d23c602515a52229efb1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/linuxptp-4.4-8.el10_2.1.x86_64_v2.rpm;name=x86_64_v2_linuxptp;unpack=0"
SRC_URI[x86_64_v2_linuxptp.sha256sum] = "a5b8730dbc580ab453f5d066abbb49bd6789fe9ab9353465ef540e38e3ff6623"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/linuxptp-selinux-4.4-8.el10_2.1.noarch.rpm;name=x86_64_v2_linuxptp-selinux;unpack=0"
SRC_URI[x86_64_v2_linuxptp-selinux.sha256sum] = "b0a99234c2a8c364d055f7e0e6a6d2a823970232b0a92c23dca57b86864ef4ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/linuxptp-4.4-8.el10_2.1.aarch64.rpm;name=aarch64_linuxptp;unpack=0"
SRC_URI[aarch64_linuxptp.sha256sum] = "0e56f92e3772edf196aaf2ae64958ff2af8c8fbd3ea49eb53ad20e7b47dc3196"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/linuxptp-selinux-4.4-8.el10_2.1.noarch.rpm;name=aarch64_linuxptp-selinux;unpack=0"
SRC_URI[aarch64_linuxptp-selinux.sha256sum] = "b0a99234c2a8c364d055f7e0e6a6d2a823970232b0a92c23dca57b86864ef4ce"

RDEPENDS:linuxptp = " \
 bash \
 glibc \
 gnutls \
 libcap \
 linuxptp-selinux \
 setup \
 shadow-utils \
 systemd \
 "
RDEPENDS:linuxptp-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
