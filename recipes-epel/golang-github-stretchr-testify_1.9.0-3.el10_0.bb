# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-stretchr-testify"
PV = "1.9.0"
PR = "3.el10_0"
PACKAGES = " \
 golang-github-stretchr-testify-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-stretchr-testify-1.9.0-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d2ed2c1fcf61e85be3ada6fdcb6869d85d0ca7aa5f20040b081e9e70bf7f8f0e"

URI_x86_64_v2_golang-github-stretchr-testify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-stretchr-testify-devel-1.9.0-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-stretchr-testify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-stretchr-testify-devel}"
SRC_URI[x86_64_v2_golang-github-stretchr-testify-devel.sha256sum] = "2df9888d330441584620f0b265dc9364713664ad2c4dd1116f7d2f75691d8746"

URI_aarch64_golang-github-stretchr-testify-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-stretchr-testify-devel-1.9.0-3.el10_0.noarch.rpm;name=aarch64_golang-github-stretchr-testify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-stretchr-testify-devel}"
SRC_URI[aarch64_golang-github-stretchr-testify-devel.sha256sum] = "90bb92c60fbb5f54ca777e5b56de1aead66b9b5058b10339b3e8d5dfda64516e"

RDEPENDS:golang-github-stretchr-testify-devel = " \
 go-filesystem \
 golang-github-davecgh-spew-devel \
 golang-github-pmezard-difflib-devel \
 golang-github-stretchr-objx-devel \
 golang-gopkg-yaml-3-devel \
 "
