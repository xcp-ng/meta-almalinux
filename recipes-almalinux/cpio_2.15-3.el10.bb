# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cpio"
PV = "2.15"
PR = "3.el10"
PACKAGES = " \
 cpio \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cpio-2.15-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6b9e143f13312a5a24715253d418b51eb0a380d4ea26085de943e9fe6622985"

URI_x86_64_v2_cpio = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cpio-2.15-3.el10.x86_64_v2.rpm;name=x86_64_v2_cpio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cpio}"
SRC_URI[x86_64_v2_cpio.sha256sum] = "3aa2a0b7fb2afba03aafec58e5daefaa2db76b43fc0f886a6413c0326d551fd1"

URI_aarch64_cpio = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cpio-2.15-3.el10.aarch64.rpm;name=aarch64_cpio;unpack=0"
SRC_URI:append = " ${URI_aarch64_cpio}"
SRC_URI[aarch64_cpio.sha256sum] = "2f3719dd9f69800d42b389a4c73b56a718936bf28a77f3a0f90665c613815a88"

RDEPENDS:cpio = " \
 glibc \
 "
