# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "orc"
PV = "0.4.39"
PR = "2.el10"
PACKAGES = " \
 orc \
 orc-compiler \
 orc-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/orc-0.4.39-2.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6d5038117842c1b8595ae2c3cea9f8f72dde65580d7a80c96a396c44c2968644"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/orc-0.4.39-2.el10.x86_64_v2.rpm;name=x86_64_v2_orc;unpack=0"
SRC_URI[x86_64_v2_orc.sha256sum] = "a6b3f5f669e2c6b95a31f97455fb49c56f18ecbf2a7d357738846136b9c59f69"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/orc-compiler-0.4.39-2.el10.x86_64_v2.rpm;name=x86_64_v2_orc-compiler;unpack=0"
SRC_URI[x86_64_v2_orc-compiler.sha256sum] = "f776546e1fb830cf3d31ae1269e88b35183f19704a307a19ffc1005be8265354"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/orc-devel-0.4.39-2.el10.x86_64_v2.rpm;name=x86_64_v2_orc-devel;unpack=0"
SRC_URI[x86_64_v2_orc-devel.sha256sum] = "9c2fd60c11ae520991ededfce674ec47e671df8f95a4e2df9f8feab364f9d51b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/orc-0.4.39-2.el10.aarch64.rpm;name=aarch64_orc;unpack=0"
SRC_URI[aarch64_orc.sha256sum] = "9ce9cb9134d9919760cd828e4616bac088026e5d1895fd620430666adba3090e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/orc-compiler-0.4.39-2.el10.aarch64.rpm;name=aarch64_orc-compiler;unpack=0"
SRC_URI[aarch64_orc-compiler.sha256sum] = "70854be6c61ec75eb2d537e50ff4e04c243ae5c820cf892e8777dde93b13a5b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/orc-devel-0.4.39-2.el10.aarch64.rpm;name=aarch64_orc-devel;unpack=0"
SRC_URI[aarch64_orc-devel.sha256sum] = "82b95342042b4d09791718914040694166f0ddff9f42388da1fcdc4ebf41c50c"

RDEPENDS:orc = " \
 glibc \
 "
RDEPENDS:orc-compiler = " \
 glibc \
 orc \
 pkgconf-pkg-config \
 "
RDEPENDS:orc-devel = " \
 orc \
 orc-compiler \
 pkgconf-pkg-config \
 "
