# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kdesu"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-kdesu \
 kf6-kdesu-devel \
 kf6-kdesu-doc \
 kf6-kdesu-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kdesu-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53d97e8b05ea7940d44eec1a31b663674ebdce9724e861b74f24506f776fc6ff"

URI_x86_64_v2_kf6-kdesu = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu}"
SRC_URI[x86_64_v2_kf6-kdesu.sha256sum] = "3bcb57f16646760ca53dea0d97099507a4a0303058d78d232fbf644bc78e37b2"

URI_x86_64_v2_kf6-kdesu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kdesu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu-devel}"
SRC_URI[x86_64_v2_kf6-kdesu-devel.sha256sum] = "cb7e3ce4c06fd4cec93336a072c0e7e384d5297361451b4e04a6ead279709688"

URI_x86_64_v2_kf6-kdesu-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdesu-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu-doc}"
SRC_URI[x86_64_v2_kf6-kdesu-doc.sha256sum] = "b628a4cc7db657dce4c8ed918fd61c91945fea4ef7e1bb80e9e213dc33506d69"

URI_x86_64_v2_kf6-kdesu-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kdesu-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kdesu-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kdesu-html}"
SRC_URI[x86_64_v2_kf6-kdesu-html.sha256sum] = "19283a9e01a6cef1d3af745cc65559b621dde40a5387f646a13f461e1ca09af0"

URI_aarch64_kf6-kdesu = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdesu;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu}"
SRC_URI[aarch64_kf6-kdesu.sha256sum] = "04266f2b25ffbd70419162e3452ac300ee91f922263cffadecdd1a3c23ae2c43"

URI_aarch64_kf6-kdesu-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-kdesu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu-devel}"
SRC_URI[aarch64_kf6-kdesu-devel.sha256sum] = "66a09a28a01aca07d06acc4730c54910a7a1aad9527d29b427d1d9b03e5d9c7c"

URI_aarch64_kf6-kdesu-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdesu-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu-doc}"
SRC_URI[aarch64_kf6-kdesu-doc.sha256sum] = "057bd0e877924274bd7c6c85b89399b8fd6e7ce96528295c74656bd375420907"

URI_aarch64_kf6-kdesu-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kdesu-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-kdesu-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kdesu-html}"
SRC_URI[aarch64_kf6-kdesu-html.sha256sum] = "c2655b09b998e27f52fc7743a6fc4a141495177b7eee4356a1e6376297616e47"

RDEPENDS:kf6-kdesu = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpty \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 sudo \
 "
RDEPENDS:kf6-kdesu-devel = " \
 cmake-filesystem \
 kf6-kdesu \
 kf6-kpty-devel \
 "
RDEPENDS:kf6-kdesu-doc = " \
 "
RDEPENDS:kf6-kdesu-html = " \
 "
