# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-markup5ever"
PV = "0.14.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-markup5ever+default-devel \
 rust-markup5ever-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-markup5ever-0.14.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e136a9b504459283bab3ca85c8ceee18399f8246c8dccfa9ac7490cc8b64640"

URI_x86_64_v2_rust-markup5ever+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever+default-devel-0.14.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever+default-devel}"
SRC_URI[x86_64_v2_rust-markup5ever+default-devel.sha256sum] = "bce808caf12591ce43728dd4b5a50b30226c7e2ab32a3357d16367829e59618d"

URI_x86_64_v2_rust-markup5ever-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever-devel-0.14.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever-devel}"
SRC_URI[x86_64_v2_rust-markup5ever-devel.sha256sum] = "3afd0c348b10d9cd79aaa90f983574163d08177f2a375ab214f1d725f1b31c2f"

URI_aarch64_rust-markup5ever+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever+default-devel-0.14.1-1.el10_0.noarch.rpm;name=aarch64_rust-markup5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever+default-devel}"
SRC_URI[aarch64_rust-markup5ever+default-devel.sha256sum] = "d8da4088837aee0ca5b2366233983c545ba376963bedcbcb0feb5d2c0c9f8015"

URI_aarch64_rust-markup5ever-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever-devel-0.14.1-1.el10_0.noarch.rpm;name=aarch64_rust-markup5ever-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever-devel}"
SRC_URI[aarch64_rust-markup5ever-devel.sha256sum] = "9b0bedcfcd3c9b0b89bdd3dcc3c0041ccf1d4995ca21ed506a6d4fc63331eaa4"

RDEPENDS:rust-markup5ever+default-devel = " \
 cargo \
 rust-markup5ever-devel \
 "
RDEPENDS:rust-markup5ever-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-phf+default-devel \
 rust-phf_codegen+default-devel \
 rust-string_cache+default-devel \
 rust-string_cache_codegen+default-devel \
 rust-tendril+default-devel \
 "
