# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-procfs-core"
PV = "0.17.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-procfs-core+backtrace-devel \
 rust-procfs-core+chrono-devel \
 rust-procfs-core+default-devel \
 rust-procfs-core+serde-devel \
 rust-procfs-core+serde1-devel \
 rust-procfs-core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-procfs-core-0.17.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "25a5905e81860a5f949b78322fab8c9ae2932a0e3b90a92dda9c869980d2633d"

URI_x86_64_v2_rust-procfs-core+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+backtrace-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+backtrace-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+backtrace-devel.sha256sum] = "e19b63eab0cf4fbf795d3af4b511b0403d4d3fe59fa9e020be5f37cb8329c66c"

URI_x86_64_v2_rust-procfs-core+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+chrono-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+chrono-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+chrono-devel.sha256sum] = "ba4c42c95695822446dd6c8f400bbf6e625a5997725c54cb28953bc78472ce46"

URI_x86_64_v2_rust-procfs-core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+default-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+default-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+default-devel.sha256sum] = "9c92c28fd88579b31d109f8da31a71a12ef511116e5c62c652e3b5aefe48c5b6"

URI_x86_64_v2_rust-procfs-core+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+serde-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+serde-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+serde-devel.sha256sum] = "9105b17c5eb61c3af03c0a0ece39f6212eca1f237bc2fa6a0feec3563d2edca9"

URI_x86_64_v2_rust-procfs-core+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core+serde1-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core+serde1-devel}"
SRC_URI[x86_64_v2_rust-procfs-core+serde1-devel.sha256sum] = "d5b43ea0d8f040a70ceb21aa673a2b3b94717aad5cfd2ff772bf3a5897429c2d"

URI_x86_64_v2_rust-procfs-core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-procfs-core-devel-0.17.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-procfs-core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-procfs-core-devel}"
SRC_URI[x86_64_v2_rust-procfs-core-devel.sha256sum] = "3b908b1caf2591999bc17b77c8b48b66cfca74e2c15ec4999be9ce0eb4ccaa79"

URI_aarch64_rust-procfs-core+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+backtrace-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-procfs-core+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+backtrace-devel}"
SRC_URI[aarch64_rust-procfs-core+backtrace-devel.sha256sum] = "1c7fbc25caae5d663c7223f6ae9df5f2e749a4e149866a67e54967d2603082ca"

URI_aarch64_rust-procfs-core+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+chrono-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-procfs-core+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+chrono-devel}"
SRC_URI[aarch64_rust-procfs-core+chrono-devel.sha256sum] = "873f672458221e8747fb924b710df8b09b0d1e41a8ba9870b559c42854a86edf"

URI_aarch64_rust-procfs-core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+default-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-procfs-core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+default-devel}"
SRC_URI[aarch64_rust-procfs-core+default-devel.sha256sum] = "542d4135f3bb1c2c97e998cf18435524f480ba62b7aa984296740e90c9208302"

URI_aarch64_rust-procfs-core+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+serde-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-procfs-core+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+serde-devel}"
SRC_URI[aarch64_rust-procfs-core+serde-devel.sha256sum] = "7e1d2edb8cb271c4dbe70f8924a0deb45bb79958ca64d916a8209780fb93d79f"

URI_aarch64_rust-procfs-core+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core+serde1-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-procfs-core+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core+serde1-devel}"
SRC_URI[aarch64_rust-procfs-core+serde1-devel.sha256sum] = "f02536293e2b371495c36c5a6615b2d774b6a95076e3695d15fea8a0d5336e9e"

URI_aarch64_rust-procfs-core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-procfs-core-devel-0.17.0-2.el10_0.noarch.rpm;name=aarch64_rust-procfs-core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-procfs-core-devel}"
SRC_URI[aarch64_rust-procfs-core-devel.sha256sum] = "f58bcf4667663a27ecf909fa71ba0807b54c318f7a001546e16031b0795adc52"

RDEPENDS:rust-procfs-core+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-procfs-core-devel \
 "
RDEPENDS:rust-procfs-core+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono-devel \
 rust-procfs-core-devel \
 "
RDEPENDS:rust-procfs-core+default-devel = " \
 cargo \
 rust-procfs-core+chrono-devel \
 rust-procfs-core-devel \
 "
RDEPENDS:rust-procfs-core+serde-devel = " \
 cargo \
 rust-procfs-core-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-procfs-core+serde1-devel = " \
 cargo \
 rust-bitflags+serde-devel \
 rust-procfs-core+serde-devel \
 rust-procfs-core-devel \
 "
RDEPENDS:rust-procfs-core-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-hex+default-devel \
 "
