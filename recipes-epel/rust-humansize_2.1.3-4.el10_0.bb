# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-humansize"
PV = "2.1.3"
PR = "4.el10_0"
PACKAGES = " \
 rust-humansize+default-devel \
 rust-humansize+impl_style-devel \
 rust-humansize+no_alloc-devel \
 rust-humansize-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-humansize-2.1.3-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e3361d6d6f3cd147c706019800da400098ba780a14250f76c1d56277dae3281"

URI_x86_64_v2_rust-humansize+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humansize+default-devel-2.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humansize+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humansize+default-devel}"
SRC_URI[x86_64_v2_rust-humansize+default-devel.sha256sum] = "6deab6de7610cd4e66173923cc1975f38fe0a0963e7f8ddf385fd4d01d896794"

URI_x86_64_v2_rust-humansize+impl_style-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humansize+impl_style-devel-2.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humansize+impl_style-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humansize+impl_style-devel}"
SRC_URI[x86_64_v2_rust-humansize+impl_style-devel.sha256sum] = "87a4800b7ce7c1f24b8cfea9cc6c6bc9ddc433f6bb2684d0a343aee4dcdf8673"

URI_x86_64_v2_rust-humansize+no_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humansize+no_alloc-devel-2.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humansize+no_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humansize+no_alloc-devel}"
SRC_URI[x86_64_v2_rust-humansize+no_alloc-devel.sha256sum] = "e4d55f85b9f5ad5590b092ca958b4c7677ae172b5fda27deea679a0cca213316"

URI_x86_64_v2_rust-humansize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-humansize-devel-2.1.3-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-humansize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-humansize-devel}"
SRC_URI[x86_64_v2_rust-humansize-devel.sha256sum] = "773338084e458ac40f061f09aa461443d0e8e5851d7e38125a3fc7a1ebea53f3"

URI_aarch64_rust-humansize+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humansize+default-devel-2.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-humansize+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humansize+default-devel}"
SRC_URI[aarch64_rust-humansize+default-devel.sha256sum] = "53fecb7d34b3f0981b86beb15d65a5a4fc0b04f7b5161523344f545cd58c599c"

URI_aarch64_rust-humansize+impl_style-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humansize+impl_style-devel-2.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-humansize+impl_style-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humansize+impl_style-devel}"
SRC_URI[aarch64_rust-humansize+impl_style-devel.sha256sum] = "25b251b0626b57b8f1bba18ba9db8422a2b900fc351a5bcce8a1a259eff6d1ce"

URI_aarch64_rust-humansize+no_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humansize+no_alloc-devel-2.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-humansize+no_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humansize+no_alloc-devel}"
SRC_URI[aarch64_rust-humansize+no_alloc-devel.sha256sum] = "ada48775c48f01697fe095337e9cc7ca0443a8e95c0923a5e905c719d1af2bc3"

URI_aarch64_rust-humansize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-humansize-devel-2.1.3-4.el10_0.noarch.rpm;name=aarch64_rust-humansize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-humansize-devel}"
SRC_URI[aarch64_rust-humansize-devel.sha256sum] = "c5d8f04fd0f33d64bbe69a927c80b3bad93921ff0fa9a488b34ec67365f115e2"

RDEPENDS:rust-humansize+default-devel = " \
 cargo \
 rust-humansize-devel \
 "
RDEPENDS:rust-humansize+impl_style-devel = " \
 cargo \
 rust-humansize-devel \
 "
RDEPENDS:rust-humansize+no_alloc-devel = " \
 cargo \
 rust-humansize-devel \
 "
RDEPENDS:rust-humansize-devel = " \
 cargo \
 rust \
 rust-libm+default-devel \
 "
