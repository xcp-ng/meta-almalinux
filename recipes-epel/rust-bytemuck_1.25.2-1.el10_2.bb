# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytemuck"
PV = "1.25.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-bytemuck+aarch64_simd-devel \
 rust-bytemuck+align_offset-devel \
 rust-bytemuck+alloc_uninit-devel \
 rust-bytemuck+avx512_simd-devel \
 rust-bytemuck+bytemuck_derive-devel \
 rust-bytemuck+const_zeroed-devel \
 rust-bytemuck+default-devel \
 rust-bytemuck+derive-devel \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-bytemuck+extern_crate_std-devel \
 rust-bytemuck+impl_core_error-devel \
 rust-bytemuck+min_const_generics-devel \
 rust-bytemuck+must_cast-devel \
 rust-bytemuck+must_cast_extra-devel \
 rust-bytemuck+nightly_stdsimd-devel \
 rust-bytemuck+track_caller-devel \
 rust-bytemuck+transparentwrapper_extra-devel \
 rust-bytemuck+unsound_ptr_pod_impl-devel \
 rust-bytemuck+zeroable_atomics-devel \
 rust-bytemuck+zeroable_maybe_uninit-devel \
 rust-bytemuck+zeroable_unwind_fn-devel \
 rust-bytemuck-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytemuck-1.25.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "769eea70470c57df00b3b95d1a298d8f62f1aaa5105732aa2f31eca5172651e6"

URI_x86_64_v2_rust-bytemuck+aarch64_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+aarch64_simd-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+aarch64_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+aarch64_simd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+aarch64_simd-devel.sha256sum] = "8d3505714cd57c3bc302281f869e02aa4cbab6c92906f7dd31921838722be258"

URI_x86_64_v2_rust-bytemuck+align_offset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+align_offset-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+align_offset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+align_offset-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+align_offset-devel.sha256sum] = "f0145d1f3d48850fadc9db2e16bc8462b8a835d65e6d104796ec47de8725f582"

URI_x86_64_v2_rust-bytemuck+alloc_uninit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+alloc_uninit-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+alloc_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+alloc_uninit-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+alloc_uninit-devel.sha256sum] = "0b3f9d74a6d37dcb1ae0badc28fab9e2b29d96930ee1375c29d2d424a167ae02"

URI_x86_64_v2_rust-bytemuck+avx512_simd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+avx512_simd-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+avx512_simd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+avx512_simd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+avx512_simd-devel.sha256sum] = "6dd6fe0c346a4dbf40ac3ebd50cb30ec66bc7d3268fd5922699606f5385ad410"

URI_x86_64_v2_rust-bytemuck+bytemuck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+bytemuck_derive-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+bytemuck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+bytemuck_derive-devel.sha256sum] = "41a0dbd2d6c9c1c94d5562924dc2120909d3b865d7d26cdc90572e57145ff9ee"

URI_x86_64_v2_rust-bytemuck+const_zeroed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+const_zeroed-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+const_zeroed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+const_zeroed-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+const_zeroed-devel.sha256sum] = "11d498d034f643f5352e7b9a6065cf1b7e63b4252b0ce6485f587a37444edcc8"

URI_x86_64_v2_rust-bytemuck+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+default-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+default-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+default-devel.sha256sum] = "bf2ab0d8ed42a7e3b5862a097148dc1cd517897d394cfb08a79add5c49beec54"

URI_x86_64_v2_rust-bytemuck+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+derive-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+derive-devel.sha256sum] = "11d4afcb0212b26fb6ce2f69a0bae9be8c853240889a9e8149e391eb8641ddcd"

URI_x86_64_v2_rust-bytemuck+extern_crate_alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+extern_crate_alloc-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+extern_crate_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+extern_crate_alloc-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+extern_crate_alloc-devel.sha256sum] = "dfa26a313d4ab473ecf4a50746806a918ebf9547b01ec4011fbbe28e0a909779"

URI_x86_64_v2_rust-bytemuck+extern_crate_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+extern_crate_std-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+extern_crate_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+extern_crate_std-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+extern_crate_std-devel.sha256sum] = "03f646dfda74a8107d255a8ceaeef28c3d9407032b7af46f7937fcb58f10a5ef"

URI_x86_64_v2_rust-bytemuck+impl_core_error-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+impl_core_error-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+impl_core_error-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+impl_core_error-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+impl_core_error-devel.sha256sum] = "74e6128064d15338151f9cd76f8668a663c7fc20b6e7c8fe35c07ea1c5781359"

URI_x86_64_v2_rust-bytemuck+min_const_generics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+min_const_generics-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+min_const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+min_const_generics-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+min_const_generics-devel.sha256sum] = "1b4d391c95ff5ea64405a20a5410061005c06203892d8dede7433f435c6eaeb0"

URI_x86_64_v2_rust-bytemuck+must_cast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+must_cast-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+must_cast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+must_cast-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+must_cast-devel.sha256sum] = "7eebe0efc9b562f2e485b844d61f82d45224dc2309c227b55786be8f9d2bef02"

URI_x86_64_v2_rust-bytemuck+must_cast_extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+must_cast_extra-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+must_cast_extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+must_cast_extra-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+must_cast_extra-devel.sha256sum] = "7bba6c6fb9b3d019e71e86bf97802a0f86630614d62262f6937095f42e613c4e"

URI_x86_64_v2_rust-bytemuck+nightly_stdsimd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+nightly_stdsimd-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+nightly_stdsimd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+nightly_stdsimd-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+nightly_stdsimd-devel.sha256sum] = "26b50f2785b2e1a2266ad45e24e33d5f2ccd06e6ea296c4380b37d7514d77b80"

URI_x86_64_v2_rust-bytemuck+track_caller-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+track_caller-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+track_caller-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+track_caller-devel.sha256sum] = "f2b13fb3351448fff1e1a2f3d8026a13ede53ddd73c41c729970a90cc7537657"

URI_x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+transparentwrapper_extra-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+transparentwrapper_extra-devel.sha256sum] = "25edcee8b56ecdf686e8475d72da1ff085b4aa1e82960bc772c0fa757e87acfe"

URI_x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+unsound_ptr_pod_impl-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+unsound_ptr_pod_impl-devel.sha256sum] = "65c6f6119dd981e44d42f322479b917345a48d9a3a64ea2d77ba70f49a293dc9"

URI_x86_64_v2_rust-bytemuck+zeroable_atomics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_atomics-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_atomics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_atomics-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_atomics-devel.sha256sum] = "27e7d07d1dbd4b9ae96bd7f40b6bb75e9f9ac9aaaedfa2f246b58fd1114d6da4"

URI_x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_maybe_uninit-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_maybe_uninit-devel.sha256sum] = "946a98f517e1757c74efac1a8f9457f902f5502a0d218bdee667dcc910a7aa86"

URI_x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck+zeroable_unwind_fn-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel}"
SRC_URI[x86_64_v2_rust-bytemuck+zeroable_unwind_fn-devel.sha256sum] = "f6cb94502942249e2df6592eba65459aa592693e20059f3bc7b7f6fab5f5584d"

URI_x86_64_v2_rust-bytemuck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck-devel-1.25.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck-devel}"
SRC_URI[x86_64_v2_rust-bytemuck-devel.sha256sum] = "afd96f01d9a23b48849a38e9549d89d4e83f0762f241f75c392984a3b2c93085"

URI_aarch64_rust-bytemuck+aarch64_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+aarch64_simd-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+aarch64_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+aarch64_simd-devel}"
SRC_URI[aarch64_rust-bytemuck+aarch64_simd-devel.sha256sum] = "419eb4ff3ac51d6b83df8aa19376963fdc5046695482dfd6450229dc25d0a17c"

URI_aarch64_rust-bytemuck+align_offset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+align_offset-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+align_offset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+align_offset-devel}"
SRC_URI[aarch64_rust-bytemuck+align_offset-devel.sha256sum] = "b790ba3744e6db2497a42f9fb45b3553bb3e226870bcb49830bdc688cd2d8a43"

URI_aarch64_rust-bytemuck+alloc_uninit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+alloc_uninit-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+alloc_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+alloc_uninit-devel}"
SRC_URI[aarch64_rust-bytemuck+alloc_uninit-devel.sha256sum] = "34e99b2403045d6af4f28d500eff175597d12c374ef1c2f86d5a22bc0ae3122e"

URI_aarch64_rust-bytemuck+avx512_simd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+avx512_simd-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+avx512_simd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+avx512_simd-devel}"
SRC_URI[aarch64_rust-bytemuck+avx512_simd-devel.sha256sum] = "84f7c5de6fa0c598942f671253ae4f7b5257733677558bcb6a67929bbf6c50d1"

URI_aarch64_rust-bytemuck+bytemuck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+bytemuck_derive-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+bytemuck_derive-devel}"
SRC_URI[aarch64_rust-bytemuck+bytemuck_derive-devel.sha256sum] = "46ac02a0327f1a6b555ae4c5df7654632250b302a1525dc54c235a180bafcca9"

URI_aarch64_rust-bytemuck+const_zeroed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+const_zeroed-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+const_zeroed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+const_zeroed-devel}"
SRC_URI[aarch64_rust-bytemuck+const_zeroed-devel.sha256sum] = "f43803a8d2e5af4f13633bd696598973994484d1af3f608cdbd52a3a1deefd57"

URI_aarch64_rust-bytemuck+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+default-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+default-devel}"
SRC_URI[aarch64_rust-bytemuck+default-devel.sha256sum] = "1bc09fb529b5132550a1f0e1cafcc947ab6af8c0144bc92064f228e348492f12"

URI_aarch64_rust-bytemuck+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+derive-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+derive-devel}"
SRC_URI[aarch64_rust-bytemuck+derive-devel.sha256sum] = "02e8ad37a7514fbb2187059aa75108867579a45efff14734959183d8fe61ed97"

URI_aarch64_rust-bytemuck+extern_crate_alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+extern_crate_alloc-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+extern_crate_alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+extern_crate_alloc-devel}"
SRC_URI[aarch64_rust-bytemuck+extern_crate_alloc-devel.sha256sum] = "856f5f377f7874d1a3ed6868f5532422a985189f423f1a23bd78503e9ff8ebd2"

URI_aarch64_rust-bytemuck+extern_crate_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+extern_crate_std-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+extern_crate_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+extern_crate_std-devel}"
SRC_URI[aarch64_rust-bytemuck+extern_crate_std-devel.sha256sum] = "9a874060171cb68b0edecdadccd4851e9c5362d68fd2d51b41cada9074397052"

URI_aarch64_rust-bytemuck+impl_core_error-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+impl_core_error-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+impl_core_error-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+impl_core_error-devel}"
SRC_URI[aarch64_rust-bytemuck+impl_core_error-devel.sha256sum] = "5b7367404532cf115055dc281a86ca7bac0fb3e8e3e29a72ead4a5db98f1a897"

URI_aarch64_rust-bytemuck+min_const_generics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+min_const_generics-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+min_const_generics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+min_const_generics-devel}"
SRC_URI[aarch64_rust-bytemuck+min_const_generics-devel.sha256sum] = "71a38e4131c8e176defca192dc6bdf4ad21dca6bea7d334417c4e621c6b7d614"

URI_aarch64_rust-bytemuck+must_cast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+must_cast-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+must_cast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+must_cast-devel}"
SRC_URI[aarch64_rust-bytemuck+must_cast-devel.sha256sum] = "cdcd165594df2bc94d7f4c1fca2da37dfa59759860b76173c7cb0f6b98573662"

URI_aarch64_rust-bytemuck+must_cast_extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+must_cast_extra-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+must_cast_extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+must_cast_extra-devel}"
SRC_URI[aarch64_rust-bytemuck+must_cast_extra-devel.sha256sum] = "b77c4e52bb26ec57545dfb73677483825786dd18865af6efa3eebddcb921bbae"

URI_aarch64_rust-bytemuck+nightly_stdsimd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+nightly_stdsimd-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+nightly_stdsimd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+nightly_stdsimd-devel}"
SRC_URI[aarch64_rust-bytemuck+nightly_stdsimd-devel.sha256sum] = "36fbd327be07ec72df985ec393de8ed9e1d4885590abdc8e1ddf36c2b7f9a37c"

URI_aarch64_rust-bytemuck+track_caller-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+track_caller-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+track_caller-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+track_caller-devel}"
SRC_URI[aarch64_rust-bytemuck+track_caller-devel.sha256sum] = "af86781ef3801e651205dfb55543a0dfabda5c9ddcf4b658cc269d795bfd8f2e"

URI_aarch64_rust-bytemuck+transparentwrapper_extra-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+transparentwrapper_extra-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+transparentwrapper_extra-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+transparentwrapper_extra-devel}"
SRC_URI[aarch64_rust-bytemuck+transparentwrapper_extra-devel.sha256sum] = "65ffe3441ad8983f5244fb66ad98dc0ebacf6615edb1b007751a2df285c9684b"

URI_aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+unsound_ptr_pod_impl-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel}"
SRC_URI[aarch64_rust-bytemuck+unsound_ptr_pod_impl-devel.sha256sum] = "39e10aa8c4d388351d3931ae586b085e044331074a18600016c7a5e64f087950"

URI_aarch64_rust-bytemuck+zeroable_atomics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_atomics-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_atomics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_atomics-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_atomics-devel.sha256sum] = "e77f1e95b977f2fbd5a66c0b1fd593227782fb86e3054d9e7006ba28c2f61565"

URI_aarch64_rust-bytemuck+zeroable_maybe_uninit-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_maybe_uninit-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_maybe_uninit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_maybe_uninit-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_maybe_uninit-devel.sha256sum] = "cc3dbe1782f70450ac11d0cc5e3d8cadaa98fc095777baefd87fc312bfb535b5"

URI_aarch64_rust-bytemuck+zeroable_unwind_fn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck+zeroable_unwind_fn-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck+zeroable_unwind_fn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck+zeroable_unwind_fn-devel}"
SRC_URI[aarch64_rust-bytemuck+zeroable_unwind_fn-devel.sha256sum] = "9203b35fb85be2528e512003d6a8e3347903a39521102c1e96ac52d442dcdaac"

URI_aarch64_rust-bytemuck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck-devel-1.25.2-1.el10_2.noarch.rpm;name=aarch64_rust-bytemuck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck-devel}"
SRC_URI[aarch64_rust-bytemuck-devel.sha256sum] = "867907f95354e6d9fea85b822bcc54da9c00285bf6bd9a29e6b230efc00d063a"

RDEPENDS:rust-bytemuck+aarch64_simd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+align_offset-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+alloc_uninit-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+avx512_simd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+bytemuck_derive-devel = " \
 cargo \
 rust-bytemuck-devel \
 rust-bytemuck_derive+default-devel \
 "
RDEPENDS:rust-bytemuck+const_zeroed-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+default-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+derive-devel = " \
 cargo \
 rust-bytemuck+bytemuck_derive-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+extern_crate_alloc-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+extern_crate_std-devel = " \
 cargo \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+impl_core_error-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+min_const_generics-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+must_cast-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+must_cast_extra-devel = " \
 cargo \
 rust-bytemuck+must_cast-devel \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+nightly_stdsimd-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+track_caller-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+transparentwrapper_extra-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+unsound_ptr_pod_impl-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_atomics-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_maybe_uninit-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck+zeroable_unwind_fn-devel = " \
 cargo \
 rust-bytemuck-devel \
 "
RDEPENDS:rust-bytemuck-devel = " \
 cargo \
 "
