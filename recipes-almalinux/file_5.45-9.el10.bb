# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "file"
PV = "5.45"
PR = "9.el10"
PACKAGES = " \
 file \
 file-devel \
 file-libs \
 python3-file-magic \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/file-5.45-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9eb2c427fc67d33337ca8a7b696a0eef776b4244961c9e58555daece9d19c72f"

URI_x86_64_v2_file = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/file-5.45-9.el10.x86_64_v2.rpm;name=x86_64_v2_file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_file}"
SRC_URI[x86_64_v2_file.sha256sum] = "493c58cb540c09b3c52247959a7271a821a60ff479e34597c5e23b0b4942062b"

URI_x86_64_v2_file-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/file-devel-5.45-9.el10.x86_64_v2.rpm;name=x86_64_v2_file-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_file-devel}"
SRC_URI[x86_64_v2_file-devel.sha256sum] = "279fced30a523102e6e9f3a9f21496f8d3b246441236eb84ec90b69d70007599"

URI_x86_64_v2_file-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/file-libs-5.45-9.el10.x86_64_v2.rpm;name=x86_64_v2_file-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_file-libs}"
SRC_URI[x86_64_v2_file-libs.sha256sum] = "a4b00b8e8ee9f32ab46b798bdd6916d9b98dd67dea474c902379bfca38824836"

URI_x86_64_v2_python3-file-magic = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-file-magic-5.45-9.el10.noarch.rpm;name=x86_64_v2_python3-file-magic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-file-magic}"
SRC_URI[x86_64_v2_python3-file-magic.sha256sum] = "87c7877f67bfc2adf9131a0c9e0546380b6ab0ddd138623fd8a09a98d3f3be8d"

URI_aarch64_file = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/file-5.45-9.el10.aarch64.rpm;name=aarch64_file;unpack=0"
SRC_URI:append = " ${URI_aarch64_file}"
SRC_URI[aarch64_file.sha256sum] = "4ff4341f2aa6d0e90bdda8f0ef646f45456908e7b56f535daa008c66c456d2fc"

URI_aarch64_file-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/file-devel-5.45-9.el10.aarch64.rpm;name=aarch64_file-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_file-devel}"
SRC_URI[aarch64_file-devel.sha256sum] = "8efddc4c2705a4f075b28793a5727ce15724e878198bd50aefcea2edd1af2f20"

URI_aarch64_file-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/file-libs-5.45-9.el10.aarch64.rpm;name=aarch64_file-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_file-libs}"
SRC_URI[aarch64_file-libs.sha256sum] = "2e6e6dd1a758ae6609e7a25718414155ec33c43caa2081dbe030fc7b64e46cd2"

URI_aarch64_python3-file-magic = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-file-magic-5.45-9.el10.noarch.rpm;name=aarch64_python3-file-magic;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-file-magic}"
SRC_URI[aarch64_python3-file-magic.sha256sum] = "87c7877f67bfc2adf9131a0c9e0546380b6ab0ddd138623fd8a09a98d3f3be8d"

RDEPENDS:file = " \
 file-libs \
 glibc \
 "
RDEPENDS:file-devel = " \
 file-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:file-libs = " \
 glibc \
 zlib-ng-compat \
 "
RDEPENDS:python3-file-magic = " \
 file-libs \
 python3 \
 "
