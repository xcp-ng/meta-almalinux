# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "subunit"
PV = "1.4.4"
PR = "4.el10_0"
PACKAGES = " \
 python3-subunit \
 python3-subunit-test \
 subunit \
 subunit-cppunit \
 subunit-cppunit-devel \
 subunit-devel \
 subunit-filters \
 subunit-shell \
 subunit-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/subunit-1.4.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abf0af13c1c9f04ab99ee1c332d1c1b5d526dfddc07989d91f1c77927f9588a7"

URI_x86_64_v2_python3-subunit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-subunit-1.4.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-subunit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-subunit}"
SRC_URI[x86_64_v2_python3-subunit.sha256sum] = "1e167ec6baedea18ef33c00a74b9103c501107579ff0fce5e0770c335ec4bbbd"

URI_x86_64_v2_python3-subunit-test = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-subunit-test-1.4.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-subunit-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-subunit-test}"
SRC_URI[x86_64_v2_python3-subunit-test.sha256sum] = "cf0e9e8dba4fe03eee7e114f9eacfb732593f66b3b0fff44f6f1f56e62ffbe72"

URI_x86_64_v2_subunit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/subunit-1.4.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_subunit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subunit}"
SRC_URI[x86_64_v2_subunit.sha256sum] = "4f5b7caa46cb1025da5e3ee2f2494d42758d220988975f1fd51f363ed87d5f01"

URI_x86_64_v2_subunit-cppunit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/subunit-cppunit-1.4.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_subunit-cppunit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subunit-cppunit}"
SRC_URI[x86_64_v2_subunit-cppunit.sha256sum] = "1d2480918e0cc5d05e5b9f176aa6397eaadf5c683a5f1637c523eface155bc3c"

URI_x86_64_v2_subunit-cppunit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/subunit-cppunit-devel-1.4.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_subunit-cppunit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subunit-cppunit-devel}"
SRC_URI[x86_64_v2_subunit-cppunit-devel.sha256sum] = "5f85b8d7887778e43efed719d44084d5d15cc2688b834d21069abdf2724f8272"

URI_x86_64_v2_subunit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/subunit-devel-1.4.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_subunit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subunit-devel}"
SRC_URI[x86_64_v2_subunit-devel.sha256sum] = "9f89f10c5d9f9e6f883708ac890f5f8eddba91cd0d192b379cc0f8168490c639"

URI_x86_64_v2_subunit-filters = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/subunit-filters-1.4.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_subunit-filters;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subunit-filters}"
SRC_URI[x86_64_v2_subunit-filters.sha256sum] = "072492897b3fc92bed29b62e7a5d40539be0b89667f9f053dd2b2c33b8f5e33c"

URI_x86_64_v2_subunit-shell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/subunit-shell-1.4.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_subunit-shell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subunit-shell}"
SRC_URI[x86_64_v2_subunit-shell.sha256sum] = "9a16d0077cd96e4e2384f7fb3c06033a267b3bc397061042d05139c03b9094ba"

URI_x86_64_v2_subunit-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/subunit-static-1.4.4-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_subunit-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_subunit-static}"
SRC_URI[x86_64_v2_subunit-static.sha256sum] = "3455d8ad7cb825f0864ed37e40517c67874fdfd131b9f274bd01282c1877cdba"

URI_aarch64_python3-subunit = "${EPEL_MIRROR}/aarch64/Packages/p/python3-subunit-1.4.4-4.el10_0.noarch.rpm;name=aarch64_python3-subunit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-subunit}"
SRC_URI[aarch64_python3-subunit.sha256sum] = "e02a3239d03d4863c0155403a08053e2e4bc4b1cbc9a037954386d18c71effad"

URI_aarch64_python3-subunit-test = "${EPEL_MIRROR}/aarch64/Packages/p/python3-subunit-test-1.4.4-4.el10_0.noarch.rpm;name=aarch64_python3-subunit-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-subunit-test}"
SRC_URI[aarch64_python3-subunit-test.sha256sum] = "e009534e8d0339f6bbab891150523d61bfb3c3d2a89df2eb17d59f997a3190ed"

URI_aarch64_subunit = "${EPEL_MIRROR}/aarch64/Packages/s/subunit-1.4.4-4.el10_0.aarch64.rpm;name=aarch64_subunit;unpack=0"
SRC_URI:append = " ${URI_aarch64_subunit}"
SRC_URI[aarch64_subunit.sha256sum] = "d77cfbc5d4177d659928071458ea5ec80903b54ddbf8bf934a492d339d8d20d3"

URI_aarch64_subunit-cppunit = "${EPEL_MIRROR}/aarch64/Packages/s/subunit-cppunit-1.4.4-4.el10_0.aarch64.rpm;name=aarch64_subunit-cppunit;unpack=0"
SRC_URI:append = " ${URI_aarch64_subunit-cppunit}"
SRC_URI[aarch64_subunit-cppunit.sha256sum] = "3ea405a2519555736283fbb6a3b3d6b501f4be412b2f12e210d5ed4e8b0312ba"

URI_aarch64_subunit-cppunit-devel = "${EPEL_MIRROR}/aarch64/Packages/s/subunit-cppunit-devel-1.4.4-4.el10_0.aarch64.rpm;name=aarch64_subunit-cppunit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_subunit-cppunit-devel}"
SRC_URI[aarch64_subunit-cppunit-devel.sha256sum] = "ffb3514223cbff3baea17508993162a79de04cf17eac4af381d25603b9b50eb0"

URI_aarch64_subunit-devel = "${EPEL_MIRROR}/aarch64/Packages/s/subunit-devel-1.4.4-4.el10_0.aarch64.rpm;name=aarch64_subunit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_subunit-devel}"
SRC_URI[aarch64_subunit-devel.sha256sum] = "29fc5185234e19d76e50cc95251d982cc232e1009799c8a84fc28a1d3aecca71"

URI_aarch64_subunit-filters = "${EPEL_MIRROR}/aarch64/Packages/s/subunit-filters-1.4.4-4.el10_0.noarch.rpm;name=aarch64_subunit-filters;unpack=0"
SRC_URI:append = " ${URI_aarch64_subunit-filters}"
SRC_URI[aarch64_subunit-filters.sha256sum] = "cfb7e38fa1205141f2c24e49a5ae92cdcff03c38fda5a855d764e1dc2f48ae69"

URI_aarch64_subunit-shell = "${EPEL_MIRROR}/aarch64/Packages/s/subunit-shell-1.4.4-4.el10_0.noarch.rpm;name=aarch64_subunit-shell;unpack=0"
SRC_URI:append = " ${URI_aarch64_subunit-shell}"
SRC_URI[aarch64_subunit-shell.sha256sum] = "605c6292c5b23eacc0f862938347418fbe64daba1924a50c93c270b9f3f2572c"

URI_aarch64_subunit-static = "${EPEL_MIRROR}/aarch64/Packages/s/subunit-static-1.4.4-4.el10_0.aarch64.rpm;name=aarch64_subunit-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_subunit-static}"
SRC_URI[aarch64_subunit-static.sha256sum] = "b0f54a1c48cb995bcabfe7a9f7be58e0f68509bf695a815f39f57bb9123edda9"

RDEPENDS:python3-subunit = " \
 python3 \
 python3-iso8601 \
 python3-testtools \
 "
RDEPENDS:python3-subunit-test = " \
 python3 \
 python3-subunit \
 subunit-filters \
 "
RDEPENDS:subunit = " \
 glibc \
 "
RDEPENDS:subunit-cppunit = " \
 cppunit \
 glibc \
 libgcc \
 libstdc++ \
 subunit \
 "
RDEPENDS:subunit-cppunit-devel = " \
 cppunit-devel \
 pkgconf-pkg-config \
 subunit-cppunit \
 subunit-devel \
 "
RDEPENDS:subunit-devel = " \
 pkgconf-pkg-config \
 subunit \
 "
RDEPENDS:subunit-filters = " \
 gtk3 \
 libnotify \
 python3 \
 python3-gobject \
 python3-junitxml \
 python3-subunit \
 "
RDEPENDS:subunit-shell = " \
 "
RDEPENDS:subunit-static = " \
 subunit-devel \
 "
