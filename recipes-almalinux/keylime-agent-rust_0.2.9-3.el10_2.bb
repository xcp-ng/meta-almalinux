# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keylime-agent-rust"
PV = "0.2.9"
PR = "3.el10_2"
PACKAGES = " \
 keylime-agent-rust \
 keylime-agent-rust-common \
 keylime-agent-rust-ima-emulator \
 keylime-agent-rust-push \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/keylime-agent-rust-0.2.9-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "685de71d05629845c10ac67966a5fb13d3d65dbde74f426b04fdaf10f493e777"

URI_x86_64_v2_keylime-agent-rust = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-0.2.9-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-agent-rust}"
SRC_URI[x86_64_v2_keylime-agent-rust.sha256sum] = "35d51d835e563edfa27f70c68bfed2d0092e60d375724ef3a1fc0b98f90feca9"
RPROVIDES:keylime-agent-rust:x86_64_v2 = "virtual/keylime-agent"

URI_x86_64_v2_keylime-agent-rust-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-common-0.2.9-3.el10_2.noarch.rpm;name=x86_64_v2_keylime-agent-rust-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-agent-rust-common}"
SRC_URI[x86_64_v2_keylime-agent-rust-common.sha256sum] = "3e0666345406d9d3160381c26f5ef7ab4e2799ff396f528e6d67ca6bc8661db3"

URI_x86_64_v2_keylime-agent-rust-ima-emulator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-ima-emulator-0.2.9-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust-ima-emulator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-agent-rust-ima-emulator}"
SRC_URI[x86_64_v2_keylime-agent-rust-ima-emulator.sha256sum] = "96498d72b2403c6b2f1a37938863cd1d0f1b5eb201131a70e8c947972fcaa88e"

URI_x86_64_v2_keylime-agent-rust-push = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/keylime-agent-rust-push-0.2.9-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_keylime-agent-rust-push;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keylime-agent-rust-push}"
SRC_URI[x86_64_v2_keylime-agent-rust-push.sha256sum] = "6e1ffa48ce85f0d235700a8745cb2a74649b6ed2ad367e0096b2d72b18e199fa"
RPROVIDES:keylime-agent-rust-push:x86_64_v2 = "virtual/keylime-agent"

URI_aarch64_keylime-agent-rust = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-0.2.9-3.el10_2.aarch64.rpm;name=aarch64_keylime-agent-rust;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-agent-rust}"
SRC_URI[aarch64_keylime-agent-rust.sha256sum] = "7d859a8c5e14a9e983b021f54663adb120cf720c1e7bc7e1cb10e5a65195d16d"
RPROVIDES:keylime-agent-rust:aarch64 = "virtual/keylime-agent"

URI_aarch64_keylime-agent-rust-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-common-0.2.9-3.el10_2.noarch.rpm;name=aarch64_keylime-agent-rust-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-agent-rust-common}"
SRC_URI[aarch64_keylime-agent-rust-common.sha256sum] = "3e0666345406d9d3160381c26f5ef7ab4e2799ff396f528e6d67ca6bc8661db3"

URI_aarch64_keylime-agent-rust-ima-emulator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-ima-emulator-0.2.9-3.el10_2.aarch64.rpm;name=aarch64_keylime-agent-rust-ima-emulator;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-agent-rust-ima-emulator}"
SRC_URI[aarch64_keylime-agent-rust-ima-emulator.sha256sum] = "4fbb446283f3cef4c5064aea4ce62d72f9ea442772723d2545a27d145e1c7beb"

URI_aarch64_keylime-agent-rust-push = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/keylime-agent-rust-push-0.2.9-3.el10_2.aarch64.rpm;name=aarch64_keylime-agent-rust-push;unpack=0"
SRC_URI:append = " ${URI_aarch64_keylime-agent-rust-push}"
SRC_URI[aarch64_keylime-agent-rust-push.sha256sum] = "8153e5f08299c6dfcd6f900bc18f100ce65785e9968556e035415d579fc8f5ed"
RPROVIDES:keylime-agent-rust-push:aarch64 = "virtual/keylime-agent"

RDEPENDS:keylime-agent-rust = " \
 bash \
 glibc \
 keylime-agent-rust-common \
 keylime-agent-rust-ima-emulator \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 util-linux-core \
 "
RDEPENDS:keylime-agent-rust-common = " \
 "
RDEPENDS:keylime-agent-rust-ima-emulator = " \
 glibc \
 keylime-agent-rust-common \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 "
RDEPENDS:keylime-agent-rust-push = " \
 glibc \
 keylime-agent-rust-common \
 keylime-agent-rust-ima-emulator \
 keylime-base \
 libgcc \
 openssl-libs \
 tpm2-tss \
 util-linux-core \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/keylime-agent"

PROVIDES:append:aarch64 = " rpm/virtual/keylime-agent"
