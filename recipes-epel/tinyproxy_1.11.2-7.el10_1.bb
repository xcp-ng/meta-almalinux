# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tinyproxy"
PV = "1.11.2"
PR = "7.el10_1"
PACKAGES = " \
 tinyproxy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/t/tinyproxy-1.11.2-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebcc508e0d79830791a7713500fae34d38a6f18bcdf289a720513e39fdeda329"

URI_x86_64_v2_tinyproxy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/tinyproxy-1.11.2-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_tinyproxy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_tinyproxy}"
SRC_URI[x86_64_v2_tinyproxy.sha256sum] = "55e24c8da8dc28a4aa7b6e1a3515e57ad6450d8ba490b31a0a1d1c8422614cc7"

URI_aarch64_tinyproxy = "${EPEL_MIRROR}/aarch64/Packages/t/tinyproxy-1.11.2-7.el10_1.aarch64.rpm;name=aarch64_tinyproxy;unpack=0"
SRC_URI:append = " ${URI_aarch64_tinyproxy}"
SRC_URI[aarch64_tinyproxy.sha256sum] = "28951954e2a7e761e27d0e24078000f7bde8db468f32f3dfb8d91a6ab8a17895"

RDEPENDS:tinyproxy = " \
 bash \
 glibc \
 "
