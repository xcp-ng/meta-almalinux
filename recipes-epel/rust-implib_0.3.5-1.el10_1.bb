# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-implib"
PV = "0.3.5"
PR = "1.el10_1"
PACKAGES = " \
 rust-implib+default-devel \
 rust-implib+gnu-devel \
 rust-implib+msvc-devel \
 rust-implib-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-implib-0.3.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46f3e740f1b16ffcc735f01bdf7c7441c80b8d59a3b77962136fdfbfd4ac1b20"

URI_x86_64_v2_rust-implib+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib+default-devel-0.3.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib+default-devel}"
SRC_URI[x86_64_v2_rust-implib+default-devel.sha256sum] = "1d27f05034bfc222d8b0fce93c96f7ecc447bf0362a42491b55536b6cf6d4ac9"

URI_x86_64_v2_rust-implib+gnu-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib+gnu-devel-0.3.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib+gnu-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib+gnu-devel}"
SRC_URI[x86_64_v2_rust-implib+gnu-devel.sha256sum] = "cc7462200215a71fd9f16bcc4da7899ad3185df6e0ae48c43c1b7a39d711f490"

URI_x86_64_v2_rust-implib+msvc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib+msvc-devel-0.3.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib+msvc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib+msvc-devel}"
SRC_URI[x86_64_v2_rust-implib+msvc-devel.sha256sum] = "1a602c34d71e4d99e0c823c7c3dc10af527fdfa718a67b1f9005a4f2c8e525e9"

URI_x86_64_v2_rust-implib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-implib-devel-0.3.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-implib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-implib-devel}"
SRC_URI[x86_64_v2_rust-implib-devel.sha256sum] = "85927626b126fdf571a41138017292886b32f59a5e45f60c33675e8883e43ee5"

URI_aarch64_rust-implib+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib+default-devel-0.3.5-1.el10_1.noarch.rpm;name=aarch64_rust-implib+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib+default-devel}"
SRC_URI[aarch64_rust-implib+default-devel.sha256sum] = "4e2e4282f3fa18a170635e4dc702c8e718bf12f4c95705f5079b9b6b33966cf5"

URI_aarch64_rust-implib+gnu-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib+gnu-devel-0.3.5-1.el10_1.noarch.rpm;name=aarch64_rust-implib+gnu-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib+gnu-devel}"
SRC_URI[aarch64_rust-implib+gnu-devel.sha256sum] = "582451ee90623829b15e43fd7aae0978952fcf12d3b2f3ca1b5d838ab1094f07"

URI_aarch64_rust-implib+msvc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib+msvc-devel-0.3.5-1.el10_1.noarch.rpm;name=aarch64_rust-implib+msvc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib+msvc-devel}"
SRC_URI[aarch64_rust-implib+msvc-devel.sha256sum] = "576a157f50e665b40102aae636384f9605b9258258b1298ea46b8388a620acc5"

URI_aarch64_rust-implib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-implib-devel-0.3.5-1.el10_1.noarch.rpm;name=aarch64_rust-implib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-implib-devel}"
SRC_URI[aarch64_rust-implib-devel.sha256sum] = "8381b12a460ac0fd7bc2d0554eeeb04bf9ca247cdeaf1e5c42e2a66b3844ab35"

RDEPENDS:rust-implib+default-devel = " \
 cargo \
 rust-implib+gnu-devel \
 rust-implib+msvc-devel \
 rust-implib-devel \
 "
RDEPENDS:rust-implib+gnu-devel = " \
 cargo \
 rust-implib-devel \
 rust-object0.36+write_std-devel \
 "
RDEPENDS:rust-implib+msvc-devel = " \
 cargo \
 rust-implib-devel \
 "
RDEPENDS:rust-implib-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-object0.36+pe-devel \
 rust-object0.36-devel \
 "
