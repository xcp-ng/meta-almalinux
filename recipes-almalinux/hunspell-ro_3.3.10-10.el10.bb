# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ro"
PV = "3.3.10"
PR = "10.el10"
PACKAGES = " \
 hunspell-ro \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ro-3.3.10-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "03254c8a25840978fb6f43ea99e37248b003464d9a4185dc10c9786b292ec52b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ro-3.3.10-10.el10.noarch.rpm;name=x86_64_v2_hunspell-ro;unpack=0"
SRC_URI[x86_64_v2_hunspell-ro.sha256sum] = "c49870ff88465a0528ebfe42d0744598ed345b0cf43db15678ba139423954dda"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ro-3.3.10-10.el10.noarch.rpm;name=aarch64_hunspell-ro;unpack=0"
SRC_URI[aarch64_hunspell-ro.sha256sum] = "c49870ff88465a0528ebfe42d0744598ed345b0cf43db15678ba139423954dda"

RDEPENDS:hunspell-ro = " \
 hunspell \
 "
