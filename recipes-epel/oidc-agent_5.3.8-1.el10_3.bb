# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oidc-agent"
PV = "5.3.8"
PR = "1.el10_3"
PACKAGES = " \
 oidc-agent-cli \
 oidc-agent-desktop \
 oidc-agent-devel \
 oidc-agent-libs \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/oidc-agent-5.3.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "62456738c8983e3e4fa97a2cd79cec51408d755a0dc8bfafdc2533f42d22fd01"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-cli-5.3.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-cli;unpack=0"
SRC_URI[x86_64_v2_oidc-agent-cli.sha256sum] = "5e22009d1db0b33eefe5e87e975b470def9bc3e4a2f5414813f1621fee8dc224"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-desktop-5.3.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-desktop;unpack=0"
SRC_URI[x86_64_v2_oidc-agent-desktop.sha256sum] = "213fa92a6d5e1136755a6113367618b4c0f9400ace23e39a4535b86f2ed58ed6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-devel-5.3.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-devel;unpack=0"
SRC_URI[x86_64_v2_oidc-agent-devel.sha256sum] = "8af1cd899bdfc04674af713308c5d737e3cf9e36dc896ba26122ca2c8d4edc50"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oidc-agent-libs-5.3.8-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_oidc-agent-libs;unpack=0"
SRC_URI[x86_64_v2_oidc-agent-libs.sha256sum] = "50395c9432fa1c07855cc7d0e9bd06102feef79a03a476d095ee761221b2c5fd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-cli-5.3.8-1.el10_3.aarch64.rpm;name=aarch64_oidc-agent-cli;unpack=0"
SRC_URI[aarch64_oidc-agent-cli.sha256sum] = "3e4cf1fa120e1bfa185a4e275fcecfa8eb20af27f681b2f86fb38abc388af8eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-desktop-5.3.8-1.el10_3.aarch64.rpm;name=aarch64_oidc-agent-desktop;unpack=0"
SRC_URI[aarch64_oidc-agent-desktop.sha256sum] = "eab7e619f0821e4bf4d92b611400b05282f88e3e1fbb590c4bc2de72a31d194f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-devel-5.3.8-1.el10_3.aarch64.rpm;name=aarch64_oidc-agent-devel;unpack=0"
SRC_URI[aarch64_oidc-agent-devel.sha256sum] = "905eb20f7a4a003137ee2d226d52560eaca58fb3c4db32f70a21b3afbe0a1c9c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oidc-agent-libs-5.3.8-1.el10_3.aarch64.rpm;name=aarch64_oidc-agent-libs;unpack=0"
SRC_URI[aarch64_oidc-agent-libs.sha256sum] = "e8f6924b3df8b1c77723c0f53100dfa1d5f730ad0bb3fabdc1e451f40a2726f3"

RDEPENDS:oidc-agent-cli = " \
 bash \
 cjson \
 clibs-list \
 glibc \
 libmicrohttpd \
 libsodium \
 oidc-agent-libs \
 qrencode-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:oidc-agent-desktop = " \
 cjson \
 clibs-list \
 glib2 \
 glibc \
 gtk3 \
 javascriptcoregtk4.1 \
 libgcc \
 libsodium \
 libstdc++ \
 oidc-agent-cli \
 oidc-agent-libs \
 webkit2gtk4.1 \
 "
RDEPENDS:oidc-agent-devel = " \
 oidc-agent-libs \
 "
RDEPENDS:oidc-agent-libs = " \
 cjson \
 clibs-list \
 glibc \
 libsodium \
 "
