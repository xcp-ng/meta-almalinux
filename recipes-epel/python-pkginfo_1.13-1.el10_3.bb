# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pkginfo"
PV = "1.13"
PR = "1.el10_3"
PACKAGES = " \
 python-pkginfo-doc \
 python3-pkginfo \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pkginfo-1.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bb58ff85017108d4c44676cb465fbeb07be5ce3bcb66090c9f2675ae5f75fd3e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pkginfo-doc-1.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-pkginfo-doc;unpack=0"
SRC_URI[x86_64_v2_python-pkginfo-doc.sha256sum] = "069a355af962aa36c393595a454a40344799003eb47be30ea98aac26828958c8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pkginfo-1.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pkginfo;unpack=0"
SRC_URI[x86_64_v2_python3-pkginfo.sha256sum] = "0f6a8ea8256c4c8d8883cfa78a56fc9ce03757597848cc83e83c9f4d4df60d3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-pkginfo-doc-1.13-1.el10_3.noarch.rpm;name=aarch64_python-pkginfo-doc;unpack=0"
SRC_URI[aarch64_python-pkginfo-doc.sha256sum] = "4624135e1b9e9f10b6c5acc631a5356a452cf7383c909c46d5edfa1bff74e5eb"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pkginfo-1.13-1.el10_3.noarch.rpm;name=aarch64_python3-pkginfo;unpack=0"
SRC_URI[aarch64_python3-pkginfo.sha256sum] = "bb9349621d22f49c06149617b3f7d24963ada01eeee43fed90c7c55f9f527fc7"

RDEPENDS:python-pkginfo-doc = " \
 "
RDEPENDS:python3-pkginfo = " \
 python3 \
 python3-setuptools \
 "
