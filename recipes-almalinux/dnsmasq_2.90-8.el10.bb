# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsmasq"
PV = "2.90"
PR = "8.el10"
PACKAGES = " \
 dnsmasq \
 dnsmasq-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dnsmasq-2.90-8.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e0c0f578c789006f8847dbfd6515810aa7f21ad6ae49a5f5b75863501ad0445d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-2.90-8.el10.x86_64_v2.rpm;name=x86_64_v2_dnsmasq;unpack=0"
SRC_URI[x86_64_v2_dnsmasq.sha256sum] = "c5917de2bc4df20949c058c87539a19b322ce2f66e23539f7fca4acd7442f24f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dnsmasq-utils-2.90-8.el10.x86_64_v2.rpm;name=x86_64_v2_dnsmasq-utils;unpack=0"
SRC_URI[x86_64_v2_dnsmasq-utils.sha256sum] = "3408fc5d9e047ea103ebceccc122460b40bafffb4ba25e286b4376714a66ed9a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-2.90-8.el10.aarch64.rpm;name=aarch64_dnsmasq;unpack=0"
SRC_URI[aarch64_dnsmasq.sha256sum] = "208c813a124f47edaeb4cf7b92717f85f6bfa6d33674e47471fd802aa4c29aea"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dnsmasq-utils-2.90-8.el10.aarch64.rpm;name=aarch64_dnsmasq-utils;unpack=0"
SRC_URI[aarch64_dnsmasq-utils.sha256sum] = "97c9ad71c880359043d38a32ad4581765cf464b6ab876d1dd432c8e8d5116dc2"

RDEPENDS:dnsmasq = " \
 bash \
 dbus-libs \
 glibc \
 gmp \
 libidn2 \
 libnetfilter_conntrack \
 nettle \
 "
RDEPENDS:dnsmasq-utils = " \
 glibc \
 "
