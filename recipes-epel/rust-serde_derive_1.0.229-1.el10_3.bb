# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_derive"
PV = "1.0.229"
PR = "1.el10_3"
PACKAGES = " \
 rust-serde_derive+default-devel \
 rust-serde_derive+deserialize_in_place-devel \
 rust-serde_derive-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-serde_derive-1.0.229-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "91cfae0280fd4ca2d58e434cf7e50a7f606a368f7bd26bf15dd2a53640fd0730"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive+default-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_derive+default-devel.sha256sum] = "c3d82865600aab3f930381623a298593e7796fd80d827da3aa404960e5d9f307"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive+deserialize_in_place-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive+deserialize_in_place-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_derive+deserialize_in_place-devel.sha256sum] = "b355beae164015e4cbce4e3eade6cf00287affb5295061bf5337a2354293b643"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_derive-devel-1.0.229-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_derive-devel;unpack=0"
SRC_URI[x86_64_v2_rust-serde_derive-devel.sha256sum] = "4b02a5ead2dac80b0d3f6cd57cecbdef663f98f58c75bcbf39cce2a92063a79a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive+default-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_derive+default-devel;unpack=0"
SRC_URI[aarch64_rust-serde_derive+default-devel.sha256sum] = "67f4cd5b9985a861f60a27153f2e5eaea402c2c5a622cc90a3f20ea3345c3bb5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive+deserialize_in_place-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_derive+deserialize_in_place-devel;unpack=0"
SRC_URI[aarch64_rust-serde_derive+deserialize_in_place-devel.sha256sum] = "84790e546dad38b5026d910890487f68c12edaeb8c573ee201c05809b2a69c4f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_derive-devel-1.0.229-1.el10_3.noarch.rpm;name=aarch64_rust-serde_derive-devel;unpack=0"
SRC_URI[aarch64_rust-serde_derive-devel.sha256sum] = "b3f89429fe9978174977dc9e5983b48b7a1e3788f9cade2386266d6ee8fcba84"

RDEPENDS:rust-serde_derive+default-devel = " \
 cargo \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-serde_derive+deserialize_in_place-devel = " \
 cargo \
 rust-serde_derive-devel \
 "
RDEPENDS:rust-serde_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+proc-macro-devel \
 rust-proc-macro2-devel \
 rust-quote+proc-macro-devel \
 rust-quote-devel \
 rust-syn+clone-impls-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 "
