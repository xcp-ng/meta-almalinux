# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-scanner"
PV = "0.31.10"
PR = "3.el10_3"
PACKAGES = " \
 rust-wayland-scanner+default-devel \
 rust-wayland-scanner-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-scanner-0.31.10-3.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d72bd839d7691ac27f550f9e09939bc41f8a03c15646ab19cd6a9b6e23d055ac"

URI_x86_64_v2_rust-wayland-scanner+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner+default-devel-0.31.10-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-scanner+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-scanner+default-devel.sha256sum] = "b5e86732ba1361a64a5c87b29a802ef2d386fad9083f44711a19a8afb740c4ba"

URI_x86_64_v2_rust-wayland-scanner-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-scanner-devel-0.31.10-3.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-scanner-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-scanner-devel}"
SRC_URI[x86_64_v2_rust-wayland-scanner-devel.sha256sum] = "e9e844978ea76c573a4ce65b319e49f1b812ab13681324f29e1c45b8d4c9d5fa"

URI_aarch64_rust-wayland-scanner+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner+default-devel-0.31.10-3.el10_3.noarch.rpm;name=aarch64_rust-wayland-scanner+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-scanner+default-devel}"
SRC_URI[aarch64_rust-wayland-scanner+default-devel.sha256sum] = "4374312246f97fef682c8ff7a61c543ee5b96590540ce3a73af2d35da52babcb"

URI_aarch64_rust-wayland-scanner-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-scanner-devel-0.31.10-3.el10_3.noarch.rpm;name=aarch64_rust-wayland-scanner-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-scanner-devel}"
SRC_URI[aarch64_rust-wayland-scanner-devel.sha256sum] = "784544ec0b3bd1b9bc223c30671161b2854ae4a4c03e2aececbff804403490df"

RDEPENDS:rust-wayland-scanner+default-devel = " \
 cargo \
 rust-wayland-scanner-devel \
 "
RDEPENDS:rust-wayland-scanner-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quick-xml+default-devel \
 rust-quote+default-devel \
 "
