# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kapidox"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kapidox \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kapidox-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b8e51f07ba5be1110f2bf2e04195dd5be80489e826465367e397578ba4220756"

URI_x86_64_v2_kf6-kapidox = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kapidox-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kapidox;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kapidox}"
SRC_URI[x86_64_v2_kf6-kapidox.sha256sum] = "e912d65781588167c896a16f75c2c5e9629a4c70fe2decbb143252984df2ab24"

URI_aarch64_kf6-kapidox = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kapidox-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kapidox;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kapidox}"
SRC_URI[aarch64_kf6-kapidox.sha256sum] = "e55fe3b46bc6049dcb7d0c0759a1a76c7a0c15b75e4885f097d715d30e2a5f8b"

RDEPENDS:kf6-kapidox = " \
 bash \
 doxygen \
 kf6-filesystem \
 python3 \
 python3-doxypypy \
 python3-doxyqml \
 python3-jinja2 \
 python3-pyyaml \
 python3-requests \
 qt6-doc-devel \
 "
