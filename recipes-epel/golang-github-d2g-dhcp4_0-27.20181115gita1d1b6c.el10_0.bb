# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-d2g-dhcp4"
PV = "0"
PR = "27.20181115gita1d1b6c.el10_0"
PACKAGES = " \
 golang-github-d2g-dhcp4-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-d2g-dhcp4-0-27.20181115gita1d1b6c.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c6c01093651e1996fdc4af35a1129808d09464d53772b8596fbf90808d15e11"

URI_aarch64_golang-github-d2g-dhcp4-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-d2g-dhcp4-devel-0-27.20181115gita1d1b6c.el10_0.noarch.rpm;name=aarch64_golang-github-d2g-dhcp4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-d2g-dhcp4-devel}"
SRC_URI[aarch64_golang-github-d2g-dhcp4-devel.sha256sum] = "7cfdde3c18fed1f18f5b933c9c69f301153f160bc2545d382192d539c9d0e2d5"

RDEPENDS:golang-github-d2g-dhcp4-devel = " \
 go-filesystem \
 "
