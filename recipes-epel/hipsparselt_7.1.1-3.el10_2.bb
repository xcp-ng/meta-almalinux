# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hipsparselt"
PV = "7.1.1"
PR = "3.el10_2"
PACKAGES:x86_64_v2 = " \
 hipsparselt \
 hipsparselt-devel \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${EPELSRC_MIRROR}/Packages/h/hipsparselt-7.1.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b9e336151b533c19cc8c1e72b3ab12710cf3ac1976815ab1f4276960dc0c0ae3"

URI_x86_64_v2_hipsparselt = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparselt-7.1.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparselt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparselt}"
SRC_URI[x86_64_v2_hipsparselt.sha256sum] = "dd0751fc7095730d85ce08791e43d8bb4b57d7badd117f6b02d4af415f30e4e1"

URI_x86_64_v2_hipsparselt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/hipsparselt-devel-7.1.1-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_hipsparselt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hipsparselt-devel}"
SRC_URI[x86_64_v2_hipsparselt-devel.sha256sum] = "20d9a3bdafec7d3f57298a72dea58ea737be2b3b77c24fe4fb914b9520e119c9"

RDEPENDS:hipsparselt = " \
 glibc \
 libgcc \
 libstdc++ \
 rocm-hip \
 rocm-origami \
 roctracer \
 "
RDEPENDS:hipsparselt-devel = " \
 cmake-filesystem \
 hipsparselt \
 "
