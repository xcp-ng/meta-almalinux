# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "syslinux"
PV = "6.04"
PR = "0.30.el10.alma.1"
PACKAGES:x86_64_v2 = " \
 syslinux \
 syslinux-extlinux \
 syslinux-extlinux-nonlinux \
 syslinux-nonlinux \
 syslinux-tftpboot \
"
PACKAGES:aarch64 = " \
 syslinux-tftpboot \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/syslinux-6.04-0.30.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7eaf2d3b201f32ba43392c342b267ad07ab9b6565b6888f378327f93615f9af4"

URI_x86_64_v2_syslinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-6.04-0.30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_syslinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux}"
SRC_URI[x86_64_v2_syslinux.sha256sum] = "5a3d1763971eb401d440784d67132072d9c229c98cba5a12fe57bafb30e8d3dc"

URI_x86_64_v2_syslinux-extlinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-extlinux-6.04-0.30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_syslinux-extlinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux-extlinux}"
SRC_URI[x86_64_v2_syslinux-extlinux.sha256sum] = "7ae2558eeb88f35296da729ab1b62b9ac2fb76e8805ee9b4ec21a186cfb3adaa"

URI_x86_64_v2_syslinux-extlinux-nonlinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-extlinux-nonlinux-6.04-0.30.el10.alma.1.noarch.rpm;name=x86_64_v2_syslinux-extlinux-nonlinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux-extlinux-nonlinux}"
SRC_URI[x86_64_v2_syslinux-extlinux-nonlinux.sha256sum] = "f8afaedbcf9af81c3299ea04889e98a0b581cb480307d2667b0579c251e20670"

URI_x86_64_v2_syslinux-nonlinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/syslinux-nonlinux-6.04-0.30.el10.alma.1.noarch.rpm;name=x86_64_v2_syslinux-nonlinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux-nonlinux}"
SRC_URI[x86_64_v2_syslinux-nonlinux.sha256sum] = "e82149bd201bf7d06b2fba3f5ea418b3b297de73142424421349631d8bdeb36a"

URI_x86_64_v2_syslinux-tftpboot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/syslinux-tftpboot-6.04-0.30.el10.alma.1.noarch.rpm;name=x86_64_v2_syslinux-tftpboot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_syslinux-tftpboot}"
SRC_URI[x86_64_v2_syslinux-tftpboot.sha256sum] = "b8a86cea5a86f9c0355a93774fa5184677481e09b2f5330bcc81c8130850fde8"

URI_aarch64_syslinux-tftpboot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/syslinux-tftpboot-6.04-0.30.el10.alma.1.noarch.rpm;name=aarch64_syslinux-tftpboot;unpack=0"
SRC_URI:append = " ${URI_aarch64_syslinux-tftpboot}"
SRC_URI[aarch64_syslinux-tftpboot.sha256sum] = "b8a86cea5a86f9c0355a93774fa5184677481e09b2f5330bcc81c8130850fde8"

RDEPENDS:syslinux = " \
 glibc \
 libuuid \
 mtools \
 syslinux-nonlinux \
 "
RDEPENDS:syslinux-extlinux = " \
 bash \
 glibc \
 syslinux \
 syslinux-extlinux-nonlinux \
 "
RDEPENDS:syslinux-extlinux-nonlinux = " \
 glibc \
 syslinux \
 "
RDEPENDS:syslinux-nonlinux = " \
 glibc \
 syslinux \
 "
RDEPENDS:syslinux-tftpboot = " \
 glibc \
 "
