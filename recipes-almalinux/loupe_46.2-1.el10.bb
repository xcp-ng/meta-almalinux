# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "loupe"
PV = "46.2"
PR = "1.el10"
PACKAGES:x86_64_v2 = " \
 loupe \
"
PACKAGES:aarch64 = " \
  \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/loupe-46.2-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1dc36401bcfa942e6fdfae73e7f56ec4de5dd206451838e1ee08605d3e46e62c"

URI_x86_64_v2_loupe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/loupe-46.2-1.el10.x86_64_v2.rpm;name=x86_64_v2_loupe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_loupe}"
SRC_URI[x86_64_v2_loupe.sha256sum] = "271bbfedbf7757b4b90ad769f63a90e851e1108ef55f87d9914f8b67db5c0860"

RDEPENDS:loupe = " \
 cairo \
 dbus \
 glib2 \
 glibc \
 glycin-loaders \
 graphene \
 gtk4 \
 hicolor-icon-theme \
 lcms2 \
 libadwaita \
 libgcc \
 libgweather \
 libseccomp \
 "
