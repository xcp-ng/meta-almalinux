# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pillow"
PV = "11.0.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-pillow \
 python3-pillow-devel \
 python3-pillow-tk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pillow-11.0.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f4f35e5b48ff69e7c290260c745786742d9256c654b81ecba431ae2eec40061b"

URI_x86_64_v2_python3-pillow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pillow-11.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pillow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pillow}"
SRC_URI[x86_64_v2_python3-pillow.sha256sum] = "8e6fddee1d951456a6dda4c751f51e08f07b2d1312a086ac47f0ac8b62edc805"

URI_x86_64_v2_python3-pillow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pillow-devel-11.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pillow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pillow-devel}"
SRC_URI[x86_64_v2_python3-pillow-devel.sha256sum] = "f92e834333a23b65108f673737a5d1c4c7c79143ca0eb18047d7569a3182cefb"

URI_x86_64_v2_python3-pillow-tk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pillow-tk-11.0.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pillow-tk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pillow-tk}"
SRC_URI[x86_64_v2_python3-pillow-tk.sha256sum] = "2cda0d476d98c0364aea0901901ee82595dd9ad9808c1295bf9d6a48d754a03e"

URI_aarch64_python3-pillow = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pillow-11.0.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pillow;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pillow}"
SRC_URI[aarch64_python3-pillow.sha256sum] = "550fd9001a41aad7b48f22cb218f4cf54bb98d8e35d5ad36be6310adc9ccc3cc"

URI_aarch64_python3-pillow-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pillow-devel-11.0.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pillow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pillow-devel}"
SRC_URI[aarch64_python3-pillow-devel.sha256sum] = "411ddf5b8797264ea56f88aea1142c5ab60fbc3f14dac340e6b6523f2fb67719"

URI_aarch64_python3-pillow-tk = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pillow-tk-11.0.0-1.el10_0.aarch64.rpm;name=aarch64_python3-pillow-tk;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pillow-tk}"
SRC_URI[aarch64_python3-pillow-tk.sha256sum] = "3739115462893bbf2e1cc181fafc5e3ec451a601a17464171ab9d0ff2151b619"

RDEPENDS:python3-pillow = " \
 freetype \
 glibc \
 lcms2 \
 libimagequant \
 libjpeg-turbo \
 libraqm \
 libtiff \
 libwebp \
 libxcb \
 openjpeg2 \
 python3 \
 python3-olefile \
 zlib-ng-compat \
 "
RDEPENDS:python3-pillow-devel = " \
 libjpeg-turbo-devel \
 python3-devel \
 python3-pillow \
 zlib-ng-compat-devel \
 "
RDEPENDS:python3-pillow-tk = " \
 glibc \
 python3 \
 python3-pillow \
 python3-tkinter \
 "
