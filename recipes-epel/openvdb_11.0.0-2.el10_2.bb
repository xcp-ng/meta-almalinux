# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvdb"
PV = "11.0.0"
PR = "2.el10_2"
PACKAGES = " \
 openvdb \
 openvdb-devel \
 openvdb-libs \
 python3-openvdb \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openvdb-11.0.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "04421253a633aae48a44262996a9a1f971a6410f42ff1601d0092e1d34166268"

URI_x86_64_v2_openvdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvdb-11.0.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvdb}"
SRC_URI[x86_64_v2_openvdb.sha256sum] = "e3758dfb00e9867635f72640f5580da275cd8e508e2b2bfb1778736059cc0325"

URI_x86_64_v2_openvdb-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvdb-devel-11.0.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvdb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvdb-devel}"
SRC_URI[x86_64_v2_openvdb-devel.sha256sum] = "74256214096ba470431a48b9c3a431228e7e3cb2f89602b6d9b15d2125d42050"

URI_x86_64_v2_openvdb-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvdb-libs-11.0.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvdb-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvdb-libs}"
SRC_URI[x86_64_v2_openvdb-libs.sha256sum] = "c0fcdb0c940deda8de5866e58204a5367753048c08c4125fd335736084b21958"

URI_x86_64_v2_python3-openvdb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-openvdb-11.0.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-openvdb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-openvdb}"
SRC_URI[x86_64_v2_python3-openvdb.sha256sum] = "dcec1aedc791d3734ffbd98b5926638a4524d7a816e9bb7e8f84210f2abfc85d"

URI_aarch64_openvdb = "${EPEL_MIRROR}/aarch64/Packages/o/openvdb-11.0.0-2.el10_2.aarch64.rpm;name=aarch64_openvdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvdb}"
SRC_URI[aarch64_openvdb.sha256sum] = "d5bb8b61b3c5c69907ab0349d4b6c8b1544a771a87e7738a2814aa335d5893d6"

URI_aarch64_openvdb-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openvdb-devel-11.0.0-2.el10_2.aarch64.rpm;name=aarch64_openvdb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvdb-devel}"
SRC_URI[aarch64_openvdb-devel.sha256sum] = "b14969f6ec5a21ca31f115de6174c2e947446453fddb081062ee90d65ac9c56a"

URI_aarch64_openvdb-libs = "${EPEL_MIRROR}/aarch64/Packages/o/openvdb-libs-11.0.0-2.el10_2.aarch64.rpm;name=aarch64_openvdb-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvdb-libs}"
SRC_URI[aarch64_openvdb-libs.sha256sum] = "74e3ded90fff0412478b11838d9fa33133d400e70261bc90ac3dee28176a6c7a"

URI_aarch64_python3-openvdb = "${EPEL_MIRROR}/aarch64/Packages/p/python3-openvdb-11.0.0-2.el10_2.aarch64.rpm;name=aarch64_python3-openvdb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-openvdb}"
SRC_URI[aarch64_python3-openvdb.sha256sum] = "3923f167fd40ed156332e466efe57e6ecd2aaf139a223915d5595b2639ae3f45"

RDEPENDS:openvdb = " \
 blosc \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 openvdb-libs \
 tbb \
 zlib-ng-compat \
 "
RDEPENDS:openvdb-devel = " \
 openvdb-libs \
 tbb-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:openvdb-libs = " \
 blosc \
 boost-iostreams \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 tbb \
 zlib-ng-compat \
 "
RDEPENDS:python3-openvdb = " \
 glibc \
 imath \
 libgcc \
 libstdc++ \
 openvdb-libs \
 python3 \
 tbb \
 "
