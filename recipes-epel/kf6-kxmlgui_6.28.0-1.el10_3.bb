# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kxmlgui"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kxmlgui \
 kf6-kxmlgui-devel \
 kf6-kxmlgui-doc \
 kf6-kxmlgui-html \
 python3-kf6-kxmlgui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kxmlgui-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "218cb729c34898114fee5e1c4e2c74b8b058ff90a00bcffdbcf6b66033b8b778"

URI_x86_64_v2_kf6-kxmlgui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui}"
SRC_URI[x86_64_v2_kf6-kxmlgui.sha256sum] = "b06835bd5a9ad381a224daeea7fabcb4ac3984704e63aa2dc11edf193d28dc94"

URI_x86_64_v2_kf6-kxmlgui-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kxmlgui-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-devel}"
SRC_URI[x86_64_v2_kf6-kxmlgui-devel.sha256sum] = "13cfba920ee9e0de8cf79abc8a88181d3e96ab822b7e26f79abb94b7328d4c6a"

URI_x86_64_v2_kf6-kxmlgui-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kxmlgui-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-doc}"
SRC_URI[x86_64_v2_kf6-kxmlgui-doc.sha256sum] = "67c2e1f8df4a371548c47671ff8f14eec91acb18ab8edaa5449233b54a755c15"

URI_x86_64_v2_kf6-kxmlgui-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kxmlgui-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kxmlgui-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kxmlgui-html}"
SRC_URI[x86_64_v2_kf6-kxmlgui-html.sha256sum] = "f9c1805d27f7c576baf0b84bd5a0ef8be9fd4d6a260e7ae4d13a157e8d909618"

URI_x86_64_v2_python3-kf6-kxmlgui = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kxmlgui-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kxmlgui}"
SRC_URI[x86_64_v2_python3-kf6-kxmlgui.sha256sum] = "7b88998ec17de8481684a2d3a72190c109f482c1259deeb9c82976604ee130c2"

URI_aarch64_kf6-kxmlgui = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui}"
SRC_URI[aarch64_kf6-kxmlgui.sha256sum] = "ae41e0c82358abdc3067a5c0834b0daeeac5a28e4dc63d5383fe28cef809eb0e"

URI_aarch64_kf6-kxmlgui-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kxmlgui-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-devel}"
SRC_URI[aarch64_kf6-kxmlgui-devel.sha256sum] = "2a1154e1148a0e2ae78f3df407b84187cc036f14d2861f026c0b1db8a78c2a97"

URI_aarch64_kf6-kxmlgui-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kxmlgui-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-doc}"
SRC_URI[aarch64_kf6-kxmlgui-doc.sha256sum] = "49b412c44351bd4f5972fdfad54024de6318a14a910f9cc8ff1959096a1e4257"

URI_aarch64_kf6-kxmlgui-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kxmlgui-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kxmlgui-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kxmlgui-html}"
SRC_URI[aarch64_kf6-kxmlgui-html.sha256sum] = "54eba9d6d5e72c5178a3cdabc5e53868dbf7a933e4f52fa509d800dd65e0cd51"

URI_aarch64_python3-kf6-kxmlgui = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kxmlgui-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_python3-kf6-kxmlgui;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kxmlgui}"
SRC_URI[aarch64_python3-kf6-kxmlgui.sha256sum] = "3baa266c4ee4c7b55ff180233e6e038b4064616f1608f5c4c1ecd84d629e58db"

RDEPENDS:kf6-kxmlgui = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kitemviews \
 kf6-kwidgetsaddons \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-devel = " \
 cmake-filesystem \
 glibc \
 kf6-kconfig-devel \
 kf6-kconfigwidgets-devel \
 kf6-kguiaddons-devel \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kxmlgui-doc = " \
 "
RDEPENDS:kf6-kxmlgui-html = " \
 "
RDEPENDS:python3-kf6-kxmlgui = " \
 glibc \
 kf6-kxmlgui \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
