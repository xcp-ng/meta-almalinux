# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iri-string"
PV = "0.7.13"
PR = "1.el10_3"
PACKAGES = " \
 rust-iri-string+alloc-devel \
 rust-iri-string+default-devel \
 rust-iri-string+memchr-devel \
 rust-iri-string+serde-devel \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iri-string-0.7.13-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc5572769b5b47844af0c8d34bcf0db35d17b523f4ea88f2c63890de9179b18e"

URI_x86_64_v2_rust-iri-string+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+alloc-devel-0.7.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+alloc-devel}"
SRC_URI[x86_64_v2_rust-iri-string+alloc-devel.sha256sum] = "574ebe7a4aee7a3b032d9089c59852e26613640727ac9501ba323c9c1c4a1c62"

URI_x86_64_v2_rust-iri-string+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+default-devel-0.7.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+default-devel}"
SRC_URI[x86_64_v2_rust-iri-string+default-devel.sha256sum] = "55d1f6481aa09de24d6c1532ff8baabea13ae6ee6d1633221abb3de96ec3a8d0"

URI_x86_64_v2_rust-iri-string+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+memchr-devel-0.7.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+memchr-devel}"
SRC_URI[x86_64_v2_rust-iri-string+memchr-devel.sha256sum] = "b37f7943ab3840609a77b8bdb3f28952d5bc9c89b49684eee341a8423077388e"

URI_x86_64_v2_rust-iri-string+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+serde-devel-0.7.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+serde-devel}"
SRC_URI[x86_64_v2_rust-iri-string+serde-devel.sha256sum] = "22221a1a7321efc515c09fc70560bd3e8ae89dc9186a04b99b17ea3c3086b954"

URI_x86_64_v2_rust-iri-string+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+std-devel-0.7.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+std-devel}"
SRC_URI[x86_64_v2_rust-iri-string+std-devel.sha256sum] = "af0230609d0a23731133c46ef60fc90d47d778891a09ad179d2cfa12e490ba8e"

URI_x86_64_v2_rust-iri-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string-devel-0.7.13-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string-devel}"
SRC_URI[x86_64_v2_rust-iri-string-devel.sha256sum] = "9ffff6e92f7b82109f264a48fcfe70c9c462052d0212f2e0fa3b82d77d998d6b"

URI_aarch64_rust-iri-string+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+alloc-devel-0.7.13-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+alloc-devel}"
SRC_URI[aarch64_rust-iri-string+alloc-devel.sha256sum] = "36cbcf6fad3739304e990ca40a512480f9deee3704f9ac5202848d25d7bf300c"

URI_aarch64_rust-iri-string+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+default-devel-0.7.13-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+default-devel}"
SRC_URI[aarch64_rust-iri-string+default-devel.sha256sum] = "e85d738e787684f2a74c9f7b4e1ad6aabcd537d180c2da155fa794dea2b42039"

URI_aarch64_rust-iri-string+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+memchr-devel-0.7.13-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+memchr-devel}"
SRC_URI[aarch64_rust-iri-string+memchr-devel.sha256sum] = "ffccf012a743b789f260769da962bb395aa37225de5a229f166407f0ffcb0716"

URI_aarch64_rust-iri-string+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+serde-devel-0.7.13-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+serde-devel}"
SRC_URI[aarch64_rust-iri-string+serde-devel.sha256sum] = "1e1ae84a4b18bf868397c8fae4f8419ad2c81bbbafc22abd30951238eb8d9e64"

URI_aarch64_rust-iri-string+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+std-devel-0.7.13-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+std-devel}"
SRC_URI[aarch64_rust-iri-string+std-devel.sha256sum] = "5d42b4b913e0ec65d3d7519354ef65a095e522c5bbbeb989121b6fc1002e5dfb"

URI_aarch64_rust-iri-string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string-devel-0.7.13-1.el10_3.noarch.rpm;name=aarch64_rust-iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string-devel}"
SRC_URI[aarch64_rust-iri-string-devel.sha256sum] = "f8d8df9f596831ef75e63d26abc989622e0d4e48f3d4a93e952956d6cfc2ed7a"

RDEPENDS:rust-iri-string+alloc-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+default-devel = " \
 cargo \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "
RDEPENDS:rust-iri-string+memchr-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-iri-string+serde-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+std-devel = " \
 cargo \
 rust-iri-string+alloc-devel \
 rust-iri-string-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string-devel = " \
 cargo \
 rust \
 "
