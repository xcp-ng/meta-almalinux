# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-google-uuid"
PV = "1.6.0"
PR = "2.el10_0"
PACKAGES = " \
 golang-github-google-uuid-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-google-uuid-1.6.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c075a00c680fa04692faa34b4a68b62510acc8376f1da0bd564107bc889e4a8e"

URI_x86_64_v2_golang-github-google-uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-google-uuid-devel-1.6.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-google-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-google-uuid-devel}"
SRC_URI[x86_64_v2_golang-github-google-uuid-devel.sha256sum] = "ad8ef75a39467f52ec1379bea4f23672f943a6994a2c00c96f0a5829ccb9d238"

URI_aarch64_golang-github-google-uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-uuid-devel-1.6.0-2.el10_0.noarch.rpm;name=aarch64_golang-github-google-uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-google-uuid-devel}"
SRC_URI[aarch64_golang-github-google-uuid-devel.sha256sum] = "684895719959856333777fe3144406ab2fe5e19c73772301bfd27943ac87139d"

RDEPENDS:golang-github-google-uuid-devel = " \
 go-filesystem \
 "
