# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dymo-cups-drivers"
PV = "1.4.0.5"
PR = "24.el10_2"
PACKAGES = " \
 dymo-cups-drivers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dymo-cups-drivers-1.4.0.5-24.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad39e3e911c82d81c291fb610df27d375e3a758e9f4281da7ebddce8a13fc70d"

URI_x86_64_v2_dymo-cups-drivers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dymo-cups-drivers-1.4.0.5-24.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dymo-cups-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dymo-cups-drivers}"
SRC_URI[x86_64_v2_dymo-cups-drivers.sha256sum] = "20132676b483f306e2408a1a2a5624e5273079878e56466cffab06982a8fe399"

URI_aarch64_dymo-cups-drivers = "${EPEL_MIRROR}/aarch64/Packages/d/dymo-cups-drivers-1.4.0.5-24.el10_2.aarch64.rpm;name=aarch64_dymo-cups-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_dymo-cups-drivers}"
SRC_URI[aarch64_dymo-cups-drivers.sha256sum] = "e1075e3394c6bc89ef4f4811a891c535b436304be29bca1d54f477592e4b3f55"

RDEPENDS:dymo-cups-drivers = " \
 cups \
 cups-libs \
 glibc \
 libgcc \
 libstdc++ \
 "
