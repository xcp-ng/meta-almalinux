# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-find-crate"
PV = "0.6.3"
PR = "11.el10_1"
PACKAGES = " \
 rust-find-crate+default-devel \
 rust-find-crate-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-find-crate-0.6.3-11.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3ec563cb95c487729638abf6b723e443ef5cb02d5e44237e52982c80cc389b28"

URI_x86_64_v2_rust-find-crate+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-crate+default-devel-0.6.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-crate+default-devel}"
SRC_URI[x86_64_v2_rust-find-crate+default-devel.sha256sum] = "6b2c9a5bfb29c75212f1b06d9b5cf12daebb15deb43c0385a682b4f387df29a9"

URI_x86_64_v2_rust-find-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-find-crate-devel-0.6.3-11.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-find-crate-devel}"
SRC_URI[x86_64_v2_rust-find-crate-devel.sha256sum] = "c3f2c123df750a7078a156cd4fb0d178538360782890309ff68e9abc50aec9a5"

URI_aarch64_rust-find-crate+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-crate+default-devel-0.6.3-11.el10_1.noarch.rpm;name=aarch64_rust-find-crate+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-crate+default-devel}"
SRC_URI[aarch64_rust-find-crate+default-devel.sha256sum] = "04702c043a6eb7f4bde983e0164a043e6258873dd3db47f844cd918d9dfa1dfc"

URI_aarch64_rust-find-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-find-crate-devel-0.6.3-11.el10_1.noarch.rpm;name=aarch64_rust-find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-find-crate-devel}"
SRC_URI[aarch64_rust-find-crate-devel.sha256sum] = "58e3d9fdffb044f8db1e00960d6c1a81d9acff22ce4ea4232a5c0c1a069516ca"

RDEPENDS:rust-find-crate+default-devel = " \
 cargo \
 rust-find-crate-devel \
 "
RDEPENDS:rust-find-crate-devel = " \
 cargo \
 rust-toml0.5+default-devel \
 "
