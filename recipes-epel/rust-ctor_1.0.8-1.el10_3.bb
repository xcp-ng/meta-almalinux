# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ctor"
PV = "1.0.8"
PR = "1.el10_3"
PACKAGES = " \
 rust-ctor+default-devel \
 rust-ctor+priority-devel \
 rust-ctor+proc_macro-devel \
 rust-ctor+std-devel \
 rust-ctor-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ctor-1.0.8-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a06e5133c91f65c138383312f53522c44e798c888d98e3f40a59be196bc46ff"

URI_x86_64_v2_rust-ctor+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+default-devel-1.0.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor+default-devel}"
SRC_URI[x86_64_v2_rust-ctor+default-devel.sha256sum] = "668ccfb7a870d3c994f0a1523a0c4cfc0445aea8c92a1640d65d88aa98f055eb"

URI_x86_64_v2_rust-ctor+priority-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+priority-devel-1.0.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+priority-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor+priority-devel}"
SRC_URI[x86_64_v2_rust-ctor+priority-devel.sha256sum] = "050bba63fd251aa416add57e76b90d2654f8776f149322df8d6196a8d5236375"

URI_x86_64_v2_rust-ctor+proc_macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+proc_macro-devel-1.0.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor+proc_macro-devel}"
SRC_URI[x86_64_v2_rust-ctor+proc_macro-devel.sha256sum] = "ee7423fa39c56ccff53463906d95dbd4f206ab9e077256e36d4e66adc3834b95"

URI_x86_64_v2_rust-ctor+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor+std-devel-1.0.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor+std-devel}"
SRC_URI[x86_64_v2_rust-ctor+std-devel.sha256sum] = "c70112a150f81fb3d5aa3c8f239ccbedc89b0176ea3418c638ffdebbbf9b9781"

URI_x86_64_v2_rust-ctor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ctor-devel-1.0.8-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ctor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ctor-devel}"
SRC_URI[x86_64_v2_rust-ctor-devel.sha256sum] = "a08a39d58da703586911da49243298587734979da352dc62f1d293da1e6129f1"

URI_aarch64_rust-ctor+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+default-devel-1.0.8-1.el10_3.noarch.rpm;name=aarch64_rust-ctor+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor+default-devel}"
SRC_URI[aarch64_rust-ctor+default-devel.sha256sum] = "ceaa914e8f1abbb6c3ec79b86f0b8cf70a4aebcb5da4a8d9e5b55decac551415"

URI_aarch64_rust-ctor+priority-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+priority-devel-1.0.8-1.el10_3.noarch.rpm;name=aarch64_rust-ctor+priority-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor+priority-devel}"
SRC_URI[aarch64_rust-ctor+priority-devel.sha256sum] = "d918e284163b48d49ee7c34aff542580677a97619039f1c75c77ede0b5fe4688"

URI_aarch64_rust-ctor+proc_macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+proc_macro-devel-1.0.8-1.el10_3.noarch.rpm;name=aarch64_rust-ctor+proc_macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor+proc_macro-devel}"
SRC_URI[aarch64_rust-ctor+proc_macro-devel.sha256sum] = "bcd297f03251845e3bd65b9b523a623a8536e932cfdbb226dd99bfe602407839"

URI_aarch64_rust-ctor+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor+std-devel-1.0.8-1.el10_3.noarch.rpm;name=aarch64_rust-ctor+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor+std-devel}"
SRC_URI[aarch64_rust-ctor+std-devel.sha256sum] = "1d7b494f803461ec72896cb9244a8c5370336de5b202e111d4fe92157ab0018f"

URI_aarch64_rust-ctor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ctor-devel-1.0.8-1.el10_3.noarch.rpm;name=aarch64_rust-ctor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ctor-devel}"
SRC_URI[aarch64_rust-ctor-devel.sha256sum] = "8f64082000ba6d30611cefc5bd7ca4a45665f55174bbc211ebbe176c03b61318"

RDEPENDS:rust-ctor+default-devel = " \
 cargo \
 rust-ctor+priority-devel \
 rust-ctor+proc_macro-devel \
 rust-ctor+std-devel \
 rust-ctor-devel \
 "
RDEPENDS:rust-ctor+priority-devel = " \
 cargo \
 rust-ctor-devel \
 rust-link-section-devel \
 "
RDEPENDS:rust-ctor+proc_macro-devel = " \
 cargo \
 rust-ctor-devel \
 rust-linktime-proc-macro+ctor-devel \
 rust-linktime-proc-macro+default-devel \
 "
RDEPENDS:rust-ctor+std-devel = " \
 cargo \
 rust-ctor-devel \
 "
RDEPENDS:rust-ctor-devel = " \
 cargo \
 rust \
 "
