# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror-impl"
PV = "2.0.21"
PR = "1.el10_3"
PACKAGES = " \
 rust-thiserror-impl+default-devel \
 rust-thiserror-impl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-impl-2.0.21-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3dfee01f9880116fe3b3382ffb41778d69dd95225127f7e269afd244acfc9632"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl+default-devel-2.0.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thiserror-impl+default-devel.sha256sum] = "320a3585fd553fddc758bd72145b71b8bb9cdd47d805f7048f3274737dbc0225"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl-devel-2.0.21-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-thiserror-impl-devel.sha256sum] = "d51bc646acfb603d6999859076aafbe18cd2bcc33147fb16840405ab6df2bf9b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl+default-devel-2.0.21-1.el10_3.noarch.rpm;name=aarch64_rust-thiserror-impl+default-devel;unpack=0"
SRC_URI[aarch64_rust-thiserror-impl+default-devel.sha256sum] = "891e10a589652574b771bba568858bec3c05edb09a95f0bd8ff2f1d29e1a9d5f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl-devel-2.0.21-1.el10_3.noarch.rpm;name=aarch64_rust-thiserror-impl-devel;unpack=0"
SRC_URI[aarch64_rust-thiserror-impl-devel.sha256sum] = "f48448b9e5f72ac0fbb24e54dcbf5b55aaff4e789280fad8c7efcf7e5c7344fa"

RDEPENDS:rust-thiserror-impl+default-devel = " \
 cargo \
 rust-thiserror-impl-devel \
 "
RDEPENDS:rust-thiserror-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
