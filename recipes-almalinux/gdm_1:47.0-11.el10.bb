# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gdm"
PE = "1"
PV = "47.0"
PR = "11.el10"
PACKAGES = " \
 gdm \
 gdm-devel \
 gdm-pam-extensions-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gdm-47.0-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "66a34ebf8dc46673c2ea2e33dd03e012ca2c865ba77a1544478fa0ca184888dd"

URI_x86_64_v2_gdm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gdm-47.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_gdm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm}"
SRC_URI[x86_64_v2_gdm.sha256sum] = "27de42234cab3bb8cc7a14fc05a8b80bc4d8afe359683efb2f05efc44f7a995c"

URI_x86_64_v2_gdm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-devel-47.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_gdm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm-devel}"
SRC_URI[x86_64_v2_gdm-devel.sha256sum] = "b4335d56a7a0790bca1be8916625da27ce0357e5fca354f2f79223764b6093fa"

URI_x86_64_v2_gdm-pam-extensions-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gdm-pam-extensions-devel-47.0-11.el10.x86_64_v2.rpm;name=x86_64_v2_gdm-pam-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gdm-pam-extensions-devel}"
SRC_URI[x86_64_v2_gdm-pam-extensions-devel.sha256sum] = "5a50265cdda8896b378298511afe14c9c1b0078e458c3d82cda3d1447056ac35"

URI_aarch64_gdm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gdm-47.0-11.el10.aarch64.rpm;name=aarch64_gdm;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm}"
SRC_URI[aarch64_gdm.sha256sum] = "11ec3e5145105d978f549720b4a80a0c9608847f9171353b0ee68d49b9c11fcf"

URI_aarch64_gdm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-devel-47.0-11.el10.aarch64.rpm;name=aarch64_gdm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm-devel}"
SRC_URI[aarch64_gdm-devel.sha256sum] = "c3fb1f6a32def5aff6c4dfcb3f730535e8b15128d54cf4c82e7927ba53b4c20e"

URI_aarch64_gdm-pam-extensions-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gdm-pam-extensions-devel-47.0-11.el10.aarch64.rpm;name=aarch64_gdm-pam-extensions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gdm-pam-extensions-devel}"
SRC_URI[aarch64_gdm-pam-extensions-devel.sha256sum] = "cd3b39709871b088b59f8529c39d06a62a87aed49102feab333794660414449e"

RDEPENDS:gdm = " \
 accountsservice \
 accountsservice-libs \
 almalinux-logos \
 audit-libs \
 bash \
 dbus-daemon \
 dconf \
 glib2 \
 glibc \
 gnome-keyring-pam \
 gnome-session \
 gnome-session-wayland-session \
 gnome-settings-daemon \
 gnome-shell \
 iso-codes \
 json-glib \
 keyutils-libs \
 libXau \
 libgcc \
 libgudev \
 libselinux \
 pam \
 pam-libs \
 python3 \
 python3-pam \
 shadow-utils \
 systemd \
 systemd-libs \
 util-linux \
 "
RDEPENDS:gdm-devel = " \
 gdm \
 gdm-pam-extensions-devel \
 glib2-devel \
 libselinux-devel \
 pkgconf-pkg-config \
 systemd-devel \
 "
RDEPENDS:gdm-pam-extensions-devel = " \
 pam-devel \
 pkgconf-pkg-config \
 "
