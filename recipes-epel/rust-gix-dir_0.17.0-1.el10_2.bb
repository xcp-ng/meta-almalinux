# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-dir"
PV = "0.17.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-dir+default-devel \
 rust-gix-dir-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-dir-0.17.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "479b4812a5c820d01a3f90cde7b1ffa00a792607691d69dc507883dadccd3ef4"

URI_x86_64_v2_rust-gix-dir+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir+default-devel-0.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir+default-devel}"
SRC_URI[x86_64_v2_rust-gix-dir+default-devel.sha256sum] = "883b64cdd7db46148c0f923b6e588b88c5140e38e82c4bc5dc661c0b31d6e424"

URI_x86_64_v2_rust-gix-dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-dir-devel-0.17.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-dir-devel}"
SRC_URI[x86_64_v2_rust-gix-dir-devel.sha256sum] = "3f2e9724e7ff5ad068b970dd29e3a1482675cffa5082332e556c4b66dec990ac"

URI_aarch64_rust-gix-dir+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir+default-devel-0.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-dir+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir+default-devel}"
SRC_URI[aarch64_rust-gix-dir+default-devel.sha256sum] = "0b75c6fbbd68b6f4770ab2c4d71c30296178eb914270d538bad97c40a38c94b6"

URI_aarch64_rust-gix-dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-dir-devel-0.17.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-dir-devel}"
SRC_URI[aarch64_rust-gix-dir-devel.sha256sum] = "0a2c87b30bff4580606164cf3b79e7eea246d6faf8ea103e129bf2dfd9b2bfe5"

RDEPENDS:rust-gix-dir+default-devel = " \
 cargo \
 rust-gix-dir-devel \
 "
RDEPENDS:rust-gix-dir-devel = " \
 bash \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-discover+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-ignore+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-utils+bstr-devel \
 rust-gix-utils+default-devel \
 rust-gix-worktree-devel \
 rust-thiserror+default-devel \
 "
