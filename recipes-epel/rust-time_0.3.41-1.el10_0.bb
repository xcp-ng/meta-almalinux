# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-time"
PV = "0.3.41"
PR = "1.el10_0"
PACKAGES = " \
 rust-time+alloc-devel \
 rust-time+default-devel \
 rust-time+formatting-devel \
 rust-time+large-dates-devel \
 rust-time+local-offset-devel \
 rust-time+macros-devel \
 rust-time+parsing-devel \
 rust-time+quickcheck-devel \
 rust-time+rand-devel \
 rust-time+serde-devel \
 rust-time+serde-human-readable-devel \
 rust-time+serde-well-known-devel \
 rust-time+std-devel \
 rust-time-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-time-0.3.41-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "133b59a7ebe820f4d0e23ee164d8c884e1008dba441ce968c9fb1b988fcca9fb"

URI_x86_64_v2_rust-time+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+alloc-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+alloc-devel}"
SRC_URI[x86_64_v2_rust-time+alloc-devel.sha256sum] = "8f9d6fb504b2036183cb8863bed84439a597f1a282b858da339b311f8d549e07"

URI_x86_64_v2_rust-time+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+default-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+default-devel}"
SRC_URI[x86_64_v2_rust-time+default-devel.sha256sum] = "5f9767ce854011371770ddf527e436eb0c7ff24c9f106d6e92c3cb44b06e0b0f"

URI_x86_64_v2_rust-time+formatting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+formatting-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+formatting-devel}"
SRC_URI[x86_64_v2_rust-time+formatting-devel.sha256sum] = "b3406f1fd4c646063fe7768c46474d0c290c2752a5399904c1f22415725d5793"

URI_x86_64_v2_rust-time+large-dates-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+large-dates-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+large-dates-devel}"
SRC_URI[x86_64_v2_rust-time+large-dates-devel.sha256sum] = "d6912e2db2d6d6bdb45fe857ce5f81500134d45187e59a84e3677754f4f39588"

URI_x86_64_v2_rust-time+local-offset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+local-offset-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+local-offset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+local-offset-devel}"
SRC_URI[x86_64_v2_rust-time+local-offset-devel.sha256sum] = "8fa6d6332c4db65a11b9c61a7d4e90ff77106862dce463987b271ecafde456bd"

URI_x86_64_v2_rust-time+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+macros-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+macros-devel}"
SRC_URI[x86_64_v2_rust-time+macros-devel.sha256sum] = "4e0f23efc992328fa4e5cc2f3a5e081ae1a86e41bf775d56f4da8d979bb2cba9"

URI_x86_64_v2_rust-time+parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+parsing-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+parsing-devel}"
SRC_URI[x86_64_v2_rust-time+parsing-devel.sha256sum] = "afc6e0be0776e7423007021f843893b8d434baf223c425ae32e2cf6dc3205f94"

URI_x86_64_v2_rust-time+quickcheck-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+quickcheck-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+quickcheck-devel}"
SRC_URI[x86_64_v2_rust-time+quickcheck-devel.sha256sum] = "eadf1085816130e314502dddc1d8291e70ab0394b185390fdbdf8902b6bd0e14"

URI_x86_64_v2_rust-time+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+rand-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+rand-devel}"
SRC_URI[x86_64_v2_rust-time+rand-devel.sha256sum] = "0d9d9166a291265b4d108b70f840b7c2dd450919f7e3a724731538027b721dcd"

URI_x86_64_v2_rust-time+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+serde-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+serde-devel}"
SRC_URI[x86_64_v2_rust-time+serde-devel.sha256sum] = "e36c66ee4a768da185942593c7d01e57dfb4ec2525fc9ee592883af880f10829"

URI_x86_64_v2_rust-time+serde-human-readable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+serde-human-readable-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+serde-human-readable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+serde-human-readable-devel}"
SRC_URI[x86_64_v2_rust-time+serde-human-readable-devel.sha256sum] = "feba09033db1c21a3e585cb6733f881953f712eaf715e8fd4340688ee8b4882e"

URI_x86_64_v2_rust-time+serde-well-known-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+serde-well-known-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+serde-well-known-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+serde-well-known-devel}"
SRC_URI[x86_64_v2_rust-time+serde-well-known-devel.sha256sum] = "f2b2a6618d5d8ff4df13a553a63a19c90df520f4bc4da92189be9a687f2cdb10"

URI_x86_64_v2_rust-time+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time+std-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time+std-devel}"
SRC_URI[x86_64_v2_rust-time+std-devel.sha256sum] = "e23f72b0b54c3a81042dd4654a09e8518da90cd4f615b3ac5983788ba9c6cfc8"

URI_x86_64_v2_rust-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-time-devel-0.3.41-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-time-devel}"
SRC_URI[x86_64_v2_rust-time-devel.sha256sum] = "a42f7eb961c46a30a94929f76a584751bf131da1aff4257694f6aab27765f076"

URI_aarch64_rust-time+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+alloc-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+alloc-devel}"
SRC_URI[aarch64_rust-time+alloc-devel.sha256sum] = "decfe4bc93e0689bd343e1b398eaf038b0c01fd601ca6e53fb6d7a956687f2ed"

URI_aarch64_rust-time+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+default-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+default-devel}"
SRC_URI[aarch64_rust-time+default-devel.sha256sum] = "ce53d5f1c3fe2dd62d2bc80871bf43b8cc42eb03b178ab3a9432b5d52d7e4de5"

URI_aarch64_rust-time+formatting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+formatting-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+formatting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+formatting-devel}"
SRC_URI[aarch64_rust-time+formatting-devel.sha256sum] = "5b443618f86a39c3d7f2bf1ed8a5ed915bc83bae1f3350461d748f241deccb6e"

URI_aarch64_rust-time+large-dates-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+large-dates-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+large-dates-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+large-dates-devel}"
SRC_URI[aarch64_rust-time+large-dates-devel.sha256sum] = "5092c25ceecaa58ce5392ec38aec6974b34d9ddd905c80d751722e2a872dbde8"

URI_aarch64_rust-time+local-offset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+local-offset-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+local-offset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+local-offset-devel}"
SRC_URI[aarch64_rust-time+local-offset-devel.sha256sum] = "bde00587732ac19f6d3754d8c8a10c386cf1f4e15cc9f690e1617facdc699570"

URI_aarch64_rust-time+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+macros-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+macros-devel}"
SRC_URI[aarch64_rust-time+macros-devel.sha256sum] = "04f074dbb43af3228e409f55b78fb2226444491b921e9c5aebbdb8e467b59cc7"

URI_aarch64_rust-time+parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+parsing-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+parsing-devel}"
SRC_URI[aarch64_rust-time+parsing-devel.sha256sum] = "14a1f1fc03a714043cb8d1a1642a6d82c2c35f33c37af382d48f068ac85ee844"

URI_aarch64_rust-time+quickcheck-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+quickcheck-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+quickcheck-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+quickcheck-devel}"
SRC_URI[aarch64_rust-time+quickcheck-devel.sha256sum] = "ead234a77092cc982983ce128aac457549d1a703d9a9786e18c3e2031f452d65"

URI_aarch64_rust-time+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+rand-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+rand-devel}"
SRC_URI[aarch64_rust-time+rand-devel.sha256sum] = "0323420a6d3142f4db256bb25703caf6db0fc39ebfd17221f834b5fe176f4d06"

URI_aarch64_rust-time+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+serde-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+serde-devel}"
SRC_URI[aarch64_rust-time+serde-devel.sha256sum] = "5e8bb8341abe2e9202d4f06c3d0cf324742cf048545aff5c18752d4d1e567afb"

URI_aarch64_rust-time+serde-human-readable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+serde-human-readable-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+serde-human-readable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+serde-human-readable-devel}"
SRC_URI[aarch64_rust-time+serde-human-readable-devel.sha256sum] = "029821b2200e49b6d9cd90cd57f8dcee95a5a195591e8d05ea438e4d9c6fe016"

URI_aarch64_rust-time+serde-well-known-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+serde-well-known-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+serde-well-known-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+serde-well-known-devel}"
SRC_URI[aarch64_rust-time+serde-well-known-devel.sha256sum] = "08c241a201089addc11d024dcc5cb23209b0564d2678d7c36afdc314e25baff8"

URI_aarch64_rust-time+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time+std-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time+std-devel}"
SRC_URI[aarch64_rust-time+std-devel.sha256sum] = "25685ec91a7bcfe4efaa4a587b432a9300073f6f95fdfaf5b51daaa01b961ce9"

URI_aarch64_rust-time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-time-devel-0.3.41-1.el10_0.noarch.rpm;name=aarch64_rust-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-time-devel}"
SRC_URI[aarch64_rust-time-devel.sha256sum] = "a831c80e048fde1b142c7d9daa057b1bf092d9ae877e422332f0f7db93f3a8a8"

RDEPENDS:rust-time+alloc-devel = " \
 cargo \
 rust-serde+alloc-devel \
 rust-serde-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+default-devel = " \
 cargo \
 rust-time+std-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+formatting-devel = " \
 cargo \
 rust-itoa+default-devel \
 rust-time+std-devel \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+formatting-devel \
 "
RDEPENDS:rust-time+large-dates-devel = " \
 cargo \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+large-dates-devel \
 "
RDEPENDS:rust-time+local-offset-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-num_threads+default-devel \
 rust-time+std-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+macros-devel = " \
 cargo \
 rust-time-devel \
 rust-time-macros+default-devel \
 "
RDEPENDS:rust-time+parsing-devel = " \
 cargo \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+parsing-devel \
 "
RDEPENDS:rust-time+quickcheck-devel = " \
 cargo \
 rust-deranged+quickcheck-devel \
 rust-quickcheck-devel \
 rust-time+alloc-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+rand-devel = " \
 cargo \
 rust-deranged+rand-devel \
 rust-rand0.8-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+serde-devel = " \
 cargo \
 rust-deranged+serde-devel \
 rust-serde-devel \
 rust-time-devel \
 rust-time-macros+default-devel \
 rust-time-macros+serde-devel \
 "
RDEPENDS:rust-time+serde-human-readable-devel = " \
 cargo \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+serde-well-known-devel = " \
 cargo \
 rust-time+formatting-devel \
 rust-time+parsing-devel \
 rust-time+serde-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time+std-devel = " \
 cargo \
 rust-deranged+std-devel \
 rust-time+alloc-devel \
 rust-time-devel \
 "
RDEPENDS:rust-time-devel = " \
 cargo \
 rust \
 rust-deranged+powerfmt-devel \
 rust-deranged-devel \
 rust-num-conv+default-devel \
 rust-powerfmt-devel \
 rust-time-core+default-devel \
 "
