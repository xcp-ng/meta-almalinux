# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Email-Sender"
PE = "1"
PV = "2.601"
PR = "3.el10_0"
PACKAGES = " \
 perl-Email-Sender \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Email-Sender-2.601-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14ad003d521245c9e97b15e14a17d957c583fbbf035dda6ce22221cccc7c3a9e"

URI_x86_64_v2_perl-Email-Sender = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Email-Sender-2.601-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Email-Sender;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Email-Sender}"
SRC_URI[x86_64_v2_perl-Email-Sender.sha256sum] = "dd0d7078c8635c3e0158b33b15a9031d2dafe8203a1607b49b1e935351161042"

URI_aarch64_perl-Email-Sender = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Email-Sender-2.601-3.el10_0.noarch.rpm;name=aarch64_perl-Email-Sender;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Email-Sender}"
SRC_URI[aarch64_perl-Email-Sender.sha256sum] = "320a425a665e749b6b8bdac854c36ed78f239db501dee316b4ed1aba9061c43c"

RDEPENDS:perl-Email-Sender = " \
 perl-Carp \
 perl-Email-Abstract \
 perl-Email-Address-XS \
 perl-Email-Sender \
 perl-Email-Simple \
 perl-Errno \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Path \
 perl-IO \
 perl-Module-Runtime \
 perl-Moo \
 perl-MooX-Types-MooseLike \
 perl-Net-SMTP-SSL \
 perl-PathTools \
 perl-Scalar-List-Utils \
 perl-Sub-Exporter \
 perl-Sys-Hostname \
 perl-Throwable \
 perl-Try-Tiny \
 perl-libnet \
 perl-libs \
 "
