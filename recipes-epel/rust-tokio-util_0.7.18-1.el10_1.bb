# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-util"
PV = "0.7.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-tokio-util+codec-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+default-devel \
 rust-tokio-util+full-devel \
 rust-tokio-util+futures-io-devel \
 rust-tokio-util+futures-util-devel \
 rust-tokio-util+hashbrown-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util+io-util-devel \
 rust-tokio-util+join-map-devel \
 rust-tokio-util+net-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util+slab-devel \
 rust-tokio-util+time-devel \
 rust-tokio-util+tracing-devel \
 rust-tokio-util-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-util-0.7.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbf65ec1d2545737416ed09b596c8b7254262a8fd5df554c226b9ea05e0f27ac"

URI_x86_64_v2_rust-tokio-util+codec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+codec-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+codec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+codec-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+codec-devel.sha256sum] = "b28603e27bc3511bfdd6a2fe79993ab9740173e30897ba970024dd13fb389240"

URI_x86_64_v2_rust-tokio-util+compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+compat-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+compat-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+compat-devel.sha256sum] = "9fc8dc1855c0358c06f6634b803c5debab4ce04f65dff0aebfd18a544402dd91"

URI_x86_64_v2_rust-tokio-util+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+default-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+default-devel.sha256sum] = "9ee9ea4138924a64a7384401bb32aa2e34888d86fdce87d93db387799d34b34f"

URI_x86_64_v2_rust-tokio-util+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+full-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+full-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+full-devel.sha256sum] = "700258bad3676a275bb015a4740b26d577c5100308307eddb50754c09fb14a35"

URI_x86_64_v2_rust-tokio-util+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+futures-io-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+futures-io-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+futures-io-devel.sha256sum] = "1cf63f0e4931097984b8ae578a3a53d359cc03310f82b1d141208d89c567a507"

URI_x86_64_v2_rust-tokio-util+futures-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+futures-util-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+futures-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+futures-util-devel.sha256sum] = "4328f377729e60e30338d33d384408e2a21debbd746cf42cc4545a16ec11d3fe"

URI_x86_64_v2_rust-tokio-util+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+hashbrown-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+hashbrown-devel.sha256sum] = "877a718602ff337106a61f810e9a2a9bc79d4ffd7a73e272b99868b23b4865cb"

URI_x86_64_v2_rust-tokio-util+io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+io-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+io-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+io-devel.sha256sum] = "e485e0de69ac382d0d98296b5f382bd10b1c20c2744d7b0ba944c67b5aa2910a"

URI_x86_64_v2_rust-tokio-util+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+io-util-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+io-util-devel.sha256sum] = "f83f78b158f18981e9e566e4b8346c392ba3864fdc78d9448e321999f25f20d2"

URI_x86_64_v2_rust-tokio-util+join-map-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+join-map-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+join-map-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+join-map-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+join-map-devel.sha256sum] = "995d037bec0dd7fdf6da57fb1a537b855c73b392f84d280f82614cd9d456124f"

URI_x86_64_v2_rust-tokio-util+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+net-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+net-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+net-devel.sha256sum] = "745eeb5eebcdb297f71de6fc9966601c577d3de91afca941ab8a4de2daf95259"

URI_x86_64_v2_rust-tokio-util+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+rt-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+rt-devel.sha256sum] = "b0bb58c568b40f6ab8107b57d648009d3c1e58fb5f96ccf2b0ddf85f7507e3b6"

URI_x86_64_v2_rust-tokio-util+slab-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+slab-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+slab-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+slab-devel.sha256sum] = "b341c65e8403bd3f823537a9de0b24c080133e030125a651c26d59c0dd791e67"

URI_x86_64_v2_rust-tokio-util+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+time-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+time-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+time-devel.sha256sum] = "d8e8ab1fbe861f8541fc309513605bf0d58c39cfe2930f1ee2e6f72dba279b77"

URI_x86_64_v2_rust-tokio-util+tracing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util+tracing-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util+tracing-devel}"
SRC_URI[x86_64_v2_rust-tokio-util+tracing-devel.sha256sum] = "11c0c142a637012b78f6c43871d5733601058d1d36364e466388af86e7220222"

URI_x86_64_v2_rust-tokio-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-util-devel-0.7.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-util-devel}"
SRC_URI[x86_64_v2_rust-tokio-util-devel.sha256sum] = "3ecdad24cf5bf63660a45780dc9ff2809cba931cd16b255ac39918ae5328949e"

URI_aarch64_rust-tokio-util+codec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+codec-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+codec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+codec-devel}"
SRC_URI[aarch64_rust-tokio-util+codec-devel.sha256sum] = "f35da6bb2d77baa47776ad525a23ea0204c704d05d2da922d50c2c40d61d577f"

URI_aarch64_rust-tokio-util+compat-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+compat-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+compat-devel}"
SRC_URI[aarch64_rust-tokio-util+compat-devel.sha256sum] = "452633c11025b5ec427145c51e7eccc6146fbac344aa06300fc0a55567adb328"

URI_aarch64_rust-tokio-util+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+default-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+default-devel}"
SRC_URI[aarch64_rust-tokio-util+default-devel.sha256sum] = "a0f36cc34ed45c1b214d57ac282a5103b642eced730227d73ec2369dc5523521"

URI_aarch64_rust-tokio-util+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+full-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+full-devel}"
SRC_URI[aarch64_rust-tokio-util+full-devel.sha256sum] = "f3bc744ae06d2b15071c006040cfb775de722ba608968765b184990a6cd2dcc0"

URI_aarch64_rust-tokio-util+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+futures-io-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+futures-io-devel}"
SRC_URI[aarch64_rust-tokio-util+futures-io-devel.sha256sum] = "8e114457f962a6afe79482066cea31ff2ece642cf764e4eecc9fa28821c857cd"

URI_aarch64_rust-tokio-util+futures-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+futures-util-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+futures-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+futures-util-devel}"
SRC_URI[aarch64_rust-tokio-util+futures-util-devel.sha256sum] = "e1ee85a7708ce5fcd742554a813e7a4e8fa562ac583f455c80eea847825b1432"

URI_aarch64_rust-tokio-util+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+hashbrown-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+hashbrown-devel}"
SRC_URI[aarch64_rust-tokio-util+hashbrown-devel.sha256sum] = "40bb139c7015b3cd2fb9a80c59b004079fafbe5f820ad924d56ec4bc2278439f"

URI_aarch64_rust-tokio-util+io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+io-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+io-devel}"
SRC_URI[aarch64_rust-tokio-util+io-devel.sha256sum] = "971ce8d6c0a88666413caae10ff0875a2d5599c6060a9e206faff535d9bf6507"

URI_aarch64_rust-tokio-util+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+io-util-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+io-util-devel}"
SRC_URI[aarch64_rust-tokio-util+io-util-devel.sha256sum] = "a51e539829e8b75bf4bb9c8d1de9aff40de11d6d1eac1c565de68cce120e781b"

URI_aarch64_rust-tokio-util+join-map-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+join-map-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+join-map-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+join-map-devel}"
SRC_URI[aarch64_rust-tokio-util+join-map-devel.sha256sum] = "c844485018763b04831fe84a71bd468f395dfdc983f3f5535c02d15e33a85dd9"

URI_aarch64_rust-tokio-util+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+net-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+net-devel}"
SRC_URI[aarch64_rust-tokio-util+net-devel.sha256sum] = "c5faa980c3b29aff624306df0087451f6dea42eab801fec286c5cf40be913f68"

URI_aarch64_rust-tokio-util+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+rt-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+rt-devel}"
SRC_URI[aarch64_rust-tokio-util+rt-devel.sha256sum] = "a60f29dd642d4e2ea3ea9b882a936ee9a39b227e10b567723e4e8af77e170877"

URI_aarch64_rust-tokio-util+slab-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+slab-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+slab-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+slab-devel}"
SRC_URI[aarch64_rust-tokio-util+slab-devel.sha256sum] = "e8996cd8f3079b62f1745f7e5f28abdcfde9b4011883edd4ef46f5eb24acc6e5"

URI_aarch64_rust-tokio-util+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+time-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+time-devel}"
SRC_URI[aarch64_rust-tokio-util+time-devel.sha256sum] = "00e782ba282a2189f3bcd059c767cee6f2832e21a3fc783bc59a0dde498f0255"

URI_aarch64_rust-tokio-util+tracing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util+tracing-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util+tracing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util+tracing-devel}"
SRC_URI[aarch64_rust-tokio-util+tracing-devel.sha256sum] = "16bb418da08be9369f6b3397c4a76cc8852f8bdeaa98e67b489c363cb393c02e"

URI_aarch64_rust-tokio-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-util-devel-0.7.18-1.el10_1.noarch.rpm;name=aarch64_rust-tokio-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-util-devel}"
SRC_URI[aarch64_rust-tokio-util-devel.sha256sum] = "348ba535db9f61f17a0bde4bbd2e6c4c7ae3d31610fae5b67b70a8be713c4bdf"

RDEPENDS:rust-tokio-util+codec-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+compat-devel = " \
 cargo \
 rust-tokio-util+futures-io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+default-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+full-devel = " \
 cargo \
 rust-tokio-util+codec-devel \
 rust-tokio-util+compat-devel \
 rust-tokio-util+io-util-devel \
 rust-tokio-util+join-map-devel \
 rust-tokio-util+net-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util+time-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+futures-util-devel = " \
 cargo \
 rust-futures-util+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+hashbrown-devel = " \
 cargo \
 rust-hashbrown-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+io-devel = " \
 cargo \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+io-util-devel = " \
 cargo \
 rust-tokio+io-util-devel \
 rust-tokio+rt-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+join-map-devel = " \
 cargo \
 rust-tokio-util+hashbrown-devel \
 rust-tokio-util+rt-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+net-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+rt-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio-util+futures-util-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+slab-devel = " \
 cargo \
 rust-slab+default-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+time-devel = " \
 cargo \
 rust-tokio+time-devel \
 rust-tokio-util+slab-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-tokio-util+tracing-devel = " \
 cargo \
 rust-tokio-util-devel \
 rust-tracing+std-devel \
 rust-tracing-devel \
 "
RDEPENDS:rust-tokio-util-devel = " \
 cargo \
 rust \
 rust-bytes+default-devel \
 rust-futures-core+default-devel \
 rust-futures-sink+default-devel \
 rust-pin-project-lite+default-devel \
 rust-tokio+default-devel \
 rust-tokio+sync-devel \
 "
