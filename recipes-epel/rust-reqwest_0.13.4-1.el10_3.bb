# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest"
PV = "0.13.4"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqwest+__native-tls-alpn-devel \
 rust-reqwest+__native-tls-devel \
 rust-reqwest+__rustls-devel \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+brotli-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+cookies-devel \
 rust-reqwest+default-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+deflate-devel \
 rust-reqwest+form-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+hickory-dns-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+json-devel \
 rust-reqwest+multipart-devel \
 rust-reqwest+native-tls-devel \
 rust-reqwest+native-tls-no-alpn-devel \
 rust-reqwest+query-devel \
 rust-reqwest+rustls-devel \
 rust-reqwest+rustls-no-provider-devel \
 rust-reqwest+socks-devel \
 rust-reqwest+stream-devel \
 rust-reqwest+system-proxy-devel \
 rust-reqwest+zstd-devel \
 rust-reqwest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-0.13.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e05e0a456d8a347a7cf842a4598654a5e5d6f18137aecc11e18796559cd4dc8e"

URI_x86_64_v2_rust-reqwest+__native-tls-alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__native-tls-alpn-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__native-tls-alpn-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__native-tls-alpn-devel.sha256sum] = "02dc6a8e067234762ea75fdbef9b5b0fed21571ba41b048238ea3d959c604439"

URI_x86_64_v2_rust-reqwest+__native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__native-tls-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__native-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__native-tls-devel.sha256sum] = "5361d7d1962a6c24ec40293af1d55b6681b50dba831bcfd590fcfbfc1c1f4230"

URI_x86_64_v2_rust-reqwest+__rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__rustls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-devel.sha256sum] = "30d6507a0359f883268af42998eead1b8d8c1a241ba7c3b8c52e40adf5357f71"

URI_x86_64_v2_rust-reqwest+__rustls-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-ring-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__rustls-ring-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-ring-devel.sha256sum] = "43374f65b2f04f85baa95a3913c946147058b852c7972f3716d1067c30e3e652"

URI_x86_64_v2_rust-reqwest+__tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__tls-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__tls-devel.sha256sum] = "40d02eb31b040ad4d1fad852aae2383eaf49a156b1aa49bb2c78195d26082d88"

URI_x86_64_v2_rust-reqwest+blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+blocking-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+blocking-devel}"
SRC_URI[x86_64_v2_rust-reqwest+blocking-devel.sha256sum] = "86c465b6f4569c79347a195a1bbf5d110960e6bf4cf79fc44829ebe12d5b7813"

URI_x86_64_v2_rust-reqwest+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+brotli-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+brotli-devel}"
SRC_URI[x86_64_v2_rust-reqwest+brotli-devel.sha256sum] = "30e6cb796a2dc8612f61968c16b3403bfca6409f043131c566ce42f6ead56e65"

URI_x86_64_v2_rust-reqwest+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+charset-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest+charset-devel.sha256sum] = "2604945cc6e394708091c628d188152bf8b54524c551bb6032be62442bc23e56"

URI_x86_64_v2_rust-reqwest+cookies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+cookies-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+cookies-devel}"
SRC_URI[x86_64_v2_rust-reqwest+cookies-devel.sha256sum] = "b4572b8706ce588bfecb1d44fa06e29ad8605db1817ef1729effe9884ad4f79c"

URI_x86_64_v2_rust-reqwest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest+default-devel.sha256sum] = "b363e4cb9b3ab968b734516546ddfe4c7ed386b2b8a013e7038476548d65477c"

URI_x86_64_v2_rust-reqwest+default-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-tls-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+default-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+default-tls-devel.sha256sum] = "a66f4bebd2b69deb99b6191aa5bc36f3f76a24f55f815f160d5ef052eeb55660"

URI_x86_64_v2_rust-reqwest+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+deflate-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+deflate-devel}"
SRC_URI[x86_64_v2_rust-reqwest+deflate-devel.sha256sum] = "4d477bae55eff187c05a16995d5a1f589f1178465449daf4829f6874e5d6fa0f"

URI_x86_64_v2_rust-reqwest+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+form-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+form-devel}"
SRC_URI[x86_64_v2_rust-reqwest+form-devel.sha256sum] = "0c5578074aff620f8e5e0facfd233ceb896f0136a8735189e38bd84f3fdb5247"

URI_x86_64_v2_rust-reqwest+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+gzip-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+gzip-devel}"
SRC_URI[x86_64_v2_rust-reqwest+gzip-devel.sha256sum] = "867565243b778fd090bebabc41b4189406de48f2e2203f3d28becd67182b793a"

URI_x86_64_v2_rust-reqwest+hickory-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+hickory-dns-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+hickory-dns-devel}"
SRC_URI[x86_64_v2_rust-reqwest+hickory-dns-devel.sha256sum] = "a99247b4f01c0f46ba7fb35edd9c5a848b333a71544f19aecf0232080e4f31a1"

URI_x86_64_v2_rust-reqwest+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+http2-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest+http2-devel.sha256sum] = "748c1aefd209d9f254fc3891cc1a31a9e290319155f402d4c75c92898c83aef2"

URI_x86_64_v2_rust-reqwest+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+json-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest+json-devel.sha256sum] = "d3b14cacfb20f40313845604210d4508a6843ad0748ac7fb39119150647c3f21"

URI_x86_64_v2_rust-reqwest+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+multipart-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest+multipart-devel.sha256sum] = "3b69e1d82ba19fae3b99662fd419fe451ec0fa3288b25fa272b14d614d7e51df"

URI_x86_64_v2_rust-reqwest+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+native-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-devel.sha256sum] = "9b1e75b35deed2027d05ba2a281fadd5dbf1d5555a4351f7e09dc07a7435e4d4"

URI_x86_64_v2_rust-reqwest+native-tls-no-alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-no-alpn-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-no-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+native-tls-no-alpn-devel}"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-no-alpn-devel.sha256sum] = "df68cb45b495a530e54c50b4e73b047025a6b58a15c1b2c57df0f35b3c873a9b"

URI_x86_64_v2_rust-reqwest+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+query-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+query-devel}"
SRC_URI[x86_64_v2_rust-reqwest+query-devel.sha256sum] = "37895bc6bd7543d7fdb926dd3f800df50014bee7e61335775c10f49acc1eca87"

URI_x86_64_v2_rust-reqwest+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-devel.sha256sum] = "11d88cc387a024aadd30e770ba9c9f1b32cfcda34258e0c50a875876f644f159"

URI_x86_64_v2_rust-reqwest+rustls-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-no-provider-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-no-provider-devel.sha256sum] = "b2058cd3b3a35105bcbfd6d4f1c0d84d11b38d66a66c47b4f5fd640f4cba9124"

URI_x86_64_v2_rust-reqwest+socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+socks-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+socks-devel}"
SRC_URI[x86_64_v2_rust-reqwest+socks-devel.sha256sum] = "22640682ed2f787c1ee771876ca432cba38415017c2c32879816d75fd49befed"

URI_x86_64_v2_rust-reqwest+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+stream-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+stream-devel}"
SRC_URI[x86_64_v2_rust-reqwest+stream-devel.sha256sum] = "83ce0f178917d95619cb1100b5c6f0fdd897cfa0219a8d0178833255fbc0c239"

URI_x86_64_v2_rust-reqwest+system-proxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+system-proxy-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+system-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+system-proxy-devel}"
SRC_URI[x86_64_v2_rust-reqwest+system-proxy-devel.sha256sum] = "2e3c2244ebce287337b47e30af964b4ccfe3aecf2bb1153ab020c0503164604b"

URI_x86_64_v2_rust-reqwest+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+zstd-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+zstd-devel}"
SRC_URI[x86_64_v2_rust-reqwest+zstd-devel.sha256sum] = "f46e6929419872f66b6d32831f7b132fe74fa8bfd54b55d253b8b26a027f3ccd"

URI_x86_64_v2_rust-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-devel-0.13.4-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-devel}"
SRC_URI[x86_64_v2_rust-reqwest-devel.sha256sum] = "85bfc871752c29442bb5db19e0ccadb7cc4ba5d64609ff6801c59d61820c22cd"

URI_aarch64_rust-reqwest+__native-tls-alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__native-tls-alpn-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__native-tls-alpn-devel}"
SRC_URI[aarch64_rust-reqwest+__native-tls-alpn-devel.sha256sum] = "c0d6f61c26b57a48a85bee648733bfbcf13ac41650bd82cf824e6b38c37579ba"

URI_aarch64_rust-reqwest+__native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__native-tls-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__native-tls-devel}"
SRC_URI[aarch64_rust-reqwest+__native-tls-devel.sha256sum] = "1d007f84e1dd3f332743bb3d1e37b30365e345d07a49a034669751df592bdc95"

URI_aarch64_rust-reqwest+__rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__rustls-devel}"
SRC_URI[aarch64_rust-reqwest+__rustls-devel.sha256sum] = "3f2f0ebdd6fca966b7feddbffb5ebf3f642b147d43036d694c9961a9e8c2e1d4"

URI_aarch64_rust-reqwest+__rustls-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-ring-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__rustls-ring-devel}"
SRC_URI[aarch64_rust-reqwest+__rustls-ring-devel.sha256sum] = "888512ef7badccece180a0b25847e2575cf40e55a4c32dca08935b73f5ec65c3"

URI_aarch64_rust-reqwest+__tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__tls-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__tls-devel}"
SRC_URI[aarch64_rust-reqwest+__tls-devel.sha256sum] = "098276dee03666e6d5ba443b4b6205f2ca9a8d2b54a441e4882d05a648f020d0"

URI_aarch64_rust-reqwest+blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+blocking-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+blocking-devel}"
SRC_URI[aarch64_rust-reqwest+blocking-devel.sha256sum] = "6f74b53b72fef6d0c922bdcae46fb264296febef2d87f882f748f37db576fc70"

URI_aarch64_rust-reqwest+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+brotli-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+brotli-devel}"
SRC_URI[aarch64_rust-reqwest+brotli-devel.sha256sum] = "ae6317589d640eefdf37c7366023114ad88c156c1907b8ac9c4e02fe7c5250cf"

URI_aarch64_rust-reqwest+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+charset-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+charset-devel}"
SRC_URI[aarch64_rust-reqwest+charset-devel.sha256sum] = "c4d0fc4152a21bc752c34023445ab8e293bf1157832ecbd0f850d60ce1a5d76c"

URI_aarch64_rust-reqwest+cookies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+cookies-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+cookies-devel}"
SRC_URI[aarch64_rust-reqwest+cookies-devel.sha256sum] = "b254bd82599efc2683fb7014919925f4c862d911421297376d564d046936c306"

URI_aarch64_rust-reqwest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+default-devel}"
SRC_URI[aarch64_rust-reqwest+default-devel.sha256sum] = "5a26e2b14dd15f0607474e170bb90e3672f3ce6e5f40b31d4db798f13684d9fd"

URI_aarch64_rust-reqwest+default-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-tls-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+default-tls-devel}"
SRC_URI[aarch64_rust-reqwest+default-tls-devel.sha256sum] = "99a903155dcd6cffece2d0d7af488fcca4c75be8615a47aaed517e68e0989b5f"

URI_aarch64_rust-reqwest+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+deflate-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+deflate-devel}"
SRC_URI[aarch64_rust-reqwest+deflate-devel.sha256sum] = "665a53d85222d50ee8d3be5bea296cd7602a08efcd3318f4eabbd1a79e0a8cb0"

URI_aarch64_rust-reqwest+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+form-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+form-devel}"
SRC_URI[aarch64_rust-reqwest+form-devel.sha256sum] = "d41881632e8b5028e23c935faeebe4f01bbc1b8a8251f719f587537161488902"

URI_aarch64_rust-reqwest+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+gzip-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+gzip-devel}"
SRC_URI[aarch64_rust-reqwest+gzip-devel.sha256sum] = "ffc04fd0cdc75ca54a5cd92a526dbdc4c597459d5035412400946533a94b2507"

URI_aarch64_rust-reqwest+hickory-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+hickory-dns-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+hickory-dns-devel}"
SRC_URI[aarch64_rust-reqwest+hickory-dns-devel.sha256sum] = "8e39487f5d85591eefcd242ab7bd7a37b11fa712efd3cb033e4dec3873f63245"

URI_aarch64_rust-reqwest+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+http2-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+http2-devel}"
SRC_URI[aarch64_rust-reqwest+http2-devel.sha256sum] = "2bda45765f270c941151855e9a6e246b4783555d19fe7abcf68384cea6b37cd3"

URI_aarch64_rust-reqwest+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+json-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+json-devel}"
SRC_URI[aarch64_rust-reqwest+json-devel.sha256sum] = "911ccabca4743d6f03e3cd460b3a595a955abab2a61c9b9bb4d5c191402eb0b5"

URI_aarch64_rust-reqwest+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+multipart-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+multipart-devel}"
SRC_URI[aarch64_rust-reqwest+multipart-devel.sha256sum] = "7f7f99a6dd0d6f0b5797d05aa2075a757ad4f5404be578900cc3465a392655e9"

URI_aarch64_rust-reqwest+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+native-tls-devel}"
SRC_URI[aarch64_rust-reqwest+native-tls-devel.sha256sum] = "85536b5e4b4562e1622e128af68ea1336f53ea7f04201c2eb315bbb27d74d487"

URI_aarch64_rust-reqwest+native-tls-no-alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-no-alpn-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+native-tls-no-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+native-tls-no-alpn-devel}"
SRC_URI[aarch64_rust-reqwest+native-tls-no-alpn-devel.sha256sum] = "2c5827d88a6a171b6e3ae61c6743afbf53f8a9dab8e9c0206459e8851d547fa7"

URI_aarch64_rust-reqwest+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+query-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+query-devel}"
SRC_URI[aarch64_rust-reqwest+query-devel.sha256sum] = "4ea143437b7ad02e7213c836533e5a64502b173b6a269c54d668ae292175b81b"

URI_aarch64_rust-reqwest+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-devel.sha256sum] = "4b6bc443688dc21ae295926bef7a1b67baad46b90bb15cf583a8e22464e7fc2e"

URI_aarch64_rust-reqwest+rustls-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-no-provider-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+rustls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-no-provider-devel.sha256sum] = "7795d4a14e311e0b36e24b65bd3d21f64bbff1ccd875b007420a61ba640b6a4e"

URI_aarch64_rust-reqwest+socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+socks-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+socks-devel}"
SRC_URI[aarch64_rust-reqwest+socks-devel.sha256sum] = "22e15169c2e44829d8f3fd28f12559e244713d707ed1dc3d223bf0f0cdf439fe"

URI_aarch64_rust-reqwest+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+stream-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+stream-devel}"
SRC_URI[aarch64_rust-reqwest+stream-devel.sha256sum] = "43407c6e6299aa7db5836e63ea8760d8ebca6ccdad65a8ce026479edd3e7a930"

URI_aarch64_rust-reqwest+system-proxy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+system-proxy-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+system-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+system-proxy-devel}"
SRC_URI[aarch64_rust-reqwest+system-proxy-devel.sha256sum] = "b992cd5119b99c73fa4c004209ecb4e17a241d7bd297bf503a88803980bc7fc3"

URI_aarch64_rust-reqwest+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+zstd-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+zstd-devel}"
SRC_URI[aarch64_rust-reqwest+zstd-devel.sha256sum] = "23125e62e2218f8957f19d06e595b2a86d2b1a865e29f3b0287fa2b0cefcb5e2"

URI_aarch64_rust-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-devel-0.13.4-1.el10_3.noarch.rpm;name=aarch64_rust-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-devel}"
SRC_URI[aarch64_rust-reqwest-devel.sha256sum] = "e77f05a868f830cbfedb3ce1ea866661e6befe1998dbc6af671d1c011935bfe9"

RDEPENDS:rust-reqwest+__native-tls-alpn-devel = " \
 cargo \
 rust-hyper-tls+alpn-devel \
 rust-hyper-tls+default-devel \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+__native-tls-devel = " \
 cargo \
 rust-hyper-tls+default-devel \
 rust-native-tls+default-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-reqwest+__rustls-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__rustls-ring-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__tls-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-reqwest+blocking-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-futures-channel+sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-reqwest+brotli-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-br-devel \
 "
RDEPENDS:rust-reqwest+charset-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-mime+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+cookies-devel = " \
 cargo \
 rust-cookie+default-devel \
 rust-cookie_store+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-devel = " \
 cargo \
 rust-reqwest+charset-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+system-proxy-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-tls-devel = " \
 cargo \
 rust-reqwest+native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+deflate-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-deflate-devel \
 "
RDEPENDS:rust-reqwest+form-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-reqwest+gzip-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-gzip-devel \
 "
RDEPENDS:rust-reqwest+hickory-dns-devel = " \
 cargo \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+tokio-devel \
 rust-once_cell+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+http2-devel = " \
 cargo \
 rust-h2+default-devel \
 rust-hyper+http2-devel \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+http2-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-hyper-util+http2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+json-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-reqwest+multipart-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-mime_guess-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-devel = " \
 cargo \
 rust-reqwest+__native-tls-alpn-devel \
 rust-reqwest+__native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-no-alpn-devel = " \
 cargo \
 rust-reqwest+__native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+query-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-reqwest+rustls-devel = " \
 cargo \
 rust-reqwest+__rustls-devel \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest-devel \
 rust-rustls-platform-verifier+default-devel \
 "
RDEPENDS:rust-reqwest+rustls-no-provider-devel = " \
 cargo \
 rust-reqwest+__rustls-devel \
 rust-reqwest-devel \
 rust-rustls-platform-verifier+default-devel \
 "
RDEPENDS:rust-reqwest+socks-devel = " \
 cargo \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+stream-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio+fs-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+system-proxy-devel = " \
 cargo \
 rust-hyper-util+client-proxy-system-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+zstd-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-zstd-devel \
 "
RDEPENDS:rust-reqwest-devel = " \
 cargo \
 rust \
 rust-base64_0.22+default-devel \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+tokio-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-sync_wrapper+default-devel \
 rust-sync_wrapper+futures-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower+retry-devel \
 rust-tower+timeout-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http-devel \
 rust-tower-service+default-devel \
 rust-url+default-devel \
 "
