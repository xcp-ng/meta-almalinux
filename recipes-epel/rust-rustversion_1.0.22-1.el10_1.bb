# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustversion"
PV = "1.0.22"
PR = "1.el10_1"
PACKAGES = " \
 rust-rustversion+default-devel \
 rust-rustversion-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustversion-1.0.22-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7efe276f8d74a2354824ea3c00525299129f0bd6ca099c79f584ed80fc7b73c1"

URI_x86_64_v2_rust-rustversion+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustversion+default-devel-1.0.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustversion+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustversion+default-devel}"
SRC_URI[x86_64_v2_rust-rustversion+default-devel.sha256sum] = "7cbc8da628fd65ee06dad5416f98eaf32a80bd75aba6e8f89e2592f1136dd795"

URI_x86_64_v2_rust-rustversion-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustversion-devel-1.0.22-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustversion-devel}"
SRC_URI[x86_64_v2_rust-rustversion-devel.sha256sum] = "a17f53800d2bf11cc67c29cde39e95486fda9ddc7b7a0e27b80f49bbe322625d"

URI_aarch64_rust-rustversion+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustversion+default-devel-1.0.22-1.el10_1.noarch.rpm;name=aarch64_rust-rustversion+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustversion+default-devel}"
SRC_URI[aarch64_rust-rustversion+default-devel.sha256sum] = "d31cfe9c739e8588f918c36bddb7e30915191fa2d4c2aaeff23683c3741fa572"

URI_aarch64_rust-rustversion-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustversion-devel-1.0.22-1.el10_1.noarch.rpm;name=aarch64_rust-rustversion-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustversion-devel}"
SRC_URI[aarch64_rust-rustversion-devel.sha256sum] = "93a6f28b3739d481e2768e4eaa18a8f8bf1716802d54376ff5fda31528ab88cc"

RDEPENDS:rust-rustversion+default-devel = " \
 cargo \
 rust-rustversion-devel \
 "
RDEPENDS:rust-rustversion-devel = " \
 cargo \
 rust \
 "
