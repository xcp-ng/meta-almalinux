# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-terminado"
PV = "0.18.1"
PR = "3.el10_1"
PACKAGES = " \
 python3-terminado \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-terminado-0.18.1-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3bdf0b2f08f69f3d65fa5bda221dd512f2d2b0b2a64b824aff35200a5a67e14d"

URI_x86_64_v2_python3-terminado = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-terminado-0.18.1-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-terminado;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-terminado}"
SRC_URI[x86_64_v2_python3-terminado.sha256sum] = "3ceff5e8b6fb44467559fb6a32f4f23ef8357d52bcbccd0ca2e05a0a0fc7e4e6"

URI_aarch64_python3-terminado = "${EPEL_MIRROR}/aarch64/Packages/p/python3-terminado-0.18.1-3.el10_1.noarch.rpm;name=aarch64_python3-terminado;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-terminado}"
SRC_URI[aarch64_python3-terminado.sha256sum] = "ad6f6de359386a4242bb9c22d65f68d3f673fcd2a39e24aef1a6c4d6e2ba53fb"

RDEPENDS:python3-terminado = " \
 python3 \
 python3-ptyprocess \
 python3-tornado \
 "
