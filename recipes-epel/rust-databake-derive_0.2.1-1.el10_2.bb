# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-databake-derive"
PV = "0.2.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-databake-derive+default-devel \
 rust-databake-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-databake-derive-0.2.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0e330a98df5b9d11eb3d08dbbec806c9558ec062064015dfd1f8fd9624955e09"

URI_x86_64_v2_rust-databake-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-derive+default-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-derive+default-devel}"
SRC_URI[x86_64_v2_rust-databake-derive+default-devel.sha256sum] = "f7c2cbecae54da3546fa065a82c304f951fef016079469a105ba86c86e61bf58"

URI_x86_64_v2_rust-databake-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-databake-derive-devel-0.2.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-databake-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-databake-derive-devel}"
SRC_URI[x86_64_v2_rust-databake-derive-devel.sha256sum] = "56ad3d4d8a8f9dee46eacb0b4beaec5aec47008f2cfcac8771ce701ea59e617c"

URI_aarch64_rust-databake-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-derive+default-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-databake-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-derive+default-devel}"
SRC_URI[aarch64_rust-databake-derive+default-devel.sha256sum] = "eca12974dadb3e6fba84bc9ee90e2cd13c1fdb13dd1b7729142a12b0f2f52a4a"

URI_aarch64_rust-databake-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-databake-derive-devel-0.2.1-1.el10_2.noarch.rpm;name=aarch64_rust-databake-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-databake-derive-devel}"
SRC_URI[aarch64_rust-databake-derive-devel.sha256sum] = "48caf6f3ed89827e4aca4a10ac0fd0558ca6f3e11142d3073f6f37d015950a70"

RDEPENDS:rust-databake-derive+default-devel = " \
 cargo \
 rust-databake-derive-devel \
 "
RDEPENDS:rust-databake-derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-synstructure+default-devel \
 "
