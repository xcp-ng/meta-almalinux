# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dotnet11.0"
PV = "11.0.100~preview.6.26359.118"
PR = "0.7.el10"
PACKAGES = " \
 aspnetcore-runtime-11.0 \
 aspnetcore-runtime-dbg-11.0 \
 aspnetcore-targeting-pack-11.0 \
 dotnet-apphost-pack-11.0 \
 dotnet-host \
 dotnet-hostfxr-11.0 \
 dotnet-runtime-11.0 \
 dotnet-runtime-dbg-11.0 \
 dotnet-sdk-11.0 \
 dotnet-sdk-11.0-source-built-artifacts \
 dotnet-sdk-aot-11.0 \
 dotnet-sdk-dbg-11.0 \
 dotnet-targeting-pack-11.0 \
 dotnet-templates-11.0 \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/dotnet11.0-11.0.100~preview.6.26359.118-0.7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f9a3cea07b9b74dba4f695b50fd78ce3e2b4999c683cce699732ff393b8e23b1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-11.0-11.0.0~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-11.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-11.0.sha256sum] = "e41d601ae31eab28495f8806ee1fb837bbca354e7ccd844f9755f25e075bd5a7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-runtime-dbg-11.0-11.0.0~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-runtime-dbg-11.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-runtime-dbg-11.0.sha256sum] = "0c3f7d98b2342dfdb0067b496aa2e729075e28af0697c16d2daa2c177eee9870"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/aspnetcore-targeting-pack-11.0-11.0.0~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_aspnetcore-targeting-pack-11.0;unpack=0"
SRC_URI[x86_64_v2_aspnetcore-targeting-pack-11.0.sha256sum] = "272d6047eda6ae7c0145ca7f80f0d3b8483743758c2345f6e9c3f132d929fbbd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-apphost-pack-11.0-11.0.0~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-apphost-pack-11.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-apphost-pack-11.0.sha256sum] = "1e16b0bcb8d738f3c36849fd367a4da31d2387fc9c27cfb9014de6340629ce04"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-host-11.0.0~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-host;unpack=0"
SRC_URI[x86_64_v2_dotnet-host.sha256sum] = "48aeb57b50043964492e9ac708565debff731ae027983ef983c7a890f56540dd"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-hostfxr-11.0-11.0.0~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-hostfxr-11.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-hostfxr-11.0.sha256sum] = "ca3f00b0ba0e16d3e102701e614f6850557acf729ff8f1a048028a44e584f296"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-11.0-11.0.0~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-11.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-11.0.sha256sum] = "805677bd36857c39c205269959a6fc847d812258e5033d40787790288d1ed7ad"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-runtime-dbg-11.0-11.0.0~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-runtime-dbg-11.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-runtime-dbg-11.0.sha256sum] = "2a30bee77b43c0621988abb0179907a22106a61092d85a0afa202c719cb52cc1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-11.0-11.0.100~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-11.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-11.0.sha256sum] = "ee13c63e322b81c08f78eb271c23fcd119a0f8057ebf48ff0e0e5689a7d52307"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/dotnet-sdk-11.0-source-built-artifacts-11.0.100~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-11.0-source-built-artifacts;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-11.0-source-built-artifacts.sha256sum] = "0b9482c1342cfb354ecfc78e9200f6cf00417a42a434d4178831463f0c90c4b5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-aot-11.0-11.0.100~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-aot-11.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-aot-11.0.sha256sum] = "2e457e5e6f2e9207bdfa62a75294ccb6139ea3e50c19917d9d5606c056a3a643"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-sdk-dbg-11.0-11.0.100~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-sdk-dbg-11.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-sdk-dbg-11.0.sha256sum] = "3e53c74359db3490238541778aafba8e69d3c0c21c3bfa696c95588780e8f5c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-targeting-pack-11.0-11.0.0~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-targeting-pack-11.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-targeting-pack-11.0.sha256sum] = "6e4514ee0298c58816c95b3dd9e17396ad80195e1222fe9a2a7180685bf0c183"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/dotnet-templates-11.0-11.0.100~preview.6.26359.118-0.7.el10.x86_64_v2.rpm;name=x86_64_v2_dotnet-templates-11.0;unpack=0"
SRC_URI[x86_64_v2_dotnet-templates-11.0.sha256sum] = "3871d1c906d3b017b06426694cccae2508742482a42120a939f567bb6559ca30"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-11.0-11.0.0~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-11.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-11.0.sha256sum] = "6b97ae7bf18ac13f69a33b20ca1a27409afcd0ab11692d29bf8c07d0b7c756b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-runtime-dbg-11.0-11.0.0~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_aspnetcore-runtime-dbg-11.0;unpack=0"
SRC_URI[aarch64_aspnetcore-runtime-dbg-11.0.sha256sum] = "194c005d765c4d0e7b3d65cd4cfabf7ddf53281985c28353ef6f4c43781cfb58"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/aspnetcore-targeting-pack-11.0-11.0.0~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_aspnetcore-targeting-pack-11.0;unpack=0"
SRC_URI[aarch64_aspnetcore-targeting-pack-11.0.sha256sum] = "718d31598fcdb9eaf621ad1a79098dec90623216d2ac665762f4b4043a94fb48"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-apphost-pack-11.0-11.0.0~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-apphost-pack-11.0;unpack=0"
SRC_URI[aarch64_dotnet-apphost-pack-11.0.sha256sum] = "e976f25da7736187fc0023063bf09f0af3d0dc422f52f5926b3e0eae25309b88"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-host-11.0.0~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-host;unpack=0"
SRC_URI[aarch64_dotnet-host.sha256sum] = "02635ade7c6fa09b1e13968859091a593122808e0699380e66f446f079ecad99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-hostfxr-11.0-11.0.0~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-hostfxr-11.0;unpack=0"
SRC_URI[aarch64_dotnet-hostfxr-11.0.sha256sum] = "852777ddb6b7bd028ad4cf421a4f41b2d00c4fad0e589dd0958d7352d6d3c983"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-11.0-11.0.0~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-runtime-11.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-11.0.sha256sum] = "a7a14bd880362311f0542dc48554f393cd0a4aea9fc791056205a1b37d373ac0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-runtime-dbg-11.0-11.0.0~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-runtime-dbg-11.0;unpack=0"
SRC_URI[aarch64_dotnet-runtime-dbg-11.0.sha256sum] = "af095118e7713aac4ebc9e03a50fad8b3a5ec0f7afbf98f75e28f8ed101b12e0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-11.0-11.0.100~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-sdk-11.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-11.0.sha256sum] = "17d1d056015f541190d3fb497446e58e3d6b626246f35aa20f9a8e21adefbc99"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/dotnet-sdk-11.0-source-built-artifacts-11.0.100~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-sdk-11.0-source-built-artifacts;unpack=0"
SRC_URI[aarch64_dotnet-sdk-11.0-source-built-artifacts.sha256sum] = "bd53483575fc29e802d39afe70fb1a2adf96e4b0739eb8d63fdf336668bdbda8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-aot-11.0-11.0.100~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-sdk-aot-11.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-aot-11.0.sha256sum] = "515db46e0f8fdda9db3362be0b8f9a6347285352e6d2b52037abaa0d8bc30ff9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-sdk-dbg-11.0-11.0.100~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-sdk-dbg-11.0;unpack=0"
SRC_URI[aarch64_dotnet-sdk-dbg-11.0.sha256sum] = "5aa48374fc7dc81677901505f7f67c4b1113ff1ec30c90bf45bc3e246fc32b74"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-targeting-pack-11.0-11.0.0~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-targeting-pack-11.0;unpack=0"
SRC_URI[aarch64_dotnet-targeting-pack-11.0.sha256sum] = "36c366cac18fad20402fcb74a7d68533c1e9544771ee1938bbc5058538818cdc"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/dotnet-templates-11.0-11.0.100~preview.6.26359.118-0.7.el10.aarch64.rpm;name=aarch64_dotnet-templates-11.0;unpack=0"
SRC_URI[aarch64_dotnet-templates-11.0.sha256sum] = "615723bd665d3b033ac98ff94678c222c7b6e1cdc512f4edb86723cca9162458"

RDEPENDS:aspnetcore-runtime-11.0 = " \
 dotnet-runtime-11.0 \
 "
RDEPENDS:aspnetcore-runtime-dbg-11.0 = " \
 aspnetcore-runtime-11.0 \
 "
RDEPENDS:aspnetcore-targeting-pack-11.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-apphost-pack-11.0 = " \
 dotnet-host \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-host = " \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-hostfxr-11.0 = " \
 dotnet-host \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-runtime-11.0 = " \
 dotnet-hostfxr-11.0 \
 glibc \
 libbrotli \
 libgcc \
 libicu \
 libstdc++ \
 openssl-libs \
 zlib-ng-compat \
 "
RDEPENDS:dotnet-runtime-dbg-11.0 = " \
 dotnet-runtime-11.0 \
 "
RDEPENDS:dotnet-sdk-11.0 = " \
 aspnetcore-runtime-11.0 \
 aspnetcore-targeting-pack-11.0 \
 dotnet-apphost-pack-11.0 \
 dotnet-runtime-11.0 \
 dotnet-targeting-pack-11.0 \
 dotnet-templates-11.0 \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:dotnet-sdk-11.0-source-built-artifacts = " \
 "
RDEPENDS:dotnet-sdk-aot-11.0 = " \
 brotli-devel \
 clang \
 dotnet-sdk-11.0 \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 openssl-devel \
 openssl-libs \
 zlib-ng-compat \
 zlib-ng-compat-devel \
 "
RDEPENDS:dotnet-sdk-dbg-11.0 = " \
 dotnet-sdk-11.0 \
 "
RDEPENDS:dotnet-targeting-pack-11.0 = " \
 dotnet-host \
 "
RDEPENDS:dotnet-templates-11.0 = " \
 dotnet-host \
 "
