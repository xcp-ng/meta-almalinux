# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kidletime"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kidletime \
 kf6-kidletime-devel \
 kf6-kidletime-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-kidletime-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "63b46ea7efad38fae91528b678e9ed0f618179ed1480d3d0efcb1a6b13457914"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime;unpack=0"
SRC_URI[x86_64_v2_kf6-kidletime.sha256sum] = "82366fef1ae0f77fc776e50baffa81d61caff82ae0ff1369d88a7ccc3b7eefa4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kidletime-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-kidletime-devel.sha256sum] = "3adf63c93970adc6f048be9008b70f651fca877c4799dae234863e1d7b2c4355"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kidletime-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kidletime-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-kidletime-doc.sha256sum] = "c5f2ef89f59776e3e8bfa76504dd8852946ff32b9e0bc382899fdc49ac07315d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kidletime;unpack=0"
SRC_URI[aarch64_kf6-kidletime.sha256sum] = "825d51164a44ea8d989ac93c0b5dc151afa52dec4faee79416c22cce7b3bdb67"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kidletime-devel;unpack=0"
SRC_URI[aarch64_kf6-kidletime-devel.sha256sum] = "840c881f3d897d8297d0ee49641d55c5a8f23403011e4f8db6bb7d2fc9e6e1d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-kidletime-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kidletime-doc;unpack=0"
SRC_URI[aarch64_kf6-kidletime-doc.sha256sum] = "821ff741b668a989faccffffa25646d5ade3c7478e22c6118ea72bbfe4c454e1"

RDEPENDS:kf6-kidletime = " \
 glibc \
 kf6-filesystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtwayland \
 "
RDEPENDS:kf6-kidletime-devel = " \
 cmake-filesystem \
 kf6-kidletime \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kidletime-doc = " \
 "
