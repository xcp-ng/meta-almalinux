# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fast-cdr"
PV = "2.3.4"
PR = "1.el10_2"
PACKAGES = " \
 fast-cdr \
 fast-cdr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fast-cdr-2.3.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d4bb36a670f8eeee75c070da4ce8d2a15de5eb31d9ec340b5bbf10865fea8402"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fast-cdr-2.3.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fast-cdr;unpack=0"
SRC_URI[x86_64_v2_fast-cdr.sha256sum] = "766152c2506ef4c32eea7d6493897ad1e1367c0c90e43cc7726958eb411bbce7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fast-cdr-devel-2.3.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_fast-cdr-devel;unpack=0"
SRC_URI[x86_64_v2_fast-cdr-devel.sha256sum] = "53a6568f7fb4a199f1cb59a0c5bb04a0cd8bebb71436d4df2bb1b355265d7741"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fast-cdr-2.3.4-1.el10_2.aarch64.rpm;name=aarch64_fast-cdr;unpack=0"
SRC_URI[aarch64_fast-cdr.sha256sum] = "baa969c54203c6464a42886d6f3f25b21077d39026b413b6249c6622f7f71fca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fast-cdr-devel-2.3.4-1.el10_2.aarch64.rpm;name=aarch64_fast-cdr-devel;unpack=0"
SRC_URI[aarch64_fast-cdr-devel.sha256sum] = "76913e0942f306c30b8ff086c95b4cbfed9a755eb4db9df97e7b47e049600b17"

RDEPENDS:fast-cdr = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:fast-cdr-devel = " \
 cmake-filesystem \
 fast-cdr \
 "
