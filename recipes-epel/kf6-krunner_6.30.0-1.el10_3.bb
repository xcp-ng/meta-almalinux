# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-krunner"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-krunner \
 kf6-krunner-devel \
 kf6-krunner-doc \
 kf6-krunner-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-krunner-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "afacf49c6b2ae507dfb2f39f4e5311b18e61744045fd419f75421449b1454f36"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner;unpack=0"
SRC_URI[x86_64_v2_kf6-krunner.sha256sum] = "d2d8c36fd06a6bf9810dfdb1bdc4e3c7611d600582cf1b364bf9f0825c2b544c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-krunner-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-krunner-devel.sha256sum] = "a1d36d5910ee3e4adb9dda4e62d44630359bad26dfad32c3c2fa98b5f9b018d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-krunner-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-krunner-doc.sha256sum] = "64c9a4fe8431358bdd2bf371857a1c24813032592deab67456fbfdb01f670972"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-krunner-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-krunner-html;unpack=0"
SRC_URI[x86_64_v2_kf6-krunner-html.sha256sum] = "7f57760211cd16d24a2056b2da41426ec655e4b5713d6ed7f48d648af8017df7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-krunner;unpack=0"
SRC_URI[aarch64_kf6-krunner.sha256sum] = "835b3b24d8d1ae8f9bfba4db46f4c8a942f1b2543f597894f56ffc7d33f1aef6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-krunner-devel;unpack=0"
SRC_URI[aarch64_kf6-krunner-devel.sha256sum] = "3aa444e768c52cbbbc44049aa2963c36efc23019a5faeb9d414472c8b83f3f31"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-krunner-doc;unpack=0"
SRC_URI[aarch64_kf6-krunner-doc.sha256sum] = "e1f99ffc12ac8dfa3097777ecf4b7e19e63d40045c235e2465d59a7a0584956e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-krunner-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-krunner-html;unpack=0"
SRC_URI[aarch64_kf6-krunner-html.sha256sum] = "bf7de3b52f17280180c3c6bdafe70b3db973832b49ec2060913522061716261b"

RDEPENDS:kf6-krunner = " \
 glibc \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kitemmodels \
 kf6-kwindowsystem \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-krunner-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons-devel \
 kf6-krunner \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-krunner-doc = " \
 "
RDEPENDS:kf6-krunner-html = " \
 "
