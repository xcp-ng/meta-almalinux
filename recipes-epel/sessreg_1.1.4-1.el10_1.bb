# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sessreg"
PV = "1.1.4"
PR = "1.el10_1"
PACKAGES = " \
 sessreg \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sessreg-1.1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17b316f0cdc680c9eca70a22bd5448e68ea129d3f90a751ce3cf12a4926c9583"

URI_x86_64_v2_sessreg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sessreg-1.1.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sessreg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sessreg}"
SRC_URI[x86_64_v2_sessreg.sha256sum] = "83f5846a3c60cea3c3b25829d8bce06337b4a834d6f7dde3fa81d93ed4d1455c"

URI_aarch64_sessreg = "${EPEL_MIRROR}/aarch64/Packages/s/sessreg-1.1.4-1.el10_1.aarch64.rpm;name=aarch64_sessreg;unpack=0"
SRC_URI:append = " ${URI_aarch64_sessreg}"
SRC_URI[aarch64_sessreg.sha256sum] = "3b385b406fb1eb3487738ef05f144cd26e328db7a0e332c30e76c351ed51183a"

RDEPENDS:sessreg = " \
 glibc \
 "
