# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "oxygen-sounds"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 oxygen-sounds \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/o/oxygen-sounds-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0d4fa9624d998573a16973d578858f6083464d911f420356fd384423caee3f19"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/oxygen-sounds-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_oxygen-sounds;unpack=0"
SRC_URI[x86_64_v2_oxygen-sounds.sha256sum] = "f1e04e841f37c9d4c5922d4736cac5e81b9befc3e6f7d1a456f48eb5c02b7210"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/o/oxygen-sounds-6.7.5-1.el10_3.noarch.rpm;name=aarch64_oxygen-sounds;unpack=0"
SRC_URI[aarch64_oxygen-sounds.sha256sum] = "219cb9be259cbbbbf54a08def07208bdbb18db4b530d6837c0f177fdfe43d079"

RDEPENDS:oxygen-sounds = " \
 "
