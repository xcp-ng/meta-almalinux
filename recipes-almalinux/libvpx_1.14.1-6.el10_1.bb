# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvpx"
PV = "1.14.1"
PR = "6.el10_1"
PACKAGES = " \
 libvpx \
 libvpx-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libvpx-1.14.1-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c58e9dfbe0f12001201f7ba93ed7023a9377c029511aeea120c1d0665bc3a13"

URI_x86_64_v2_libvpx = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libvpx-1.14.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_libvpx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpx}"
SRC_URI[x86_64_v2_libvpx.sha256sum] = "439d6f011b96468d1fcdbfdc093ec1e46876e00177fcd06ceca47f0cdf9bbbb3"

URI_x86_64_v2_libvpx-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libvpx-devel-1.14.1-6.el10_1.x86_64_v2.rpm;name=x86_64_v2_libvpx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvpx-devel}"
SRC_URI[x86_64_v2_libvpx-devel.sha256sum] = "6dfcbc14ae569d2802703a4613cfd37bd36cbcd95a6500055450233f02b27fec"

URI_aarch64_libvpx = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libvpx-1.14.1-6.el10_1.aarch64.rpm;name=aarch64_libvpx;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvpx}"
SRC_URI[aarch64_libvpx.sha256sum] = "30369f746b54ccb7dbf3936774628f04895a7f8b526876244a19bb4cd71c2e3d"

URI_aarch64_libvpx-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libvpx-devel-1.14.1-6.el10_1.aarch64.rpm;name=aarch64_libvpx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvpx-devel}"
SRC_URI[aarch64_libvpx-devel.sha256sum] = "3de206dad83740f7de562014096b0b3977e73c08f78556ab982f02f5cf27f4b0"

RDEPENDS:libvpx = " \
 glibc \
 "
RDEPENDS:libvpx-devel = " \
 libvpx \
 pkgconf-pkg-config \
 "
