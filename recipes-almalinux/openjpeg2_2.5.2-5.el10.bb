# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openjpeg2"
PV = "2.5.2"
PR = "5.el10"
PACKAGES = " \
 openjpeg2 \
 openjpeg2-devel \
 openjpeg2-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openjpeg2-2.5.2-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3f6891687bdd98d4445d66bc7f87a591dc147d2ad45e9a83b7760897e95f9ffa"

URI_x86_64_v2_openjpeg2 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openjpeg2-2.5.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_openjpeg2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openjpeg2}"
SRC_URI[x86_64_v2_openjpeg2.sha256sum] = "ea4cf8d7c71126f672588ffa54d9009fbda46e7b21f66a53044595acd5fdb281"

URI_x86_64_v2_openjpeg2-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openjpeg2-devel-2.5.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_openjpeg2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openjpeg2-devel}"
SRC_URI[x86_64_v2_openjpeg2-devel.sha256sum] = "c5c85bdfe8d02ec09b9fa4b6a563ff86442547d27e85055501d2b708e5dc946c"

URI_x86_64_v2_openjpeg2-tools = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/openjpeg2-tools-2.5.2-5.el10.x86_64_v2.rpm;name=x86_64_v2_openjpeg2-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openjpeg2-tools}"
SRC_URI[x86_64_v2_openjpeg2-tools.sha256sum] = "7834357f826669530370c30831fcfccc6072c8ed57136a20f266a43626d58071"

URI_aarch64_openjpeg2 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openjpeg2-2.5.2-5.el10.aarch64.rpm;name=aarch64_openjpeg2;unpack=0"
SRC_URI:append = " ${URI_aarch64_openjpeg2}"
SRC_URI[aarch64_openjpeg2.sha256sum] = "bad4937cc8f045b7b09aa4a9ec8f611b918762cb22669558703c2ddd5a26211e"

URI_aarch64_openjpeg2-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openjpeg2-devel-2.5.2-5.el10.aarch64.rpm;name=aarch64_openjpeg2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openjpeg2-devel}"
SRC_URI[aarch64_openjpeg2-devel.sha256sum] = "1e1fff879f477ff0d1f885a331a9ef9c296864fae13a4e436e189060f4507f7c"

URI_aarch64_openjpeg2-tools = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/openjpeg2-tools-2.5.2-5.el10.aarch64.rpm;name=aarch64_openjpeg2-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_openjpeg2-tools}"
SRC_URI[aarch64_openjpeg2-tools.sha256sum] = "88f461f023356be71392b8484b9bae6d0d2e2a8562b72574ef7a4d1a50b9a001"

RDEPENDS:openjpeg2 = " \
 glibc \
 "
RDEPENDS:openjpeg2-devel = " \
 cmake-filesystem \
 openjpeg2 \
 openjpeg2-tools \
 pkgconf-pkg-config \
 "
RDEPENDS:openjpeg2-tools = " \
 glibc \
 lcms2 \
 libpng \
 libtiff \
 openjpeg2 \
 "
