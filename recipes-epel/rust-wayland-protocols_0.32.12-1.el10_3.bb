# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-protocols"
PV = "0.32.12"
PR = "1.el10_3"
PACKAGES = " \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-protocols+server-devel \
 rust-wayland-protocols+staging-devel \
 rust-wayland-protocols+unstable-devel \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-protocols-0.32.12-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2c22c0a3fa749dffd3e16a33b20526c6c65d37be20959c6a27e6777daa96571f"

URI_x86_64_v2_rust-wayland-protocols+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+client-devel-0.32.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+client-devel.sha256sum] = "30c420e48cd70c40f358c54c8f8ac9fb70067a6f576b76e590d0159f8c591bb8"

URI_x86_64_v2_rust-wayland-protocols+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+default-devel-0.32.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+default-devel.sha256sum] = "4865e97308d6c5595a92d53b025a66e472bbba9f596b30a026f38371d58ed91b"

URI_x86_64_v2_rust-wayland-protocols+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+server-devel-0.32.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+server-devel.sha256sum] = "3c27df7988bb4e5944028ac984285ab2aa4a93a83c8f4e24b31dd1caa506d8ce"

URI_x86_64_v2_rust-wayland-protocols+staging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+staging-devel-0.32.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+staging-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+staging-devel.sha256sum] = "985e07b364f924fa96e6c185c43eb4b0e6e04d1fe85e7b746f6f871a485dda42"

URI_x86_64_v2_rust-wayland-protocols+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+unstable-devel-0.32.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+unstable-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+unstable-devel.sha256sum] = "3d347787568ddd428f1ff100ef6d961781226b01c39b8305f1c7ba31e3e434f9"

URI_x86_64_v2_rust-wayland-protocols+wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-client-devel-0.32.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-client-devel.sha256sum] = "d84224490c90e66bb7da755f3d500d0b540a8cb56e3aa247df9982071a5a304a"

URI_x86_64_v2_rust-wayland-protocols+wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-server-devel-0.32.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-server-devel.sha256sum] = "a29713cb4ddd61544ea45833d2bac99381153f3a2f1077157b25290f53687cdf"

URI_x86_64_v2_rust-wayland-protocols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-devel-0.32.12-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-devel.sha256sum] = "b7bf7c64bd9ebadb1a0c23c9c2c4ec1da47cc7f4daccaea2573d67f462331552"

URI_aarch64_rust-wayland-protocols+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+client-devel-0.32.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+client-devel}"
SRC_URI[aarch64_rust-wayland-protocols+client-devel.sha256sum] = "471b98610dd45b94ac3bf47ac8bed015e95d2da6ca229790c62f0f966671acd1"

URI_aarch64_rust-wayland-protocols+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+default-devel-0.32.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+default-devel}"
SRC_URI[aarch64_rust-wayland-protocols+default-devel.sha256sum] = "c291eb8a84d50ef0bda8997c2cd2ed4265c37b69063734150d3fed6160424baf"

URI_aarch64_rust-wayland-protocols+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+server-devel-0.32.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+server-devel}"
SRC_URI[aarch64_rust-wayland-protocols+server-devel.sha256sum] = "0d73772377372de78df58b0665edd8a88c15b93bc55aaad85d7212b71672dc1c"

URI_aarch64_rust-wayland-protocols+staging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+staging-devel-0.32.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+staging-devel}"
SRC_URI[aarch64_rust-wayland-protocols+staging-devel.sha256sum] = "b78e8e32203bc6bdce5f5e300b838302fa67b3848f7a1d4dd1603882ec2f3657"

URI_aarch64_rust-wayland-protocols+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+unstable-devel-0.32.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+unstable-devel}"
SRC_URI[aarch64_rust-wayland-protocols+unstable-devel.sha256sum] = "bb0194549e4e75c7c7a0ff0cc5a34710dc7b65beded075d7261e01136ef94fdb"

URI_aarch64_rust-wayland-protocols+wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-client-devel-0.32.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-protocols+wayland-client-devel.sha256sum] = "d1d08d7a64c6f1a4ab4bb04bb7a6cc2ced3f489d20c6733e90ea284fc4731096"

URI_aarch64_rust-wayland-protocols+wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-server-devel-0.32.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-protocols+wayland-server-devel.sha256sum] = "c48320ef629a0a61d5ab7d1e2b80ec170bbc09f632c9681c84837be32811cba2"

URI_aarch64_rust-wayland-protocols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-devel-0.32.12-1.el10_3.noarch.rpm;name=aarch64_rust-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-devel}"
SRC_URI[aarch64_rust-wayland-protocols-devel.sha256sum] = "9de6c83299b10d5c0d86334f3fc0b78b3951221d3d99b848655571fb82c565a4"

RDEPENDS:rust-wayland-protocols+client-devel = " \
 cargo \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+default-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+server-devel = " \
 cargo \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+staging-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+unstable-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-client-devel = " \
 cargo \
 rust-wayland-client+default-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-server-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 rust-wayland-server+default-devel \
 "
RDEPENDS:rust-wayland-protocols-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
