# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-http-send-reqwest"
PV = "2.0.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqsign-http-send-reqwest+default-devel \
 rust-reqsign-http-send-reqwest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-http-send-reqwest-2.0.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58900520b3fced59067020b713ac5558144ffec7659cca50df0e1cc6cc197b93"

URI_x86_64_v2_rust-reqsign-http-send-reqwest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-http-send-reqwest+default-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-http-send-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-http-send-reqwest+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-http-send-reqwest+default-devel.sha256sum] = "2c219514233dd22bc783859c4c5eb17dc6d211708f9221aae4e0a1a925556f08"

URI_x86_64_v2_rust-reqsign-http-send-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-http-send-reqwest-devel-2.0.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-http-send-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-http-send-reqwest-devel}"
SRC_URI[x86_64_v2_rust-reqsign-http-send-reqwest-devel.sha256sum] = "d6d659ac875652ba22128731b7c84cab7bf8867f6c37e18ecbe91e3af96aa563"

URI_aarch64_rust-reqsign-http-send-reqwest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-http-send-reqwest+default-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-http-send-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-http-send-reqwest+default-devel}"
SRC_URI[aarch64_rust-reqsign-http-send-reqwest+default-devel.sha256sum] = "4a2ccd91d1e8ca0b7d3bb86427643e6f6f1271d127851bc83e930e6c209b8cd3"

URI_aarch64_rust-reqsign-http-send-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-http-send-reqwest-devel-2.0.1-1.el10_2.noarch.rpm;name=aarch64_rust-reqsign-http-send-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-http-send-reqwest-devel}"
SRC_URI[aarch64_rust-reqsign-http-send-reqwest-devel.sha256sum] = "52ee86903899799a0038d1f9a28f16bf152a1d2b2147fede57dd4c1194582c29"

RDEPENDS:rust-reqsign-http-send-reqwest+default-devel = " \
 cargo \
 rust-reqsign-http-send-reqwest-devel \
 "
RDEPENDS:rust-reqsign-http-send-reqwest-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-async-trait+default-devel \
 rust-bytes+default-devel \
 rust-http+default-devel \
 rust-http-body-util+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqwest0.12-devel \
 "
