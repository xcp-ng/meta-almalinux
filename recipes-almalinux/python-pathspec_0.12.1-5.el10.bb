# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pathspec"
PV = "0.12.1"
PR = "5.el10"
PACKAGES = " \
 python3-pathspec \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-pathspec-0.12.1-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d3ea2879bbb30064b2dabaa3ab1d9b2c7724b679ef106c14b4af24f34cbbe772"

URI_x86_64_v2_python3-pathspec = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-pathspec-0.12.1-5.el10.noarch.rpm;name=x86_64_v2_python3-pathspec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pathspec}"
SRC_URI[x86_64_v2_python3-pathspec.sha256sum] = "ecca56cb0142efbfa04d3cc95a916a9c16150f25ab598b2225044c33c6260380"

URI_aarch64_python3-pathspec = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-pathspec-0.12.1-5.el10.noarch.rpm;name=aarch64_python3-pathspec;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pathspec}"
SRC_URI[aarch64_python3-pathspec.sha256sum] = "ecca56cb0142efbfa04d3cc95a916a9c16150f25ab598b2225044c33c6260380"

RDEPENDS:python3-pathspec = " \
 python3 \
 "
