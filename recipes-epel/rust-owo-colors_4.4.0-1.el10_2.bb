# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-owo-colors"
PV = "4.4.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-owo-colors+alloc-devel \
 rust-owo-colors+default-devel \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors+supports-colors-devel \
 rust-owo-colors-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-owo-colors-4.4.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "9d925086eb886da358af5aa50fa4893b4c720e4d7c60fe6e432e01f9bb6b3377"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+alloc-devel-4.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors+alloc-devel.sha256sum] = "8215df3d3e2370fc1e05aa7a7b8404c8ef93f3fa5ae802fd5ead3768589b7218"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+default-devel-4.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors+default-devel.sha256sum] = "f298e9f3718959e2e0df775f713296827eecda871a7b7de8dbfc57eeba88cc8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-color-devel-4.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors+supports-color-devel.sha256sum] = "f53df86abce2e385522dabef6dde85c757f6acda2443a70c48d708ca70a8cefe"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-colors-devel-4.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors+supports-colors-devel.sha256sum] = "e3f3401b489382d3fecf1717998df7a885a7ca7e05db29910fe76f6bd12dc4e1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors-devel-4.4.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors-devel.sha256sum] = "aed9c5f80c8254c6cb491f81e7b57d60a159c912cd14fecd8486273443bb6080"
RPROVIDES:rust-owo-colors-devel:append:x86_64_v2 = " virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+alloc-devel-4.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors+alloc-devel.sha256sum] = "229ece3e9471fa77895c6b655a9b73324173253234ad483ba70c286e5a3145f2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+default-devel-4.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors+default-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors+default-devel.sha256sum] = "9ada2c0297c3ccd2116a0b3c1ae034248a684326f7237c4fc1bc428643827dc2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-color-devel-4.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors+supports-color-devel.sha256sum] = "103fed13c5b37282a152ae9a70a624480bfcab1d3f6b7b2f6a88d9365b8f03a9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-colors-devel-4.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors+supports-colors-devel.sha256sum] = "4a4e41a51180685857492430ffab32beb0e9542674feb6103ea2759dcfab5eab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors-devel-4.4.0-1.el10_2.noarch.rpm;name=aarch64_rust-owo-colors-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors-devel.sha256sum] = "ecfda8477bb28654d1980dd30ee4f924132bbc1835759579cd84a1b54df06b7d"
RPROVIDES:rust-owo-colors-devel:append:aarch64 = " virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

RDEPENDS:rust-owo-colors+alloc-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+default-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+supports-color-devel = " \
 cargo \
 rust-owo-colors-devel \
 rust-supports-color+default-devel \
 "
RDEPENDS:rust-owo-colors+supports-colors-devel = " \
 cargo \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors-devel \
 rust-supports-color2+default-devel \
 "
RDEPENDS:rust-owo-colors-devel = " \
 cargo \
 rust \
 "
