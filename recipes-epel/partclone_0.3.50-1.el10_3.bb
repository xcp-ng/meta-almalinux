# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "partclone"
PV = "0.3.50"
PR = "1.el10_3"
PACKAGES = " \
 partclone \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/partclone-0.3.50-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b613512c4912c65420dde24d6c6fcca12a9c6b82628a3abbb6449edc9648aae9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/partclone-0.3.50-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_partclone;unpack=0"
SRC_URI[x86_64_v2_partclone.sha256sum] = "fe35806fc5ed5e63798a3616364d210259e2928beb227d34267b16220d531675"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/partclone-0.3.50-1.el10_3.aarch64.rpm;name=aarch64_partclone;unpack=0"
SRC_URI[aarch64_partclone.sha256sum] = "4f7e466bef3ffc4e745a0259f17c19e5cf628e46749dd814ad003010642c7b32"

RDEPENDS:partclone = " \
 e2fsprogs-libs \
 fuse3-libs \
 glibc \
 libblkid \
 libuuid \
 ncurses-libs \
 ntfs-3g-libs \
 openssl-libs \
 userspace-rcu \
 xxhash-libs \
 "
