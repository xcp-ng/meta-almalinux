# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tuned"
PV = "2.28.0"
PR = "1.el10"
PACKAGES = " \
 tuned \
 tuned-gtk \
 tuned-ppd \
 tuned-profiles-atomic \
 tuned-profiles-cpu-partitioning \
 tuned-profiles-mssql \
 tuned-profiles-oracle \
 tuned-profiles-postgresql \
 tuned-profiles-spectrumscale \
 tuned-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tuned-2.28.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "dd68b45c460ff72c4354e803b3872d866be5d4b0fd1db7a927458ec4d8bbcc36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned;unpack=0"
SRC_URI[x86_64_v2_tuned.sha256sum] = "d69cddc685410be339c3f34b697cede95613cfd899e35d935cb0e96c761f0f80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-gtk-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned-gtk;unpack=0"
SRC_URI[x86_64_v2_tuned-gtk.sha256sum] = "2e0e0b9576bed92f15df7da74e8701dbcca3c5e5229ceda6466ec478a98d6ba1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-ppd-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned-ppd;unpack=0"
SRC_URI[x86_64_v2_tuned-ppd.sha256sum] = "415d853d49af39bd7f6a9f583ba94238cd69027fb873bc67d3d602fff9cb1b01"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-atomic-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-atomic;unpack=0"
SRC_URI[x86_64_v2_tuned-profiles-atomic.sha256sum] = "4cb4404a3f1203c99d72dbd4fff752aae6ed7cb2bed3a2972d89092348e125e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tuned-profiles-cpu-partitioning-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI[x86_64_v2_tuned-profiles-cpu-partitioning.sha256sum] = "6a54d177bc9a317b67cede19bf7dfba2f1b9783aa662534db88101666d035c3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-mssql-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-mssql;unpack=0"
SRC_URI[x86_64_v2_tuned-profiles-mssql.sha256sum] = "2b73f51a45ca05949d89c86ada5b9911ca93ccce9795cba5dc5079bdac450711"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-oracle-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-oracle;unpack=0"
SRC_URI[x86_64_v2_tuned-profiles-oracle.sha256sum] = "2a6794f776ca0b502ca44d64e0f444f0addce3f0dd7233d63b74fbf6b7bfb8a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-postgresql-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-postgresql;unpack=0"
SRC_URI[x86_64_v2_tuned-profiles-postgresql.sha256sum] = "5c75a83f4043736da0d9c439b87218cceb7b094c7bc17f41beb79aab4553b3e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-profiles-spectrumscale-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned-profiles-spectrumscale;unpack=0"
SRC_URI[x86_64_v2_tuned-profiles-spectrumscale.sha256sum] = "e3621e75ffe4c614a4be76b895a9c5a2efa8d1e232dea73c4de403828733e786"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tuned-utils-2.28.0-1.el10.noarch.rpm;name=x86_64_v2_tuned-utils;unpack=0"
SRC_URI[x86_64_v2_tuned-utils.sha256sum] = "105f96d09614f3f39efe8f2796854c596ab720d0a50e7d652b65a0064bdd1bee"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned;unpack=0"
SRC_URI[aarch64_tuned.sha256sum] = "d69cddc685410be339c3f34b697cede95613cfd899e35d935cb0e96c761f0f80"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-gtk-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned-gtk;unpack=0"
SRC_URI[aarch64_tuned-gtk.sha256sum] = "2e0e0b9576bed92f15df7da74e8701dbcca3c5e5229ceda6466ec478a98d6ba1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-ppd-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned-ppd;unpack=0"
SRC_URI[aarch64_tuned-ppd.sha256sum] = "415d853d49af39bd7f6a9f583ba94238cd69027fb873bc67d3d602fff9cb1b01"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-atomic-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned-profiles-atomic;unpack=0"
SRC_URI[aarch64_tuned-profiles-atomic.sha256sum] = "4cb4404a3f1203c99d72dbd4fff752aae6ed7cb2bed3a2972d89092348e125e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tuned-profiles-cpu-partitioning-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned-profiles-cpu-partitioning;unpack=0"
SRC_URI[aarch64_tuned-profiles-cpu-partitioning.sha256sum] = "6a54d177bc9a317b67cede19bf7dfba2f1b9783aa662534db88101666d035c3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-mssql-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned-profiles-mssql;unpack=0"
SRC_URI[aarch64_tuned-profiles-mssql.sha256sum] = "2b73f51a45ca05949d89c86ada5b9911ca93ccce9795cba5dc5079bdac450711"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-oracle-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned-profiles-oracle;unpack=0"
SRC_URI[aarch64_tuned-profiles-oracle.sha256sum] = "2a6794f776ca0b502ca44d64e0f444f0addce3f0dd7233d63b74fbf6b7bfb8a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-postgresql-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned-profiles-postgresql;unpack=0"
SRC_URI[aarch64_tuned-profiles-postgresql.sha256sum] = "5c75a83f4043736da0d9c439b87218cceb7b094c7bc17f41beb79aab4553b3e6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-profiles-spectrumscale-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned-profiles-spectrumscale;unpack=0"
SRC_URI[aarch64_tuned-profiles-spectrumscale.sha256sum] = "e3621e75ffe4c614a4be76b895a9c5a2efa8d1e232dea73c4de403828733e786"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tuned-utils-2.28.0-1.el10.noarch.rpm;name=aarch64_tuned-utils;unpack=0"
SRC_URI[aarch64_tuned-utils.sha256sum] = "105f96d09614f3f39efe8f2796854c596ab720d0a50e7d652b65a0064bdd1bee"

RDEPENDS:tuned = " \
 bash \
 dbus \
 ethtool \
 gawk \
 hdparm \
 iproute \
 iw \
 kmod \
 polkit \
 python3 \
 python3-dbus \
 python3-gobject-base \
 python3-inotify \
 python3-linux-procfs \
 python3-pyudev \
 rpm-ostree \
 systemd \
 util-linux \
 virt-what \
 "
RDEPENDS:tuned-gtk = " \
 polkit \
 powertop \
 python3 \
 python3-gobject-base \
 tuned \
 "
RDEPENDS:tuned-ppd = " \
 bash \
 python3 \
 tuned \
 "
RDEPENDS:tuned-profiles-atomic = " \
 tuned \
 "
RDEPENDS:tuned-profiles-cpu-partitioning = " \
 bash \
 tuned \
 "
RDEPENDS:tuned-profiles-mssql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-oracle = " \
 tuned \
 "
RDEPENDS:tuned-profiles-postgresql = " \
 tuned \
 "
RDEPENDS:tuned-profiles-spectrumscale = " \
 tuned \
 "
RDEPENDS:tuned-utils = " \
 powertop \
 python3 \
 tuned \
 "
