# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bytemuck_derive"
PV = "1.10.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-bytemuck_derive+default-devel \
 rust-bytemuck_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bytemuck_derive-1.10.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cb82e4665d8075c7b195d4544bc63a8aae742795d5b4fc37e47f4de58b89658f"

URI_x86_64_v2_rust-bytemuck_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive+default-devel-1.10.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck_derive+default-devel}"
SRC_URI[x86_64_v2_rust-bytemuck_derive+default-devel.sha256sum] = "ba007403060cc6f77c49ca7e746a5621fdc06934823463f795ffc9bc67d38841"

URI_x86_64_v2_rust-bytemuck_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bytemuck_derive-devel-1.10.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bytemuck_derive-devel}"
SRC_URI[x86_64_v2_rust-bytemuck_derive-devel.sha256sum] = "5b5791c73580ab97645a8af9fbbfb7170e189267f58b49b9c6601f1b4fcc6f0d"

URI_aarch64_rust-bytemuck_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive+default-devel-1.10.2-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck_derive+default-devel}"
SRC_URI[aarch64_rust-bytemuck_derive+default-devel.sha256sum] = "bab15626ea4033d7c931c4350831f80f07f749e97201ecff82fb8cccc63d361c"

URI_aarch64_rust-bytemuck_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bytemuck_derive-devel-1.10.2-1.el10_1.noarch.rpm;name=aarch64_rust-bytemuck_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bytemuck_derive-devel}"
SRC_URI[aarch64_rust-bytemuck_derive-devel.sha256sum] = "4047ec7abe8e2619f27253bed5459a845f9075e3552d90c6ed429a0f55a28fdf"

RDEPENDS:rust-bytemuck_derive+default-devel = " \
 cargo \
 rust-bytemuck_derive-devel \
 "
RDEPENDS:rust-bytemuck_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
