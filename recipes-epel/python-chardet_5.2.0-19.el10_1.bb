# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-chardet"
PV = "5.2.0"
PR = "19.el10_1"
PACKAGES = " \
 python3-chardet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-chardet-5.2.0-19.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0abdab93d511b96982e15218b20337a83896b7d34fcbc6ed4a84dab5554f25a4"

URI_x86_64_v2_python3-chardet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-chardet-5.2.0-19.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-chardet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-chardet}"
SRC_URI[x86_64_v2_python3-chardet.sha256sum] = "90078d94b9dedf997044eaf8d3685797960f59e46a6737cf334380fde9887c8b"

URI_aarch64_python3-chardet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-chardet-5.2.0-19.el10_1.noarch.rpm;name=aarch64_python3-chardet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-chardet}"
SRC_URI[aarch64_python3-chardet.sha256sum] = "a142b35b131d38c0a47102a02f947e8fd555c310230026b5c73fede7885d0bb3"

RDEPENDS:python3-chardet = " \
 python3 \
 "
