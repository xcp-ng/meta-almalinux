# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xattr"
PV = "1.4.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-xattr+default-devel \
 rust-xattr+unsupported-devel \
 rust-xattr-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-xattr-1.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c72714695517735531ff378834636e6804f59e55662309e99084b14a041c6036"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xattr+default-devel-1.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xattr+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xattr+default-devel.sha256sum] = "b96459a37cc58a4c47c9c8ac181e626c0c8bfbf9130ca37e395be02528e6a10d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xattr+unsupported-devel-1.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xattr+unsupported-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xattr+unsupported-devel.sha256sum] = "e443c4f8460e9ea0e6f0200a5cc871bcf2c0bff75aa86c5b591c533491d55fca"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xattr-devel-1.4.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xattr-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xattr-devel.sha256sum] = "15a184fec26077d1b9a44c236fc5a78aa0780159a26b96b4a583512f135e313f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xattr+default-devel-1.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-xattr+default-devel;unpack=0"
SRC_URI[aarch64_rust-xattr+default-devel.sha256sum] = "897da0ac438835001779765c6c55210b05d500dbfd6507967fdbc1f4eb6ef174"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xattr+unsupported-devel-1.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-xattr+unsupported-devel;unpack=0"
SRC_URI[aarch64_rust-xattr+unsupported-devel.sha256sum] = "66f3b61d10727c4fbcc18ddabdad639f04e553f7ba657b75a145587297b8430b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xattr-devel-1.4.0-1.el10_0.noarch.rpm;name=aarch64_rust-xattr-devel;unpack=0"
SRC_URI[aarch64_rust-xattr-devel.sha256sum] = "e5e7e535a873410cba1aaef7ad8eb5343fb86ec3646237e815d4cfc7116474bf"

RDEPENDS:rust-xattr+default-devel = " \
 cargo \
 rust-xattr+unsupported-devel \
 rust-xattr-devel \
 "
RDEPENDS:rust-xattr+unsupported-devel = " \
 cargo \
 rust-xattr-devel \
 "
RDEPENDS:rust-xattr-devel = " \
 cargo \
 rust-linux-raw-sys0.4+std-devel \
 rust-linux-raw-sys0.4-devel \
 rust-rustix+fs-devel \
 rust-rustix+std-devel \
 rust-rustix-devel \
 "
