# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-async-broadcast"
PV = "0.7.2"
PR = "4.el10_1"
PACKAGES = " \
 rust-async-broadcast+default-devel \
 rust-async-broadcast-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-async-broadcast-0.7.2-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "089f75678bf377db2a8e18b0f155ec6d0d7c521cfd3eb3e5ac769a284b4099d4"

URI_x86_64_v2_rust-async-broadcast+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-broadcast+default-devel-0.7.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-broadcast+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-broadcast+default-devel}"
SRC_URI[x86_64_v2_rust-async-broadcast+default-devel.sha256sum] = "bda827208fbe1484e491c3893a937a1feb16a2df6c14da39f7ee9252bb90d6e4"

URI_x86_64_v2_rust-async-broadcast-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-async-broadcast-devel-0.7.2-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-async-broadcast-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-async-broadcast-devel}"
SRC_URI[x86_64_v2_rust-async-broadcast-devel.sha256sum] = "578efe0d575ad3215b08ba3939d55fea070b53393cb484f587453bf6aba506cd"

URI_aarch64_rust-async-broadcast+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-broadcast+default-devel-0.7.2-4.el10_1.noarch.rpm;name=aarch64_rust-async-broadcast+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-broadcast+default-devel}"
SRC_URI[aarch64_rust-async-broadcast+default-devel.sha256sum] = "31983722641a704e299325d0e3bd044227f2d85e2538cedda4dc88439423986c"

URI_aarch64_rust-async-broadcast-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-async-broadcast-devel-0.7.2-4.el10_1.noarch.rpm;name=aarch64_rust-async-broadcast-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-async-broadcast-devel}"
SRC_URI[aarch64_rust-async-broadcast-devel.sha256sum] = "5db344ad7ec171c2945c8dfc5a00e90154978b522bcd651332aa22730931081c"

RDEPENDS:rust-async-broadcast+default-devel = " \
 cargo \
 rust-async-broadcast-devel \
 "
RDEPENDS:rust-async-broadcast-devel = " \
 cargo \
 rust \
 rust-event-listener+default-devel \
 rust-event-listener-strategy+default-devel \
 rust-futures-core+default-devel \
 rust-pin-project-lite+default-devel \
 "
