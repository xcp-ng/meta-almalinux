# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-camino"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-camino+default-devel \
 rust-camino+proptest1-devel \
 rust-camino+serde1-devel \
 rust-camino-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-camino-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb3ae24465300b746d768dfbd374925b3a47bf9a92620105067667dec49a0b40"

URI_x86_64_v2_rust-camino+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+default-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+default-devel}"
SRC_URI[x86_64_v2_rust-camino+default-devel.sha256sum] = "cf4ac14455aac1946f67e8025430f72bb03a72181df40d18e308278ca065289f"

URI_x86_64_v2_rust-camino+proptest1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+proptest1-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+proptest1-devel}"
SRC_URI[x86_64_v2_rust-camino+proptest1-devel.sha256sum] = "b3a5ea8eaaf372d1c7034638bf43201e890581aeab66103b33c87f3616569ba7"

URI_x86_64_v2_rust-camino+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+serde1-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+serde1-devel}"
SRC_URI[x86_64_v2_rust-camino+serde1-devel.sha256sum] = "6ac34ad50ff511bf356c598ff60873d6a4cd5cc48c5b8ae25bdb446fe3ec7f71"

URI_x86_64_v2_rust-camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino-devel}"
SRC_URI[x86_64_v2_rust-camino-devel.sha256sum] = "e105d3901700d3fdbf1066150a8b8650771715302d6d6c7f3607260af6ee6efa"

URI_aarch64_rust-camino+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+default-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-camino+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+default-devel}"
SRC_URI[aarch64_rust-camino+default-devel.sha256sum] = "108d9a07f22d9b333ce456874354a4f15f3efecfd81ce78f67d5a4cda7a6e5c1"

URI_aarch64_rust-camino+proptest1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+proptest1-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-camino+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+proptest1-devel}"
SRC_URI[aarch64_rust-camino+proptest1-devel.sha256sum] = "947d48bdfc4f9c8e42bbdf5122ccbf22c4a7cd8ff67785d1757ee75c74c7832c"

URI_aarch64_rust-camino+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+serde1-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-camino+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+serde1-devel}"
SRC_URI[aarch64_rust-camino+serde1-devel.sha256sum] = "30925ad6105f6e67b3fc5fa5048084fa06855d7dd603e81bee233989d76ee884"

URI_aarch64_rust-camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_rust-camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino-devel}"
SRC_URI[aarch64_rust-camino-devel.sha256sum] = "2e950cf71df0b2d804c1f8619745f67c856232626b5d3c4065b5a73ad97444c8"

RDEPENDS:rust-camino+default-devel = " \
 cargo \
 rust-camino-devel \
 "
RDEPENDS:rust-camino+proptest1-devel = " \
 cargo \
 rust-camino-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-camino+serde1-devel = " \
 cargo \
 rust-camino-devel \
 rust-serde_core+default-devel \
 "
RDEPENDS:rust-camino-devel = " \
 cargo \
 rust \
 "
