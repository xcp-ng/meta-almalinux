# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-tungstenite"
PV = "0.23.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+connect-devel \
 rust-tokio-tungstenite+default-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+native-tls-crate-devel \
 rust-tokio-tungstenite+native-tls-devel \
 rust-tokio-tungstenite+rustls-devel \
 rust-tokio-tungstenite+rustls-native-certs-devel \
 rust-tokio-tungstenite+rustls-pki-types-devel \
 rust-tokio-tungstenite+rustls-tls-native-roots-devel \
 rust-tokio-tungstenite+rustls-tls-webpki-roots-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-native-tls-devel \
 rust-tokio-tungstenite+tokio-rustls-devel \
 rust-tokio-tungstenite+url-devel \
 rust-tokio-tungstenite+webpki-roots-devel \
 rust-tokio-tungstenite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-tungstenite-0.23.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ec1baa6767b125c5912ad271accc3059de449d00529010ea5d344b2e9b28638"

URI_x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+__rustls-tls-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+__rustls-tls-devel.sha256sum] = "b6797baa0789704fd0c28b0bca1bfd7af6d4634a30dc57512b38f27b7a395b19"

URI_x86_64_v2_rust-tokio-tungstenite+connect-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+connect-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+connect-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+connect-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+connect-devel.sha256sum] = "3076546d69357c7683883ba1ecd6edcd40cd664cc259e2daec09406c33b54b60"

URI_x86_64_v2_rust-tokio-tungstenite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+default-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+default-devel.sha256sum] = "cf4f6b0fcaad57458501a93024e25cd6b9d990201c427517ebcdc086fcb2b486"

URI_x86_64_v2_rust-tokio-tungstenite+handshake-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+handshake-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+handshake-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+handshake-devel.sha256sum] = "ac2d51ae991b1479294b799ae50c3840d8856ad7cad34ce442de21a60a898514"

URI_x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+native-tls-crate-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+native-tls-crate-devel.sha256sum] = "34ad0375b80cc511d0a520d2da0764c807778622c2f0f72ee60b2e8695917f9f"

URI_x86_64_v2_rust-tokio-tungstenite+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+native-tls-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+native-tls-devel.sha256sum] = "e72642124a100f03e533c93b37468e73800a0c006ed316156807ec612c9b7f49"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-devel.sha256sum] = "d46e25b56952eb2fd1d0534734df8266e2f8bfebab689458aadbbc5483ed53ac"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-native-certs-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-native-certs-devel.sha256sum] = "af8750071adb8215511b722f831af9ac88c3383c08f79ee82da2393e1e59cf43"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-pki-types-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-pki-types-devel.sha256sum] = "c43ad9bd869811a99ea3c184547b1045cdf83675e5083a0b50035652e0bd60a2"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-tls-native-roots-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "e00507bf386e620e0bc3d4500affc235acf5adc9c11ab13e15858c446b63d685"

URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+rustls-tls-webpki-roots-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "871179a018aa29e7979ba301e009b23e2bf867a253a2ffface742178bb3f44b7"

URI_x86_64_v2_rust-tokio-tungstenite+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+stream-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+stream-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+stream-devel.sha256sum] = "ba345184c945e42f75272b0a8571761e6e6eeddabdaefb515b1a3bf8d2b17c52"

URI_x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+tokio-native-tls-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+tokio-native-tls-devel.sha256sum] = "6a9d87abe3237ea052f621aaa7e2ae2abc6f39bf16b091e55b8a9cdd8c0ce90e"

URI_x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+tokio-rustls-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+tokio-rustls-devel.sha256sum] = "71d289849bdcf511ed00436fe3466af7fcc47e58d47e7a485562b7e8c05b821b"

URI_x86_64_v2_rust-tokio-tungstenite+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+url-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+url-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+url-devel.sha256sum] = "873847f1d7ab7fc370a6d4ad72ea909b081fe729b5d0649a068485492419e233"

URI_x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite+webpki-roots-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite+webpki-roots-devel.sha256sum] = "b521e15d7cdef4c695fb31c3bb86301bcbd35b806c5aab9da0078ab866c8a008"

URI_x86_64_v2_rust-tokio-tungstenite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-tungstenite-devel-0.23.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-tungstenite-devel}"
SRC_URI[x86_64_v2_rust-tokio-tungstenite-devel.sha256sum] = "f96ccdb0a9c2815a356f852dd9ec9accdeb07fc8bd162290e9a5aa5ce82b9fff"

URI_aarch64_rust-tokio-tungstenite+__rustls-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+__rustls-tls-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+__rustls-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+__rustls-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+__rustls-tls-devel.sha256sum] = "4559396856fad6f0d5d3091cf638f35eeb429e88a3a3539125c019269253108c"

URI_aarch64_rust-tokio-tungstenite+connect-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+connect-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+connect-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+connect-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+connect-devel.sha256sum] = "742dc859dad1588cc06fb0f75891dcc4a52f976dadc6a33c0189772b9c40e8e8"

URI_aarch64_rust-tokio-tungstenite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+default-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+default-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+default-devel.sha256sum] = "24cc69621d3dbd0463ccbfb300cbc0c66fdfa706e3f8fdce007d688193bcca39"

URI_aarch64_rust-tokio-tungstenite+handshake-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+handshake-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+handshake-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+handshake-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+handshake-devel.sha256sum] = "c0de6c78ce7d58895d76499f03810598c0c39174cf26457b320a3e3c5adeeee7"

URI_aarch64_rust-tokio-tungstenite+native-tls-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+native-tls-crate-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+native-tls-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+native-tls-crate-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+native-tls-crate-devel.sha256sum] = "e1786214a1c4050d7738c3b562d746e1d6b32315b50a92e2da46bd6bd3128521"

URI_aarch64_rust-tokio-tungstenite+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+native-tls-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+native-tls-devel.sha256sum] = "cb24742d095371d65f472e054ba722dbdd63a98b88363501c25a93e636a4be77"

URI_aarch64_rust-tokio-tungstenite+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-devel.sha256sum] = "9be8824b69542093ace87a268149b83b720b7c99bda4789c04e702bd6b2d9393"

URI_aarch64_rust-tokio-tungstenite+rustls-native-certs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-native-certs-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-native-certs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-native-certs-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-native-certs-devel.sha256sum] = "510b015871614fa60c1f840d37df22a10b4be596d0095d0b406b90d8b8697648"

URI_aarch64_rust-tokio-tungstenite+rustls-pki-types-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-pki-types-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-pki-types-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-pki-types-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-pki-types-devel.sha256sum] = "f31e42e483b025aa446e73175b884c2836b703d7bd2bc0e7255c7aca823bf026"

URI_aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-tls-native-roots-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-tls-native-roots-devel.sha256sum] = "12744ee9218d476e19cb0d8fab111826e2e25f1b8e5d782b7085893eed2d2379"

URI_aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+rustls-tls-webpki-roots-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+rustls-tls-webpki-roots-devel.sha256sum] = "7c613ffce9886565adc5d31e769a2c6c83a1acf553f693913652947544c52e50"

URI_aarch64_rust-tokio-tungstenite+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+stream-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+stream-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+stream-devel.sha256sum] = "c829493faa47d4afdd9d282f74e655ece52eba2d9f9786d8f4226d7adb3266be"

URI_aarch64_rust-tokio-tungstenite+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+tokio-native-tls-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+tokio-native-tls-devel.sha256sum] = "e95399ff5513cf7b46647a8627658ba108e617ecf0242baf9e38e004d46866c5"

URI_aarch64_rust-tokio-tungstenite+tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+tokio-rustls-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+tokio-rustls-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+tokio-rustls-devel.sha256sum] = "151e6a16b95da96dca89ad0f9848d959d372d30a5249e9d641c05bf3fb989593"

URI_aarch64_rust-tokio-tungstenite+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+url-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+url-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+url-devel.sha256sum] = "e7daee3bc4dd8116d4c2339bb05d38b2b3137cd18ae6ebb298dca18d95eb63c1"

URI_aarch64_rust-tokio-tungstenite+webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite+webpki-roots-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite+webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite+webpki-roots-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite+webpki-roots-devel.sha256sum] = "10319017188b1c5e47b8578c03674a12c5ad6185174501f5234532f85dbf65c5"

URI_aarch64_rust-tokio-tungstenite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-tungstenite-devel-0.23.1-3.el10_0.noarch.rpm;name=aarch64_rust-tokio-tungstenite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-tungstenite-devel}"
SRC_URI[aarch64_rust-tokio-tungstenite-devel.sha256sum] = "4720868f9de09bdca9363d9fedec9b9028b3b083081e852578ca7720fc95a25b"

RDEPENDS:rust-tokio-tungstenite+__rustls-tls-devel = " \
 cargo \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+rustls-devel \
 rust-tokio-tungstenite+rustls-pki-types-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-rustls-devel \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+__rustls-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite+connect-devel = " \
 cargo \
 rust-tokio+net-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+default-devel = " \
 cargo \
 rust-tokio-tungstenite+connect-devel \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+handshake-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+handshake-devel \
 "
RDEPENDS:rust-tokio-tungstenite+native-tls-crate-devel = " \
 cargo \
 rust-native-tls+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+native-tls-devel = " \
 cargo \
 rust-tokio-tungstenite+handshake-devel \
 rust-tokio-tungstenite+native-tls-crate-devel \
 rust-tokio-tungstenite+stream-devel \
 rust-tokio-tungstenite+tokio-native-tls-devel \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+native-tls-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-devel = " \
 cargo \
 rust-rustls-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-native-certs-devel = " \
 cargo \
 rust-rustls-native-certs0.7+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-pki-types-devel = " \
 cargo \
 rust-rustls-pki-types+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-tls-native-roots-devel = " \
 cargo \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+rustls-native-certs-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+rustls-tls-webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite+__rustls-tls-devel \
 rust-tokio-tungstenite+webpki-roots-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+stream-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+tokio-native-tls-devel = " \
 cargo \
 rust-tokio-native-tls+default-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+tokio-rustls-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 rust-tokio-tungstenite-devel \
 "
RDEPENDS:rust-tokio-tungstenite+url-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-tungstenite+url-devel \
 "
RDEPENDS:rust-tokio-tungstenite+webpki-roots-devel = " \
 cargo \
 rust-tokio-tungstenite-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-tokio-tungstenite-devel = " \
 cargo \
 rust \
 rust-futures-util+sink-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-log+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio-devel \
 rust-tungstenite-devel \
 "
