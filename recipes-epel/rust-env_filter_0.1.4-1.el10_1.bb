# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-env_filter"
PV = "0.1.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-env_filter+default-devel \
 rust-env_filter+regex-devel \
 rust-env_filter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-env_filter-0.1.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b6856b9a87221a15ee916dda410b6e18c1755664dca24fac94e78d6dfdfe0a51"

URI_x86_64_v2_rust-env_filter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter+default-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter+default-devel}"
SRC_URI[x86_64_v2_rust-env_filter+default-devel.sha256sum] = "cfa9954da0b16e5d69cec31ea8ff2513d1f97103d57040e49df1cadb7be76173"

URI_x86_64_v2_rust-env_filter+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter+regex-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter+regex-devel}"
SRC_URI[x86_64_v2_rust-env_filter+regex-devel.sha256sum] = "f04878c73f9efc27f4bcb7bed780d05c3f323d239ddf1f8719afe106d718a3b8"

URI_x86_64_v2_rust-env_filter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-env_filter-devel-0.1.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-env_filter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-env_filter-devel}"
SRC_URI[x86_64_v2_rust-env_filter-devel.sha256sum] = "012a99fa986fa7c0661b579e041e363f6dbd161afe6c1f9793dc84529275f4dc"

URI_aarch64_rust-env_filter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter+default-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-env_filter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter+default-devel}"
SRC_URI[aarch64_rust-env_filter+default-devel.sha256sum] = "98034a7b651036bfd6141304c6720c0dca96dac71f6c2afd1927d72f3e7560b3"

URI_aarch64_rust-env_filter+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter+regex-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-env_filter+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter+regex-devel}"
SRC_URI[aarch64_rust-env_filter+regex-devel.sha256sum] = "f31c9d2ec7473957fd8601a64a9bc8de7b5c4373e9d814ff35d3a01bd3512268"

URI_aarch64_rust-env_filter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-env_filter-devel-0.1.4-1.el10_1.noarch.rpm;name=aarch64_rust-env_filter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-env_filter-devel}"
SRC_URI[aarch64_rust-env_filter-devel.sha256sum] = "5ed6e65d2a7a4b1b181361ada4270f79c0bb5fb4a788df4b9b43981cee7d1f12"

RDEPENDS:rust-env_filter+default-devel = " \
 cargo \
 rust-env_filter+regex-devel \
 rust-env_filter-devel \
 "
RDEPENDS:rust-env_filter+regex-devel = " \
 cargo \
 rust-env_filter-devel \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-devel \
 "
RDEPENDS:rust-env_filter-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-log+std-devel \
 "
