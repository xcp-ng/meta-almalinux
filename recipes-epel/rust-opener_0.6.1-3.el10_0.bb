# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-opener"
PV = "0.6.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-opener+default-devel \
 rust-opener-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-opener-0.6.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0dcfb3de5a01cd7d9bbb34866be94058e965583e4f924b54a1e7e8426709202"

URI_x86_64_v2_rust-opener+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-opener+default-devel-0.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-opener+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-opener+default-devel}"
SRC_URI[x86_64_v2_rust-opener+default-devel.sha256sum] = "32a48e47c97fdf9370f50b599ea969b4f4ccaf4f68f266325c68402f3a454960"

URI_x86_64_v2_rust-opener-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-opener-devel-0.6.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-opener-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-opener-devel}"
SRC_URI[x86_64_v2_rust-opener-devel.sha256sum] = "7c79c2c32ebc23f67cfa87662581b0c3a063077ac316e05f073676fed2749133"

URI_aarch64_rust-opener+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-opener+default-devel-0.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-opener+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-opener+default-devel}"
SRC_URI[aarch64_rust-opener+default-devel.sha256sum] = "260e0e2b332078ddf165a107557b6d334a64ab3124fe57f12e8506b8e6336241"

URI_aarch64_rust-opener-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-opener-devel-0.6.1-3.el10_0.noarch.rpm;name=aarch64_rust-opener-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-opener-devel}"
SRC_URI[aarch64_rust-opener-devel.sha256sum] = "0692f01c375661a87977f15b183dd249f17171677e6de7959c3ea16268fe00fb"

RDEPENDS:rust-opener+default-devel = " \
 cargo \
 rust-opener-devel \
 "
RDEPENDS:rust-opener-devel = " \
 cargo \
 rust-bstr+default-devel \
 "
