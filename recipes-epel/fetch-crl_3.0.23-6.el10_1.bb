# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fetch-crl"
PV = "3.0.23"
PR = "6.el10_1"
PACKAGES = " \
 fetch-crl \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/f/fetch-crl-3.0.23-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6b2e40ee33f96429e3aaf863318308608addd7bf3ddfa125d6f8887cc1c60f81"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/fetch-crl-3.0.23-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_fetch-crl;unpack=0"
SRC_URI[x86_64_v2_fetch-crl.sha256sum] = "e4f562408bdd3c875761f18ca6a51a157e84744cc6fd394a2e8999a96c179b6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/f/fetch-crl-3.0.23-6.el10_1.noarch.rpm;name=aarch64_fetch-crl;unpack=0"
SRC_URI[aarch64_fetch-crl.sha256sum] = "fe72427b6a25e42ba9b5cdb57223e9f7452986cb39fa0aa33e6862dc688a2383"

RDEPENDS:fetch-crl = " \
 bash \
 openssl \
 perl-File-Basename \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-IPC-Open3 \
 perl-LWP-Protocol-https \
 perl-POSIX \
 perl-Sys-Syslog \
 perl-Time-Local \
 perl-interpreter \
 perl-libs \
 perl-libwww-perl \
 perl-vars \
 systemd \
 "
