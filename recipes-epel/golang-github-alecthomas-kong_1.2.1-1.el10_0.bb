# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-alecthomas-kong"
PV = "1.2.1"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-alecthomas-kong-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-alecthomas-kong-1.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fe36e4980502cd38bdc65cdc6d84fe81e607847795684aabed02de55964039c0"

URI_x86_64_v2_golang-github-alecthomas-kong-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-alecthomas-kong-devel-1.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-alecthomas-kong-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-alecthomas-kong-devel}"
SRC_URI[x86_64_v2_golang-github-alecthomas-kong-devel.sha256sum] = "e7d688a024a1ea9144e262316534664c8dfaa1e8283a7c3394187b59683cce4b"

URI_aarch64_golang-github-alecthomas-kong-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-alecthomas-kong-devel-1.2.1-1.el10_0.noarch.rpm;name=aarch64_golang-github-alecthomas-kong-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-alecthomas-kong-devel}"
SRC_URI[aarch64_golang-github-alecthomas-kong-devel.sha256sum] = "db42815129ebad23702dbdfe62f5df7ad454b5540810026704b638fd7776f28d"

RDEPENDS:golang-github-alecthomas-kong-devel = " \
 go-filesystem \
 "
