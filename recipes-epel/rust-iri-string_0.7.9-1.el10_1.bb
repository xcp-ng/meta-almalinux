# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-iri-string"
PV = "0.7.9"
PR = "1.el10_1"
PACKAGES = " \
 rust-iri-string+alloc-devel \
 rust-iri-string+default-devel \
 rust-iri-string+memchr-devel \
 rust-iri-string+serde-devel \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-iri-string-0.7.9-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9c2dea7935d8aae3a26b2f4655c6e27aed2346e56f52a62cc4a9f65b42fba079"

URI_x86_64_v2_rust-iri-string+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+alloc-devel-0.7.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+alloc-devel}"
SRC_URI[x86_64_v2_rust-iri-string+alloc-devel.sha256sum] = "5d3633710517ef7ad86116e315da2fa563fbe4342c38cf21882bf259dcaf2f70"

URI_x86_64_v2_rust-iri-string+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+default-devel-0.7.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+default-devel}"
SRC_URI[x86_64_v2_rust-iri-string+default-devel.sha256sum] = "1e880f87844feacc5a2d7f0bfb2c1ba3f778ca8042db16ab4a9796ba85861fd6"

URI_x86_64_v2_rust-iri-string+memchr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+memchr-devel-0.7.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+memchr-devel}"
SRC_URI[x86_64_v2_rust-iri-string+memchr-devel.sha256sum] = "ef286154ef2420478d2d33fb132a69f72a4863e29c7e7c13b528f36225a00638"

URI_x86_64_v2_rust-iri-string+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+serde-devel-0.7.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+serde-devel}"
SRC_URI[x86_64_v2_rust-iri-string+serde-devel.sha256sum] = "22d4c8c719e21709be6d6af3eb88e7c7a8a3be27f7df1009e0e37977548691cd"

URI_x86_64_v2_rust-iri-string+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string+std-devel-0.7.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string+std-devel}"
SRC_URI[x86_64_v2_rust-iri-string+std-devel.sha256sum] = "cd174689c4e60f65eca47df9e053589b90c536a992a1302929b9b69b1b3af5ed"

URI_x86_64_v2_rust-iri-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-iri-string-devel-0.7.9-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-iri-string-devel}"
SRC_URI[x86_64_v2_rust-iri-string-devel.sha256sum] = "df65d4fcd3c25a85909d2d5e6d16e2c5ef14799043e20464b7c4242b11334feb"

URI_aarch64_rust-iri-string+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+alloc-devel-0.7.9-1.el10_1.noarch.rpm;name=aarch64_rust-iri-string+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+alloc-devel}"
SRC_URI[aarch64_rust-iri-string+alloc-devel.sha256sum] = "d1768b38644522177c8deb58c75706d0b2a86c8d529afa6a64ea6fee9f7304fa"

URI_aarch64_rust-iri-string+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+default-devel-0.7.9-1.el10_1.noarch.rpm;name=aarch64_rust-iri-string+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+default-devel}"
SRC_URI[aarch64_rust-iri-string+default-devel.sha256sum] = "0a40acb4a585dbd680c49dbe1d347b1338dc17e3519113f00868b02175736acc"

URI_aarch64_rust-iri-string+memchr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+memchr-devel-0.7.9-1.el10_1.noarch.rpm;name=aarch64_rust-iri-string+memchr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+memchr-devel}"
SRC_URI[aarch64_rust-iri-string+memchr-devel.sha256sum] = "ea1b49569c24533df8b17c111604baf8511e3a44c865ac68a1b68aff6991836e"

URI_aarch64_rust-iri-string+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+serde-devel-0.7.9-1.el10_1.noarch.rpm;name=aarch64_rust-iri-string+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+serde-devel}"
SRC_URI[aarch64_rust-iri-string+serde-devel.sha256sum] = "51da4a0ffdc3b7973999a525ba6ca18521c3029ebc39ce6c994a39226c6f2182"

URI_aarch64_rust-iri-string+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string+std-devel-0.7.9-1.el10_1.noarch.rpm;name=aarch64_rust-iri-string+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string+std-devel}"
SRC_URI[aarch64_rust-iri-string+std-devel.sha256sum] = "c00a53eb83226632f5d0b32295c5067cbbd4045610b0c852d08312c16f7c93fc"

URI_aarch64_rust-iri-string-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-iri-string-devel-0.7.9-1.el10_1.noarch.rpm;name=aarch64_rust-iri-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-iri-string-devel}"
SRC_URI[aarch64_rust-iri-string-devel.sha256sum] = "dc5499900cc01f9417e1b43820faabbfcc903968f2757e7fc714a1a8625a0683"

RDEPENDS:rust-iri-string+alloc-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+default-devel = " \
 cargo \
 rust-iri-string+std-devel \
 rust-iri-string-devel \
 "
RDEPENDS:rust-iri-string+memchr-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-memchr-devel \
 "
RDEPENDS:rust-iri-string+serde-devel = " \
 cargo \
 rust-iri-string-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string+std-devel = " \
 cargo \
 rust-iri-string+alloc-devel \
 rust-iri-string-devel \
 rust-memchr+std-devel \
 rust-memchr-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-iri-string-devel = " \
 cargo \
 rust \
 "
