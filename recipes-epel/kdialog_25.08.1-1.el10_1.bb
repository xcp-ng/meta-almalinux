# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdialog"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kdialog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdialog-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e35973c2ef91e5121149d3def343e92fc073fe329243da39ad03e3341d8eaf44"

URI_x86_64_v2_kdialog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdialog-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdialog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdialog}"
SRC_URI[x86_64_v2_kdialog.sha256sum] = "34aa0381eaf68309a2cd90bad98f9a7af92854f21b82ccc51b8d56de6cd16780"

URI_aarch64_kdialog = "${EPEL_MIRROR}/aarch64/Packages/k/kdialog-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kdialog;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdialog}"
SRC_URI[aarch64_kdialog.sha256sum] = "09a461848a74589fae3ec7de54cdc163c76cc3f746156622fb8244d85fd6fc79"

RDEPENDS:kdialog = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
