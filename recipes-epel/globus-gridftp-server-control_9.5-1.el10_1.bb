# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gridftp-server-control"
PV = "9.5"
PR = "1.el10_1"
PACKAGES = " \
 globus-gridftp-server-control \
 globus-gridftp-server-control-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gridftp-server-control-9.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "267144561b7e84fa45d5249b983fed32c6e02a255f99ed017af600b3e1b1ead8"

URI_x86_64_v2_globus-gridftp-server-control = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-control-9.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-control;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server-control}"
SRC_URI[x86_64_v2_globus-gridftp-server-control.sha256sum] = "16e0375ac8a9931b5609bc9f06c540b7a87b5a96c497ffaef3c19e3d0c79eca1"

URI_x86_64_v2_globus-gridftp-server-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gridftp-server-control-devel-9.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gridftp-server-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gridftp-server-control-devel}"
SRC_URI[x86_64_v2_globus-gridftp-server-control-devel.sha256sum] = "c14f49b76e72e8d8efd0aad687e47e311c10a5ce7b6509bd47eb83e30a6ed0dc"

URI_aarch64_globus-gridftp-server-control = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-control-9.5-1.el10_1.aarch64.rpm;name=aarch64_globus-gridftp-server-control;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server-control}"
SRC_URI[aarch64_globus-gridftp-server-control.sha256sum] = "277ea390d0752811f6012fe3c2f087e9be3a69a088d8a8e5a430e0742163816d"

URI_aarch64_globus-gridftp-server-control-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gridftp-server-control-devel-9.5-1.el10_1.aarch64.rpm;name=aarch64_globus-gridftp-server-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gridftp-server-control-devel}"
SRC_URI[aarch64_globus-gridftp-server-control-devel.sha256sum] = "cc96893b7f40adc968b3efc74b452a6f87686ee8faf7faf19a30fb8ee2ab3cab"

RDEPENDS:globus-gridftp-server-control = " \
 glibc \
 globus-common \
 globus-gsi-openssl-error \
 globus-gss-assist \
 globus-gssapi-error \
 globus-gssapi-gsi \
 globus-xio \
 globus-xio-gsi-driver \
 globus-xio-pipe-driver \
 "
RDEPENDS:globus-gridftp-server-control-devel = " \
 globus-common-devel \
 globus-gridftp-server-control \
 globus-gsi-openssl-error-devel \
 globus-gss-assist-devel \
 globus-gssapi-error-devel \
 globus-gssapi-gsi-devel \
 globus-xio-devel \
 globus-xio-gsi-driver-devel \
 globus-xio-pipe-driver-devel \
 pkgconf-pkg-config \
 "
