# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-notification"
PV = "0.3.3"
PR = "1.el10_3"
PACKAGES = " \
 python3-colcon-notification \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-colcon-notification-0.3.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "53411a4e0ffe33b23fdf790124cd3eb74739e71ed26dc026b6a6f1a3cc2fb4b9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-notification-0.3.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-notification;unpack=0"
SRC_URI[x86_64_v2_python3-colcon-notification.sha256sum] = "21a48b42c511076608d9818f85443a1aa259822417a70d01580c9aba4b712cd8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-notification-0.3.3-1.el10_3.noarch.rpm;name=aarch64_python3-colcon-notification;unpack=0"
SRC_URI[aarch64_python3-colcon-notification.sha256sum] = "5e90e092de3de62f6bc185578579c8bf8d8e7f84844481db1b313776e92ce2a2"

RDEPENDS:python3-colcon-notification = " \
 python3 \
 python3-colcon-core \
 python3-notify2 \
 "
