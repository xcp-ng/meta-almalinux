# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-blobby0.3"
PV = "0.3.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-blobby0.3+default-devel \
 rust-blobby0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-blobby0.3-0.3.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0ab2d930e9e354fd42eb317b4db04f7c7d9c47d465e09c7e6dd518fc9ad9b660"

URI_x86_64_v2_rust-blobby0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blobby0.3+default-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blobby0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blobby0.3+default-devel}"
SRC_URI[x86_64_v2_rust-blobby0.3+default-devel.sha256sum] = "47d87ec26c01fa433a7d70c594258c717b6a99d28fe66c67f1b1a287be669053"

URI_x86_64_v2_rust-blobby0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-blobby0.3-devel-0.3.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-blobby0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-blobby0.3-devel}"
SRC_URI[x86_64_v2_rust-blobby0.3-devel.sha256sum] = "b65242b028b9fb94234ff50b2d8e23d8d21f53b9ba4816ebc2fcb746325dc990"

URI_aarch64_rust-blobby0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blobby0.3+default-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-blobby0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blobby0.3+default-devel}"
SRC_URI[aarch64_rust-blobby0.3+default-devel.sha256sum] = "82c1cd3065e1e20edd0f0e0d42dbd3e574d60aba76265cb719f9d4d8553d3bbc"

URI_aarch64_rust-blobby0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-blobby0.3-devel-0.3.1-1.el10_2.noarch.rpm;name=aarch64_rust-blobby0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-blobby0.3-devel}"
SRC_URI[aarch64_rust-blobby0.3-devel.sha256sum] = "abdd9eb12519b95ce4f54f4b18faa56230575637b3a9c4acef9fee964c681b38"

RDEPENDS:rust-blobby0.3+default-devel = " \
 cargo \
 rust-blobby0.3-devel \
 "
RDEPENDS:rust-blobby0.3-devel = " \
 cargo \
 "
