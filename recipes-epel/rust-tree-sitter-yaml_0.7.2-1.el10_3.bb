# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-yaml"
PV = "0.7.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-tree-sitter-yaml+default-devel \
 rust-tree-sitter-yaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-yaml-0.7.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "75496f747e7441e6991961435e8f5479ddd2f7eb506b15c6695aa056bd67af8e"

URI_x86_64_v2_rust-tree-sitter-yaml+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-yaml+default-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-yaml+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-yaml+default-devel.sha256sum] = "a364f9f26f8fc886172ec78f3e5439b102009d6cbdd459bc775f25e176e4443a"

URI_x86_64_v2_rust-tree-sitter-yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-yaml-devel-0.7.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-yaml-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-yaml-devel.sha256sum] = "104be7eb9f1a614e2dc6689918e1636f481ccb90bb752dcaa64715c5938547b3"

URI_aarch64_rust-tree-sitter-yaml+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-yaml+default-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-yaml+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-yaml+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-yaml+default-devel.sha256sum] = "eb673fb6c6224bc8f3500b0ffce9d84b5bb5b3eef3fd4beaa566559b64bb9152"

URI_aarch64_rust-tree-sitter-yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-yaml-devel-0.7.2-1.el10_3.noarch.rpm;name=aarch64_rust-tree-sitter-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-yaml-devel}"
SRC_URI[aarch64_rust-tree-sitter-yaml-devel.sha256sum] = "b7ace750220761b515649f002888ae688d698c36e1ec60d344bef0890d1830cb"

RDEPENDS:rust-tree-sitter-yaml+default-devel = " \
 cargo \
 rust-tree-sitter-yaml-devel \
 "
RDEPENDS:rust-tree-sitter-yaml-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
