# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-File-NFSLock"
PV = "1.29"
PR = "18.el10_0"
PACKAGES = " \
 perl-File-NFSLock \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-File-NFSLock-1.29-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a4af7e06e10e8c5209a5f8844aea357211fad92d269d2383e9b00324ac319437"

URI_x86_64_v2_perl-File-NFSLock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-File-NFSLock-1.29-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-File-NFSLock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-File-NFSLock}"
SRC_URI[x86_64_v2_perl-File-NFSLock.sha256sum] = "75f770fc6849f8314015e7337b672f0f71b3c88d92e6dfed586da98972bf8452"

URI_aarch64_perl-File-NFSLock = "${EPEL_MIRROR}/aarch64/Packages/p/perl-File-NFSLock-1.29-18.el10_0.noarch.rpm;name=aarch64_perl-File-NFSLock;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-File-NFSLock}"
SRC_URI[aarch64_perl-File-NFSLock.sha256sum] = "dd8807c90fcd83778de2912792f6f88030fede13bac966e2540e28ad09c23c66"

RDEPENDS:perl-File-NFSLock = " \
 perl-Carp \
 perl-Exporter \
 perl-Sys-Hostname \
 perl-base \
 perl-constant \
 perl-libs \
 "
