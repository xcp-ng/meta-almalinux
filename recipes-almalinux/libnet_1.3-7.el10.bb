# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnet"
PV = "1.3"
PR = "7.el10"
PACKAGES = " \
 libnet \
 libnet-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libnet-1.3-7.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "72f719b07d783d5a669da6ad1a8abdc1d21b38f648c67bda117481b52556587e"

URI_x86_64_v2_libnet = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnet-1.3-7.el10.x86_64_v2.rpm;name=x86_64_v2_libnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnet}"
SRC_URI[x86_64_v2_libnet.sha256sum] = "3411f17aaf3afbe724a1018fc5efa11dbdda82a0cdd9c3355c7c3577fd834205"

URI_x86_64_v2_libnet-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnet-devel-1.3-7.el10.x86_64_v2.rpm;name=x86_64_v2_libnet-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnet-devel}"
SRC_URI[x86_64_v2_libnet-devel.sha256sum] = "8f7d4649ffc4cb6d8ef7d3ee29a86634b589634f0ce8b97a872076ea5077161d"

URI_aarch64_libnet = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnet-1.3-7.el10.aarch64.rpm;name=aarch64_libnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnet}"
SRC_URI[aarch64_libnet.sha256sum] = "c5a20970a828a31d9782cd9947c3eea0cd6ca436c13203dc602af8af93d3ab08"

URI_aarch64_libnet-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnet-devel-1.3-7.el10.aarch64.rpm;name=aarch64_libnet-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnet-devel}"
SRC_URI[aarch64_libnet-devel.sha256sum] = "bf061b2bd4af9cc409ac3f82e7a7bbfd10b3dbd4d5eb9d87e8d598beece30b04"

RDEPENDS:libnet = " \
 glibc \
 "
RDEPENDS:libnet-devel = " \
 bash \
 libnet \
 pkgconf-pkg-config \
 "
