# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter-fsharp"
PV = "0.1.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-tree-sitter-fsharp+default-devel \
 rust-tree-sitter-fsharp-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-fsharp-0.1.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "94b980b5bbd3ccc7fdbc1f517edbe2dc07fe5a00f951909e9e90de4a18aa6d44"

URI_x86_64_v2_rust-tree-sitter-fsharp+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-fsharp+default-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-fsharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-fsharp+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-fsharp+default-devel.sha256sum] = "8ed7fa9f8ee2f199c24ea2e6b7c552a44a63419f083dd1909c0e720a0c236e19"

URI_x86_64_v2_rust-tree-sitter-fsharp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-fsharp-devel-0.1.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-fsharp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-fsharp-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-fsharp-devel.sha256sum] = "865bc04761672e2762b5959dfc6112d4943aca972a6c6db13b0ce24ee5de2d10"

URI_aarch64_rust-tree-sitter-fsharp+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-fsharp+default-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-fsharp+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-fsharp+default-devel}"
SRC_URI[aarch64_rust-tree-sitter-fsharp+default-devel.sha256sum] = "11e9b7c08a2ef12c23483a3380767f670a624f85833bca63078e4b870038d7d8"

URI_aarch64_rust-tree-sitter-fsharp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-fsharp-devel-0.1.0-1.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-fsharp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-fsharp-devel}"
SRC_URI[aarch64_rust-tree-sitter-fsharp-devel.sha256sum] = "a548f524c5b2fbfe6db6c8a01b8c3cd26f524951948d8a93e2bccd146d701f8a"

RDEPENDS:rust-tree-sitter-fsharp+default-devel = " \
 cargo \
 rust-tree-sitter-fsharp-devel \
 "
RDEPENDS:rust-tree-sitter-fsharp-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-tree-sitter-language+default-devel \
 "
