# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "keepassxc"
PV = "2.7.10"
PR = "2.el10_1"
PACKAGES = " \
 keepassxc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/keepassxc-2.7.10-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "31fed31bf29fee8a93f974cd303f9992c8172856ed39eeb000dd4751600f4211"

URI_x86_64_v2_keepassxc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/keepassxc-2.7.10-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_keepassxc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_keepassxc}"
SRC_URI[x86_64_v2_keepassxc.sha256sum] = "9f90e4aafc01bce41de3ef6262aab112c6c34ccb6489bb048a76d6f2f7d931a5"

URI_aarch64_keepassxc = "${EPEL_MIRROR}/aarch64/Packages/k/keepassxc-2.7.10-2.el10_1.aarch64.rpm;name=aarch64_keepassxc;unpack=0"
SRC_URI:append = " ${URI_aarch64_keepassxc}"
SRC_URI[aarch64_keepassxc.sha256sum] = "fec575fbdfdc24583723be65076817e9d3ab7c888dbd3eea872811edd1b81f61"

RDEPENDS:keepassxc = " \
 botan2 \
 glibc \
 libX11 \
 libXtst \
 libargon2 \
 libgcc \
 libstdc++ \
 libusb1 \
 minizip-ng-compat \
 pcsc-lite-libs \
 qrencode-libs \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtsvg \
 qt5-qtx11extras \
 readline \
 zlib-ng-compat \
 "
