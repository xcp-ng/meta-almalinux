# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tree-sitter"
PV = "0.25.10"
PR = "3.el10_2"
PACKAGES = " \
 rust-tree-sitter+default-devel \
 rust-tree-sitter+std-devel \
 rust-tree-sitter-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tree-sitter-0.25.10-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6a1b9e7e83b4e4e93b44329f8d1f9b9c3b63f6ece3fcd3c94abc68aaed38ccf2"

URI_x86_64_v2_rust-tree-sitter+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter+default-devel-0.25.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter+default-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter+default-devel.sha256sum] = "a0d0ca1a32e64077534ab828ab65cc8bdeaa20be578588a72c0bfdf5b5d78afa"

URI_x86_64_v2_rust-tree-sitter+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter+std-devel-0.25.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter+std-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter+std-devel.sha256sum] = "29ebad8b9b7025bf78b1a72ea4912561e6a20bacd7c3db76d7bfdc854f661701"

URI_x86_64_v2_rust-tree-sitter-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tree-sitter-devel-0.25.10-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tree-sitter-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tree-sitter-devel}"
SRC_URI[x86_64_v2_rust-tree-sitter-devel.sha256sum] = "86de6841afdc28a3e361fcce9e2656129a1b2bdc8bb8cb3ed806d026feb3fdb0"

URI_aarch64_rust-tree-sitter+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter+default-devel-0.25.10-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter+default-devel}"
SRC_URI[aarch64_rust-tree-sitter+default-devel.sha256sum] = "67f6bff4b3ce9cfed841c9f30036804582e1bac4a21c5b4eebf9f7db2fbdb468"

URI_aarch64_rust-tree-sitter+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter+std-devel-0.25.10-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter+std-devel}"
SRC_URI[aarch64_rust-tree-sitter+std-devel.sha256sum] = "6c1818713cf87f90a50aa854fb07711d72c0a62cf63557e8ed92871a25fe7230"

URI_aarch64_rust-tree-sitter-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tree-sitter-devel-0.25.10-3.el10_2.noarch.rpm;name=aarch64_rust-tree-sitter-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tree-sitter-devel}"
SRC_URI[aarch64_rust-tree-sitter-devel.sha256sum] = "f92a2b28d0203a2516fdb8098c4fb9274d4cb79da4293ab3f5c9dae12af62dd3"

RDEPENDS:rust-tree-sitter+default-devel = " \
 cargo \
 rust-tree-sitter+std-devel \
 rust-tree-sitter-devel \
 "
RDEPENDS:rust-tree-sitter+std-devel = " \
 cargo \
 rust-regex+perf-devel \
 rust-regex+std-devel \
 rust-regex-syntax+unicode-devel \
 rust-tree-sitter-devel \
 "
RDEPENDS:rust-tree-sitter-devel = " \
 cargo \
 rust \
 rust-bindgen+default-devel \
 rust-cc+default-devel \
 rust-regex+unicode-devel \
 rust-regex-devel \
 rust-regex-syntax-devel \
 rust-serde_json+default-devel \
 rust-serde_json+preserve_order-devel \
 rust-streaming-iterator+default-devel \
 rust-tree-sitter-language+default-devel \
 "
