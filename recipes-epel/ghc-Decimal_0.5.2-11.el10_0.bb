# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-Decimal"
PV = "0.5.2"
PR = "11.el10_0"
PACKAGES = " \
 ghc-Decimal \
 ghc-Decimal-devel \
 ghc-Decimal-doc \
 ghc-Decimal-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-Decimal-0.5.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "068cfb594285d5e787c77886468d62d42a143e4115511d51d9e3839f025ae79e"

URI_x86_64_v2_ghc-Decimal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Decimal-0.5.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Decimal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Decimal}"
SRC_URI[x86_64_v2_ghc-Decimal.sha256sum] = "2808ed1acea0e321141e307eb997616c9900cfbb9456d1e20aac4bf34677a215"

URI_x86_64_v2_ghc-Decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Decimal-devel-0.5.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Decimal-devel}"
SRC_URI[x86_64_v2_ghc-Decimal-devel.sha256sum] = "ddb869c4dceef9a6bfd332bba78f369bb799bacd95b648362e4ece2f12d62b5b"

URI_x86_64_v2_ghc-Decimal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Decimal-doc-0.5.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-Decimal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Decimal-doc}"
SRC_URI[x86_64_v2_ghc-Decimal-doc.sha256sum] = "5e4557f924165281029e3b49b631a55036859aa9e7d3e569bef89235b43ca8c3"

URI_x86_64_v2_ghc-Decimal-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-Decimal-prof-0.5.2-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-Decimal-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-Decimal-prof}"
SRC_URI[x86_64_v2_ghc-Decimal-prof.sha256sum] = "97107079ca91f1cd604dc6df616bbf954a4a2fdf8f1148b87755d6e022c501a0"

URI_aarch64_ghc-Decimal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Decimal-0.5.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-Decimal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Decimal}"
SRC_URI[aarch64_ghc-Decimal.sha256sum] = "41b797ba14b7f236d08204cecfa2c126024b56762c76e8c5d981f808d02a7e89"

URI_aarch64_ghc-Decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Decimal-devel-0.5.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-Decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Decimal-devel}"
SRC_URI[aarch64_ghc-Decimal-devel.sha256sum] = "37335dce757f84e2345c8519fe963795fe6d73681a15db296fc0d35f5ac77d72"

URI_aarch64_ghc-Decimal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Decimal-doc-0.5.2-11.el10_0.noarch.rpm;name=aarch64_ghc-Decimal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Decimal-doc}"
SRC_URI[aarch64_ghc-Decimal-doc.sha256sum] = "f2aba23cd7f2b030874136dfcde1218e5fc1399497147e4893d9fec4df1add58"

URI_aarch64_ghc-Decimal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-Decimal-prof-0.5.2-11.el10_0.aarch64.rpm;name=aarch64_ghc-Decimal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-Decimal-prof}"
SRC_URI[aarch64_ghc-Decimal-prof.sha256sum] = "4edcb7dc787f146ee4b72118edcfbe936ca1ef61b0da7fb70ff130952108207e"

RDEPENDS:ghc-Decimal = " \
 ghc-array \
 ghc-base \
 ghc-deepseq \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-Decimal-devel = " \
 ghc-Decimal \
 ghc-base-devel \
 ghc-compiler \
 ghc-deepseq-devel \
 "
RDEPENDS:ghc-Decimal-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-Decimal-prof = " \
 ghc-Decimal-devel \
 ghc-base-prof \
 ghc-deepseq-prof \
 "
