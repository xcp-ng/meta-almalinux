# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipv6calc"
PV = "4.4.0"
PR = "1.el10_0"
PACKAGES = " \
 ipv6calc \
 ipv6calc-ipv6calcweb \
 ipv6calc-mod_ipv6calc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/ipv6calc-4.4.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "642c9fe69bc29b5e29ef29b6643eb8775f58e591b93049d395d1f7837dda0f49"

URI_x86_64_v2_ipv6calc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ipv6calc-4.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ipv6calc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipv6calc}"
SRC_URI[x86_64_v2_ipv6calc.sha256sum] = "4e1208d5b1c3283f7d0a5c6628e7fa2689bf010df235cf42f51ecb8ec85a3963"

URI_x86_64_v2_ipv6calc-ipv6calcweb = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ipv6calc-ipv6calcweb-4.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ipv6calc-ipv6calcweb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipv6calc-ipv6calcweb}"
SRC_URI[x86_64_v2_ipv6calc-ipv6calcweb.sha256sum] = "0e05c9a36ca859b6511f84f0cb9bbe3a907e2d5617ee07d2a9dd41680edd21f1"

URI_x86_64_v2_ipv6calc-mod_ipv6calc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ipv6calc-mod_ipv6calc-4.4.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ipv6calc-mod_ipv6calc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipv6calc-mod_ipv6calc}"
SRC_URI[x86_64_v2_ipv6calc-mod_ipv6calc.sha256sum] = "e715e9ad7358a8313b61ba92df4320b03893aa187f076738a970842f06eaabff"

URI_aarch64_ipv6calc = "${EPEL_MIRROR}/aarch64/Packages/i/ipv6calc-4.4.0-1.el10_0.aarch64.rpm;name=aarch64_ipv6calc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipv6calc}"
SRC_URI[aarch64_ipv6calc.sha256sum] = "7138cf81f1f62c495dc7e2d5e99b1586cbcaf170152b26854657f9ad2acc2cf9"

URI_aarch64_ipv6calc-ipv6calcweb = "${EPEL_MIRROR}/aarch64/Packages/i/ipv6calc-ipv6calcweb-4.4.0-1.el10_0.aarch64.rpm;name=aarch64_ipv6calc-ipv6calcweb;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipv6calc-ipv6calcweb}"
SRC_URI[aarch64_ipv6calc-ipv6calcweb.sha256sum] = "98a4b6f82ab60dff327d48c072d7b405be737e9bb9df46b227e2fb75edec2847"

URI_aarch64_ipv6calc-mod_ipv6calc = "${EPEL_MIRROR}/aarch64/Packages/i/ipv6calc-mod_ipv6calc-4.4.0-1.el10_0.aarch64.rpm;name=aarch64_ipv6calc-mod_ipv6calc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipv6calc-mod_ipv6calc}"
SRC_URI[aarch64_ipv6calc-mod_ipv6calc.sha256sum] = "6c38454e80fedd5f0fb06de6d23a8a47bc9a11680e6b17b429c729f6a7b769e8"

RDEPENDS:ipv6calc = " \
 bash \
 glibc \
 libdb \
 openssl-libs \
 perl-BerkeleyDB \
 perl-Getopt-Std \
 perl-IPC-Open3 \
 perl-Math-BigInt \
 perl-Net-IP \
 perl-POSIX \
 perl-XML-Simple \
 perl-interpreter \
 perl-libs \
 unzip \
 "
RDEPENDS:ipv6calc-ipv6calcweb = " \
 httpd \
 ipv6calc \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-Digest-SHA1 \
 perl-HTML-Parser \
 perl-POSIX \
 perl-URI \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:ipv6calc-mod_ipv6calc = " \
 glibc \
 httpd \
 ipv6calc \
 libdb \
 perl-POSIX \
 perl-interpreter \
 perl-libs \
 "
