# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-imgref"
PV = "1.12.3"
PR = "2.el10_2"
PACKAGES = " \
 rust-imgref+default-devel \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-imgref-1.12.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e45fa2a2ef96a666028d5d9f9e723effd239e1276914dc42630001c7aceac7ef"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+default-devel-1.12.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-imgref+default-devel.sha256sum] = "69e8d4f1ab37081b457166241bd54342018a7f2d63b9ebda91359a2dc70c2395"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref+deprecated-devel-1.12.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref+deprecated-devel;unpack=0"
SRC_URI[x86_64_v2_rust-imgref+deprecated-devel.sha256sum] = "4a078d6cf04146111a240f0c0077d09dcdb93f3687464be32748d97a1c4f0759"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-imgref-devel-1.12.3-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-imgref-devel;unpack=0"
SRC_URI[x86_64_v2_rust-imgref-devel.sha256sum] = "6298e90a93d39da0bd82c995abd11a6b2f8b794c231a172cc059dfa54c161897"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+default-devel-1.12.3-2.el10_2.noarch.rpm;name=aarch64_rust-imgref+default-devel;unpack=0"
SRC_URI[aarch64_rust-imgref+default-devel.sha256sum] = "0cfc92e35ddde2f0afed42250492b857deb19c9684acc024f058fbc0c43890f6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref+deprecated-devel-1.12.3-2.el10_2.noarch.rpm;name=aarch64_rust-imgref+deprecated-devel;unpack=0"
SRC_URI[aarch64_rust-imgref+deprecated-devel.sha256sum] = "30fc1f988162c8127e5b9d786c8f827b1ac2b53183d5ff3e7477db8c316ae465"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-imgref-devel-1.12.3-2.el10_2.noarch.rpm;name=aarch64_rust-imgref-devel;unpack=0"
SRC_URI[aarch64_rust-imgref-devel.sha256sum] = "32fa00721a1245e0579749e12061fd30ddc31823a38e4f9134c131150b132bcd"

RDEPENDS:rust-imgref+default-devel = " \
 cargo \
 rust-imgref+deprecated-devel \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref+deprecated-devel = " \
 cargo \
 rust-imgref-devel \
 "
RDEPENDS:rust-imgref-devel = " \
 cargo \
 rust \
 "
