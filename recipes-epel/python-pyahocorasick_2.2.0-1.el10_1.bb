# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyahocorasick"
PV = "2.2.0"
PR = "1.el10_1"
PACKAGES = " \
 python-pyahocorasick-doc \
 python3-pyahocorasick \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyahocorasick-2.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00de40bd4e60fcf6b8d120d1fe72f9f85cda744a9f93ee6856226cf300b32062"

URI_x86_64_v2_python-pyahocorasick-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pyahocorasick-doc-2.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-pyahocorasick-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-pyahocorasick-doc}"
SRC_URI[x86_64_v2_python-pyahocorasick-doc.sha256sum] = "d3eac5e4d7d6b6e65e10f7b4001b28c400a33e61dcb327a873e16dcfc0328da8"

URI_x86_64_v2_python3-pyahocorasick = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyahocorasick-2.2.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyahocorasick;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyahocorasick}"
SRC_URI[x86_64_v2_python3-pyahocorasick.sha256sum] = "b1a2544f4d0fb0f075e39ce58ec174a28a68b6fc31295223a7b2d969cc78e5cd"

URI_aarch64_python-pyahocorasick-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-pyahocorasick-doc-2.2.0-1.el10_1.noarch.rpm;name=aarch64_python-pyahocorasick-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-pyahocorasick-doc}"
SRC_URI[aarch64_python-pyahocorasick-doc.sha256sum] = "6a81f68c14efa401914300166f28b55ca4a4c162403c87eb357e1b9090f4d4b3"

URI_aarch64_python3-pyahocorasick = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyahocorasick-2.2.0-1.el10_1.aarch64.rpm;name=aarch64_python3-pyahocorasick;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyahocorasick}"
SRC_URI[aarch64_python3-pyahocorasick.sha256sum] = "a1a25991f589fe87abeb5760657bf9e8ec449b6e9bf3f12103e2d01c088fcde1"

RDEPENDS:python-pyahocorasick-doc = " \
 python3-pyahocorasick \
 "
RDEPENDS:python3-pyahocorasick = " \
 glibc \
 python3 \
 "
