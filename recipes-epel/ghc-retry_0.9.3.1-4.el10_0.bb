# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-retry"
PV = "0.9.3.1"
PR = "4.el10_0"
PACKAGES = " \
 ghc-retry \
 ghc-retry-devel \
 ghc-retry-doc \
 ghc-retry-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-retry-0.9.3.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "47e96c1e7972bc0cfeac41f38cbf75e6c708f6733896c12130889b7bacf1b68e"

URI_x86_64_v2_ghc-retry = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-retry-0.9.3.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-retry;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-retry}"
SRC_URI[x86_64_v2_ghc-retry.sha256sum] = "a074a1263c9c26ab386d5057c832a7c8ddd36292d3cbbde6edb507363a63d56f"

URI_x86_64_v2_ghc-retry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-retry-devel-0.9.3.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-retry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-retry-devel}"
SRC_URI[x86_64_v2_ghc-retry-devel.sha256sum] = "7c984f17d7b6cee521a1385aac9de5c21ba30f802ec302444d27edafe9f83488"

URI_x86_64_v2_ghc-retry-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-retry-doc-0.9.3.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-retry-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-retry-doc}"
SRC_URI[x86_64_v2_ghc-retry-doc.sha256sum] = "5012081ddfa52482f82c81e7a5a9a13a6c3377ced4626d303f19cd7dd8c10439"

URI_x86_64_v2_ghc-retry-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-retry-prof-0.9.3.1-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-retry-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-retry-prof}"
SRC_URI[x86_64_v2_ghc-retry-prof.sha256sum] = "9962a94d25f94872835ba0deaf9cc8bcbc0df32405dbda677b489b46667554e7"

URI_aarch64_ghc-retry = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-retry-0.9.3.1-4.el10_0.aarch64.rpm;name=aarch64_ghc-retry;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-retry}"
SRC_URI[aarch64_ghc-retry.sha256sum] = "0b466344a9aae2efbcf0462f154f41f4bd2dc789d1ffedbf5a64db7a81b33c16"

URI_aarch64_ghc-retry-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-retry-devel-0.9.3.1-4.el10_0.aarch64.rpm;name=aarch64_ghc-retry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-retry-devel}"
SRC_URI[aarch64_ghc-retry-devel.sha256sum] = "b5334ca9903215296d6878c869bcb187b0f568e1d5217a7b996d1325aa5c2f23"

URI_aarch64_ghc-retry-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-retry-doc-0.9.3.1-4.el10_0.noarch.rpm;name=aarch64_ghc-retry-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-retry-doc}"
SRC_URI[aarch64_ghc-retry-doc.sha256sum] = "4033c2f67f335eea2f8cb3f7181ea0b0f6f0c35ef04b66b4c08802a502722ca3"

URI_aarch64_ghc-retry-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-retry-prof-0.9.3.1-4.el10_0.aarch64.rpm;name=aarch64_ghc-retry-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-retry-prof}"
SRC_URI[aarch64_ghc-retry-prof.sha256sum] = "62f64d6ec76c29bba5c0fc6caa431ff91c7a4fe6811c0266b769edcd5e6d9fa7"

RDEPENDS:ghc-retry = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-exceptions \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-transformers \
 ghc-unliftio-core \
 glibc \
 gmp \
 "
RDEPENDS:ghc-retry-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-exceptions-devel \
 ghc-mtl-devel \
 ghc-random-devel \
 ghc-retry \
 ghc-transformers-devel \
 ghc-unliftio-core-devel \
 "
RDEPENDS:ghc-retry-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-retry-prof = " \
 ghc-base-prof \
 ghc-exceptions-prof \
 ghc-mtl-prof \
 ghc-random-prof \
 ghc-retry-devel \
 ghc-transformers-prof \
 ghc-unliftio-core-prof \
 "
