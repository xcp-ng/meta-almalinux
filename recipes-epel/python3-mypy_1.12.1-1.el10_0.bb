# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python3-mypy"
PV = "1.12.1"
PR = "1.el10_0"
PACKAGES = " \
 python3-mypy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python3-mypy-1.12.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "297119fa15af3887df993c4609511f4f11df67ce7f99570463a4b35c517d1c7e"

URI_x86_64_v2_python3-mypy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-mypy-1.12.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-mypy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-mypy}"
SRC_URI[x86_64_v2_python3-mypy.sha256sum] = "df6373dc837cbd56bff22fc2980a67068d39a506b1aa21844149185ee7eaedec"

URI_aarch64_python3-mypy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-mypy-1.12.1-1.el10_0.noarch.rpm;name=aarch64_python3-mypy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-mypy}"
SRC_URI[aarch64_python3-mypy.sha256sum] = "fdc111b154c5ef5ad36eb3a8c6711b931693e1835c71ee63116027b8a6cc2d96"

RDEPENDS:python3-mypy = " \
 bash \
 python3 \
 python3-mypy_extensions \
 python3-typing-extensions \
 "
