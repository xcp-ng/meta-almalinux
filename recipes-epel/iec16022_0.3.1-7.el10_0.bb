# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "iec16022"
PV = "0.3.1"
PR = "7.el10_0"
PACKAGES = " \
 iec16022 \
 iec16022-devel \
 iec16022-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/iec16022-0.3.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8e531459e8c2c45db610394f7294a8b1a65f8242f1374615de0ac869e4b10125"

URI_x86_64_v2_iec16022 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iec16022-0.3.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iec16022;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iec16022}"
SRC_URI[x86_64_v2_iec16022.sha256sum] = "d4e86853ae74f564922a1a9df6bcf56176c5161216c9f4d56c2f826b8d072b0f"

URI_x86_64_v2_iec16022-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iec16022-devel-0.3.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iec16022-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iec16022-devel}"
SRC_URI[x86_64_v2_iec16022-devel.sha256sum] = "6c5d8d21df238932e9541dcf1a62bde99096a031424d27ed8266d7880d53f1fe"

URI_x86_64_v2_iec16022-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/iec16022-libs-0.3.1-7.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_iec16022-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_iec16022-libs}"
SRC_URI[x86_64_v2_iec16022-libs.sha256sum] = "e2f794e3073a5a51481f86e4aad3fbd753208d506ce4626af6dd583b0deaf6a9"

URI_aarch64_iec16022 = "${EPEL_MIRROR}/aarch64/Packages/i/iec16022-0.3.1-7.el10_0.aarch64.rpm;name=aarch64_iec16022;unpack=0"
SRC_URI:append = " ${URI_aarch64_iec16022}"
SRC_URI[aarch64_iec16022.sha256sum] = "48edec882af152b4f156eb1356dd080c41aff62f09f1297591966376e6861ebc"

URI_aarch64_iec16022-devel = "${EPEL_MIRROR}/aarch64/Packages/i/iec16022-devel-0.3.1-7.el10_0.aarch64.rpm;name=aarch64_iec16022-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_iec16022-devel}"
SRC_URI[aarch64_iec16022-devel.sha256sum] = "10033d4de2eddfdbc4e257e4ba69a5b5ac3f7ac6d28f40abc3307b987fdfdec5"

URI_aarch64_iec16022-libs = "${EPEL_MIRROR}/aarch64/Packages/i/iec16022-libs-0.3.1-7.el10_0.aarch64.rpm;name=aarch64_iec16022-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_iec16022-libs}"
SRC_URI[aarch64_iec16022-libs.sha256sum] = "228fc3cb90e5249bf3d8c8e9ce4dae79a88c3d9d3c138c82cc69f7595bd6f06e"

RDEPENDS:iec16022 = " \
 glibc \
 iec16022-libs \
 popt \
 "
RDEPENDS:iec16022-devel = " \
 iec16022-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:iec16022-libs = " \
 glibc \
 "
