# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-uu_logname"
PV = "0.7.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-uu_logname+default-devel \
 rust-uu_logname-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-uu_logname-0.7.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a0332e6e4f97ceb3d8f9c201db7c65ed6f8a70d990624e3535cb055769ef6c4"

URI_x86_64_v2_rust-uu_logname+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_logname+default-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_logname+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_logname+default-devel}"
SRC_URI[x86_64_v2_rust-uu_logname+default-devel.sha256sum] = "4664043649dc3be2759e08247723152869d7636d48bd185abc64c5b721b53153"

URI_x86_64_v2_rust-uu_logname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-uu_logname-devel-0.7.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-uu_logname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-uu_logname-devel}"
SRC_URI[x86_64_v2_rust-uu_logname-devel.sha256sum] = "aa984b1ffe49505b90f855e0e8321732046c1fa65f00028c7652cf0533ecc6bf"

URI_aarch64_rust-uu_logname+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_logname+default-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_logname+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_logname+default-devel}"
SRC_URI[aarch64_rust-uu_logname+default-devel.sha256sum] = "ef57dd8e0836fdef932e54a21fd260ad17df8995856545897daf59f287398970"

URI_aarch64_rust-uu_logname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-uu_logname-devel-0.7.0-1.el10_3.noarch.rpm;name=aarch64_rust-uu_logname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-uu_logname-devel}"
SRC_URI[aarch64_rust-uu_logname-devel.sha256sum] = "ba3af74e0d7f8cb4c00b2e9e612aad80ebe8bda29a339c2f9c060cce10d60d39"

RDEPENDS:rust-uu_logname+default-devel = " \
 cargo \
 rust-uu_logname-devel \
 "
RDEPENDS:rust-uu_logname-devel = " \
 cargo \
 rust \
 rust-clap+cargo-devel \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+wrap_help-devel \
 rust-fluent+default-devel \
 rust-libc+default-devel \
 rust-uucore+default-devel \
 "
