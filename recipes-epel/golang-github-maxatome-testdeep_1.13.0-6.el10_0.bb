# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-maxatome-testdeep"
PV = "1.13.0"
PR = "6.el10_0"
PACKAGES = " \
 golang-github-maxatome-testdeep-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-maxatome-testdeep-1.13.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "8ac99ce2d02535db7ce761116c758d394e0e4050c7248e6605f012ae35ddfbd7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-maxatome-testdeep-devel-1.13.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-maxatome-testdeep-devel;unpack=0"
SRC_URI[x86_64_v2_golang-github-maxatome-testdeep-devel.sha256sum] = "f37d14cbe2bd58135c894ee3471ec0ead7bf3db762fa248f7f3679419a4f83bd"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-maxatome-testdeep-devel-1.13.0-6.el10_0.noarch.rpm;name=aarch64_golang-github-maxatome-testdeep-devel;unpack=0"
SRC_URI[aarch64_golang-github-maxatome-testdeep-devel.sha256sum] = "3e2d0375b47552b26f4b8e9e9c436e5b248dfffc459c2c794d0e49d9ad6782d7"

RDEPENDS:golang-github-maxatome-testdeep-devel = " \
 go-filesystem \
 golang-github-davecgh-spew-devel \
 "
