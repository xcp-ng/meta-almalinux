# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kclock"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kclock \
 kclock-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kclock-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d865fc3c61cc4b92442c18bf40928e3ba74e41e16e2d79909a56c41255868899"

URI_x86_64_v2_kclock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kclock}"
SRC_URI[x86_64_v2_kclock.sha256sum] = "35b580c98d735e7c95b3c35aeb29da1bb0ab783f0d9c2ea0b1194c31272cdb23"

URI_x86_64_v2_kclock-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-plasma-applet-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kclock-plasma-applet}"
SRC_URI[x86_64_v2_kclock-plasma-applet.sha256sum] = "3b8c44f019d72d0d30d69691bc3fd027aab1d8d46bc31f4f265aa22c66f34bf8"

URI_aarch64_kclock = "${EPEL_MIRROR}/aarch64/Packages/k/kclock-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kclock;unpack=0"
SRC_URI:append = " ${URI_aarch64_kclock}"
SRC_URI[aarch64_kclock.sha256sum] = "79432ffce530df0c9d94b621c360f3826b1ee44d5117926e6b2cd32d79c12deb"

URI_aarch64_kclock-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kclock-plasma-applet-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kclock-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kclock-plasma-applet}"
SRC_URI[aarch64_kclock-plasma-applet.sha256sum] = "ea250e617b1e1424bd06a6f27d112bcc13dae7f3b042e4c722e92d35f4208fa5"

RDEPENDS:kclock = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 kf6-kwindowsystem \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kclock-plasma-applet = " \
 glibc \
 kclock \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-kservice \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 "
