# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "samba"
PV = "4.24.3"
PR = "100.el10"
PACKAGES:x86_64_v2 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-tools \
 samba-core-libs \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-ndr-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
 samba-winexe \
"
PACKAGES:aarch64 = " \
 ldb-tools \
 libldb \
 libldb-devel \
 libnetapi \
 libnetapi-devel \
 libsmbclient \
 libsmbclient-devel \
 libwbclient \
 libwbclient-devel \
 python3-ldb \
 python3-samba \
 python3-samba-dc \
 python3-samba-test \
 samba \
 samba-client \
 samba-client-libs \
 samba-common \
 samba-common-tools \
 samba-core-libs \
 samba-dc-libs \
 samba-dcerpc \
 samba-devel \
 samba-gpupdate \
 samba-krb5-printing \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-ndr-libs \
 samba-pidl \
 samba-test \
 samba-test-libs \
 samba-tools \
 samba-usershares \
 samba-vfs-iouring \
 samba-winbind \
 samba-winbind-clients \
 samba-winbind-krb5-locator \
 samba-winbind-modules \
"

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/samba-4.24.3-100.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f46f943b8ed6c5bcb8d3957645a202a0f7a0f61d08c4c4c4c1158eb74848a5e7"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - samba-client-libs: libcap.so.2()(64bit)

URI_x86_64_v2_ldb-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ldb-tools-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_ldb-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ldb-tools}"
SRC_URI[x86_64_v2_ldb-tools.sha256sum] = "edc75660d6e946e8b772ca185b0526c6f3562c4ea888f641da8d690537dfe4c5"

URI_x86_64_v2_libldb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libldb-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libldb}"
SRC_URI[x86_64_v2_libldb.sha256sum] = "889b35b435561fd898b4f7b6e3e997a76a3d8fd84155e79a29e1d8e6566d1cf8"

URI_x86_64_v2_libldb-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libldb-devel-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libldb-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libldb-devel}"
SRC_URI[x86_64_v2_libldb-devel.sha256sum] = "d32c146e0383e4a27140b44c5897940185757df29d7c8aa7590e35e4ca83c04e"

URI_x86_64_v2_libnetapi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnetapi-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libnetapi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetapi}"
SRC_URI[x86_64_v2_libnetapi.sha256sum] = "3adea6c75301c1629b349ef6687a7b36cc55e1242d50958ea2991e8f1acb11f8"

URI_x86_64_v2_libnetapi-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnetapi-devel-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libnetapi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnetapi-devel}"
SRC_URI[x86_64_v2_libnetapi-devel.sha256sum] = "2703da37e35bb1cff5792be17224d8475ba1b1e2d242210cfc97ab3181c5e64e"

URI_x86_64_v2_libsmbclient = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libsmbclient-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libsmbclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmbclient}"
SRC_URI[x86_64_v2_libsmbclient.sha256sum] = "0b8c9d551986b3d6e1dfd786c8fe31130bd59e9871329c2a358461634eea78ec"

URI_x86_64_v2_libsmbclient-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libsmbclient-devel-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libsmbclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsmbclient-devel}"
SRC_URI[x86_64_v2_libsmbclient-devel.sha256sum] = "e7bdc332a5b6fedf639a5d413a34da60c458e956d48d143a4a471067a41462e3"

URI_x86_64_v2_libwbclient = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libwbclient-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libwbclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwbclient}"
SRC_URI[x86_64_v2_libwbclient.sha256sum] = "1acc5d12b68de3ebbc763b6c7fcd7e48896e5245aa7c4caf8db8fc6f0dcc2f52"

URI_x86_64_v2_libwbclient-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libwbclient-devel-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_libwbclient-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwbclient-devel}"
SRC_URI[x86_64_v2_libwbclient-devel.sha256sum] = "85cc1e3161e5a7445d4e2d52acd9bc6a4034ab56ee773b1955a49f8b0e97aa00"

URI_x86_64_v2_python3-ldb = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-ldb-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_python3-ldb;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ldb}"
SRC_URI[x86_64_v2_python3-ldb.sha256sum] = "7f1de5a9ab3e4e62a1bd62656947cf68c3280a33b749425b93e0fc2baec81f14"

URI_x86_64_v2_python3-samba = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_python3-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba}"
SRC_URI[x86_64_v2_python3-samba.sha256sum] = "003368879f40a09540a0d83891c16614eb8d1b5395c4f29bb2e21d0dfd8ae115"

URI_x86_64_v2_python3-samba-dc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/python3-samba-dc-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_python3-samba-dc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba-dc}"
SRC_URI[x86_64_v2_python3-samba-dc.sha256sum] = "4e04848331c0380e7fe217246f9e379f9a0ed6ed954af5db035624272c4194f2"

URI_x86_64_v2_python3-samba-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-samba-test-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_python3-samba-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-samba-test}"
SRC_URI[x86_64_v2_python3-samba-test.sha256sum] = "045155ea3b6c318310ae23abafaf7314389e7cc61b87b21265b349fd34250100"

URI_x86_64_v2_samba = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba}"
SRC_URI[x86_64_v2_samba.sha256sum] = "97e00c8c8dc8a476f2840274e3353b9c739ca68861e34ee27d3e515c03af043c"

URI_x86_64_v2_samba-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-client-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-client}"
SRC_URI[x86_64_v2_samba-client.sha256sum] = "99c0e30af5059123c017852ffb8e3a059521a52e487ef55d3cbb1bdd9bb7f77c"

URI_x86_64_v2_samba-client-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-client-libs-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-client-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-client-libs}"
SRC_URI[x86_64_v2_samba-client-libs.sha256sum] = "cd0f48480373e8b044d018e07f323628b1ce9358573ba8a008780303f0230260"

URI_x86_64_v2_samba-common = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-4.24.3-100.el10.noarch.rpm;name=x86_64_v2_samba-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common}"
SRC_URI[x86_64_v2_samba-common.sha256sum] = "4506a5a425e80ded6cfdcc8ad0a4edb7912a22abff9dd1d5e83be0a4e9296b76"

URI_x86_64_v2_samba-common-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-common-tools-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-common-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-common-tools}"
SRC_URI[x86_64_v2_samba-common-tools.sha256sum] = "01369c6a9949ca7c992d5054f955097bfcf019441ac92ad1715e47f45c02a399"

URI_x86_64_v2_samba-core-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-core-libs-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-core-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-core-libs}"
SRC_URI[x86_64_v2_samba-core-libs.sha256sum] = "2df186f36e008c0d48437c4e3d490a9a9ba20ca1121ceda34187d88980b3d552"

URI_x86_64_v2_samba-dc-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dc-libs-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-dc-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-dc-libs}"
SRC_URI[x86_64_v2_samba-dc-libs.sha256sum] = "6bf55adb841abf3f66febd8953ef86d287e07b094a2730d62a94586127fdafc1"

URI_x86_64_v2_samba-dcerpc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-dcerpc-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-dcerpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-dcerpc}"
SRC_URI[x86_64_v2_samba-dcerpc.sha256sum] = "9650442f246ab1abeac4f472affa9f009d85bd658e479ddbf4eb0b67a07d7965"

URI_x86_64_v2_samba-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-devel-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-devel}"
SRC_URI[x86_64_v2_samba-devel.sha256sum] = "bae37adfcad6cb72e693a19ab8716ca948e011e0446485c4e88fe524322126fc"

URI_x86_64_v2_samba-gpupdate = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-gpupdate-4.24.3-100.el10.noarch.rpm;name=x86_64_v2_samba-gpupdate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-gpupdate}"
SRC_URI[x86_64_v2_samba-gpupdate.sha256sum] = "b0d877289c2cb02377b2f8c02a57568a0ede04605b6c51b188742f4101bfcc28"

URI_x86_64_v2_samba-krb5-printing = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-krb5-printing-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-krb5-printing;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-krb5-printing}"
SRC_URI[x86_64_v2_samba-krb5-printing.sha256sum] = "ecd7b120453f9ff5d3941f2dc4466f5042efcbf9250c2706e33cccb47991e26a"

URI_x86_64_v2_samba-ldb-ldap-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-ldb-ldap-modules-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-ldb-ldap-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-ldb-ldap-modules}"
SRC_URI[x86_64_v2_samba-ldb-ldap-modules.sha256sum] = "03a2187deaeadb318558bd5788f227ce83791c34163994b8f446735679423b92"

URI_x86_64_v2_samba-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-libs-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-libs}"
SRC_URI[x86_64_v2_samba-libs.sha256sum] = "e3ba7785ce164da08731c4805e3768796ace44c56c3edc468899f422bb14df5d"

URI_x86_64_v2_samba-ndr-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-ndr-libs-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-ndr-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-ndr-libs}"
SRC_URI[x86_64_v2_samba-ndr-libs.sha256sum] = "11b2e0b277f618de6dbaa9946f8a78215b7b148eaff6a32a13b3d385fb8befbc"

URI_x86_64_v2_samba-pidl = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-pidl-4.24.3-100.el10.noarch.rpm;name=x86_64_v2_samba-pidl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-pidl}"
SRC_URI[x86_64_v2_samba-pidl.sha256sum] = "381c3457028c8d2017ab6f9beed37fec77c7b4d1b7d6b7a7e03c3db95cba9be4"

URI_x86_64_v2_samba-test = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-test;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-test}"
SRC_URI[x86_64_v2_samba-test.sha256sum] = "fc8908b2ae758016066f679ee185ab7a99d3902c867730420bb03322906a9f59"

URI_x86_64_v2_samba-test-libs = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/samba-test-libs-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-test-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-test-libs}"
SRC_URI[x86_64_v2_samba-test-libs.sha256sum] = "93e8e323f39537247aa32c122867034215481a492e815fe58b313457b214867f"

URI_x86_64_v2_samba-tools = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-tools-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-tools}"
SRC_URI[x86_64_v2_samba-tools.sha256sum] = "768cf6b07732bb955929891951f6d80b3ef476803d430cb7d53fb0b0f990271a"

URI_x86_64_v2_samba-usershares = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-usershares-4.24.3-100.el10.noarch.rpm;name=x86_64_v2_samba-usershares;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-usershares}"
SRC_URI[x86_64_v2_samba-usershares.sha256sum] = "f7742ef5e3c155526fe8a4ba3719092261325f27349992ac12d3582dd47d382d"

URI_x86_64_v2_samba-vfs-iouring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-vfs-iouring-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-vfs-iouring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-vfs-iouring}"
SRC_URI[x86_64_v2_samba-vfs-iouring.sha256sum] = "ada3b6f8e371062c61b03462c53c0c640d4f54152f54317d1ef903b5788ffd23"

URI_x86_64_v2_samba-winbind = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winbind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind}"
SRC_URI[x86_64_v2_samba-winbind.sha256sum] = "83c2dae4a01688ab706fa5286f55696f4346b2291ab6a91cbf5e87b1c26bb12b"

URI_x86_64_v2_samba-winbind-clients = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-clients-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-clients;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-clients}"
SRC_URI[x86_64_v2_samba-winbind-clients.sha256sum] = "e55681b158aa8113698679e7ca8633ed1db045f838e39001ec01195112295751"

URI_x86_64_v2_samba-winbind-krb5-locator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winbind-krb5-locator-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-krb5-locator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-krb5-locator}"
SRC_URI[x86_64_v2_samba-winbind-krb5-locator.sha256sum] = "4475d559e45ce18ef93301b45a4881d5cdcead0d84286d14ca205469345733a7"

URI_x86_64_v2_samba-winbind-modules = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/samba-winbind-modules-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winbind-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winbind-modules}"
SRC_URI[x86_64_v2_samba-winbind-modules.sha256sum] = "f49b67127e68b7062345f16b3c4d93498516afd886c7896ded9f5718338eb4e7"

URI_x86_64_v2_samba-winexe = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/samba-winexe-4.24.3-100.el10.x86_64_v2.rpm;name=x86_64_v2_samba-winexe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_samba-winexe}"
SRC_URI[x86_64_v2_samba-winexe.sha256sum] = "a40078ee03f31a4627fb48bb652f1aaff5aa8696fa78cd273a3a74c56e129d02"

URI_aarch64_ldb-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ldb-tools-4.24.3-100.el10.aarch64.rpm;name=aarch64_ldb-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_ldb-tools}"
SRC_URI[aarch64_ldb-tools.sha256sum] = "f5e1baa45a4ecf6da1e170bd7d8b4c9e73ebe92becdf57b96c97c511d5f75e1a"

URI_aarch64_libldb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libldb-4.24.3-100.el10.aarch64.rpm;name=aarch64_libldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_libldb}"
SRC_URI[aarch64_libldb.sha256sum] = "ebb8effa2251e433663b32502eff2595af7820162f87b2f64a6b17033cadb9ba"

URI_aarch64_libldb-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libldb-devel-4.24.3-100.el10.aarch64.rpm;name=aarch64_libldb-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libldb-devel}"
SRC_URI[aarch64_libldb-devel.sha256sum] = "a26927e57ec31012dbab71bdb71d56517f65a2e734d9d2d09d9f7b451701d5f2"

URI_aarch64_libnetapi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnetapi-4.24.3-100.el10.aarch64.rpm;name=aarch64_libnetapi;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetapi}"
SRC_URI[aarch64_libnetapi.sha256sum] = "ae787d725b9c16fa74fc17484855d9e1b3eb0d73bc2c8523c795e6130a82be1a"

URI_aarch64_libnetapi-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnetapi-devel-4.24.3-100.el10.aarch64.rpm;name=aarch64_libnetapi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnetapi-devel}"
SRC_URI[aarch64_libnetapi-devel.sha256sum] = "1ff8586e4d22e040fde3b667d9e0d4c664d98603e36b2e28a029db8bb895fffc"

URI_aarch64_libsmbclient = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libsmbclient-4.24.3-100.el10.aarch64.rpm;name=aarch64_libsmbclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmbclient}"
SRC_URI[aarch64_libsmbclient.sha256sum] = "4634f2ddebc3ed76f8cd65b1a740f9573fa3aaa1fab4efca5112a239eb7097da"

URI_aarch64_libsmbclient-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libsmbclient-devel-4.24.3-100.el10.aarch64.rpm;name=aarch64_libsmbclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsmbclient-devel}"
SRC_URI[aarch64_libsmbclient-devel.sha256sum] = "86d57c11232aa84c186544ce7c4d85abeed2bf2b5feb6e84db6dd0fce8c699ec"

URI_aarch64_libwbclient = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libwbclient-4.24.3-100.el10.aarch64.rpm;name=aarch64_libwbclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwbclient}"
SRC_URI[aarch64_libwbclient.sha256sum] = "64dff24ea8eaa0a6a1ef7ff361bdd67650838b57c5daee3d9d6de20d61f45062"

URI_aarch64_libwbclient-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libwbclient-devel-4.24.3-100.el10.aarch64.rpm;name=aarch64_libwbclient-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwbclient-devel}"
SRC_URI[aarch64_libwbclient-devel.sha256sum] = "faf0c294f78de0645c8040efb26a5d2a38429a135e8f702895d1b99cc3ec013f"

URI_aarch64_python3-ldb = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-ldb-4.24.3-100.el10.aarch64.rpm;name=aarch64_python3-ldb;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ldb}"
SRC_URI[aarch64_python3-ldb.sha256sum] = "b39abe7379cf6466b573f416e54393b89ece2fe8a6051eb049842fc5349585a0"

URI_aarch64_python3-samba = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-4.24.3-100.el10.aarch64.rpm;name=aarch64_python3-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba}"
SRC_URI[aarch64_python3-samba.sha256sum] = "34cc511d9fa7187e6bafb39092e40b5c8cf0bcf8a734208ae3631e0fe6057d20"

URI_aarch64_python3-samba-dc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/python3-samba-dc-4.24.3-100.el10.aarch64.rpm;name=aarch64_python3-samba-dc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba-dc}"
SRC_URI[aarch64_python3-samba-dc.sha256sum] = "605330725158c9158812df1a0f93733a9ec6acdf9f1e2eb8c14929e34300812c"

URI_aarch64_python3-samba-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-samba-test-4.24.3-100.el10.aarch64.rpm;name=aarch64_python3-samba-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-samba-test}"
SRC_URI[aarch64_python3-samba-test.sha256sum] = "4654e83667eede71ef4edf593c40042b57951be29ab4f8cd62bd4dadab0eafe8"

URI_aarch64_samba = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba}"
SRC_URI[aarch64_samba.sha256sum] = "acd9e54af17306b82830f4532387b08abefb536091ae1e1c5113a50aeb96b618"

URI_aarch64_samba-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-client-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-client}"
SRC_URI[aarch64_samba-client.sha256sum] = "1613b1edd8464db0d88e84029f6f1a9469e011d2ff4d184867af8261d4f14f49"

URI_aarch64_samba-client-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-client-libs-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-client-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-client-libs}"
SRC_URI[aarch64_samba-client-libs.sha256sum] = "4c2bffc9b631f6855dcc39130d994801a5e3d6310053c472dfb7a7803c6beb20"

URI_aarch64_samba-common = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-4.24.3-100.el10.noarch.rpm;name=aarch64_samba-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common}"
SRC_URI[aarch64_samba-common.sha256sum] = "4506a5a425e80ded6cfdcc8ad0a4edb7912a22abff9dd1d5e83be0a4e9296b76"

URI_aarch64_samba-common-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-common-tools-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-common-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-common-tools}"
SRC_URI[aarch64_samba-common-tools.sha256sum] = "e6b0211649a2f8dcf6273d8dd94533bd460572b1970f051d220d5386938baa07"

URI_aarch64_samba-core-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-core-libs-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-core-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-core-libs}"
SRC_URI[aarch64_samba-core-libs.sha256sum] = "782e9c9be5f7fb2783f0a1202d5da985e9c22d98ae16fdc4dd765be0c8a35220"

URI_aarch64_samba-dc-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dc-libs-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-dc-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-dc-libs}"
SRC_URI[aarch64_samba-dc-libs.sha256sum] = "f0ad71dc91a0303640b570b67f55fc4c9ba69127ddf33fdf78ff548deb4d3a9b"

URI_aarch64_samba-dcerpc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-dcerpc-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-dcerpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-dcerpc}"
SRC_URI[aarch64_samba-dcerpc.sha256sum] = "1c175dcef15098980e4171159f1b332ba5bd5ece427b8e0152ddaa9f675db666"

URI_aarch64_samba-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-devel-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-devel}"
SRC_URI[aarch64_samba-devel.sha256sum] = "c3507ffa2a778e2174b980ffbf7d886793eb05873dad676ec6a674d04cfb7f3e"

URI_aarch64_samba-gpupdate = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-gpupdate-4.24.3-100.el10.noarch.rpm;name=aarch64_samba-gpupdate;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-gpupdate}"
SRC_URI[aarch64_samba-gpupdate.sha256sum] = "b0d877289c2cb02377b2f8c02a57568a0ede04605b6c51b188742f4101bfcc28"

URI_aarch64_samba-krb5-printing = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-krb5-printing-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-krb5-printing;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-krb5-printing}"
SRC_URI[aarch64_samba-krb5-printing.sha256sum] = "d17117cf56d02fcb166e421ec3b76e143811f2ec938d3c5c778b4b5c0113ddf4"

URI_aarch64_samba-ldb-ldap-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-ldb-ldap-modules-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-ldb-ldap-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-ldb-ldap-modules}"
SRC_URI[aarch64_samba-ldb-ldap-modules.sha256sum] = "da9b4d63dd178c71dc220303ed9105b60f48a43d11455dd8933975049cd6a881"

URI_aarch64_samba-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-libs-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-libs}"
SRC_URI[aarch64_samba-libs.sha256sum] = "af4f444b445355cb582587e63e477f8c61de3826cfb95d5e44b4e00ed2a2d7c7"

URI_aarch64_samba-ndr-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-ndr-libs-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-ndr-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-ndr-libs}"
SRC_URI[aarch64_samba-ndr-libs.sha256sum] = "e8520fdd63a032c9df4b10c78830f664d49549fb1e0264ec1464d64ebba8fa63"

URI_aarch64_samba-pidl = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-pidl-4.24.3-100.el10.noarch.rpm;name=aarch64_samba-pidl;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-pidl}"
SRC_URI[aarch64_samba-pidl.sha256sum] = "381c3457028c8d2017ab6f9beed37fec77c7b4d1b7d6b7a7e03c3db95cba9be4"

URI_aarch64_samba-test = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-test;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-test}"
SRC_URI[aarch64_samba-test.sha256sum] = "deabc34fe1d2bb8379292b8d429a4e009f97c40f6f071d99b316b131603c8abb"

URI_aarch64_samba-test-libs = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/samba-test-libs-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-test-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-test-libs}"
SRC_URI[aarch64_samba-test-libs.sha256sum] = "4e71d053a5ef68bb35a45660580fd89789379e4d9c119d7868121f7689a5542a"

URI_aarch64_samba-tools = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-tools-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-tools}"
SRC_URI[aarch64_samba-tools.sha256sum] = "8d2c10e6dc19468644456028e072688486ca55a1088d28058b29d8541467c9c0"

URI_aarch64_samba-usershares = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-usershares-4.24.3-100.el10.noarch.rpm;name=aarch64_samba-usershares;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-usershares}"
SRC_URI[aarch64_samba-usershares.sha256sum] = "f7742ef5e3c155526fe8a4ba3719092261325f27349992ac12d3582dd47d382d"

URI_aarch64_samba-vfs-iouring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-vfs-iouring-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-vfs-iouring;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-vfs-iouring}"
SRC_URI[aarch64_samba-vfs-iouring.sha256sum] = "18c8a2eab4a1886cf4cb872b85c6186c25bc225c595a615e21c50ce07a812ae0"

URI_aarch64_samba-winbind = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-winbind;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind}"
SRC_URI[aarch64_samba-winbind.sha256sum] = "12c77105d274d0909bceca96c1d760d773279bf41efd7766e2cbbd166ca7f397"

URI_aarch64_samba-winbind-clients = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-clients-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-winbind-clients;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-clients}"
SRC_URI[aarch64_samba-winbind-clients.sha256sum] = "cbe5803ad730a398c69a8f3c58f56c6a47534b08251357e36858a920ac5ad6b1"

URI_aarch64_samba-winbind-krb5-locator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/samba-winbind-krb5-locator-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-winbind-krb5-locator;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-krb5-locator}"
SRC_URI[aarch64_samba-winbind-krb5-locator.sha256sum] = "c1a730765c8aaa0e19ef08fb7f3f43cb1ca71f5719873adeebb65e9a9fc8f95f"

URI_aarch64_samba-winbind-modules = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/samba-winbind-modules-4.24.3-100.el10.aarch64.rpm;name=aarch64_samba-winbind-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_samba-winbind-modules}"
SRC_URI[aarch64_samba-winbind-modules.sha256sum] = "0bbd34cf94094e686721e2acd7dddfd5aa9d2dc9e423b050c6a79e485ca91149"

RDEPENDS:ldb-tools = " \
 glibc \
 libldb \
 libtalloc \
 popt \
 "
RDEPENDS:libldb = " \
 glibc \
 libtalloc \
 libtdb \
 libtevent \
 lmdb-libs \
 "
RDEPENDS:libldb-devel = " \
 libldb \
 libtalloc-devel \
 libtdb-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libnetapi = " \
 glibc \
 gnutls \
 libgcc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:libnetapi-devel = " \
 libnetapi \
 pkgconf-pkg-config \
 "
RDEPENDS:libsmbclient = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:libsmbclient-devel = " \
 libsmbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:libwbclient = " \
 bash \
 glibc \
 "
RDEPENDS:libwbclient-devel = " \
 libwbclient \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-ldb = " \
 glibc \
 libldb \
 libtalloc \
 python3 \
 python3-libs \
 python3-tdb \
 samba-client-libs \
 samba-core-libs \
 "
RDEPENDS:python3-samba = " \
 glibc \
 gnutls \
 krb5-libs \
 libgcc \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 python3 \
 python3-cryptography \
 python3-dns \
 python3-ldb \
 python3-libs \
 python3-requests \
 python3-talloc \
 python3-tdb \
 python3-tevent \
 samba-client-libs \
 samba-core-libs \
 samba-dc-libs \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:python3-samba-dc = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 python3 \
 python3-libs \
 python3-markdown \
 python3-samba \
 python3-talloc \
 samba-client-libs \
 samba-core-libs \
 samba-dc-libs \
 samba-ndr-libs \
 "
RDEPENDS:python3-samba-test = " \
 python3 \
 python3-samba \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba = " \
 bash \
 cups-libs \
 dbus-libs \
 glibc \
 gnutls \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 pam \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-tools \
 samba-core-libs \
 samba-dcerpc \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-client = " \
 alternatives \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libarchive \
 libcom_err \
 libldb \
 libsmbclient \
 libtalloc \
 libtevent \
 libwbclient \
 ncurses-libs \
 popt \
 readline \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-client-libs:x86_64_v2 = " \
 glibc \
 glibc-gconv-extra \
 gnutls \
 jansson \
 krb5-libs \
 libcap \
 libcom_err \
 libgcc \
 libldb \
 libtalloc \
 libtasn1 \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 zlib-ng-compat \
"
RDEPENDS:samba-client-libs:aarch64 = " \
 glibc \
 glibc-gconv-extra \
 gnutls \
 jansson \
 krb5-libs \
 libcom_err \
 libgcc \
 libldb \
 libtalloc \
 libtasn1 \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-common \
 samba-core-libs \
 samba-ndr-libs \
 zlib-ng-compat \
"
RDEPENDS:samba-common = " \
 bash \
 systemd \
 "
RDEPENDS:samba-common-tools = " \
 glibc \
 gnutls \
 jansson \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 python3 \
 readline \
 samba-client-libs \
 samba-core-libs \
 samba-ldb-ldap-modules \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-core-libs = " \
 glibc \
 gnutls \
 libicu \
 libtalloc \
 libtevent \
 samba-common \
 systemd-libs \
 "
RDEPENDS:samba-dc-libs = " \
 glibc \
 gnutls \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 samba-client-libs \
 samba-core-libs \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-dcerpc = " \
 cups-libs \
 glibc \
 gnutls \
 jansson \
 libldb \
 libnetapi \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-devel = " \
 libldb-devel \
 libnetapi \
 libtalloc-devel \
 libtevent-devel \
 pkgconf-pkg-config \
 samba-client-libs \
 samba-core-libs \
 samba-dc-libs \
 samba-devel \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-gpupdate = " \
 cepces-certmonger \
 certmonger \
 python3 \
 python3-samba \
 python3-samba-dc \
 samba-ldb-ldap-modules \
 "
RDEPENDS:samba-krb5-printing = " \
 alternatives \
 bash \
 glibc \
 krb5-libs \
 samba-client \
 samba-client-libs \
 samba-core-libs \
 "
RDEPENDS:samba-ldb-ldap-modules = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 openldap \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-libs = " \
 avahi-libs \
 glibc \
 gnutls \
 krb5-libs \
 libacl \
 libcom_err \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libtirpc \
 libwbclient \
 libxcrypt \
 openldap \
 pam-libs \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-ndr-libs = " \
 glibc \
 libtalloc \
 libtdb \
 libtevent \
 samba-common \
 samba-core-libs \
 zlib-ng-compat \
 "
RDEPENDS:samba-pidl = " \
 perl-Exporter \
 perl-File-Basename \
 perl-FindBin \
 perl-Getopt-Long \
 perl-Parse-Yapp \
 perl-base \
 perl-interpreter \
 perl-lib \
 perl-libs \
 perl-parent \
 perl-vars \
 samba-pidl \
 "
RDEPENDS:samba-test = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libnetapi \
 libsmbclient \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 perl-Archive-Tar \
 popt \
 python3-samba \
 readline \
 samba \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-dc-libs \
 samba-libs \
 samba-ndr-libs \
 samba-test-libs \
 samba-winbind \
 "
RDEPENDS:samba-test-libs = " \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-core-libs \
 samba-libs \
 samba-ndr-libs \
 "
RDEPENDS:samba-tools = " \
 python3 \
 python3-samba \
 python3-samba-dc \
 "
RDEPENDS:samba-usershares = " \
 bash \
 samba \
 samba-common-tools \
 "
RDEPENDS:samba-vfs-iouring = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 liburing \
 libwbclient \
 samba \
 samba-client-libs \
 samba-core-libs \
 samba-libs \
 "
RDEPENDS:samba-winbind = " \
 bash \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtdb \
 libtevent \
 libwbclient \
 openldap \
 popt \
 samba-client-libs \
 samba-common \
 samba-common-tools \
 samba-core-libs \
 samba-dcerpc \
 samba-libs \
 samba-ndr-libs \
 samba-winbind-modules \
 "
RDEPENDS:samba-winbind-clients = " \
 glibc \
 gnutls \
 krb5-libs \
 libcom_err \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-common \
 samba-core-libs \
 samba-libs \
 samba-ndr-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-krb5-locator = " \
 alternatives \
 bash \
 glibc \
 libldb \
 libtalloc \
 libwbclient \
 samba-client-libs \
 samba-core-libs \
 samba-winbind \
 "
RDEPENDS:samba-winbind-modules = " \
 glibc \
 libtalloc \
 libwbclient \
 pam \
 pam-libs \
 samba-client-libs \
 samba-libs \
 "
RDEPENDS:samba-winexe = " \
 glibc \
 libldb \
 libtalloc \
 libtevent \
 libwbclient \
 popt \
 samba-client-libs \
 samba-core-libs \
 samba-ndr-libs \
 "
