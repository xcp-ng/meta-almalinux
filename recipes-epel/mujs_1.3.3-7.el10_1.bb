# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mujs"
PV = "1.3.3"
PR = "7.el10_1"
PACKAGES = " \
 mujs \
 mujs-devel \
 mujs-static \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mujs-1.3.3-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5fb655f12c47fee11adf7b0b18199c0c03011112e61389b3004cc3bf7cfa1ee6"

URI_x86_64_v2_mujs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mujs-1.3.3-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mujs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mujs}"
SRC_URI[x86_64_v2_mujs.sha256sum] = "2515428d73309a8a9408b89e140d8d2c55dc452a866e754082404885b2fdc7c2"

URI_x86_64_v2_mujs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mujs-devel-1.3.3-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mujs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mujs-devel}"
SRC_URI[x86_64_v2_mujs-devel.sha256sum] = "e37c774e9bc6054b5640bef0bcc374d585fc37fdf71937e946f030c821018430"

URI_x86_64_v2_mujs-static = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mujs-static-1.3.3-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mujs-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mujs-static}"
SRC_URI[x86_64_v2_mujs-static.sha256sum] = "2790cb3e72e7dd924e4d3e31b8443fc6346b090e081d2b4cdfe499045f2bd0fc"

URI_aarch64_mujs = "${EPEL_MIRROR}/aarch64/Packages/m/mujs-1.3.3-7.el10_1.aarch64.rpm;name=aarch64_mujs;unpack=0"
SRC_URI:append = " ${URI_aarch64_mujs}"
SRC_URI[aarch64_mujs.sha256sum] = "697b509ff65e1a13ba45ddc3a0bb19d8b662c819126008b069872faa89b2a892"

URI_aarch64_mujs-devel = "${EPEL_MIRROR}/aarch64/Packages/m/mujs-devel-1.3.3-7.el10_1.aarch64.rpm;name=aarch64_mujs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mujs-devel}"
SRC_URI[aarch64_mujs-devel.sha256sum] = "522a4a3b04fba616861101fb27a3a2091f14b470c5fb0bf07a653d207650c2ab"

URI_aarch64_mujs-static = "${EPEL_MIRROR}/aarch64/Packages/m/mujs-static-1.3.3-7.el10_1.aarch64.rpm;name=aarch64_mujs-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_mujs-static}"
SRC_URI[aarch64_mujs-static.sha256sum] = "d705894105b422898d70296711e2f6758186c8191c439840db1156f7f7e69dd3"

RDEPENDS:mujs = " \
 glibc \
 readline \
 "
RDEPENDS:mujs-devel = " \
 mujs \
 pkgconf-pkg-config \
 "
RDEPENDS:mujs-static = " \
 mujs-devel \
 "
