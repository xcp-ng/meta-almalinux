# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Net-UPnP"
PE = "1"
PV = "1.4.6"
PR = "18.el10_0"
PACKAGES = " \
 perl-Net-UPnP \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Net-UPnP-1.4.6-18.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "047b06dfc7089bd51cb7aa3a83fd767398770edccf68eb724b37650a092d4532"

URI_x86_64_v2_perl-Net-UPnP = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Net-UPnP-1.4.6-18.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Net-UPnP;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Net-UPnP}"
SRC_URI[x86_64_v2_perl-Net-UPnP.sha256sum] = "17a764484e5f22acf23e105d597b8a679e5a57922723c1319b03dda446f98772"

URI_aarch64_perl-Net-UPnP = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Net-UPnP-1.4.6-18.el10_0.noarch.rpm;name=aarch64_perl-Net-UPnP;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Net-UPnP}"
SRC_URI[aarch64_perl-Net-UPnP.sha256sum] = "c02359649b1af4888293aceebacb2425f4ca507bace381fbb591bfbbefb0b423"

RDEPENDS:perl-Net-UPnP = " \
 perl-Net-UPnP \
 perl-Socket \
 perl-libs \
 perl-vars \
 perl-version \
 "
