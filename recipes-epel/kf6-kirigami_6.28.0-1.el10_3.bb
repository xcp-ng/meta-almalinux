# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami"
PV = "6.28.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-kirigami \
 kf6-kirigami-devel \
 kf6-kirigami-doc \
 kf6-kirigami-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-6.28.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d261b10b8cc4bb080074cd316684ced9cfd1014203110887e94e08b13f71add8"

URI_x86_64_v2_kf6-kirigami = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami}"
SRC_URI[x86_64_v2_kf6-kirigami.sha256sum] = "b77ee2375cf11cc71dd636c4341684ab1a5200b962d383927232f4f057718128"

URI_x86_64_v2_kf6-kirigami-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-devel-6.28.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-devel}"
SRC_URI[x86_64_v2_kf6-kirigami-devel.sha256sum] = "3c6bb1a50f0fd4b015a25be40c04e977b1a44d4b4b7afb890000f4a405cee4e3"

URI_x86_64_v2_kf6-kirigami-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-doc-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kirigami-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-doc}"
SRC_URI[x86_64_v2_kf6-kirigami-doc.sha256sum] = "a34ff43b4779f8dbd1bd1a5945137c81354d12936c1f223daedba23ab3871351"

URI_x86_64_v2_kf6-kirigami-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-html-6.28.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kirigami-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-html}"
SRC_URI[x86_64_v2_kf6-kirigami-html.sha256sum] = "aae56b183bf92ea8ff1e5ac32d5a1a942c23d7243a757d083c7d4542987c549d"

URI_aarch64_kf6-kirigami = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kirigami;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami}"
SRC_URI[aarch64_kf6-kirigami.sha256sum] = "fe7a9e3cab4c2ba262f865448b820a9ba31aaa728aadd05f2519bb9c38d5641b"

URI_aarch64_kf6-kirigami-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-devel-6.28.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-kirigami-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-devel}"
SRC_URI[aarch64_kf6-kirigami-devel.sha256sum] = "1d8c5a66a170059b54cb741c0ca0076791c81cb832ab3a81b23d5ca38295cc9a"

URI_aarch64_kf6-kirigami-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-doc-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kirigami-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-doc}"
SRC_URI[aarch64_kf6-kirigami-doc.sha256sum] = "4fce02e0faa7238486e36ed705d209d6707aa4174563dd3330afc674391851e6"

URI_aarch64_kf6-kirigami-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-html-6.28.0-1.el10_3.noarch.rpm;name=aarch64_kf6-kirigami-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-html}"
SRC_URI[aarch64_kf6-kirigami-html.sha256sum] = "9bb958ad5b23955245c0d580883fb669476cc47106c0a5a9156a4bb963aa9cd9"

RDEPENDS:kf6-kirigami = " \
 glibc \
 libgomp \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-devel = " \
 cmake-filesystem \
 kf6-kirigami \
 "
RDEPENDS:kf6-kirigami-doc = " \
 "
RDEPENDS:kf6-kirigami-html = " \
 "
