# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-embed"
PV = "8.11.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-rust-embed+debug-embed-devel \
 rust-rust-embed+default-devel \
 rust-rust-embed+deterministic-timestamps-devel \
 rust-rust-embed+hex-devel \
 rust-rust-embed+include-exclude-devel \
 rust-rust-embed+interpolate-folder-path-devel \
 rust-rust-embed-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-embed-8.11.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0695f2f07029cc007ec4e1c485584535fc3109e1299dda115eb1834bc30afeb4"

URI_x86_64_v2_rust-rust-embed+debug-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+debug-embed-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+debug-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+debug-embed-devel.sha256sum] = "7542ff31a8ca292c18ab46ab078cd01f7bfed6fff968cd14b6953ef33e8bc373"

URI_x86_64_v2_rust-rust-embed+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+default-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+default-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+default-devel.sha256sum] = "9cb4a99f3055abde33c8d59a3c9661184c3472c43dd72091c1e471cd03c181a2"

URI_x86_64_v2_rust-rust-embed+deterministic-timestamps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+deterministic-timestamps-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+deterministic-timestamps-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+deterministic-timestamps-devel.sha256sum] = "e7ec5d538ebd8c393ccbeeb0b99a75e5db5f88adf0678a3d0ad8bbddecd355cc"

URI_x86_64_v2_rust-rust-embed+hex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+hex-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+hex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+hex-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+hex-devel.sha256sum] = "3509da655c6270db23ea8c5d2e2f6240669ee174b58603fa5fc475a65cb7b0ba"

URI_x86_64_v2_rust-rust-embed+include-exclude-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+include-exclude-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+include-exclude-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+include-exclude-devel.sha256sum] = "2b0787487d8423a68bab28d0555807b6f2d787885fcee877459d59f602d2b277"

URI_x86_64_v2_rust-rust-embed+interpolate-folder-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed+interpolate-folder-path-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed+interpolate-folder-path-devel}"
SRC_URI[x86_64_v2_rust-rust-embed+interpolate-folder-path-devel.sha256sum] = "6f79a709642736c01b15ad98cfeba49b92f0f4de90e2b09035f85cf9b40c065e"

URI_x86_64_v2_rust-rust-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-devel-8.11.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-devel.sha256sum] = "3ebf3b1245f727cfe2b28f60009ec680196b394e1ecc53e376fcc2e1a6041bcf"

URI_aarch64_rust-rust-embed+debug-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+debug-embed-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+debug-embed-devel}"
SRC_URI[aarch64_rust-rust-embed+debug-embed-devel.sha256sum] = "0611131a0daa127a661375e3da2c04c2cd075bfdf7f2af72c7e1bd30caf6cb7e"

URI_aarch64_rust-rust-embed+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+default-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+default-devel}"
SRC_URI[aarch64_rust-rust-embed+default-devel.sha256sum] = "6a8bbda7baf2e96731e23dc05d0d171015df5040593af7fc6788b3edfe003570"

URI_aarch64_rust-rust-embed+deterministic-timestamps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+deterministic-timestamps-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+deterministic-timestamps-devel}"
SRC_URI[aarch64_rust-rust-embed+deterministic-timestamps-devel.sha256sum] = "15fcb504fbfb2b1fdada5e733e00cac9ee527bb3884b0e94455fdeeb74df7ad1"

URI_aarch64_rust-rust-embed+hex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+hex-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed+hex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+hex-devel}"
SRC_URI[aarch64_rust-rust-embed+hex-devel.sha256sum] = "b7d8f447c73e10b84a569f6e0c204eb3d899f214de563882d1210c44ed864e49"

URI_aarch64_rust-rust-embed+include-exclude-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+include-exclude-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+include-exclude-devel}"
SRC_URI[aarch64_rust-rust-embed+include-exclude-devel.sha256sum] = "34395fa43a3f96a8d5764a563ba75f05df3ac797d48495983d84e53367c66e89"

URI_aarch64_rust-rust-embed+interpolate-folder-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed+interpolate-folder-path-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed+interpolate-folder-path-devel}"
SRC_URI[aarch64_rust-rust-embed+interpolate-folder-path-devel.sha256sum] = "2bebc8de64f6914f34eb4c5530a485c97b24fe3d8d36ac6ae2b33d36f58e04af"

URI_aarch64_rust-rust-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-devel-8.11.0-1.el10_2.noarch.rpm;name=aarch64_rust-rust-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-devel}"
SRC_URI[aarch64_rust-rust-embed-devel.sha256sum] = "9ae738e117cde2ef5b871de52b3bcc2ba0f118c7ea6e24ee002adc7c6917e159"

RDEPENDS:rust-rust-embed+debug-embed-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+debug-embed-devel \
 rust-rust-embed-utils+debug-embed-devel \
 "
RDEPENDS:rust-rust-embed+default-devel = " \
 cargo \
 rust-rust-embed-devel \
 "
RDEPENDS:rust-rust-embed+deterministic-timestamps-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+deterministic-timestamps-devel \
 "
RDEPENDS:rust-rust-embed+hex-devel = " \
 cargo \
 rust-hex+default-devel \
 rust-rust-embed-devel \
 "
RDEPENDS:rust-rust-embed+include-exclude-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+include-exclude-devel \
 rust-rust-embed-utils+include-exclude-devel \
 "
RDEPENDS:rust-rust-embed+interpolate-folder-path-devel = " \
 cargo \
 rust-rust-embed-devel \
 rust-rust-embed-impl+interpolate-folder-path-devel \
 "
RDEPENDS:rust-rust-embed-devel = " \
 cargo \
 rust \
 rust-rust-embed-impl+default-devel \
 rust-rust-embed-utils+default-devel \
 rust-walkdir+default-devel \
 "
