# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-astropy"
PV = "7.0.1"
PR = "2.el10_2"
PACKAGES = " \
 astropy-tools \
 python3-astropy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-astropy-7.0.1-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d3ff3e81a2c23327c2e34cd96d9ca25aaaa2f3578b0f457d8b410de26440000"

URI_x86_64_v2_astropy-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/astropy-tools-7.0.1-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_astropy-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_astropy-tools}"
SRC_URI[x86_64_v2_astropy-tools.sha256sum] = "3516cbbf382ffa175a9a2e029e59eada3a481fa16f9c74acce3e0158ab7d1b8c"

URI_x86_64_v2_python3-astropy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-astropy-7.0.1-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-astropy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-astropy}"
SRC_URI[x86_64_v2_python3-astropy.sha256sum] = "f5fc0124592494654aa63e8c7b51112ad6d9346c09209e9f51bcd55bb2ae9341"

URI_aarch64_astropy-tools = "${EPEL_MIRROR}/aarch64/Packages/a/astropy-tools-7.0.1-2.el10_2.noarch.rpm;name=aarch64_astropy-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_astropy-tools}"
SRC_URI[aarch64_astropy-tools.sha256sum] = "ea140a57694c4312bb972e8cc4d6f2e4d2f1e4571138a49b47685d36aea76ffe"

URI_aarch64_python3-astropy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-astropy-7.0.1-2.el10_2.aarch64.rpm;name=aarch64_python3-astropy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-astropy}"
SRC_URI[aarch64_python3-astropy.sha256sum] = "8415c26f5dd1f32c6db49e4265af70bed05ae58ea14ef264856314317603d326"

RDEPENDS:astropy-tools = " \
 python3 \
 python3-astropy \
 "
RDEPENDS:python3-astropy = " \
 expat \
 glibc \
 python3 \
 python3-astropy-iers-data \
 python3-configobj \
 python3-numpy \
 python3-packaging \
 python3-ply \
 python3-pyerfa \
 python3-pyyaml \
 wcslib \
 "
