# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-ravif"
PV = "0.13.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-ravif+asm-devel \
 rust-ravif+default-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-ravif-0.13.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcb86b913e08487a9ba5ca6cf447336b0c84758dabd82a88e74804a46e467a97"

URI_x86_64_v2_rust-ravif+asm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+asm-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+asm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+asm-devel}"
SRC_URI[x86_64_v2_rust-ravif+asm-devel.sha256sum] = "10751ddf7086e504e95a29be77053007ce920abd5b32a21c725084063aa3f7a4"

URI_x86_64_v2_rust-ravif+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+default-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+default-devel}"
SRC_URI[x86_64_v2_rust-ravif+default-devel.sha256sum] = "a1e32cc67303f16d7026f9cce792012b2fcf638afeac24c8597f52079bd98c62"

URI_x86_64_v2_rust-ravif+threading-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif+threading-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif+threading-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif+threading-devel}"
SRC_URI[x86_64_v2_rust-ravif+threading-devel.sha256sum] = "c8e970f720373896aa1ae984762a5d56b9c9a825b0e566cb572ab66601ca493f"

URI_x86_64_v2_rust-ravif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-ravif-devel-0.13.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-ravif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-ravif-devel}"
SRC_URI[x86_64_v2_rust-ravif-devel.sha256sum] = "69f2cf29fcc96f539aa3c3a0b281ed50b1a9ffb68377522691f5f999ffcd3aa7"

URI_aarch64_rust-ravif+asm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+asm-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-ravif+asm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+asm-devel}"
SRC_URI[aarch64_rust-ravif+asm-devel.sha256sum] = "45cd28b7f181901339ce46e253add58b62d9d1b44ec13d944c5fa1abf55695f8"

URI_aarch64_rust-ravif+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+default-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-ravif+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+default-devel}"
SRC_URI[aarch64_rust-ravif+default-devel.sha256sum] = "b80b3c3d04be1e199c032c95874c8a9bdf22406a4c304cf1bc9478faaadb3c1f"

URI_aarch64_rust-ravif+threading-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif+threading-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-ravif+threading-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif+threading-devel}"
SRC_URI[aarch64_rust-ravif+threading-devel.sha256sum] = "d6b1dccfcae1d56b49ad4836330230777c92df3f28afcfd499c0d1e3d120377b"

URI_aarch64_rust-ravif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-ravif-devel-0.13.0-1.el10_3.noarch.rpm;name=aarch64_rust-ravif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-ravif-devel}"
SRC_URI[aarch64_rust-ravif-devel.sha256sum] = "5dc419dcfbcb495aeae9fc0a60a94f5b31d04a8afa7b2e703915e1cd323198c3"

RDEPENDS:rust-ravif+asm-devel = " \
 cargo \
 rust-rav1e+asm-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-ravif+default-devel = " \
 cargo \
 rust-ravif+asm-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-ravif+threading-devel = " \
 cargo \
 rust-rav1e+threading-devel \
 rust-ravif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-ravif-devel = " \
 cargo \
 rust \
 rust-avif-serialize+default-devel \
 rust-imgref+default-devel \
 rust-loop9+default-devel \
 rust-quick-error+default-devel \
 rust-rav1e-devel \
 rust-rgb-devel \
 "
