# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rust-embed-impl"
PV = "8.7.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-rust-embed-impl+debug-embed-devel \
 rust-rust-embed-impl+default-devel \
 rust-rust-embed-impl+deterministic-timestamps-devel \
 rust-rust-embed-impl+include-exclude-devel \
 rust-rust-embed-impl+interpolate-folder-path-devel \
 rust-rust-embed-impl+shellexpand-devel \
 rust-rust-embed-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rust-embed-impl-8.7.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0f596ff9bc4416baa84d7d71a874de6dbeb109b2fa8120a8ed16f6887b414b8c"

URI_x86_64_v2_rust-rust-embed-impl+debug-embed-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+debug-embed-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+debug-embed-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+debug-embed-devel.sha256sum] = "929882983ea637dd4af1399b68eff75118bba0dd11d3ba4034b197011373e67a"

URI_x86_64_v2_rust-rust-embed-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+default-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+default-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+default-devel.sha256sum] = "2fadc8648364c621a5273aa3e2b9042f360e0d72f44ff814510e10ad827625e2"

URI_x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+deterministic-timestamps-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+deterministic-timestamps-devel.sha256sum] = "68b240501f75c8634d55f8a9297b6f2493bccd344e4e6c6a187c2c274e934fc7"

URI_x86_64_v2_rust-rust-embed-impl+include-exclude-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+include-exclude-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+include-exclude-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+include-exclude-devel.sha256sum] = "77de54d53c1942098693c8a059fa946bd0b35fb3ac5af8faf2f70d5ac7f50ad0"

URI_x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+interpolate-folder-path-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+interpolate-folder-path-devel.sha256sum] = "b325d154bdbbe547134aa28598922ee032198b854787285aafb56d4f1bc841db"

URI_x86_64_v2_rust-rust-embed-impl+shellexpand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl+shellexpand-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl+shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl+shellexpand-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl+shellexpand-devel.sha256sum] = "e4de44e931f6ff9bfb580a8ab9468ff40a7eaf33901bbf1c4f4b1430967881ba"

URI_x86_64_v2_rust-rust-embed-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rust-embed-impl-devel-8.7.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rust-embed-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rust-embed-impl-devel}"
SRC_URI[x86_64_v2_rust-rust-embed-impl-devel.sha256sum] = "d4374a1344c9117101366d2c987069d76c8444b9891f1d0e117026631cba0e70"

URI_aarch64_rust-rust-embed-impl+debug-embed-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+debug-embed-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-impl+debug-embed-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+debug-embed-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+debug-embed-devel.sha256sum] = "48afcf425ad2dc92303fdb2b27c0386fea2f189d0fb997bc1675332aa3874828"

URI_aarch64_rust-rust-embed-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+default-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+default-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+default-devel.sha256sum] = "7dc0cafaecb008e7f42e5b1b243e4871859627ba8e98a362cc7eb523f950e914"

URI_aarch64_rust-rust-embed-impl+deterministic-timestamps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+deterministic-timestamps-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-impl+deterministic-timestamps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+deterministic-timestamps-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+deterministic-timestamps-devel.sha256sum] = "431867f779a8ccdb60b35bcde8d7a3445d22da8caf1f0d5640242f41be708db9"

URI_aarch64_rust-rust-embed-impl+include-exclude-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+include-exclude-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-impl+include-exclude-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+include-exclude-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+include-exclude-devel.sha256sum] = "4a27de4c8c2b21fa297632398bc096983d33fac2e9ee5ef995fadc30a1eb1917"

URI_aarch64_rust-rust-embed-impl+interpolate-folder-path-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+interpolate-folder-path-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-impl+interpolate-folder-path-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+interpolate-folder-path-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+interpolate-folder-path-devel.sha256sum] = "a72bb82f4f3580766d600857f634efe5a894045aa6615896987b1f2211317336"

URI_aarch64_rust-rust-embed-impl+shellexpand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl+shellexpand-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-impl+shellexpand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl+shellexpand-devel}"
SRC_URI[aarch64_rust-rust-embed-impl+shellexpand-devel.sha256sum] = "343dfd8a4ab063a420f875ca7f2b66b54769db2349143792c70b4ce64462dff1"

URI_aarch64_rust-rust-embed-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rust-embed-impl-devel-8.7.2-1.el10_0.noarch.rpm;name=aarch64_rust-rust-embed-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rust-embed-impl-devel}"
SRC_URI[aarch64_rust-rust-embed-impl-devel.sha256sum] = "9246501c487ad3e7cce20df5ab97a0d8aee5375a96c7557aff6dcd09097a242a"

RDEPENDS:rust-rust-embed-impl+debug-embed-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+default-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+deterministic-timestamps-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+include-exclude-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 rust-rust-embed-utils+include-exclude-devel \
 "
RDEPENDS:rust-rust-embed-impl+interpolate-folder-path-devel = " \
 cargo \
 rust-rust-embed-impl+shellexpand-devel \
 rust-rust-embed-impl-devel \
 "
RDEPENDS:rust-rust-embed-impl+shellexpand-devel = " \
 cargo \
 rust-rust-embed-impl-devel \
 rust-shellexpand+default-devel \
 "
RDEPENDS:rust-rust-embed-impl-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-rust-embed-utils+default-devel \
 rust-syn+derive-devel \
 rust-syn+parsing-devel \
 rust-syn+printing-devel \
 rust-syn+proc-macro-devel \
 rust-syn-devel \
 rust-walkdir+default-devel \
 "
