# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-CSS-Tiny"
PV = "1.20"
PR = "26.el10_0"
PACKAGES = " \
 perl-CSS-Tiny \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-CSS-Tiny-1.20-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8464f3374a421e8f4666512aedf7ac7d777d66ca86d82f0c3ae8beb9c3837ebc"

URI_x86_64_v2_perl-CSS-Tiny = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-CSS-Tiny-1.20-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-CSS-Tiny;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-CSS-Tiny}"
SRC_URI[x86_64_v2_perl-CSS-Tiny.sha256sum] = "ef511fe8fa4c1f4a608779bfa6b876bcd8399fc02bbd12f9501241cdcfe28931"

URI_aarch64_perl-CSS-Tiny = "${EPEL_MIRROR}/aarch64/Packages/p/perl-CSS-Tiny-1.20-26.el10_0.noarch.rpm;name=aarch64_perl-CSS-Tiny;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-CSS-Tiny}"
SRC_URI[aarch64_perl-CSS-Tiny.sha256sum] = "aba2bd184ae3821a5f4a7e36c74aec93699d99db0b6f58c0aca3252c483e4274"

RDEPENDS:perl-CSS-Tiny = " \
 perl-Clone \
 perl-libs \
 "
