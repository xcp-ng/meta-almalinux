# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wayland"
PV = "1.24.0"
PR = "1.el10"
PACKAGES = " \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 wayland-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/wayland-1.24.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a7742712cd2232936724194f0b95dc014486a23fe7539693237be1f844567ed0"

URI_x86_64_v2_libwayland-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-client-1.24.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-client}"
SRC_URI[x86_64_v2_libwayland-client.sha256sum] = "925f478d738324e46b4b58b6c5f5b65ca13454d4ed836365932e7bd93d3a58fd"

URI_x86_64_v2_libwayland-cursor = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-cursor-1.24.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-cursor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-cursor}"
SRC_URI[x86_64_v2_libwayland-cursor.sha256sum] = "ad8277d23742c0f07ccb3a8017ea5293ddc79d1b5db683ebc0e549c42aceab2e"

URI_x86_64_v2_libwayland-egl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-egl-1.24.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-egl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-egl}"
SRC_URI[x86_64_v2_libwayland-egl.sha256sum] = "f93948672408cdcc2b3ea2b420e13a3531c566badb349e64db4ae64236d6169f"

URI_x86_64_v2_libwayland-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libwayland-server-1.24.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_libwayland-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libwayland-server}"
SRC_URI[x86_64_v2_libwayland-server.sha256sum] = "47ec3d9403df7cebaa6851e26410e21057025d2478e9d085a7d77a07109cf4ce"

URI_x86_64_v2_wayland-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/wayland-devel-1.24.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_wayland-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_wayland-devel}"
SRC_URI[x86_64_v2_wayland-devel.sha256sum] = "0ef39ced5a0b5012231da4d91b3f6a71dba1fe3c196fff6327f3b326f331d30e"

URI_aarch64_libwayland-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-client-1.24.0-1.el10.aarch64.rpm;name=aarch64_libwayland-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-client}"
SRC_URI[aarch64_libwayland-client.sha256sum] = "a5d2b8a60987d6dd0d7c0da8e53eda1c1503075f7b3fc9e63206dfbd50e0b728"

URI_aarch64_libwayland-cursor = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-cursor-1.24.0-1.el10.aarch64.rpm;name=aarch64_libwayland-cursor;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-cursor}"
SRC_URI[aarch64_libwayland-cursor.sha256sum] = "52ad3c8ea6a4611a04d8f61004e905e0f7d6ddcc1ee0bfc0a7531f525658d209"

URI_aarch64_libwayland-egl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-egl-1.24.0-1.el10.aarch64.rpm;name=aarch64_libwayland-egl;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-egl}"
SRC_URI[aarch64_libwayland-egl.sha256sum] = "68a395755d0e22ad909b5099b5d0fb10d2f77bc3363f0d15240518b29c5b4cc9"

URI_aarch64_libwayland-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libwayland-server-1.24.0-1.el10.aarch64.rpm;name=aarch64_libwayland-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_libwayland-server}"
SRC_URI[aarch64_libwayland-server.sha256sum] = "db3a8020f482d5c13220a6c0b1693e06b4392e753d45283a90e303130d084648"

URI_aarch64_wayland-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/wayland-devel-1.24.0-1.el10.aarch64.rpm;name=aarch64_wayland-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_wayland-devel}"
SRC_URI[aarch64_wayland-devel.sha256sum] = "0e8b0198656db19b8e7e959c07d804f37366cddc04559c97b2120dc770012386"

RDEPENDS:libwayland-client = " \
 glibc \
 libffi \
 "
RDEPENDS:libwayland-cursor = " \
 glibc \
 libwayland-client \
 "
RDEPENDS:libwayland-egl = " \
 glibc \
 "
RDEPENDS:libwayland-server = " \
 glibc \
 libffi \
 "
RDEPENDS:wayland-devel = " \
 expat \
 glibc \
 libffi-devel \
 libwayland-client \
 libwayland-cursor \
 libwayland-egl \
 libwayland-server \
 libxml2 \
 pkgconf-pkg-config \
 wayland-devel \
 "
