# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rpm-ostree"
PV = "2026.3"
PR = "2.el10_2"
PACKAGES = " \
 rpm-ostree \
 rpm-ostree-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rpm-ostree-2026.3-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "95be20459bee1ec827607cfe405293379cdff691a54cef19983bd7d47ef0a730"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-2026.3-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree;unpack=0"
SRC_URI[x86_64_v2_rpm-ostree.sha256sum] = "8814220e9a5b5bb760617f1bba36c373b57847f12411250d524ba3d38a639557"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/rpm-ostree-libs-2026.3-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_rpm-ostree-libs;unpack=0"
SRC_URI[x86_64_v2_rpm-ostree-libs.sha256sum] = "2b4b5b848f74eb12fa36237939d7a70653c3f601598adf0e4bd4c9e03c0b50b0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-2026.3-2.el10_2.aarch64.rpm;name=aarch64_rpm-ostree;unpack=0"
SRC_URI[aarch64_rpm-ostree.sha256sum] = "f7e217f93f73260c4fa03bfc76cbb1b64f3286e5c10cf147ae72b7d49253cf36"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/rpm-ostree-libs-2026.3-2.el10_2.aarch64.rpm;name=aarch64_rpm-ostree-libs;unpack=0"
SRC_URI[aarch64_rpm-ostree-libs.sha256sum] = "45cdf79ddcabaac39f63c5d83b02edaae4b004a0b04bc1f39630c0922350ab8d"

RDEPENDS:rpm-ostree = " \
 bash \
 bootc \
 bubblewrap \
 fuse3 \
 glib2 \
 glibc \
 json-c \
 json-glib \
 libarchive \
 libcap \
 libgcc \
 libmodulemd \
 librepo \
 libsolv \
 libstdc++ \
 libzstd \
 openssl-libs \
 ostree \
 ostree-libs \
 pcre2 \
 polkit-libs \
 rpm-libs \
 rpm-ostree-libs \
 skopeo \
 sqlite-libs \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:rpm-ostree-libs = " \
 glib2 \
 glibc \
 json-glib \
 libgcc \
 ostree-libs \
 popt \
 rpm-libs \
 "
