# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "artwiz-aleczapka-fonts"
PV = "1.3"
PR = "40.el10_0"
PACKAGES = " \
 artwiz-aleczapka-anorexia-fonts \
 artwiz-aleczapka-aqui-fonts \
 artwiz-aleczapka-cure-fonts \
 artwiz-aleczapka-drift-fonts \
 artwiz-aleczapka-edges-fonts \
 artwiz-aleczapka-fkp-fonts \
 artwiz-aleczapka-fonts \
 artwiz-aleczapka-fonts-common \
 artwiz-aleczapka-gelly-fonts \
 artwiz-aleczapka-glisp-fonts \
 artwiz-aleczapka-kates-fonts \
 artwiz-aleczapka-lime-fonts \
 artwiz-aleczapka-mints-mild-fonts \
 artwiz-aleczapka-mints-strong-fonts \
 artwiz-aleczapka-nu-fonts \
 artwiz-aleczapka-smoothansi-fonts \
 artwiz-aleczapka-snap-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/artwiz-aleczapka-fonts-1.3-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "796a797eabfaefafc4c32660e7094411f37dab5351b7a9f9572bc9b3786a0bd5"

URI_x86_64_v2_artwiz-aleczapka-anorexia-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-anorexia-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-anorexia-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-anorexia-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-anorexia-fonts.sha256sum] = "aff3c3af2f5d640283b6cec979e5c010d1b2f99fc9773a31d4ec09b2bbf85e4b"

URI_x86_64_v2_artwiz-aleczapka-aqui-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-aqui-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-aqui-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-aqui-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-aqui-fonts.sha256sum] = "f52e5db20f397c755930bf6c4984e2b9ce2c6a8aa68eeb795461d08bb60f70f8"

URI_x86_64_v2_artwiz-aleczapka-cure-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-cure-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-cure-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-cure-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-cure-fonts.sha256sum] = "f063efb52226307411d433b1cb9815946ffd3efcff19e17e299f4bb39d43f6f6"

URI_x86_64_v2_artwiz-aleczapka-drift-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-drift-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-drift-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-drift-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-drift-fonts.sha256sum] = "e3fcf349bcb374069ac75b7361f8925ea33a84b3a494dc65053af1e72ad5d8dd"

URI_x86_64_v2_artwiz-aleczapka-edges-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-edges-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-edges-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-edges-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-edges-fonts.sha256sum] = "1efbc7b44ac18fc88961bfda13176933ca89cca0d21901e6b3d6c4c63d5d5f2b"

URI_x86_64_v2_artwiz-aleczapka-fkp-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-fkp-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-fkp-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-fkp-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-fkp-fonts.sha256sum] = "b61b741f92744496e74ceaa81214fd63963679f714a5b1ebdfb08ad7766150c5"

URI_x86_64_v2_artwiz-aleczapka-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-fonts.sha256sum] = "302c93150bd51bc47fa12a5eb30b85a6515b66fee944776b30114092716b2d22"

URI_x86_64_v2_artwiz-aleczapka-fonts-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-fonts-common-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-fonts-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-fonts-common}"
SRC_URI[x86_64_v2_artwiz-aleczapka-fonts-common.sha256sum] = "b2103e4779a0c8197938db2cb43de2fb2960a61e3eb68d394d8e76b9f0fa1ae7"

URI_x86_64_v2_artwiz-aleczapka-gelly-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-gelly-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-gelly-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-gelly-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-gelly-fonts.sha256sum] = "93e2111ebb82bc3ef6bfdd17165cf65c3c618abae39f9f99a6aad838b0899db6"

URI_x86_64_v2_artwiz-aleczapka-glisp-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-glisp-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-glisp-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-glisp-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-glisp-fonts.sha256sum] = "3356b49f3ecb7ed6caf36ec604676b5165cf85177f5639eec403cae8dcd4b06d"

URI_x86_64_v2_artwiz-aleczapka-kates-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-kates-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-kates-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-kates-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-kates-fonts.sha256sum] = "71cd9540bf0eaacd311ddc9ad8eff644350ab35df664a450bab4a9d1759a6739"

URI_x86_64_v2_artwiz-aleczapka-lime-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-lime-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-lime-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-lime-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-lime-fonts.sha256sum] = "90e23ddd59500812ab1cc6de2b5efe3f6082a0cd235e88375b11ead7d3e6a808"

URI_x86_64_v2_artwiz-aleczapka-mints-mild-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-mints-mild-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-mints-mild-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-mints-mild-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-mints-mild-fonts.sha256sum] = "41d9eb24b499380150ef3c065b809b962e589b85a6c0656621040e35d2542abe"

URI_x86_64_v2_artwiz-aleczapka-mints-strong-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-mints-strong-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-mints-strong-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-mints-strong-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-mints-strong-fonts.sha256sum] = "7216a5fed179b6c65ff4c92406753bf35112247e5126c9267216bd14cd332c93"

URI_x86_64_v2_artwiz-aleczapka-nu-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-nu-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-nu-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-nu-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-nu-fonts.sha256sum] = "8f34bb8f8123ef827640a71b5eba538075f1457cacdddd31c2b8350f986f04c1"

URI_x86_64_v2_artwiz-aleczapka-smoothansi-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-smoothansi-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-smoothansi-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-smoothansi-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-smoothansi-fonts.sha256sum] = "7dcd3f66bc09402e3ba14247dcc34ce851d40cd9c3c99e980a168765d99b83ae"

URI_x86_64_v2_artwiz-aleczapka-snap-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/artwiz-aleczapka-snap-fonts-1.3-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_artwiz-aleczapka-snap-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_artwiz-aleczapka-snap-fonts}"
SRC_URI[x86_64_v2_artwiz-aleczapka-snap-fonts.sha256sum] = "21c516e08f7e93bd3c72e09407ed4a9942f39767fd602eedd256e07069443c3e"

URI_aarch64_artwiz-aleczapka-anorexia-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-anorexia-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-anorexia-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-anorexia-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-anorexia-fonts.sha256sum] = "4503d699aec6ab685c5127e5a62cbf6a0ffc20c5d186e85f3fe4e66a6b3a5b5d"

URI_aarch64_artwiz-aleczapka-aqui-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-aqui-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-aqui-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-aqui-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-aqui-fonts.sha256sum] = "b054bf0689e14e87449dbe517c7a47101fb0b22f34fdb254a40eda13c43feaeb"

URI_aarch64_artwiz-aleczapka-cure-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-cure-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-cure-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-cure-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-cure-fonts.sha256sum] = "ba2fa8b4cdb34f611eeaf8bf31d20aa4c6f101bcc97f7ed344413cb30be4221f"

URI_aarch64_artwiz-aleczapka-drift-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-drift-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-drift-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-drift-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-drift-fonts.sha256sum] = "c637e125478882245e4804ca167e0b4505b916ac4473588993bddcae3b40a90f"

URI_aarch64_artwiz-aleczapka-edges-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-edges-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-edges-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-edges-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-edges-fonts.sha256sum] = "270356e0d645dc53984c78ca95e2a6e6a226ff9152c9b949e662ae547f03e2ed"

URI_aarch64_artwiz-aleczapka-fkp-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-fkp-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-fkp-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-fkp-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-fkp-fonts.sha256sum] = "77f372878b8bde07041b64d49c536ac4b653a6c8bcb906624b6c57e7d4e895cc"

URI_aarch64_artwiz-aleczapka-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-fonts.sha256sum] = "1763c1aa31b1ab3783503b5f439828a7b10c4687ca613b4fba28bc3a18ce2e53"

URI_aarch64_artwiz-aleczapka-fonts-common = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-fonts-common-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-fonts-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-fonts-common}"
SRC_URI[aarch64_artwiz-aleczapka-fonts-common.sha256sum] = "7560e168f5d2e83879839b6d5bc9a01da25b4c6a6e70c38730392ab57180c09c"

URI_aarch64_artwiz-aleczapka-gelly-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-gelly-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-gelly-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-gelly-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-gelly-fonts.sha256sum] = "5da984b966c3c44e121620ef44412dad173cbebf11d11ff5b55edcfc26270c0e"

URI_aarch64_artwiz-aleczapka-glisp-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-glisp-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-glisp-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-glisp-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-glisp-fonts.sha256sum] = "af023b50ecfd3feff334fc2669a18412bab684df1ba941c2807fa5f5268bc1d6"

URI_aarch64_artwiz-aleczapka-kates-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-kates-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-kates-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-kates-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-kates-fonts.sha256sum] = "84e2c26e2c85d390c4dca2f2dd58c6fe98c169a22216c6c97bed6ccbeff66cc1"

URI_aarch64_artwiz-aleczapka-lime-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-lime-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-lime-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-lime-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-lime-fonts.sha256sum] = "dd95552e1e1ddc1ed6abbace702e0961d5bc4fcf99269b8849fd0f579555f646"

URI_aarch64_artwiz-aleczapka-mints-mild-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-mints-mild-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-mints-mild-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-mints-mild-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-mints-mild-fonts.sha256sum] = "2785ce569356b7698ea9852c9168926eada551c1d788b94ef807c1ad145d167f"

URI_aarch64_artwiz-aleczapka-mints-strong-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-mints-strong-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-mints-strong-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-mints-strong-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-mints-strong-fonts.sha256sum] = "cdfd4c9983edd137df4c0013a22bc52ac4ce2299754e43c537c73ebcd179b188"

URI_aarch64_artwiz-aleczapka-nu-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-nu-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-nu-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-nu-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-nu-fonts.sha256sum] = "c0b7a40f93b580e092b88b6c990756841597a9ffad6cb44a61985716ff10dd8d"

URI_aarch64_artwiz-aleczapka-smoothansi-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-smoothansi-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-smoothansi-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-smoothansi-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-smoothansi-fonts.sha256sum] = "09ef637158d0ef541768993fcf6bb9a2613ce21f44541eaffdaa61e1ea4c47b9"

URI_aarch64_artwiz-aleczapka-snap-fonts = "${EPEL_MIRROR}/aarch64/Packages/a/artwiz-aleczapka-snap-fonts-1.3-40.el10_0.noarch.rpm;name=aarch64_artwiz-aleczapka-snap-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_artwiz-aleczapka-snap-fonts}"
SRC_URI[aarch64_artwiz-aleczapka-snap-fonts.sha256sum] = "3721735c559e4597daa39c1ad9687863f771667b688ec6f5c94534a550497afd"

RDEPENDS:artwiz-aleczapka-anorexia-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-aqui-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-cure-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-drift-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-edges-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-fkp-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-fonts = " \
 artwiz-aleczapka-anorexia-fonts \
 artwiz-aleczapka-aqui-fonts \
 artwiz-aleczapka-cure-fonts \
 artwiz-aleczapka-drift-fonts \
 artwiz-aleczapka-edges-fonts \
 artwiz-aleczapka-fkp-fonts \
 artwiz-aleczapka-gelly-fonts \
 artwiz-aleczapka-glisp-fonts \
 artwiz-aleczapka-kates-fonts \
 artwiz-aleczapka-lime-fonts \
 artwiz-aleczapka-mints-mild-fonts \
 artwiz-aleczapka-mints-strong-fonts \
 artwiz-aleczapka-nu-fonts \
 artwiz-aleczapka-smoothansi-fonts \
 artwiz-aleczapka-snap-fonts \
 "
RDEPENDS:artwiz-aleczapka-fonts-common = " \
 fonts-filesystem \
 "
RDEPENDS:artwiz-aleczapka-gelly-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-glisp-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-kates-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-lime-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-mints-mild-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-mints-strong-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-nu-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-smoothansi-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
RDEPENDS:artwiz-aleczapka-snap-fonts = " \
 artwiz-aleczapka-fonts-common \
 "
