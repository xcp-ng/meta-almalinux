# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-fastavro"
PV = "1.12.1"
PR = "1.el10_1"
PACKAGES = " \
 python-fastavro-doc \
 python3-fastavro \
 python3-fastavro+codecs \
 python3-fastavro+lz4 \
 python3-fastavro+snappy \
 python3-fastavro+zstandard \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-fastavro-1.12.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b72245d19ced7a658b57895f8b9c6de6f4445c1a44c8fa73d4c0b3e3b30f0d16"

URI_x86_64_v2_python-fastavro-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-fastavro-doc-1.12.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-fastavro-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-fastavro-doc}"
SRC_URI[x86_64_v2_python-fastavro-doc.sha256sum] = "384c35950b1ef150ab55a0e5e22554365de651183213c2775a4d8b7a51c99455"

URI_x86_64_v2_python3-fastavro = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro-1.12.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro}"
SRC_URI[x86_64_v2_python3-fastavro.sha256sum] = "214a4943804b60787216858d70d16ca4aebd1775a608e2218fbdb621994288aa"

URI_x86_64_v2_python3-fastavro+codecs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+codecs-1.12.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+codecs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+codecs}"
SRC_URI[x86_64_v2_python3-fastavro+codecs.sha256sum] = "f0886a3341a97376878eb82d37921173ad7c77f3a6d6b0a52eca71facb9bb77b"

URI_x86_64_v2_python3-fastavro+lz4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+lz4-1.12.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+lz4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+lz4}"
SRC_URI[x86_64_v2_python3-fastavro+lz4.sha256sum] = "b2f98c73bf708496bbe4b2b16ff1c13cfd787101609011831106bb1dbf25afac"

URI_x86_64_v2_python3-fastavro+snappy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+snappy-1.12.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+snappy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+snappy}"
SRC_URI[x86_64_v2_python3-fastavro+snappy.sha256sum] = "3afe39b2fc96fc650da4c655b9c38456214b98d5547f60da87bbee59de5f0b0f"

URI_x86_64_v2_python3-fastavro+zstandard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-fastavro+zstandard-1.12.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-fastavro+zstandard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-fastavro+zstandard}"
SRC_URI[x86_64_v2_python3-fastavro+zstandard.sha256sum] = "ac6167460466c4b4c62f3454e82fdc1564711cda2582d0d3aa1a8336418eeda0"

URI_aarch64_python-fastavro-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-fastavro-doc-1.12.1-1.el10_1.aarch64.rpm;name=aarch64_python-fastavro-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-fastavro-doc}"
SRC_URI[aarch64_python-fastavro-doc.sha256sum] = "4f39cab1e79281bd20e6c43d5af308ef6b5d1f382e286b0efcab47502b054774"

URI_aarch64_python3-fastavro = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro-1.12.1-1.el10_1.aarch64.rpm;name=aarch64_python3-fastavro;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro}"
SRC_URI[aarch64_python3-fastavro.sha256sum] = "0d9a4cf5934258bccf4c80b02162a3b1cb62e182bac8ebc2accbff208ae8c742"

URI_aarch64_python3-fastavro+codecs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+codecs-1.12.1-1.el10_1.aarch64.rpm;name=aarch64_python3-fastavro+codecs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+codecs}"
SRC_URI[aarch64_python3-fastavro+codecs.sha256sum] = "b06a046bacc0eea3376afa00694e15c8de1740a4fee6345a38b9ae9d26a0dc3f"

URI_aarch64_python3-fastavro+lz4 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+lz4-1.12.1-1.el10_1.aarch64.rpm;name=aarch64_python3-fastavro+lz4;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+lz4}"
SRC_URI[aarch64_python3-fastavro+lz4.sha256sum] = "6806ec9b5b53017f962c521de53e9a679df80c9be512e8b907d488b496d0693d"

URI_aarch64_python3-fastavro+snappy = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+snappy-1.12.1-1.el10_1.aarch64.rpm;name=aarch64_python3-fastavro+snappy;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+snappy}"
SRC_URI[aarch64_python3-fastavro+snappy.sha256sum] = "a3894c4adb7b7329082b807c8bbf336c08a93dadc47c7fa33a47dcdaf3ea0932"

URI_aarch64_python3-fastavro+zstandard = "${EPEL_MIRROR}/aarch64/Packages/p/python3-fastavro+zstandard-1.12.1-1.el10_1.aarch64.rpm;name=aarch64_python3-fastavro+zstandard;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-fastavro+zstandard}"
SRC_URI[aarch64_python3-fastavro+zstandard.sha256sum] = "59cfea6bc2307eabefa9dc5cf3270194e53ab57130eaa4258cdda65e9262ef95"

RDEPENDS:python-fastavro-doc = " \
 "
RDEPENDS:python3-fastavro = " \
 glibc \
 python3 \
 "
RDEPENDS:python3-fastavro+codecs = " \
 python3 \
 python3-cramjam \
 python3-fastavro \
 python3-lz4 \
 python3-zstandard \
 "
RDEPENDS:python3-fastavro+lz4 = " \
 python3 \
 python3-fastavro \
 python3-lz4 \
 "
RDEPENDS:python3-fastavro+snappy = " \
 python3 \
 python3-cramjam \
 python3-fastavro \
 "
RDEPENDS:python3-fastavro+zstandard = " \
 python3 \
 python3-fastavro \
 python3-zstandard \
 "
