# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-publicsuffix"
PV = "2.2.3"
PR = "6.el10_0"
PACKAGES = " \
 rust-publicsuffix+anycase-devel \
 rust-publicsuffix+default-devel \
 rust-publicsuffix+hashbrown-devel \
 rust-publicsuffix+idna-devel \
 rust-publicsuffix+punycode-devel \
 rust-publicsuffix+std-devel \
 rust-publicsuffix+unicase-devel \
 rust-publicsuffix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-publicsuffix-2.2.3-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d18118173ab357a97f81a37af082b1333d26e6de002441a141af238f676b1c87"

URI_x86_64_v2_rust-publicsuffix+anycase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+anycase-devel-2.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+anycase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+anycase-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+anycase-devel.sha256sum] = "a142ddd2e5bd0ba2eb1c4c9363777a6bbcf35042d7caf0ef0e121875df3431f4"

URI_x86_64_v2_rust-publicsuffix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+default-devel-2.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+default-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+default-devel.sha256sum] = "59e119ce5fdfb1b66e7eb0b201faac238752919c353962becba0dc92ecd7ae44"

URI_x86_64_v2_rust-publicsuffix+hashbrown-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+hashbrown-devel-2.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+hashbrown-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+hashbrown-devel.sha256sum] = "cff51f968b8ac9672078a7994ebb823d1070163bfbdac26cb095dbabb67d0aab"

URI_x86_64_v2_rust-publicsuffix+idna-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+idna-devel-2.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+idna-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+idna-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+idna-devel.sha256sum] = "b2b07b6e89f6417cc46ac15843c6d8bfd18915cda572395cf46e64417d3891a6"

URI_x86_64_v2_rust-publicsuffix+punycode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+punycode-devel-2.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+punycode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+punycode-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+punycode-devel.sha256sum] = "a71b37e0bc7600c17be5592040bf794677a30c73e62688accbf126a938d014e5"

URI_x86_64_v2_rust-publicsuffix+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+std-devel-2.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+std-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+std-devel.sha256sum] = "64985379864a37ce1f3ec9c63fe42c095d89abdff80a4fe3bced2a804515b081"

URI_x86_64_v2_rust-publicsuffix+unicase-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix+unicase-devel-2.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix+unicase-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix+unicase-devel.sha256sum] = "8918dd5faad12017f9db8e489774d0737ffbec177cb905981e0bf4d74c9a6f76"

URI_x86_64_v2_rust-publicsuffix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-publicsuffix-devel-2.2.3-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-publicsuffix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-publicsuffix-devel}"
SRC_URI[x86_64_v2_rust-publicsuffix-devel.sha256sum] = "73dbcea9d9253e4027e31049f9c9d8070426d15fade3b4d3fd6cd830cf87beba"

URI_aarch64_rust-publicsuffix+anycase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+anycase-devel-2.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-publicsuffix+anycase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+anycase-devel}"
SRC_URI[aarch64_rust-publicsuffix+anycase-devel.sha256sum] = "5633f142d395bde8efd715b866f02457921097c8d4b92926d117453a6cbcf847"

URI_aarch64_rust-publicsuffix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+default-devel-2.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-publicsuffix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+default-devel}"
SRC_URI[aarch64_rust-publicsuffix+default-devel.sha256sum] = "769dca061731ac89f73696d520541dc74dc7f63dae8b616691a4e09051b85b8c"

URI_aarch64_rust-publicsuffix+hashbrown-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+hashbrown-devel-2.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-publicsuffix+hashbrown-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+hashbrown-devel}"
SRC_URI[aarch64_rust-publicsuffix+hashbrown-devel.sha256sum] = "71021f8e74b4f74852d3248a1a20103ba093d795f22497701b68aa32152d0d73"

URI_aarch64_rust-publicsuffix+idna-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+idna-devel-2.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-publicsuffix+idna-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+idna-devel}"
SRC_URI[aarch64_rust-publicsuffix+idna-devel.sha256sum] = "d21ad3b94dbacce62e2dc4338c53d05022ae913d95c4af89167ab531fbf2cf60"

URI_aarch64_rust-publicsuffix+punycode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+punycode-devel-2.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-publicsuffix+punycode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+punycode-devel}"
SRC_URI[aarch64_rust-publicsuffix+punycode-devel.sha256sum] = "696c4acfff6a240faf5011f8c7871b5fd04ff3acb3d6e2b8d2c8141977cf9e2c"

URI_aarch64_rust-publicsuffix+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+std-devel-2.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-publicsuffix+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+std-devel}"
SRC_URI[aarch64_rust-publicsuffix+std-devel.sha256sum] = "e6397a57eb6dc508736c29e985cce932ba1d9e9fb5acd6065275b00fc8c3745e"

URI_aarch64_rust-publicsuffix+unicase-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix+unicase-devel-2.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-publicsuffix+unicase-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix+unicase-devel}"
SRC_URI[aarch64_rust-publicsuffix+unicase-devel.sha256sum] = "cf13d98e16ae4e03f23bdb5cf182ebfef70bc557c8489018e54e20769595cb8b"

URI_aarch64_rust-publicsuffix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-publicsuffix-devel-2.2.3-6.el10_0.noarch.rpm;name=aarch64_rust-publicsuffix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-publicsuffix-devel}"
SRC_URI[aarch64_rust-publicsuffix-devel.sha256sum] = "9b090e4c9b2726af5384b6a75cca75e82a26dc8ac01a63ea541111276f408a4b"

RDEPENDS:rust-publicsuffix+anycase-devel = " \
 cargo \
 rust-publicsuffix+unicase-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+default-devel = " \
 cargo \
 rust-publicsuffix+punycode-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+hashbrown-devel = " \
 cargo \
 rust-hashbrown0.12+default-devel \
 rust-hashbrown0.12+inline-more-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+idna-devel = " \
 cargo \
 rust-idna0.4+default-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+punycode-devel = " \
 cargo \
 rust-publicsuffix+idna-devel \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+std-devel = " \
 cargo \
 rust-publicsuffix-devel \
 "
RDEPENDS:rust-publicsuffix+unicase-devel = " \
 cargo \
 rust-publicsuffix-devel \
 rust-unicase-devel \
 "
RDEPENDS:rust-publicsuffix-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
