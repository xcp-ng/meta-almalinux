# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-volcengine-tos"
PV = "3.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-volcengine-tos+default-devel \
 rust-reqsign-volcengine-tos-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-volcengine-tos-3.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e3efed627c690d41ce42e01819feec72e040821e4f61aff5d52c39b6435d9350"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-volcengine-tos+default-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-volcengine-tos+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-volcengine-tos+default-devel.sha256sum] = "61fda1f1ea8854866c4987fd991b76f690a65c0c8fa4921b1fc3d9cf59e73c59"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-volcengine-tos-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-volcengine-tos-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-volcengine-tos-devel.sha256sum] = "af218546bf75d665794a799fea32ec221c55fd88bb70953e4b0e99021047be11"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-volcengine-tos+default-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-volcengine-tos+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-volcengine-tos+default-devel.sha256sum] = "38606baf2787c88d553b2c8a00a4c051bca3d169a43e479f0dc9cf90d1fb9666"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-volcengine-tos-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-volcengine-tos-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-volcengine-tos-devel.sha256sum] = "c14e91a6893d0df4a39f263273d95d3cd7c901e9dc0a0cac973dfd75e24bb2e1"

RDEPENDS:rust-reqsign-volcengine-tos+default-devel = " \
 cargo \
 rust-reqsign-volcengine-tos-devel \
 "
RDEPENDS:rust-reqsign-volcengine-tos-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 "
