# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-WWW-RobotRules"
PV = "6.02"
PR = "41.el10"
PACKAGES = " \
 perl-WWW-RobotRules \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-WWW-RobotRules-6.02-41.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a3272f3875fd4b082c9b8df135f0efb4dff8985300dbcf768798f687549ce0c6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-WWW-RobotRules-6.02-41.el10.noarch.rpm;name=x86_64_v2_perl-WWW-RobotRules;unpack=0"
SRC_URI[x86_64_v2_perl-WWW-RobotRules.sha256sum] = "a73e89b27fa10458526a2f36a5fecbb07af4f408ef5d29686242666abf01ee66"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-WWW-RobotRules-6.02-41.el10.noarch.rpm;name=aarch64_perl-WWW-RobotRules;unpack=0"
SRC_URI[aarch64_perl-WWW-RobotRules.sha256sum] = "a73e89b27fa10458526a2f36a5fecbb07af4f408ef5d29686242666abf01ee66"

RDEPENDS:perl-WWW-RobotRules = " \
 perl-Carp \
 perl-Fcntl \
 perl-URI \
 perl-WWW-RobotRules \
 perl-libs \
 perl-vars \
 "
