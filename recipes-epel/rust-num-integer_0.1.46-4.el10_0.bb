# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-integer"
PV = "0.1.46"
PR = "4.el10_0"
PACKAGES = " \
 rust-num-integer+default-devel \
 rust-num-integer+i128-devel \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-integer-0.1.46-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eee6d5ae41088e894bcf2c5e9c0f0506bbaa05e241c1bc0da55d360a1eed326a"

URI_x86_64_v2_rust-num-integer+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+default-devel-0.1.46-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-integer+default-devel}"
SRC_URI[x86_64_v2_rust-num-integer+default-devel.sha256sum] = "cdb95c94e325fee6cab669f16f04a9f9439fedf7297e0eaaaa3bfa0c6298d3c5"

URI_x86_64_v2_rust-num-integer+i128-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+i128-devel-0.1.46-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+i128-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-integer+i128-devel}"
SRC_URI[x86_64_v2_rust-num-integer+i128-devel.sha256sum] = "59cfc4327d6d039e55a360e656efbabb944540553d83491a2f913166494c0843"

URI_x86_64_v2_rust-num-integer+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer+std-devel-0.1.46-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-integer+std-devel}"
SRC_URI[x86_64_v2_rust-num-integer+std-devel.sha256sum] = "07146174638e77ca1fbf4c8fbf9a9d194453cbef1788efbb39a6c9955e87495b"

URI_x86_64_v2_rust-num-integer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-integer-devel-0.1.46-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-integer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-integer-devel}"
SRC_URI[x86_64_v2_rust-num-integer-devel.sha256sum] = "26839b54877c24167b8b34d58c2859dd9828392243076bb245836270a00c05f9"

URI_aarch64_rust-num-integer+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+default-devel-0.1.46-4.el10_0.noarch.rpm;name=aarch64_rust-num-integer+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-integer+default-devel}"
SRC_URI[aarch64_rust-num-integer+default-devel.sha256sum] = "b06c52ba7553cfd0d8bcab1c80a72640ce9e8713dc9d4e2e311839ca886e89ae"

URI_aarch64_rust-num-integer+i128-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+i128-devel-0.1.46-4.el10_0.noarch.rpm;name=aarch64_rust-num-integer+i128-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-integer+i128-devel}"
SRC_URI[aarch64_rust-num-integer+i128-devel.sha256sum] = "930279af88b02e03e58befd76df2e9d5a0aa033b2e0874265a35fb40e3831067"

URI_aarch64_rust-num-integer+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer+std-devel-0.1.46-4.el10_0.noarch.rpm;name=aarch64_rust-num-integer+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-integer+std-devel}"
SRC_URI[aarch64_rust-num-integer+std-devel.sha256sum] = "a52c7ca42410c0f37c3dce94522b2f580ebeb24e3af284550ee9a5613fad6d7e"

URI_aarch64_rust-num-integer-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-integer-devel-0.1.46-4.el10_0.noarch.rpm;name=aarch64_rust-num-integer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-integer-devel}"
SRC_URI[aarch64_rust-num-integer-devel.sha256sum] = "def506fd06a6471e871d175f7ddbe1aba61d0345ac728658a657e5bf8431afa3"

RDEPENDS:rust-num-integer+default-devel = " \
 cargo \
 rust-num-integer+std-devel \
 rust-num-integer-devel \
 "
RDEPENDS:rust-num-integer+i128-devel = " \
 cargo \
 rust-num-integer-devel \
 "
RDEPENDS:rust-num-integer+std-devel = " \
 cargo \
 rust-num-integer-devel \
 rust-num-traits+std-devel \
 "
RDEPENDS:rust-num-integer-devel = " \
 cargo \
 rust \
 rust-num-traits+i128-devel \
 rust-num-traits-devel \
 "
