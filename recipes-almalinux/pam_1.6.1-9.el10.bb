# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam"
PV = "1.6.1"
PR = "9.el10"
PACKAGES = " \
 pam \
 pam-devel \
 pam-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pam-1.6.1-9.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7adbdf922e92336434579363d21bf0ea1a6f55d55dc3e2355925732a98db83d1"

URI_x86_64_v2_pam = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-1.6.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam}"
SRC_URI[x86_64_v2_pam.sha256sum] = "603a4459d792118ac257e036b06eb318d0d25f525249f4ad2b376b76772bb130"

URI_x86_64_v2_pam-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam-devel-1.6.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_pam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-devel}"
SRC_URI[x86_64_v2_pam-devel.sha256sum] = "e30d50156cc8020fc91ea1d716c829de7bb40a458edc074c32c1ad50a016b33a"

URI_x86_64_v2_pam-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-libs-1.6.1-9.el10.x86_64_v2.rpm;name=x86_64_v2_pam-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-libs}"
SRC_URI[x86_64_v2_pam-libs.sha256sum] = "31f58cccb7346fe1462fb3acdced8347c702ee2821fc91c7e762e684ee307934"

URI_aarch64_pam = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-1.6.1-9.el10.aarch64.rpm;name=aarch64_pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam}"
SRC_URI[aarch64_pam.sha256sum] = "d441abae09a4528ff85c88448bd3d6dbeafdc51ba884b6881909b54c1fe8da4b"

URI_aarch64_pam-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam-devel-1.6.1-9.el10.aarch64.rpm;name=aarch64_pam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-devel}"
SRC_URI[aarch64_pam-devel.sha256sum] = "3a6b5030373768b1a5fcd04bcbb23d9793b189d4949368c27bc288400e7e9f10"

URI_aarch64_pam-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-libs-1.6.1-9.el10.aarch64.rpm;name=aarch64_pam-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-libs}"
SRC_URI[aarch64_pam-libs.sha256sum] = "79f5deca2a3dd11950131a0b36f8907f37a11e82e66287358de1b0a0ce37eed8"

RDEPENDS:pam = " \
 audit-libs \
 authselect \
 bash \
 gdbm \
 gdbm-libs \
 glibc \
 libeconf \
 libpwquality \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 setup \
 "
RDEPENDS:pam-devel = " \
 pam-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pam-libs = " \
 audit-libs \
 glibc \
 libeconf \
 "
