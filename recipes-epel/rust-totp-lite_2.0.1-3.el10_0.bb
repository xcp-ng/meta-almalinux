# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-totp-lite"
PV = "2.0.1"
PR = "3.el10_0"
PACKAGES = " \
 rust-totp-lite+default-devel \
 rust-totp-lite-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-totp-lite-2.0.1-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53ba1b473e6fe564851b03d9475593c550267bd260fe800f58bfe8664041643c"

URI_x86_64_v2_rust-totp-lite+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-totp-lite+default-devel-2.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-totp-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-totp-lite+default-devel}"
SRC_URI[x86_64_v2_rust-totp-lite+default-devel.sha256sum] = "810c7e17a69e00bfba857555fbf94c0b99e0dd198c3ed1d23a3a222b725bc395"

URI_x86_64_v2_rust-totp-lite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-totp-lite-devel-2.0.1-3.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-totp-lite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-totp-lite-devel}"
SRC_URI[x86_64_v2_rust-totp-lite-devel.sha256sum] = "3993ceeffbc677487e1870625ff99e56c9a77499ba6b14286a992624216b2332"

URI_aarch64_rust-totp-lite+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-totp-lite+default-devel-2.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-totp-lite+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-totp-lite+default-devel}"
SRC_URI[aarch64_rust-totp-lite+default-devel.sha256sum] = "7199558e4f9ffaf375e2fa559c0832a1d7057300aca18277da6e641e1be0947c"

URI_aarch64_rust-totp-lite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-totp-lite-devel-2.0.1-3.el10_0.noarch.rpm;name=aarch64_rust-totp-lite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-totp-lite-devel}"
SRC_URI[aarch64_rust-totp-lite-devel.sha256sum] = "5da9fb38af8e86c4cadb741209654f0f000d5c603a419f43f0c744b0ed6697dd"

RDEPENDS:rust-totp-lite+default-devel = " \
 cargo \
 rust-totp-lite-devel \
 "
RDEPENDS:rust-totp-lite-devel = " \
 cargo \
 rust-digest+default-devel \
 rust-hmac+default-devel \
 rust-sha1+default-devel \
 rust-sha2+default-devel \
 "
