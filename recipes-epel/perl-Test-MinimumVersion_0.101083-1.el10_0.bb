# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-MinimumVersion"
PV = "0.101083"
PR = "1.el10_0"
PACKAGES = " \
 perl-Test-MinimumVersion \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-MinimumVersion-0.101083-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f1c12dbcb7f6489dcde26663bbaef822543c3eb868adc106d19b8029293e5189"

URI_x86_64_v2_perl-Test-MinimumVersion = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-MinimumVersion-0.101083-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-MinimumVersion;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-MinimumVersion}"
SRC_URI[x86_64_v2_perl-Test-MinimumVersion.sha256sum] = "4428cc0c9ca25dd754c58346770e9bd71b178f864b6b46dcba4d89a54ab247b4"

URI_aarch64_perl-Test-MinimumVersion = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-MinimumVersion-0.101083-1.el10_0.noarch.rpm;name=aarch64_perl-Test-MinimumVersion;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-MinimumVersion}"
SRC_URI[aarch64_perl-Test-MinimumVersion.sha256sum] = "c1a43e05071a0483a375dcf1d35879e44c8f5cbf7d51e0025a2463be1d16c49c"

RDEPENDS:perl-Test-MinimumVersion = " \
 perl-CPAN-Meta \
 perl-Exporter \
 perl-File-Find-Rule \
 perl-File-Find-Rule-Perl \
 perl-Perl-MinimumVersion \
 perl-Test-Simple \
 perl-base \
 perl-libs \
 perl-version \
 "
