# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-status"
PV = "0.20.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-status+default-devel \
 rust-gix-status+document-features-devel \
 rust-gix-status+worktree-rewrites-devel \
 rust-gix-status-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-status-0.20.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0a9a9c1ffb2ea39e35a7f2e3a997ccf52b3928e27f7b98e1081a0c40cd43a3b"

URI_x86_64_v2_rust-gix-status+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+default-devel-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+default-devel}"
SRC_URI[x86_64_v2_rust-gix-status+default-devel.sha256sum] = "5e401d46ca704e4ba57909436fd7a41ef5fda49ac90a930018c82d29a08972f8"

URI_x86_64_v2_rust-gix-status+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+document-features-devel-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-status+document-features-devel.sha256sum] = "386116ce681e40380bddde320e9ce0434af75edba6047f5dc54ea9351a291f6c"

URI_x86_64_v2_rust-gix-status+worktree-rewrites-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status+worktree-rewrites-devel-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status+worktree-rewrites-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status+worktree-rewrites-devel}"
SRC_URI[x86_64_v2_rust-gix-status+worktree-rewrites-devel.sha256sum] = "269497e60685d70ae184ba25c5a78ffd4b0de86fdadffe73b55dd0040ed55c3e"

URI_x86_64_v2_rust-gix-status-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-status-devel-0.20.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-status-devel}"
SRC_URI[x86_64_v2_rust-gix-status-devel.sha256sum] = "4cc4ab7c65a763f6d9a885c710a115de516292ae8ea16f564c4e170a861a37e7"

URI_aarch64_rust-gix-status+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+default-devel-0.20.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-status+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+default-devel}"
SRC_URI[aarch64_rust-gix-status+default-devel.sha256sum] = "051c07d4b52995bdc4da9a254a16b4c8fe4d6a82c407faddfde7857b81dba474"

URI_aarch64_rust-gix-status+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+document-features-devel-0.20.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-status+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+document-features-devel}"
SRC_URI[aarch64_rust-gix-status+document-features-devel.sha256sum] = "18ef7464cc37cdbf749f505e6633823ed9ba31f6d83e0e8f7263f1e90b455c32"

URI_aarch64_rust-gix-status+worktree-rewrites-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status+worktree-rewrites-devel-0.20.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-status+worktree-rewrites-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status+worktree-rewrites-devel}"
SRC_URI[aarch64_rust-gix-status+worktree-rewrites-devel.sha256sum] = "fff256f3645a7b12cf99e14037d8a73a8d985de455c41163ef270528ae48d11f"

URI_aarch64_rust-gix-status-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-status-devel-0.20.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-status-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-status-devel}"
SRC_URI[aarch64_rust-gix-status-devel.sha256sum] = "85ef32b4d4e3ef0bb56eba0dcc001d7396108e7588f85d837bb2500478592e5e"

RDEPENDS:rust-gix-status+default-devel = " \
 cargo \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status+worktree-rewrites-devel = " \
 cargo \
 rust-gix-diff+blob-devel \
 rust-gix-diff-devel \
 rust-gix-dir+default-devel \
 rust-gix-status-devel \
 "
RDEPENDS:rust-gix-status-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-filetime+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+progress-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-index+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-pathspec+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-thiserror+default-devel \
 "
