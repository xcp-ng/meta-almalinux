# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nghttp2"
PV = "1.64.0"
PR = "2.el10"
PACKAGES = " \
 libnghttp2 \
 libnghttp2-devel \
 nghttp2 \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/nghttp2-1.64.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d56bf9598635b01aa295ae99948a7ba9fa8b7f59e48820656fff393111f0e428"

URI_x86_64_v2_libnghttp2 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnghttp2-1.64.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libnghttp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnghttp2}"
SRC_URI[x86_64_v2_libnghttp2.sha256sum] = "3becf93ebd075f47483b38e5ce891d13292ae95e8c47e039552515d36f96cf3a"

URI_x86_64_v2_libnghttp2-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libnghttp2-devel-1.64.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_libnghttp2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnghttp2-devel}"
SRC_URI[x86_64_v2_libnghttp2-devel.sha256sum] = "809d57eea4b73cbe07449fedd8e04cfde45d800e7301f1336d794b1d15b47aee"

URI_x86_64_v2_nghttp2 = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/nghttp2-1.64.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_nghttp2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nghttp2}"
SRC_URI[x86_64_v2_nghttp2.sha256sum] = "7335653b29356721e7d34890cc7b3684153854e8a17def53cd501fc7a5792345"

URI_aarch64_libnghttp2 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnghttp2-1.64.0-2.el10.aarch64.rpm;name=aarch64_libnghttp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnghttp2}"
SRC_URI[aarch64_libnghttp2.sha256sum] = "c0d45aff509fd8f2235e4f61770e3fee4a117d0e969c0ca675a69bba6a36d3b9"

URI_aarch64_libnghttp2-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libnghttp2-devel-1.64.0-2.el10.aarch64.rpm;name=aarch64_libnghttp2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnghttp2-devel}"
SRC_URI[aarch64_libnghttp2-devel.sha256sum] = "d1bc133db73ba2c51063040539b0a03479dca016af63a23223620fa6da1c6fce"

URI_aarch64_nghttp2 = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/nghttp2-1.64.0-2.el10.aarch64.rpm;name=aarch64_nghttp2;unpack=0"
SRC_URI:append = " ${URI_aarch64_nghttp2}"
SRC_URI[aarch64_nghttp2.sha256sum] = "7fc838e78754e0be53a85af82294c27ff1a5f752e73573c7dadf8c1cf0f94dac"

RDEPENDS:libnghttp2 = " \
 glibc \
 "
RDEPENDS:libnghttp2-devel = " \
 libnghttp2 \
 pkgconf-pkg-config \
 "
RDEPENDS:nghttp2 = " \
 bash \
 c-ares \
 glibc \
 libev \
 libgcc \
 libnghttp2 \
 libstdc++ \
 libxml2 \
 openssl-libs \
 python3 \
 systemd \
 zlib-ng-compat \
 "
