# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pythoncapi-compat"
PE = "1"
PV = "0^20260319.75a7967"
PR = "1.el10_3"
PACKAGES = " \
 pythoncapi-compat-devel \
 pythoncapi-compat-doc \
 pythoncapi-compat-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pythoncapi-compat-0^20260319.75a7967-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1e09aff29bd1d39003977df46e94015288a9b5ae5aa17e7c832241a50583a6be"

URI_x86_64_v2_pythoncapi-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-devel-0^20260319.75a7967-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-devel}"
SRC_URI[x86_64_v2_pythoncapi-compat-devel.sha256sum] = "b7321dc93a96dd34d13f5bfa9f2a138299ac3b3e2cc235cd032bd60d0994c58b"

URI_x86_64_v2_pythoncapi-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-doc-0^20260319.75a7967-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-doc}"
SRC_URI[x86_64_v2_pythoncapi-compat-doc.sha256sum] = "a2bbe1085ee995a488bd9c0c218daa9e134007f52166f4d1b14f63ec64af0306"

URI_x86_64_v2_pythoncapi-compat-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pythoncapi-compat-tools-0^20260319.75a7967-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_pythoncapi-compat-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pythoncapi-compat-tools}"
SRC_URI[x86_64_v2_pythoncapi-compat-tools.sha256sum] = "b5b78a2eb3ccb4c366abf120986c319e4983bd041d2218c845a09407ad113b19"

URI_aarch64_pythoncapi-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-devel-0^20260319.75a7967-1.el10_3.noarch.rpm;name=aarch64_pythoncapi-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-devel}"
SRC_URI[aarch64_pythoncapi-compat-devel.sha256sum] = "5d4329039460dbea2078f6b3dbdcb346535715767ef148d1b8c44f4ccc89b63a"

URI_aarch64_pythoncapi-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-doc-0^20260319.75a7967-1.el10_3.noarch.rpm;name=aarch64_pythoncapi-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-doc}"
SRC_URI[aarch64_pythoncapi-compat-doc.sha256sum] = "bd72b6db012afe926e893a0cbfb8044dc2636a8270419d9a53e3a15d03632962"

URI_aarch64_pythoncapi-compat-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pythoncapi-compat-tools-0^20260319.75a7967-1.el10_3.noarch.rpm;name=aarch64_pythoncapi-compat-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pythoncapi-compat-tools}"
SRC_URI[aarch64_pythoncapi-compat-tools.sha256sum] = "287e1eec5fd19950c16931f7a20628c84421c97e1da1d24cfd5ed5bd94476f7e"

RDEPENDS:pythoncapi-compat-devel = " \
 "
RDEPENDS:pythoncapi-compat-doc = " \
 "
RDEPENDS:pythoncapi-compat-tools = " \
 python3 \
 "
