# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmag"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kmag \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmag-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0a0bd917e896f6e9d28c51e2f68a57949b7d60cfbe1a5bdfd13b90b6db2acad3"

URI_x86_64_v2_kmag = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmag-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmag;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmag}"
SRC_URI[x86_64_v2_kmag.sha256sum] = "10fc18620582f69fcd7269da18f904a6979305cdbd42fcac8116334fd05dd895"

URI_aarch64_kmag = "${EPEL_MIRROR}/aarch64/Packages/k/kmag-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kmag;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmag}"
SRC_URI[aarch64_kmag.sha256sum] = "18b448876dd9047b5c40ed82a7869faff91e5c413783e28f74bfd4ab3a7e5af6"

RDEPENDS:kmag = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qaccessibilityclient-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
