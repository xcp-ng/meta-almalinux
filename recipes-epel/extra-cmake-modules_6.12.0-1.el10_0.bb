# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "extra-cmake-modules"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 extra-cmake-modules \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/extra-cmake-modules-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a6666ad7c5584dcfac97e8b0e30b3b34c50678b2be74564187c5ddb7869b61f"

URI_x86_64_v2_extra-cmake-modules = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/extra-cmake-modules-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_extra-cmake-modules;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_extra-cmake-modules}"
SRC_URI[x86_64_v2_extra-cmake-modules.sha256sum] = "159de8a6ec1675ec53e7b215ef5d962a675030552f887e031ab2df69919b02c6"

URI_aarch64_extra-cmake-modules = "${EPEL_MIRROR}/aarch64/Packages/e/extra-cmake-modules-6.12.0-1.el10_0.noarch.rpm;name=aarch64_extra-cmake-modules;unpack=0"
SRC_URI:append = " ${URI_aarch64_extra-cmake-modules}"
SRC_URI[aarch64_extra-cmake-modules.sha256sum] = "19ca9ee5efc9f48bca3bce58dcec7265ef0bc862d3f2f94b867a55807a2ee099"

RDEPENDS:extra-cmake-modules = " \
 bash \
 kf6-rpm-macros \
 python3 \
 "
