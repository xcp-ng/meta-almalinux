# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-wayland-protocols"
PV = "0.32.10"
PR = "1.el10_2"
PACKAGES = " \
 rust-wayland-protocols+client-devel \
 rust-wayland-protocols+default-devel \
 rust-wayland-protocols+server-devel \
 rust-wayland-protocols+staging-devel \
 rust-wayland-protocols+unstable-devel \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-wayland-protocols-0.32.10-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d1b35653472029b2c054189758824e3d9343b32156acb6c0f694514cb4696a3f"

URI_x86_64_v2_rust-wayland-protocols+client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+client-devel-0.32.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+client-devel.sha256sum] = "d40ff8c452dd332bff28945eba375522c00bcb928e1b9f66e84f175587022699"

URI_x86_64_v2_rust-wayland-protocols+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+default-devel-0.32.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+default-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+default-devel.sha256sum] = "721b2f3efe04ce1a040542439fba20dc5a9ceda07464f3c7b9c3b1136022ff3c"

URI_x86_64_v2_rust-wayland-protocols+server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+server-devel-0.32.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+server-devel.sha256sum] = "c95e0c57d716dc19c4f8d080d1509ad5bf94774c010bf58958718ee04c388241"

URI_x86_64_v2_rust-wayland-protocols+staging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+staging-devel-0.32.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+staging-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+staging-devel.sha256sum] = "a121e3d81287e1c22117385e87147ace6c91066357d7c7dfac6356f707074dca"

URI_x86_64_v2_rust-wayland-protocols+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+unstable-devel-0.32.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+unstable-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+unstable-devel.sha256sum] = "84059f79f6b5f62d82c753c0f44d70766a9cde8fbf216e24e6975e3d8cbf2602"

URI_x86_64_v2_rust-wayland-protocols+wayland-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-client-devel-0.32.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+wayland-client-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-client-devel.sha256sum] = "e51e8134230d8cc053da4da78a3ff9095e0be6be82229eba74c3f3d19fb17471"

URI_x86_64_v2_rust-wayland-protocols+wayland-server-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols+wayland-server-devel-0.32.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols+wayland-server-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols+wayland-server-devel.sha256sum] = "77da90460e8f9cf9cd6fc858fd2a833a6230c9b130254efad8e1bbcde0fa4169"

URI_x86_64_v2_rust-wayland-protocols-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-wayland-protocols-devel-0.32.10-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-wayland-protocols-devel}"
SRC_URI[x86_64_v2_rust-wayland-protocols-devel.sha256sum] = "93cbc80c5b716a4e3a8ea9e553067868ae16a5bd8d0685aa9ef64c8ecaf5355d"

URI_aarch64_rust-wayland-protocols+client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+client-devel-0.32.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols+client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+client-devel}"
SRC_URI[aarch64_rust-wayland-protocols+client-devel.sha256sum] = "14eb1a72e600405bdeb334f14ec71c209a946b69d5f9afa9ae3de8282956ae56"

URI_aarch64_rust-wayland-protocols+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+default-devel-0.32.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+default-devel}"
SRC_URI[aarch64_rust-wayland-protocols+default-devel.sha256sum] = "8b98738e91392a29632b880f9daab775ed75abe66cd303373724c23b42a23a0f"

URI_aarch64_rust-wayland-protocols+server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+server-devel-0.32.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols+server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+server-devel}"
SRC_URI[aarch64_rust-wayland-protocols+server-devel.sha256sum] = "d3cea1b8f4dd7a237060dbda2bd4a3116aedf0cfe3f56f027d7a620bd1e8b6e3"

URI_aarch64_rust-wayland-protocols+staging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+staging-devel-0.32.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols+staging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+staging-devel}"
SRC_URI[aarch64_rust-wayland-protocols+staging-devel.sha256sum] = "b80533e95fc84e387f3233249f56b2023a761111e638f88e1ed2187733bcf556"

URI_aarch64_rust-wayland-protocols+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+unstable-devel-0.32.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+unstable-devel}"
SRC_URI[aarch64_rust-wayland-protocols+unstable-devel.sha256sum] = "19ce8849b103a827af9069a7eb99518f32d24917378d26a9f1550c9f6d59f988"

URI_aarch64_rust-wayland-protocols+wayland-client-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-client-devel-0.32.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+wayland-client-devel}"
SRC_URI[aarch64_rust-wayland-protocols+wayland-client-devel.sha256sum] = "3287f32e27b5f564b742bd8cddbedeeabdfe0fa2844dffa11f79c0f3d4cb06d2"

URI_aarch64_rust-wayland-protocols+wayland-server-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols+wayland-server-devel-0.32.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols+wayland-server-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols+wayland-server-devel}"
SRC_URI[aarch64_rust-wayland-protocols+wayland-server-devel.sha256sum] = "a0f1f08ea683f4296fedb95572a88edd6dad71eac0932c3be3596d3b08a436b3"

URI_aarch64_rust-wayland-protocols-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-wayland-protocols-devel-0.32.10-1.el10_2.noarch.rpm;name=aarch64_rust-wayland-protocols-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-wayland-protocols-devel}"
SRC_URI[aarch64_rust-wayland-protocols-devel.sha256sum] = "7e36e3ef1aeacc1dc27428043b8e9d3f4ef86a31431b1567c387f665e9463bcf"

RDEPENDS:rust-wayland-protocols+client-devel = " \
 cargo \
 rust-wayland-protocols+wayland-client-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+default-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+server-devel = " \
 cargo \
 rust-wayland-protocols+wayland-server-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+staging-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+unstable-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-client-devel = " \
 cargo \
 rust-wayland-client+default-devel \
 rust-wayland-protocols-devel \
 "
RDEPENDS:rust-wayland-protocols+wayland-server-devel = " \
 cargo \
 rust-wayland-protocols-devel \
 rust-wayland-server+default-devel \
 "
RDEPENDS:rust-wayland-protocols-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-wayland-backend+default-devel \
 rust-wayland-scanner+default-devel \
 "
