# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-threadweaver"
PV = "6.30.0"
PR = "1.el10_3"
PACKAGES = " \
 kf6-threadweaver \
 kf6-threadweaver-devel \
 kf6-threadweaver-doc \
 kf6-threadweaver-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-threadweaver-6.30.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e2ee9822349d1fff3e2de86b0dc77bb4b52dc3df7a389a8bbf047a162a0e896a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver;unpack=0"
SRC_URI[x86_64_v2_kf6-threadweaver.sha256sum] = "cb52f4759ec66c6fa96af0b40e330ca5c03d17ee29749621994c09ce482120f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-devel-6.30.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-threadweaver-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-threadweaver-devel.sha256sum] = "af5179938e7e50cf206b72cda31de935aec3b50aee73c4e065ab909bd8f4df3b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-doc-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-threadweaver-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-threadweaver-doc.sha256sum] = "3b36304a5085dbb4f480577237a1b0029788b7325c29ee7cb86885720b3c997e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-threadweaver-html-6.30.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-threadweaver-html;unpack=0"
SRC_URI[x86_64_v2_kf6-threadweaver-html.sha256sum] = "6895821eed23c0990aa359cf69c993546dbcaaf10c35e8a02f14a87819c4b4ce"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-threadweaver;unpack=0"
SRC_URI[aarch64_kf6-threadweaver.sha256sum] = "9bed8050d34c3e16c4a11afbeb6d88abc86472131a4271dd5637f3368cd482c4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-devel-6.30.0-1.el10_3.aarch64.rpm;name=aarch64_kf6-threadweaver-devel;unpack=0"
SRC_URI[aarch64_kf6-threadweaver-devel.sha256sum] = "f98fc978efd39df233ad2a6cc198a3ce50b2bf9d8f2834772f080c532fc2ebc3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-doc-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-threadweaver-doc;unpack=0"
SRC_URI[aarch64_kf6-threadweaver-doc.sha256sum] = "a7bc8e3d9166870aeff9af51929bd2386fb8d32ef621089207cf5ca1e17d9b7c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-threadweaver-html-6.30.0-1.el10_3.noarch.rpm;name=aarch64_kf6-threadweaver-html;unpack=0"
SRC_URI[aarch64_kf6-threadweaver-html.sha256sum] = "0c14e41e73324fff63f38a68bf38b93551c5054967f41a64fdf1b6ebaf0aab92"

RDEPENDS:kf6-threadweaver = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-threadweaver-devel = " \
 cmake-filesystem \
 kf6-threadweaver \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-threadweaver-doc = " \
 "
RDEPENDS:kf6-threadweaver-html = " \
 "
