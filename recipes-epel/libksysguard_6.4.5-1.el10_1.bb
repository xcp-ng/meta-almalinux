# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libksysguard"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 libksysguard \
 libksysguard-common \
 libksysguard-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libksysguard-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd91556183d7baa064b39fa3760f0dc611b47e7bbdad1808689fa60eb0c2cdbc"

URI_x86_64_v2_libksysguard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard}"
SRC_URI[x86_64_v2_libksysguard.sha256sum] = "74757c1b922c6e3ec7893cfca4d087c8f075442571fad5564d5ccefc03fa07ae"

URI_x86_64_v2_libksysguard-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-common-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard-common}"
SRC_URI[x86_64_v2_libksysguard-common.sha256sum] = "caa1072cf5611bfa1984c7a8190251e65854a88a60db4a6a7ebaca2d55440ecc"

URI_x86_64_v2_libksysguard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libksysguard-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libksysguard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libksysguard-devel}"
SRC_URI[x86_64_v2_libksysguard-devel.sha256sum] = "4e59345377da6e71ddba314e1fb6e84cc55b5bf606a99c3f88c6dec96da3fd9e"

URI_aarch64_libksysguard = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_libksysguard;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard}"
SRC_URI[aarch64_libksysguard.sha256sum] = "0b46ce25140ccf51f74839504e1bb19698eada93a433553eb2b23df6aba0661b"

URI_aarch64_libksysguard-common = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-common-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_libksysguard-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard-common}"
SRC_URI[aarch64_libksysguard-common.sha256sum] = "74b091e9cea225de1d74f8a5d04687546a0225153c92f501969f8ba0fcc27485"

URI_aarch64_libksysguard-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libksysguard-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_libksysguard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libksysguard-devel}"
SRC_URI[aarch64_libksysguard-devel.sha256sum] = "313ec5e04aab4de7c80464eb4194c2fddd7964d1cbaacdca44c872dd6e3461bc"

RDEPENDS:libksysguard = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kpackage \
 kf6-kservice \
 kf6-solid \
 libdrm \
 libgcc \
 libksysguard-common \
 libnl3 \
 libpcap \
 libstdc++ \
 lm_sensors-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:libksysguard-common = " \
 glibc \
 kf6-kauth \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:libksysguard-devel = " \
 cmake-filesystem \
 kf6-kconfig-devel \
 kf6-ki18n-devel \
 kf6-kiconthemes-devel \
 libksysguard \
 qt6-qtbase-devel \
 "
