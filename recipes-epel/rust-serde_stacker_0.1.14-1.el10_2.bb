# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_stacker"
PV = "0.1.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_stacker+default-devel \
 rust-serde_stacker-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_stacker-0.1.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3880467cbc74ee79d1717d78e621e6efd128aaa31f9a4c42b50e3b2ccc929b30"

URI_x86_64_v2_rust-serde_stacker+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_stacker+default-devel-0.1.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_stacker+default-devel}"
SRC_URI[x86_64_v2_rust-serde_stacker+default-devel.sha256sum] = "efe54d1ff68bd1e83e74e1930663538afcce926c2dfefc6d9c275d40b153259b"

URI_x86_64_v2_rust-serde_stacker-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_stacker-devel-0.1.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_stacker-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_stacker-devel}"
SRC_URI[x86_64_v2_rust-serde_stacker-devel.sha256sum] = "94803d7033e4c4bdbb5334a43d0b42506c4c9c300411b695e0a82941174209e7"

URI_aarch64_rust-serde_stacker+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_stacker+default-devel-0.1.14-1.el10_2.noarch.rpm;name=aarch64_rust-serde_stacker+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_stacker+default-devel}"
SRC_URI[aarch64_rust-serde_stacker+default-devel.sha256sum] = "b3de36aa9e8db00d71a363e27c47f934b9bcc619c93045ba5801aad1993cdd72"

URI_aarch64_rust-serde_stacker-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_stacker-devel-0.1.14-1.el10_2.noarch.rpm;name=aarch64_rust-serde_stacker-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_stacker-devel}"
SRC_URI[aarch64_rust-serde_stacker-devel.sha256sum] = "b97ce1606fd646bb3f9109e0ef2ef23058e6112993a4642d69fbceaaa031c6ef"

RDEPENDS:rust-serde_stacker+default-devel = " \
 cargo \
 rust-serde_stacker-devel \
 "
RDEPENDS:rust-serde_stacker-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-stacker+default-devel \
 "
