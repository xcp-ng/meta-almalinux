# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-sha1"
PV = "0.11.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-sha1+alloc-devel \
 rust-sha1+default-devel \
 rust-sha1+oid-devel \
 rust-sha1+zeroize-devel \
 rust-sha1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-sha1-0.11.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eb6cc295fe9a9589c714deb240b70a96b4192a25addab12d6b2b2803dbab651a"

URI_x86_64_v2_rust-sha1+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+alloc-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+alloc-devel}"
SRC_URI[x86_64_v2_rust-sha1+alloc-devel.sha256sum] = "60666fe795275c8ed6d624165fb812190caa0a08568697b9085547306d7fc65f"

URI_x86_64_v2_rust-sha1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+default-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+default-devel}"
SRC_URI[x86_64_v2_rust-sha1+default-devel.sha256sum] = "7f90a3a3690c2cc476d1d07797a65b4ee03f4146e0315d2bab694b737b4a09fc"

URI_x86_64_v2_rust-sha1+oid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+oid-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+oid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+oid-devel}"
SRC_URI[x86_64_v2_rust-sha1+oid-devel.sha256sum] = "04607a26ced7329da02ff2bf91ff9db176dfee540547f36fc5076c384f03d44b"

URI_x86_64_v2_rust-sha1+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1+zeroize-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1+zeroize-devel}"
SRC_URI[x86_64_v2_rust-sha1+zeroize-devel.sha256sum] = "455843d84ebd5128f7998b083a7c3a7e539da3888821f5f1db8fd23e66ebdcd7"

URI_x86_64_v2_rust-sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-sha1-devel-0.11.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-sha1-devel}"
SRC_URI[x86_64_v2_rust-sha1-devel.sha256sum] = "844ea676c784b88c16ab0619120dd085630b02e909ed75d802efcb9410c49826"

URI_aarch64_rust-sha1+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+alloc-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+alloc-devel}"
SRC_URI[aarch64_rust-sha1+alloc-devel.sha256sum] = "9f0ed5b258a5e47ceaeb6eb749deac3b4ed602382aa7f6a44fd613afb5c9fc99"

URI_aarch64_rust-sha1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+default-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+default-devel}"
SRC_URI[aarch64_rust-sha1+default-devel.sha256sum] = "9154cfaf6cebacf26f5408db8fb8403b43392119eef4c378aa9f4028fbb234d9"

URI_aarch64_rust-sha1+oid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+oid-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha1+oid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+oid-devel}"
SRC_URI[aarch64_rust-sha1+oid-devel.sha256sum] = "45afa0218c3703850deac3d1760495f396e6135aca9fc306356dd35c7eccd407"

URI_aarch64_rust-sha1+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1+zeroize-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1+zeroize-devel}"
SRC_URI[aarch64_rust-sha1+zeroize-devel.sha256sum] = "c2cbe642e77a22956f93d857800a27adb96519970c8489c10037dc8de446de75"

URI_aarch64_rust-sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-sha1-devel-0.11.0-1.el10_3.noarch.rpm;name=aarch64_rust-sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-sha1-devel}"
SRC_URI[aarch64_rust-sha1-devel.sha256sum] = "51c563d6348f86fbdf73c0640238dbf855fd8f773090f38f49a12adb9bb31ad0"

RDEPENDS:rust-sha1+alloc-devel = " \
 cargo \
 rust-digest+alloc-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+default-devel = " \
 cargo \
 rust-sha1+alloc-devel \
 rust-sha1+oid-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+oid-devel = " \
 cargo \
 rust-digest+oid-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1+zeroize-devel = " \
 cargo \
 rust-digest+zeroize-devel \
 rust-sha1-devel \
 "
RDEPENDS:rust-sha1-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-cpufeatures+default-devel \
 rust-digest+default-devel \
 "
