# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-endi"
PV = "1.1.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-endi+default-devel \
 rust-endi+std-devel \
 rust-endi-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-endi-1.1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b63176c113e8538242627824ce22233158115b7dd0d7959d1aad97ae8bfbae6"

URI_x86_64_v2_rust-endi+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-endi+default-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-endi+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-endi+default-devel}"
SRC_URI[x86_64_v2_rust-endi+default-devel.sha256sum] = "102d8a8ce554a34ee0dffd6405d908fd15db21a37f2611938100cee2b810a27b"

URI_x86_64_v2_rust-endi+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-endi+std-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-endi+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-endi+std-devel}"
SRC_URI[x86_64_v2_rust-endi+std-devel.sha256sum] = "0444cf7443a6b56831b46397372efb3292afeef4fdb5d4a403bf044a57cb89c5"

URI_x86_64_v2_rust-endi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-endi-devel-1.1.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-endi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-endi-devel}"
SRC_URI[x86_64_v2_rust-endi-devel.sha256sum] = "dffde29d36d56cebd3437d532cb5551b3a087126cb7ac728b30d8f82d7c4a35e"

URI_aarch64_rust-endi+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-endi+default-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-endi+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-endi+default-devel}"
SRC_URI[aarch64_rust-endi+default-devel.sha256sum] = "5f041cb0c57551dc846707dc5bf6269ede06f3050b12d03b611181f2060ac82d"

URI_aarch64_rust-endi+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-endi+std-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-endi+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-endi+std-devel}"
SRC_URI[aarch64_rust-endi+std-devel.sha256sum] = "003d165fb04b05cb67f4f93d20caee0af62703da83f59d01fd6ed54de661aefb"

URI_aarch64_rust-endi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-endi-devel-1.1.1-1.el10_1.noarch.rpm;name=aarch64_rust-endi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-endi-devel}"
SRC_URI[aarch64_rust-endi-devel.sha256sum] = "afb411befd86bfadd0ffb90021c3beca11395527ba3296143937ed90b2cb953d"

RDEPENDS:rust-endi+default-devel = " \
 cargo \
 rust-endi+std-devel \
 rust-endi-devel \
 "
RDEPENDS:rust-endi+std-devel = " \
 cargo \
 rust-endi-devel \
 "
RDEPENDS:rust-endi-devel = " \
 cargo \
 rust \
 "
