# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-discover"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 plasma-discover \
 plasma-discover-flatpak \
 plasma-discover-kns \
 plasma-discover-libs \
 plasma-discover-notifier \
 plasma-discover-offline-updates \
 plasma-discover-packagekit \
 plasma-discover-snap \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/plasma-discover-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2c159c551164da2f10e078255e7734912a601542bda8ae701a06f57e5b765178"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover;unpack=0"
SRC_URI[x86_64_v2_plasma-discover.sha256sum] = "8fd522483282e34d2978e28b85415af3a82949754c1e61a7c93fa2e6c952ca12"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-flatpak-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-flatpak;unpack=0"
SRC_URI[x86_64_v2_plasma-discover-flatpak.sha256sum] = "e7cfce6aa8deef0f0b8a99af492154e390ef8f38eadfde7117282bdd48569445"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-kns-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-kns;unpack=0"
SRC_URI[x86_64_v2_plasma-discover-kns.sha256sum] = "8100749e1159e67a77a9f96a52e6d3f1aad1bb9f94a1d2a9200bd4f88e935422"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-libs-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-libs;unpack=0"
SRC_URI[x86_64_v2_plasma-discover-libs.sha256sum] = "bd8d6b9be079c67b3678de733f507f670ddb80e0eaa5ede42a62d0befeed8d1f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-notifier-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-notifier;unpack=0"
SRC_URI[x86_64_v2_plasma-discover-notifier.sha256sum] = "f1ed15bb65fd4c550dd70b3ece025a81881f5224c092bbfe4ac0ff2d4de2f8e7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-offline-updates-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-offline-updates;unpack=0"
SRC_URI[x86_64_v2_plasma-discover-offline-updates.sha256sum] = "0c1c27360f156ae47c8c5a85f06f5890be3db23e94bdc0b1587a6e64048f57e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-packagekit-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-packagekit;unpack=0"
SRC_URI[x86_64_v2_plasma-discover-packagekit.sha256sum] = "4a6c754687eb3fae3d6edbdb71aa1692a2d7eefb7c61f43565ee8994e0da06c3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-discover-snap-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-discover-snap;unpack=0"
SRC_URI[x86_64_v2_plasma-discover-snap.sha256sum] = "ea13939165dc13691e46d9630cddbd43784092f47c4696fb6abd531b2e18d584"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover;unpack=0"
SRC_URI[aarch64_plasma-discover.sha256sum] = "d776504b44112d69ff26659aa4e7d44df4a7f169b5be6fbdcd0ba02ffd7004ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-flatpak-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-flatpak;unpack=0"
SRC_URI[aarch64_plasma-discover-flatpak.sha256sum] = "338a49b6b1d0a545120d50e3ebc365fba036a63ac831092ae9ec9957bb0a3458"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-kns-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-kns;unpack=0"
SRC_URI[aarch64_plasma-discover-kns.sha256sum] = "25ccba62554da41647ccebcd1865bbcc84e420d66f8e41adad9cc1eb8501e95c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-libs-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-libs;unpack=0"
SRC_URI[aarch64_plasma-discover-libs.sha256sum] = "ca25ba5989f306a4aea752601e6c2d34d8e67d2078bbea57b2bfb27ae86c8ee5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-notifier-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-notifier;unpack=0"
SRC_URI[aarch64_plasma-discover-notifier.sha256sum] = "e5c6b857e6e546e672554d45cc258d667eced13c640f0724f59fe4a14712217f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-offline-updates-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-offline-updates;unpack=0"
SRC_URI[aarch64_plasma-discover-offline-updates.sha256sum] = "4d029270be1586a4dd236229d269692eed24044e4ac79858132a9dc34e4a9560"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-packagekit-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-packagekit;unpack=0"
SRC_URI[aarch64_plasma-discover-packagekit.sha256sum] = "8435a69a7a5287304dd8c405c98905e403b9acf155f3d277fb25bd6d45faefa7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/plasma-discover-snap-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_plasma-discover-snap;unpack=0"
SRC_URI[aarch64_plasma-discover-snap.sha256sum] = "608114ceed1a8b5cb7e6cd701b99deb1ac17ce58bf1d69cc80e8bcff0da6a23b"

RDEPENDS:plasma-discover = " \
 glibc \
 kf6-kauth \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kitemmodels \
 kf6-kjobwidgets \
 kf6-kstatusnotifieritem \
 kf6-kwindowsystem \
 kf6-purpose \
 kf6-qqc2-desktop-style \
 libstdc++ \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwebview \
 "
RDEPENDS:plasma-discover-flatpak = " \
 appstream-qt \
 flatpak \
 flatpak-kcm \
 flatpak-libs \
 glib2 \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kservice \
 libgcc \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-kns = " \
 glibc \
 kf6-attica \
 kf6-kconfig \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-libs = " \
 appstream-qt \
 fwupd \
 glib2 \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 libgcc \
 libstdc++ \
 plasma-discover \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-discover-notifier = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kidletime \
 kf6-kio-gui \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-offline-updates = " \
 plasma-discover \
 "
RDEPENDS:plasma-discover-packagekit = " \
 PackageKit \
 PackageKit-Qt6 \
 appstream-qt \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kservice \
 libgcc \
 libmarkdown \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qcoro-qt6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:plasma-discover-snap = " \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-discover \
 plasma-discover-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 snapd \
 snapd-qt \
 "
