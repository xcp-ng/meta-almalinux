# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xio-popen-driver"
PV = "4.1"
PR = "11.el10_0"
PACKAGES = " \
 globus-xio-popen-driver \
 globus-xio-popen-driver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-xio-popen-driver-4.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "81d9b62c5ef0ff033c3387ba3936f946b0f3b90cb4d162f10d6cefd875a99f04"

URI_x86_64_v2_globus-xio-popen-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-popen-driver-4.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-popen-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-popen-driver}"
SRC_URI[x86_64_v2_globus-xio-popen-driver.sha256sum] = "4b5690ae9ccb21258f13b7e46de502428fd6a2307ef5ca4fa09e1f2841d1f9dc"

URI_x86_64_v2_globus-xio-popen-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-popen-driver-devel-4.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-popen-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-popen-driver-devel}"
SRC_URI[x86_64_v2_globus-xio-popen-driver-devel.sha256sum] = "cabc4c272ce3e0d7ff9e0b9f2a7030219e79fb0202b35b3bd6e434637601e28b"

URI_aarch64_globus-xio-popen-driver = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-popen-driver-4.1-11.el10_0.aarch64.rpm;name=aarch64_globus-xio-popen-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-popen-driver}"
SRC_URI[aarch64_globus-xio-popen-driver.sha256sum] = "3ca1e667b6d0cbb1b028ee445f26c97a09ae7476085bbf9d7c7566bc2acc18cb"

URI_aarch64_globus-xio-popen-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-popen-driver-devel-4.1-11.el10_0.aarch64.rpm;name=aarch64_globus-xio-popen-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-popen-driver-devel}"
SRC_URI[aarch64_globus-xio-popen-driver-devel.sha256sum] = "c5945a3ba5ce28b86d3640c5d0e8beb0c31a32448629b81894c4f91138690875"

RDEPENDS:globus-xio-popen-driver = " \
 glibc \
 globus-common \
 globus-xio \
 "
RDEPENDS:globus-xio-popen-driver-devel = " \
 globus-common-devel \
 globus-xio-devel \
 globus-xio-popen-driver \
 pkgconf-pkg-config \
 "
