# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-camino"
PV = "1.2.5"
PR = "1.el10_2"
PACKAGES = " \
 rust-camino+default-devel \
 rust-camino+proptest1-devel \
 rust-camino+serde1-devel \
 rust-camino-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-camino-1.2.5-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "74f9f40568a054c31462a9970c980e61e050b6844e502c6d6df213e19d8e6faa"

URI_x86_64_v2_rust-camino+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+default-devel-1.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+default-devel}"
SRC_URI[x86_64_v2_rust-camino+default-devel.sha256sum] = "4c6234510a83c33df50e0c89e1091b92c67ccbc1cc59e922c14cbccd9bb700a2"

URI_x86_64_v2_rust-camino+proptest1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+proptest1-devel-1.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+proptest1-devel}"
SRC_URI[x86_64_v2_rust-camino+proptest1-devel.sha256sum] = "d28f144433b104aa7afbe9c197487645f2640484a7f5a71e33157d3212d13d6a"

URI_x86_64_v2_rust-camino+serde1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino+serde1-devel-1.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino+serde1-devel}"
SRC_URI[x86_64_v2_rust-camino+serde1-devel.sha256sum] = "eef6932e68d14c842d57991c092c3a64491d58af35c0be95eb2f75e0b4780c3e"

URI_x86_64_v2_rust-camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-camino-devel-1.2.5-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-camino-devel}"
SRC_URI[x86_64_v2_rust-camino-devel.sha256sum] = "c2a4e05b4d6e7165f7c8b901b437c1a80def76a7c5d92abf0d616fb6640865fe"

URI_aarch64_rust-camino+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+default-devel-1.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-camino+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+default-devel}"
SRC_URI[aarch64_rust-camino+default-devel.sha256sum] = "efdc4c3105eb61d9d153ec7088efe8a0a4504d0b00607bf72a4ba09807772176"

URI_aarch64_rust-camino+proptest1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+proptest1-devel-1.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-camino+proptest1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+proptest1-devel}"
SRC_URI[aarch64_rust-camino+proptest1-devel.sha256sum] = "97c1414ebd3ceeaa234ced6919e26aa5702d980c33a34a095161a042ba8d3076"

URI_aarch64_rust-camino+serde1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino+serde1-devel-1.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-camino+serde1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino+serde1-devel}"
SRC_URI[aarch64_rust-camino+serde1-devel.sha256sum] = "928137c7384f27a6e7e52a8fca904c443967c913275d0dba45876f2feec2bcc6"

URI_aarch64_rust-camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-camino-devel-1.2.5-1.el10_2.noarch.rpm;name=aarch64_rust-camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-camino-devel}"
SRC_URI[aarch64_rust-camino-devel.sha256sum] = "460ac76ae4f3f26e5ac037473f857910a0141874c40b2faaba5b4813bb7fa571"

RDEPENDS:rust-camino+default-devel = " \
 cargo \
 rust-camino-devel \
 "
RDEPENDS:rust-camino+proptest1-devel = " \
 cargo \
 rust-camino-devel \
 rust-proptest+default-devel \
 "
RDEPENDS:rust-camino+serde1-devel = " \
 cargo \
 rust-camino-devel \
 rust-serde_core+default-devel \
 "
RDEPENDS:rust-camino-devel = " \
 cargo \
 rust \
 "
