# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kweathercore"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kweathercore \
 kweathercore-devel \
 kweathercore-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kweathercore-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c6e4fce532445295459a6cb151185d468e5454ed5e948fefcfb9558c29b3b8a2"

URI_x86_64_v2_kweathercore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore}"
SRC_URI[x86_64_v2_kweathercore.sha256sum] = "4c91283370c3ab70461d7e8b3c899921d7e5bed48cbb97f2eac31eb2db927575"

URI_x86_64_v2_kweathercore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-devel-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kweathercore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore-devel}"
SRC_URI[x86_64_v2_kweathercore-devel.sha256sum] = "9c14b5132099ef3abbc534a577ca188d69e83cc11f1f4c51680bda02bd1dbfa7"

URI_x86_64_v2_kweathercore-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kweathercore-doc-25.12.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kweathercore-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kweathercore-doc}"
SRC_URI[x86_64_v2_kweathercore-doc.sha256sum] = "abf13fe00868f582edd664d4d3177cf09e3dc44ecf16bb5cee9576b910a35b3b"

URI_aarch64_kweathercore = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kweathercore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore}"
SRC_URI[aarch64_kweathercore.sha256sum] = "b348eebabe0befd695fdd6ce2287f03286e0774d0c1ffeee8f58ac09f73d2c93"

URI_aarch64_kweathercore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-devel-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kweathercore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore-devel}"
SRC_URI[aarch64_kweathercore-devel.sha256sum] = "53fbd092f6fa2a3903f50ad5092c4083941aa96a8ab4116d8aa45564faf67763"

URI_aarch64_kweathercore-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kweathercore-doc-25.12.3-1.el10_2.noarch.rpm;name=aarch64_kweathercore-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kweathercore-doc}"
SRC_URI[aarch64_kweathercore-doc.sha256sum] = "17e4dfb92c1967ba2d336bac32dbbae75cefeca82a7455257fd4fdfc0588f3a5"

RDEPENDS:kweathercore = " \
 glibc \
 kf6-kholidays \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 qt6-qtpositioning \
 "
RDEPENDS:kweathercore-devel = " \
 cmake-filesystem \
 kweathercore \
 "
RDEPENDS:kweathercore-doc = " \
 "
