# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-ed25519"
PV = "0.0.5.0"
PR = "39.el10_0"
PACKAGES = " \
 ghc-ed25519 \
 ghc-ed25519-devel \
 ghc-ed25519-doc \
 ghc-ed25519-prof \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/ghc-ed25519-0.0.5.0-39.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0b30a2bf7ace8dc72e63a763ceb4b884168350df78d4adf384f92b4ec672cf24"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ed25519-0.0.5.0-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ed25519;unpack=0"
SRC_URI[x86_64_v2_ghc-ed25519.sha256sum] = "703322b1957dd9e39c30ce523949856193a358ed6e76e0e4848374ffd0733456"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ed25519-devel-0.0.5.0-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ed25519-devel;unpack=0"
SRC_URI[x86_64_v2_ghc-ed25519-devel.sha256sum] = "b2afa27b8845affda4f9b19a03f6cce9093595e646a1049b81640664ccd742d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ed25519-doc-0.0.5.0-39.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-ed25519-doc;unpack=0"
SRC_URI[x86_64_v2_ghc-ed25519-doc.sha256sum] = "605ed4606df66c1f52f3df8456b882db4d6bee059d7e48b4d78d7642ecc479d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-ed25519-prof-0.0.5.0-39.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-ed25519-prof;unpack=0"
SRC_URI[x86_64_v2_ghc-ed25519-prof.sha256sum] = "922c0a25d296c3952cfa7bd75ec3e3a67ae533dd940791131a381fed06b28a6b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-ed25519-0.0.5.0-39.el10_0.aarch64.rpm;name=aarch64_ghc-ed25519;unpack=0"
SRC_URI[aarch64_ghc-ed25519.sha256sum] = "5ba914d6afbfb4843ec94fc9dbc0547ba90f5f2c7694546dcda9a98670c4cc63"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-ed25519-devel-0.0.5.0-39.el10_0.aarch64.rpm;name=aarch64_ghc-ed25519-devel;unpack=0"
SRC_URI[aarch64_ghc-ed25519-devel.sha256sum] = "632636330416c0b691e9c76ed4f3a66a70f93c0ddc4c69e2a3fc872790e01511"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-ed25519-doc-0.0.5.0-39.el10_0.noarch.rpm;name=aarch64_ghc-ed25519-doc;unpack=0"
SRC_URI[aarch64_ghc-ed25519-doc.sha256sum] = "a7d653c2df18a7bac34a49031155f66391f3e757bde1570a8872b5bc8f0a2126"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/ghc-ed25519-prof-0.0.5.0-39.el10_0.aarch64.rpm;name=aarch64_ghc-ed25519-prof;unpack=0"
SRC_URI[aarch64_ghc-ed25519-prof.sha256sum] = "16b185de99285efced06cbd482ef9bc101124ffaa4c6a0322c0e5a7451235e3e"

RDEPENDS:ghc-ed25519 = " \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-ed25519-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-ed25519 \
 "
RDEPENDS:ghc-ed25519-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-ed25519-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-ed25519-devel \
 "
