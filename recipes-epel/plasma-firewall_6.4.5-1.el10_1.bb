# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-firewall"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-firewall \
 plasma-firewall-firewalld \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-firewall-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fbdf61192fc51b5468f3f5f42d3488fb2b2670a8a021c8ad7ef2e05c89851d7b"

URI_x86_64_v2_plasma-firewall = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-firewall}"
SRC_URI[x86_64_v2_plasma-firewall.sha256sum] = "e36fd4fc3423539ff8b2d96344466f533a181bd6bf8639e3e5fc40c431ffb660"

URI_x86_64_v2_plasma-firewall-firewalld = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-firewall-firewalld-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-firewall-firewalld;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-firewall-firewalld}"
SRC_URI[x86_64_v2_plasma-firewall-firewalld.sha256sum] = "fafd213ca369bef47616821c7dba0e733fb3baa10d1539174b4c77baf7365b28"

URI_aarch64_plasma-firewall = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-firewall;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-firewall}"
SRC_URI[aarch64_plasma-firewall.sha256sum] = "7eb3f6b199976f8dfa0c7dc3f09b4213cc75d9a96f31e0a78dc995eae892dd92"

URI_aarch64_plasma-firewall-firewalld = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-firewall-firewalld-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_plasma-firewall-firewalld;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-firewall-firewalld}"
SRC_URI[aarch64_plasma-firewall-firewalld.sha256sum] = "9abae7be5acbb62049a90341db0902e159902d0695a543cf024422f635c994f1"

RDEPENDS:plasma-firewall = " \
 glibc \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall-firewalld \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:plasma-firewall-firewalld = " \
 firewalld \
 glibc \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 plasma-firewall \
 qt6-qtbase \
 "
