# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kolf"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kolf \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kolf-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "215d92bb76189a35631fa0afb19c2eb2151fe210b730732f5eb6ade1b03c24e9"

URI_x86_64_v2_kolf = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kolf-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kolf;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kolf}"
SRC_URI[x86_64_v2_kolf.sha256sum] = "043a1c1a700a9c4824f15de00d9f9bb2a10be3edf19d613339b83e2b93305d5d"

URI_aarch64_kolf = "${EPEL_MIRROR}/aarch64/Packages/k/kolf-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kolf;unpack=0"
SRC_URI:append = " ${URI_aarch64_kolf}"
SRC_URI[aarch64_kolf.sha256sum] = "c8c19df24bedc7371ee7cda42f711c9b85d6aeb518da8d693c399593efa2a99c"

RDEPENDS:kolf = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
