# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sqlite"
PV = "3.46.1"
PR = "5.el10_1"
PACKAGES = " \
 sqlite \
 sqlite-devel \
 sqlite-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/sqlite-3.46.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "70ca9c10cc5bdbb731df7a0b0aee14c5790b352f5abb4d61f45ca31d5bc5f160"

URI_x86_64_v2_sqlite = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-3.46.1-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_sqlite;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlite}"
SRC_URI[x86_64_v2_sqlite.sha256sum] = "30a24d461305d1703b77b3a496386f6ff653f156cc4446f0b505b6a717b280ed"

URI_x86_64_v2_sqlite-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/sqlite-devel-3.46.1-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlite-devel}"
SRC_URI[x86_64_v2_sqlite-devel.sha256sum] = "1eb0f401f023ef7c382202b06cd9c36e1e144d934f4ab0a05688b86f0513255f"

URI_x86_64_v2_sqlite-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/sqlite-libs-3.46.1-5.el10_1.x86_64_v2.rpm;name=x86_64_v2_sqlite-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sqlite-libs}"
SRC_URI[x86_64_v2_sqlite-libs.sha256sum] = "6dacefa4c321061a4471536881685808afac32e209384ce0c44ac70de59e039f"

URI_aarch64_sqlite = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-3.46.1-5.el10_1.aarch64.rpm;name=aarch64_sqlite;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlite}"
SRC_URI[aarch64_sqlite.sha256sum] = "b2633b001a260c8cdeab67fc74014786b1a6f8fddba3bace6c1be4c50b8a6461"

URI_aarch64_sqlite-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/sqlite-devel-3.46.1-5.el10_1.aarch64.rpm;name=aarch64_sqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlite-devel}"
SRC_URI[aarch64_sqlite-devel.sha256sum] = "0bee280d3919645571a2d2ac5113cc749b405f54aa45c48317bf5e7554faade2"

URI_aarch64_sqlite-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/sqlite-libs-3.46.1-5.el10_1.aarch64.rpm;name=aarch64_sqlite-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_sqlite-libs}"
SRC_URI[aarch64_sqlite-libs.sha256sum] = "0e906151ff298cc7e8cfbec364864fa065bb5a91787cbf1927439b23806290ff"

RDEPENDS:sqlite = " \
 glibc \
 readline \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:sqlite-devel = " \
 pkgconf-pkg-config \
 sqlite \
 sqlite-libs \
 "
RDEPENDS:sqlite-libs = " \
 glibc \
 zlib-ng-compat \
 "
