# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-RC4"
PV = "2.02"
PR = "40.el10_0"
PACKAGES = " \
 perl-Crypt-RC4 \
 perl-Crypt-RC4-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-RC4-2.02-40.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d46be1901fc8a27ce8c6ae6b4d80437e8adcf10f236b23bffd63044eb6c48fe3"

URI_x86_64_v2_perl-Crypt-RC4 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-RC4-2.02-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-RC4;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-RC4}"
SRC_URI[x86_64_v2_perl-Crypt-RC4.sha256sum] = "3d318ecfead6092b713751b12d218d0facc256a22f6fb469bb056a2b165ad6f7"

URI_x86_64_v2_perl-Crypt-RC4-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-RC4-tests-2.02-40.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-RC4-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-RC4-tests}"
SRC_URI[x86_64_v2_perl-Crypt-RC4-tests.sha256sum] = "f706b872cc1f49fe63b1cf9f4d98f3021ddcbcd48f57672a91a9d05d303f7c09"

URI_aarch64_perl-Crypt-RC4 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-RC4-2.02-40.el10_0.noarch.rpm;name=aarch64_perl-Crypt-RC4;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-RC4}"
SRC_URI[aarch64_perl-Crypt-RC4.sha256sum] = "59a771dacefae44ae47c0e0541da97a1e5ab51bc5de7fa6195d835ad93548eb4"

URI_aarch64_perl-Crypt-RC4-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-RC4-tests-2.02-40.el10_0.noarch.rpm;name=aarch64_perl-Crypt-RC4-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-RC4-tests}"
SRC_URI[aarch64_perl-Crypt-RC4-tests.sha256sum] = "9360dae027f6669ce1121a9354cc1bdc8be47cd2bd229df78a4c599ad052eb49"

RDEPENDS:perl-Crypt-RC4 = " \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Crypt-RC4-tests = " \
 bash \
 perl-Crypt-RC4 \
 perl-Test-Harness \
 perl-libs \
 "
