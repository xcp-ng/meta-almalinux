# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aespipe"
PV = "2.4g"
PR = "2.el10_1"
PACKAGES = " \
 aespipe \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aespipe-2.4g-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7121380662c4101874a83105983668bed0a74294995d083e7dfdf2c3a987930"

URI_x86_64_v2_aespipe = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aespipe-2.4g-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aespipe;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aespipe}"
SRC_URI[x86_64_v2_aespipe.sha256sum] = "5fc0d79c5b58b642935ad12d668346b24f38721e7ca842711d746e0b1b32bf4d"

URI_aarch64_aespipe = "${EPEL_MIRROR}/aarch64/Packages/a/aespipe-2.4g-2.el10_1.aarch64.rpm;name=aarch64_aespipe;unpack=0"
SRC_URI:append = " ${URI_aarch64_aespipe}"
SRC_URI[aarch64_aespipe.sha256sum] = "9a48ed4b6814693c1ea06eecff1ab6a3d09953546fe25d47e1e1d040e4082724"

RDEPENDS:aespipe = " \
 glibc \
 gnupg2 \
 "
