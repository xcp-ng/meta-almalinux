# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-dalli"
PV = "3.2.0"
PR = "10.el10_2"
PACKAGES = " \
 rubygem-dalli \
 rubygem-dalli-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-dalli-3.2.0-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca0b7a16f311bd9a84e782fbe5840a757023f08527de5ee04cb956b4ae720ccb"

URI_x86_64_v2_rubygem-dalli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-dalli-3.2.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-dalli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-dalli}"
SRC_URI[x86_64_v2_rubygem-dalli.sha256sum] = "4301d580546d122af19da5e2c457aa94989105a49858abddc1542a8b392b5ed6"

URI_x86_64_v2_rubygem-dalli-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-dalli-doc-3.2.0-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-dalli-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-dalli-doc}"
SRC_URI[x86_64_v2_rubygem-dalli-doc.sha256sum] = "426b00ff03378e0db8eeec31cf221c97b4fb53b518a7191fa55de998f0761d59"

URI_aarch64_rubygem-dalli = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-dalli-3.2.0-10.el10_2.noarch.rpm;name=aarch64_rubygem-dalli;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-dalli}"
SRC_URI[aarch64_rubygem-dalli.sha256sum] = "cf321ba8516fdd50ab8168935bc12fab2d14830b0096fb70c48b90fedb969653"

URI_aarch64_rubygem-dalli-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-dalli-doc-3.2.0-10.el10_2.noarch.rpm;name=aarch64_rubygem-dalli-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-dalli-doc}"
SRC_URI[aarch64_rubygem-dalli-doc.sha256sum] = "b519a4196ed59d2b93ea0a7262fa3d04cbbbc22465b6733a5b0fa14beb29f78f"

RDEPENDS:rubygem-dalli = " \
 ruby-default-gems \
 rubygems \
 "
RDEPENDS:rubygem-dalli-doc = " \
 rubygem-dalli \
 "
