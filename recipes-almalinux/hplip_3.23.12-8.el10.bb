# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hplip"
PV = "3.23.12"
PR = "8.el10"
PACKAGES = " \
 hplip \
 hplip-common \
 hplip-libs \
 libsane-hpaio \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hplip-3.23.12-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0849aa8d889694f68607556f8db5777bb65325fa521cfabe8f14a19ebc4b7838"

URI_x86_64_v2_hplip = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hplip-3.23.12-8.el10.x86_64_v2.rpm;name=x86_64_v2_hplip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hplip}"
SRC_URI[x86_64_v2_hplip.sha256sum] = "487de0913659ea91992b9c64750cebd5b3498332a39a1b348e9c070d294ad225"

URI_x86_64_v2_hplip-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hplip-common-3.23.12-8.el10.x86_64_v2.rpm;name=x86_64_v2_hplip-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hplip-common}"
SRC_URI[x86_64_v2_hplip-common.sha256sum] = "6ec55da1a530756f4039e008298899ac37e9ebb23765354e49e2733e9bf66b32"

URI_x86_64_v2_hplip-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hplip-libs-3.23.12-8.el10.x86_64_v2.rpm;name=x86_64_v2_hplip-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hplip-libs}"
SRC_URI[x86_64_v2_hplip-libs.sha256sum] = "4fcfc0ee9a68622346dabf6b2ab4dcc9ca6918426835abd2bda9d94986fad2ae"

URI_x86_64_v2_libsane-hpaio = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libsane-hpaio-3.23.12-8.el10.x86_64_v2.rpm;name=x86_64_v2_libsane-hpaio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libsane-hpaio}"
SRC_URI[x86_64_v2_libsane-hpaio.sha256sum] = "af462d8a33615dfdf63f248af4e50732f32b79c137c873a3c9a4ad22e2bc58f4"

URI_aarch64_hplip = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hplip-3.23.12-8.el10.aarch64.rpm;name=aarch64_hplip;unpack=0"
SRC_URI:append = " ${URI_aarch64_hplip}"
SRC_URI[aarch64_hplip.sha256sum] = "0df31c1add0319a41ec56bfa99ca04daa6b79a03359cc6b24c89ab8f5a45f478"

URI_aarch64_hplip-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hplip-common-3.23.12-8.el10.aarch64.rpm;name=aarch64_hplip-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_hplip-common}"
SRC_URI[aarch64_hplip-common.sha256sum] = "9d83bb457d9d90a3fb4b3a5c9f90aa14315a813657a04187cb5ed41e95a90bf2"

URI_aarch64_hplip-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hplip-libs-3.23.12-8.el10.aarch64.rpm;name=aarch64_hplip-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_hplip-libs}"
SRC_URI[aarch64_hplip-libs.sha256sum] = "9c54a026479d4c8e46f4cb9d9214a75d80205365aadf62df71bbcc78f845d7bf"

URI_aarch64_libsane-hpaio = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libsane-hpaio-3.23.12-8.el10.aarch64.rpm;name=aarch64_libsane-hpaio;unpack=0"
SRC_URI:append = " ${URI_aarch64_libsane-hpaio}"
SRC_URI[aarch64_libsane-hpaio.sha256sum] = "ca6fe903802316f5cb4cac0c157652bf985a9176df16454efd80fbe1e023f54f"

RDEPENDS:hplip = " \
 bash \
 cups \
 cups-libs \
 curl \
 dbus-libs \
 gawk \
 glibc \
 gnupg2 \
 hplip-libs \
 libgcc \
 libjpeg-turbo \
 libstdc++ \
 python3 \
 python3-dbus \
 systemd \
 tar \
 usbutils \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:hplip-common = " \
 "
RDEPENDS:hplip-libs = " \
 avahi \
 avahi-libs \
 cups-libs \
 dbus-libs \
 glibc \
 hplip-common \
 libusb1 \
 net-snmp-libs \
 openssl-libs \
 python3 \
 sane-backends-libs \
 "
RDEPENDS:libsane-hpaio = " \
 avahi \
 avahi-libs \
 cups-libs \
 dbus-libs \
 glibc \
 hplip-libs \
 libusb1 \
 net-snmp-libs \
 openssl-libs \
 sane-backends \
 "
