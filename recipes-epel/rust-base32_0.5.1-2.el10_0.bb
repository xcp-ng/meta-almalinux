# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base32"
PV = "0.5.1"
PR = "2.el10_0"
PACKAGES = " \
 rust-base32+default-devel \
 rust-base32-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base32-0.5.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82a71a35094129cc3bcbcdadf75305264af3cc427b57faeec085034bf42ab844"

URI_x86_64_v2_rust-base32+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base32+default-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base32+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base32+default-devel}"
SRC_URI[x86_64_v2_rust-base32+default-devel.sha256sum] = "3846346a8695d5f7b52479fcafc15aa42764a7998b3dd10b91b49ad398490752"

URI_x86_64_v2_rust-base32-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base32-devel-0.5.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base32-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base32-devel}"
SRC_URI[x86_64_v2_rust-base32-devel.sha256sum] = "6ef358ee034549b14890651e68e34012b10b804e6accd1d825ac7936c186c027"

URI_aarch64_rust-base32+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base32+default-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-base32+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base32+default-devel}"
SRC_URI[aarch64_rust-base32+default-devel.sha256sum] = "9eb3b060f5d70730faf7b8e2a8a2fd0599b54a05d7ec68d6a9e7be97e911da62"

URI_aarch64_rust-base32-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base32-devel-0.5.1-2.el10_0.noarch.rpm;name=aarch64_rust-base32-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base32-devel}"
SRC_URI[aarch64_rust-base32-devel.sha256sum] = "03238b0194c7a6a82c0b4fc699442cdeda74b1d7605c2293b18ade51f3c8fe32"

RDEPENDS:rust-base32+default-devel = " \
 cargo \
 rust-base32-devel \
 "
RDEPENDS:rust-base32-devel = " \
 cargo \
 "
