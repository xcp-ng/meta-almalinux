# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gram_grep"
PV = "0.10.2"
PR = "4.el10_2"
PACKAGES = " \
 gram_grep \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gram_grep-0.10.2-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e5f2c44d0cc54a694e291ffd7e4e4bb45087084f767d017e21c8f3f383e4b09"

URI_x86_64_v2_gram_grep = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gram_grep-0.10.2-4.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_gram_grep;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gram_grep}"
SRC_URI[x86_64_v2_gram_grep.sha256sum] = "e417ba3cfd947e7407a810068e3d9ce82a1c8f0928413380fde09bb43f10e4a1"

URI_aarch64_gram_grep = "${EPEL_MIRROR}/aarch64/Packages/g/gram_grep-0.10.2-4.el10_2.aarch64.rpm;name=aarch64_gram_grep;unpack=0"
SRC_URI:append = " ${URI_aarch64_gram_grep}"
SRC_URI[aarch64_gram_grep.sha256sum] = "999ba11482d52e738a7c8b1e32fa8f0e56fbc926b4d310e8a7c41a8a101e7eff"

RDEPENDS:gram_grep = " \
 glibc \
 libgcc \
 libstdc++ \
 "
