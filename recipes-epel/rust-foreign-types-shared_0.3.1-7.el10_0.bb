# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-foreign-types-shared"
PV = "0.3.1"
PR = "7.el10_0"
PACKAGES = " \
 rust-foreign-types-shared+default-devel \
 rust-foreign-types-shared-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-foreign-types-shared-0.3.1-7.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fcb1d910e5cd53b7dbb8a16aa80d38ba37fee67fdb9961654e06bdf081d31758"

URI_x86_64_v2_rust-foreign-types-shared+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types-shared+default-devel-0.3.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types-shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types-shared+default-devel}"
SRC_URI[x86_64_v2_rust-foreign-types-shared+default-devel.sha256sum] = "fbc25cb21b8198bd16414da5b7b49e7f8f9d814f36af9b9120149ca570d9499b"

URI_x86_64_v2_rust-foreign-types-shared-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-foreign-types-shared-devel-0.3.1-7.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-foreign-types-shared-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-foreign-types-shared-devel}"
SRC_URI[x86_64_v2_rust-foreign-types-shared-devel.sha256sum] = "59d1db8dfeffd4e44b7ae25795aedcb43f8d72d14f40e3ee60fad80ec9dba762"

URI_aarch64_rust-foreign-types-shared+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types-shared+default-devel-0.3.1-7.el10_0.noarch.rpm;name=aarch64_rust-foreign-types-shared+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types-shared+default-devel}"
SRC_URI[aarch64_rust-foreign-types-shared+default-devel.sha256sum] = "5fdf303e50d42511e9322273b1e19b59bc9fd0a5144ee7446508b69e4911dd49"

URI_aarch64_rust-foreign-types-shared-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-foreign-types-shared-devel-0.3.1-7.el10_0.noarch.rpm;name=aarch64_rust-foreign-types-shared-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-foreign-types-shared-devel}"
SRC_URI[aarch64_rust-foreign-types-shared-devel.sha256sum] = "59af32258c0fa4012b99a35c6bb8874745ad5e42b03715dfd05e5c813b4458bf"

RDEPENDS:rust-foreign-types-shared+default-devel = " \
 cargo \
 rust-foreign-types-shared-devel \
 "
RDEPENDS:rust-foreign-types-shared-devel = " \
 cargo \
 "
