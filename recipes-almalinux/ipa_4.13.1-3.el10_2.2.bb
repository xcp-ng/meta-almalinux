# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ipa"
PV = "4.13.1"
PR = "3.el10_2.2"
PACKAGES = " \
 ipa-client \
 ipa-client-common \
 ipa-client-encrypted-dns \
 ipa-client-epn \
 ipa-client-samba \
 ipa-common \
 ipa-selinux \
 ipa-selinux-luna \
 ipa-selinux-nfast \
 ipa-server \
 ipa-server-common \
 ipa-server-dns \
 ipa-server-encrypted-dns \
 ipa-server-trust-ad \
 python3-ipaclient \
 python3-ipalib \
 python3-ipaserver \
 python3-ipatests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/ipa-4.13.1-3.el10_2.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "35a30ae0ae49c5c05a7c85a10321736e76a853a1bd088df5f0878166ecdd21f7"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - python3-ipaclient: augeas-libs >= 1.12.1-0
# - python3-ipaserver: augeas-libs >= 1.12.1-0

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - python3-ipaclient: augeas-libs >= 1.12.1-0
# - python3-ipaserver: augeas-libs >= 1.12.1-0

URI_x86_64_v2_ipa-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-4.13.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_ipa-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client}"
SRC_URI[x86_64_v2_ipa-client.sha256sum] = "e2d35ff3e569fe7e87c5f78c46f1857aa2db3c8cdcf3962d0727a7a6e27516dd"

URI_x86_64_v2_ipa-client-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-common-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_ipa-client-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-common}"
SRC_URI[x86_64_v2_ipa-client-common.sha256sum] = "c4fbe70d5583d4699e5c5aa411f3e861feb21e19cf38c226516e09b1b1efc247"

URI_x86_64_v2_ipa-client-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-encrypted-dns-4.13.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_ipa-client-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-encrypted-dns}"
SRC_URI[x86_64_v2_ipa-client-encrypted-dns.sha256sum] = "04ad23eb3768721aa9a915e711038b338b6988de2609fa4e24474050e7165a11"

URI_x86_64_v2_ipa-client-epn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-epn-4.13.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_ipa-client-epn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-epn}"
SRC_URI[x86_64_v2_ipa-client-epn.sha256sum] = "f84133069443f1aca3e2363774f0c6d5d6935e0e5584fb1fb1a910f7235d30f6"

URI_x86_64_v2_ipa-client-samba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-client-samba-4.13.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_ipa-client-samba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-client-samba}"
SRC_URI[x86_64_v2_ipa-client-samba.sha256sum] = "a80bca18a91feaf06178824e69b227d508ea46cc0f098508d09af9d8af2d3120"

URI_x86_64_v2_ipa-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-common-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_ipa-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-common}"
SRC_URI[x86_64_v2_ipa-common.sha256sum] = "5f6aa99de990853f920fd3239650c7191682f7da9cef171d3f23cb8e822c9ee3"

URI_x86_64_v2_ipa-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_ipa-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-selinux}"
SRC_URI[x86_64_v2_ipa-selinux.sha256sum] = "e121332c4f800ce14b2b222a3ef1a6796b656b1b91a6b05e4f998c0b34191a28"

URI_x86_64_v2_ipa-selinux-luna = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-luna-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_ipa-selinux-luna;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-selinux-luna}"
SRC_URI[x86_64_v2_ipa-selinux-luna.sha256sum] = "29a4a8bb83d9e612a2f998a9aa2c98ebba02bedb7c356c74531b4d6330ba0310"

URI_x86_64_v2_ipa-selinux-nfast = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-selinux-nfast-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_ipa-selinux-nfast;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-selinux-nfast}"
SRC_URI[x86_64_v2_ipa-selinux-nfast.sha256sum] = "191cff5a1e7310e24c3ca10e4e4f88164c8ecf231b35babbebf9600c61af5e22"

URI_x86_64_v2_ipa-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-4.13.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_ipa-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server}"
SRC_URI[x86_64_v2_ipa-server.sha256sum] = "ace99fa21a7eaefb6d8c4ebe254fb721f33db46a30fa9649cdb0d188a5868ab4"

URI_x86_64_v2_ipa-server-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-common-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_ipa-server-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-common}"
SRC_URI[x86_64_v2_ipa-server-common.sha256sum] = "ab4dac3dc4b4f0c97cca63ac8dc6b57cbd7aec8c5494167f3e43e59a153b1c6b"

URI_x86_64_v2_ipa-server-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-dns-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_ipa-server-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-dns}"
SRC_URI[x86_64_v2_ipa-server-dns.sha256sum] = "621b8d1e19618cb8f16a6a488856a4fbee94ce3d8811b9406a6cba417b0e6758"

URI_x86_64_v2_ipa-server-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-encrypted-dns-4.13.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_ipa-server-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-encrypted-dns}"
SRC_URI[x86_64_v2_ipa-server-encrypted-dns.sha256sum] = "dec58b66fef8ee411db5456240ac3cc93935b0a178c308dbb4b4a04c39e50cbf"

URI_x86_64_v2_ipa-server-trust-ad = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ipa-server-trust-ad-4.13.1-3.el10_2.2.x86_64_v2.rpm;name=x86_64_v2_ipa-server-trust-ad;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ipa-server-trust-ad}"
SRC_URI[x86_64_v2_ipa-server-trust-ad.sha256sum] = "da28ed567689e6d972386d08fb942591be48e4798fac8e60a5bc71f585b90f72"

URI_x86_64_v2_python3-ipaclient = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaclient-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_python3-ipaclient;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipaclient}"
SRC_URI[x86_64_v2_python3-ipaclient.sha256sum] = "721dd810a7a628d7fa06994893a9ad0e4a8d456631b7b3fd5c7de893bedf32f1"

URI_x86_64_v2_python3-ipalib = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipalib-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_python3-ipalib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipalib}"
SRC_URI[x86_64_v2_python3-ipalib.sha256sum] = "78f9b45cd00d72a463900b772147d3dd2c8ed546cdc396fc7c2d38f801c23f1c"

URI_x86_64_v2_python3-ipaserver = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-ipaserver-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_python3-ipaserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipaserver}"
SRC_URI[x86_64_v2_python3-ipaserver.sha256sum] = "1e738a8e37b342572c83acd42cb7588afdb90dfc46e803ce4985843482845ec6"

URI_x86_64_v2_python3-ipatests = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-ipatests-4.13.1-3.el10_2.2.noarch.rpm;name=x86_64_v2_python3-ipatests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipatests}"
SRC_URI[x86_64_v2_python3-ipatests.sha256sum] = "8c14446fd5b69dc95033799a64c25682325fbd939214ff1297db7acdb70c8242"

URI_aarch64_ipa-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-4.13.1-3.el10_2.2.aarch64.rpm;name=aarch64_ipa-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client}"
SRC_URI[aarch64_ipa-client.sha256sum] = "ab5316c58b6616366bd04e24971826b3a25c15381287a26413510095f2c9c8be"

URI_aarch64_ipa-client-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-common-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_ipa-client-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-common}"
SRC_URI[aarch64_ipa-client-common.sha256sum] = "c4fbe70d5583d4699e5c5aa411f3e861feb21e19cf38c226516e09b1b1efc247"

URI_aarch64_ipa-client-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-encrypted-dns-4.13.1-3.el10_2.2.aarch64.rpm;name=aarch64_ipa-client-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-encrypted-dns}"
SRC_URI[aarch64_ipa-client-encrypted-dns.sha256sum] = "d773db5c6a6deab1f8bdfff813889a9d0ecbbe0ed130e257faff40647b562430"

URI_aarch64_ipa-client-epn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-epn-4.13.1-3.el10_2.2.aarch64.rpm;name=aarch64_ipa-client-epn;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-epn}"
SRC_URI[aarch64_ipa-client-epn.sha256sum] = "10131f515ac65bab84e80014f3ff391ac9759bb0c728aae730a350cab8ae993f"

URI_aarch64_ipa-client-samba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-client-samba-4.13.1-3.el10_2.2.aarch64.rpm;name=aarch64_ipa-client-samba;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-client-samba}"
SRC_URI[aarch64_ipa-client-samba.sha256sum] = "fa4ae6a45fee4d9cf6b17ddfe21c9a469328e95023455b741da675d669ff707b"

URI_aarch64_ipa-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-common-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_ipa-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-common}"
SRC_URI[aarch64_ipa-common.sha256sum] = "5f6aa99de990853f920fd3239650c7191682f7da9cef171d3f23cb8e822c9ee3"

URI_aarch64_ipa-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_ipa-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-selinux}"
SRC_URI[aarch64_ipa-selinux.sha256sum] = "e121332c4f800ce14b2b222a3ef1a6796b656b1b91a6b05e4f998c0b34191a28"

URI_aarch64_ipa-selinux-luna = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-luna-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_ipa-selinux-luna;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-selinux-luna}"
SRC_URI[aarch64_ipa-selinux-luna.sha256sum] = "29a4a8bb83d9e612a2f998a9aa2c98ebba02bedb7c356c74531b4d6330ba0310"

URI_aarch64_ipa-selinux-nfast = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-selinux-nfast-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_ipa-selinux-nfast;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-selinux-nfast}"
SRC_URI[aarch64_ipa-selinux-nfast.sha256sum] = "191cff5a1e7310e24c3ca10e4e4f88164c8ecf231b35babbebf9600c61af5e22"

URI_aarch64_ipa-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-4.13.1-3.el10_2.2.aarch64.rpm;name=aarch64_ipa-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server}"
SRC_URI[aarch64_ipa-server.sha256sum] = "9df88235b9100f62b665dfb81ff44ba62edcafbecbab903b05891c60a76b8b45"

URI_aarch64_ipa-server-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-common-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_ipa-server-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-common}"
SRC_URI[aarch64_ipa-server-common.sha256sum] = "ab4dac3dc4b4f0c97cca63ac8dc6b57cbd7aec8c5494167f3e43e59a153b1c6b"

URI_aarch64_ipa-server-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-dns-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_ipa-server-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-dns}"
SRC_URI[aarch64_ipa-server-dns.sha256sum] = "621b8d1e19618cb8f16a6a488856a4fbee94ce3d8811b9406a6cba417b0e6758"

URI_aarch64_ipa-server-encrypted-dns = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-encrypted-dns-4.13.1-3.el10_2.2.aarch64.rpm;name=aarch64_ipa-server-encrypted-dns;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-encrypted-dns}"
SRC_URI[aarch64_ipa-server-encrypted-dns.sha256sum] = "0926dbd8725aac9dc56a66136ad6fc1aaf501c2276dd41a437a9dcdf48802eb9"

URI_aarch64_ipa-server-trust-ad = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ipa-server-trust-ad-4.13.1-3.el10_2.2.aarch64.rpm;name=aarch64_ipa-server-trust-ad;unpack=0"
SRC_URI:append = " ${URI_aarch64_ipa-server-trust-ad}"
SRC_URI[aarch64_ipa-server-trust-ad.sha256sum] = "9a8f1983b0fb2941c933650d86cddd9f96719b98649fcc7a9de5aa138d17ffb9"

URI_aarch64_python3-ipaclient = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaclient-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_python3-ipaclient;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipaclient}"
SRC_URI[aarch64_python3-ipaclient.sha256sum] = "721dd810a7a628d7fa06994893a9ad0e4a8d456631b7b3fd5c7de893bedf32f1"

URI_aarch64_python3-ipalib = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipalib-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_python3-ipalib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipalib}"
SRC_URI[aarch64_python3-ipalib.sha256sum] = "78f9b45cd00d72a463900b772147d3dd2c8ed546cdc396fc7c2d38f801c23f1c"

URI_aarch64_python3-ipaserver = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-ipaserver-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_python3-ipaserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipaserver}"
SRC_URI[aarch64_python3-ipaserver.sha256sum] = "1e738a8e37b342572c83acd42cb7588afdb90dfc46e803ce4985843482845ec6"

URI_aarch64_python3-ipatests = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-ipatests-4.13.1-3.el10_2.2.noarch.rpm;name=aarch64_python3-ipatests;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipatests}"
SRC_URI[aarch64_python3-ipatests.sha256sum] = "8c14446fd5b69dc95033799a64c25682325fbd939214ff1297db7acdb70c8242"

RDEPENDS:ipa-client = " \
 authselect \
 autofs \
 bash \
 bind-utils \
 certmonger \
 chrony \
 curl \
 cyrus-sasl-gssapi \
 glibc \
 hostname \
 ipa-client-common \
 ipa-common \
 jansson \
 krb5-libs \
 krb5-pkinit \
 krb5-workstation \
 libcom_err \
 libini_config \
 libnfsidmap \
 libsss_autofs \
 libsss_sudo \
 nss-tools \
 oddjob-mkhomedir \
 openldap \
 openssl-libs \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaclient \
 python3-ldap \
 python3-sssdconfig \
 sssd-idp \
 sssd-ipa \
 sssd-krb5 \
 sssd-tools \
 virtual/libcurl.so.4___64bit_ \
 virtual/libcurl_ge_7.21.7-2 \
 virtual/nfs-utils_or_nfsv4-client-utils \
 "
RDEPENDS:ipa-client-common = " \
 "
RDEPENDS:ipa-client-encrypted-dns = " \
 unbound \
 "
RDEPENDS:ipa-client-epn = " \
 bash \
 ipa-client \
 python3 \
 systemd \
 "
RDEPENDS:ipa-client-samba = " \
 cifs-utils \
 ipa-client \
 python3 \
 python3-samba \
 samba \
 samba-client \
 samba-common-tools \
 samba-winbind \
 sssd-winbind-idmap \
 tdb-tools \
 "
RDEPENDS:ipa-common = " \
 ipa-selinux \
 "
RDEPENDS:ipa-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-luna = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-selinux-nfast = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
RDEPENDS:ipa-server = " \
 389-ds-base \
 acl \
 bash \
 certmonger \
 chrony \
 cracklib-dicts \
 cyrus-sasl-gssapi \
 fontawesome4-fonts \
 glibc \
 gssproxy \
 gzip \
 httpd \
 idm-pki-acme \
 idm-pki-ca \
 idm-pki-kra \
 ipa-client \
 ipa-common \
 ipa-server-common \
 jansson \
 krb5-libs \
 krb5-server \
 libcom_err \
 libgcc \
 libpwquality \
 libsss_certmap \
 libsss_nss_idmap \
 libtalloc \
 libtevent \
 libunistring \
 libuuid \
 libverto \
 mod_auth_gssapi \
 mod_lookup_identity \
 mod_session \
 mod_ssl \
 nss-tools \
 oddjob \
 open-sans-fonts \
 openldap \
 openldap-clients \
 openssl \
 openssl-libs \
 p11-kit \
 policycoreutils \
 popt \
 python3 \
 python3-gssapi \
 python3-ipaserver \
 python3-ldap \
 python3-mod_wsgi \
 python3-systemd \
 samba-client-libs \
 selinux-policy \
 shadow-utils \
 slapi-nis \
 softhsm \
 sssd-dbus \
 systemd \
 tar \
 "
RDEPENDS:ipa-server-common = " \
 almalinux-logos-ipa \
 httpd \
 ipa-client-common \
 systemd \
 "
RDEPENDS:ipa-server-dns = " \
 bash \
 bind \
 bind-dnssec-utils \
 bind-dyndb-ldap \
 bind-utils \
 ipa-server \
 opendnssec \
 pkcs11-provider \
 python3 \
 softhsm \
 systemd \
 "
RDEPENDS:ipa-server-encrypted-dns = " \
 bind-dyndb-ldap \
 ipa-client-encrypted-dns \
 "
RDEPENDS:ipa-server-trust-ad = " \
 alternatives \
 bash \
 glibc \
 ipa-common \
 ipa-server \
 krb5-libs \
 libcom_err \
 libpwquality \
 libsss_idmap \
 libtalloc \
 libtevent \
 openldap \
 openssl-libs \
 python3 \
 python3-libsss_nss_idmap \
 python3-samba \
 python3-sss \
 samba \
 samba-client-libs \
 samba-winbind \
 sssd-winbind-idmap \
 "
RDEPENDS:python3-ipaclient = " \
 ipa-client-common \
 ipa-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dns \
 python3-ipalib \
 python3-jinja2 \
 python3-qrcode \
 python3-six \
 "
RDEPENDS:python3-ipalib = " \
 gnupg2 \
 ipa-common \
 keyutils \
 python3 \
 python3-argcomplete \
 python3-cffi \
 python3-cryptography \
 python3-dateutil \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-ifaddr \
 python3-jwcrypto \
 python3-ldap \
 python3-libipa_hbac \
 python3-netaddr \
 python3-packaging \
 python3-pyasn1 \
 python3-pyasn1-modules \
 python3-pyusb \
 python3-qrcode \
 python3-requests \
 python3-six \
 python3-sss-murmur \
 python3-systemd \
 python3-urllib3 \
 python3-yubico \
 "
RDEPENDS:python3-ipaserver = " \
 ipa-common \
 ipa-server-common \
 python3 \
 python3-augeas \
 python3-cryptography \
 python3-dbus \
 python3-dns \
 python3-gssapi \
 python3-idm-pki \
 python3-ipaclient \
 python3-ipalib \
 python3-jwcrypto \
 python3-kdcproxy \
 python3-ldap \
 python3-lxml \
 python3-netaddr \
 python3-psutil \
 python3-pyasn1 \
 python3-requests \
 python3-six \
 python3-sssdconfig \
 python3-urllib3 \
 rpm-libs \
 "
RDEPENDS:python3-ipatests = " \
 iptables-nft \
 openssh-clients \
 python3-cryptography \
 python3-ipaclient \
 python3-ipaserver \
 python3-sssdconfig \
 tar \
 xz \
 "
