# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-jq"
PV = "1.7.0"
PR = "1.el10_2"
PACKAGES = " \
 python3-jq \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-jq-1.7.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "06730c0d1ce1414b0b65229b35499ee377739a95893c02406456d9ae72b700e2"

URI_x86_64_v2_python3-jq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-jq-1.7.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-jq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-jq}"
SRC_URI[x86_64_v2_python3-jq.sha256sum] = "46b4e328026f57d99b0336614f7e5e45841f4e8efc5f1b2bae8ac5b75bafd355"

URI_aarch64_python3-jq = "${EPEL_MIRROR}/aarch64/Packages/p/python3-jq-1.7.0-1.el10_2.aarch64.rpm;name=aarch64_python3-jq;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-jq}"
SRC_URI[aarch64_python3-jq.sha256sum] = "7f70df219b7648c8f806941fa95ea45e2bf06027eda53371e8641e2965fa61f4"

RDEPENDS:python3-jq = " \
 glibc \
 jq \
 python3 \
 "
