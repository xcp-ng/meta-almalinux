# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pulp-cli"
PV = "0.37.0"
PR = "1.el10_2"
PACKAGES = " \
 pulp-cli \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pulp-cli-0.37.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8192fb060a07b9ff8a5fbbcbb161849efdfbe9f9cb59ec1f7e4d8f93775b5cbc"

URI_x86_64_v2_pulp-cli = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pulp-cli-0.37.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pulp-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pulp-cli}"
SRC_URI[x86_64_v2_pulp-cli.sha256sum] = "82b06178cba28760b22753f1379eff5252f5e4e783e0c9603f20ff4d735fa9f8"

URI_aarch64_pulp-cli = "${EPEL_MIRROR}/aarch64/Packages/p/pulp-cli-0.37.0-1.el10_2.noarch.rpm;name=aarch64_pulp-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_pulp-cli}"
SRC_URI[aarch64_pulp-cli.sha256sum] = "b6c5243b06c718d9ebd2c01e676c2f67c342bffd2033a9b688c86d3d8a7ec41b"

RDEPENDS:pulp-cli = " \
 python3 \
 python3-click \
 python3-pulp-glue \
 python3-pyyaml \
 python3-schema \
 python3-tomli-w \
 "
