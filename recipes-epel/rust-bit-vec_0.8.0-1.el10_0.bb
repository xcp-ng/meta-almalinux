# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-bit-vec"
PV = "0.8.0"
PR = "1.el10_0"
PACKAGES = " \
 rust-bit-vec+default-devel \
 rust-bit-vec+serde-devel \
 rust-bit-vec+serde_no_std-devel \
 rust-bit-vec+serde_std-devel \
 rust-bit-vec+std-devel \
 rust-bit-vec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-bit-vec-0.8.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4410836a80f27daee5caaaa902e96a2b4f187c3280763b1a0908b0902915f2b3"

URI_x86_64_v2_rust-bit-vec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec+default-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec+default-devel}"
SRC_URI[x86_64_v2_rust-bit-vec+default-devel.sha256sum] = "3907993274e2b10d69305c41d4d27eeaec8f8d370ce863a562376f374f803451"

URI_x86_64_v2_rust-bit-vec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec+serde-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec+serde-devel}"
SRC_URI[x86_64_v2_rust-bit-vec+serde-devel.sha256sum] = "21c367e6e33e6b11a85c79b72b0b05255f7f763b48672542c2ee49dc275c2941"

URI_x86_64_v2_rust-bit-vec+serde_no_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec+serde_no_std-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec+serde_no_std-devel}"
SRC_URI[x86_64_v2_rust-bit-vec+serde_no_std-devel.sha256sum] = "a93dcde02d5e81a53a40d3cdacff0039c4e4f3f574dc75db949a33906f710e4f"

URI_x86_64_v2_rust-bit-vec+serde_std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec+serde_std-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec+serde_std-devel}"
SRC_URI[x86_64_v2_rust-bit-vec+serde_std-devel.sha256sum] = "0cf0e9397d7e648949ab7efecf1f685a26912b14f425de8dadc639930e28523b"

URI_x86_64_v2_rust-bit-vec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec+std-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec+std-devel}"
SRC_URI[x86_64_v2_rust-bit-vec+std-devel.sha256sum] = "9c0625acb70223a8d318eb34874253bfd0b7176e8e2012645bf86126b24ce000"

URI_x86_64_v2_rust-bit-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-bit-vec-devel-0.8.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-bit-vec-devel}"
SRC_URI[x86_64_v2_rust-bit-vec-devel.sha256sum] = "af09d0938a53962c7d9f24d7ddf3b261ae3908759b191b6657d6659446b03442"

URI_aarch64_rust-bit-vec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec+default-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec+default-devel}"
SRC_URI[aarch64_rust-bit-vec+default-devel.sha256sum] = "225aad00ed4a0bdc0625d504620dd34a1ce8d463ebdacd9a986714258bd41ff5"

URI_aarch64_rust-bit-vec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec+serde-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec+serde-devel}"
SRC_URI[aarch64_rust-bit-vec+serde-devel.sha256sum] = "8c0f750c21155c5440c98abfa84974f5bf51e76b18d222bfd80ba3ebc004be25"

URI_aarch64_rust-bit-vec+serde_no_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec+serde_no_std-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec+serde_no_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec+serde_no_std-devel}"
SRC_URI[aarch64_rust-bit-vec+serde_no_std-devel.sha256sum] = "21e11727ec35e9356e01b889aa6331b100b87ddfaf04ef2531ccf2ea71b4f994"

URI_aarch64_rust-bit-vec+serde_std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec+serde_std-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec+serde_std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec+serde_std-devel}"
SRC_URI[aarch64_rust-bit-vec+serde_std-devel.sha256sum] = "1b6356f9e0ffcc54403071d46ee5564dcf8df599dd9adc49a5232e4e2d1fedbe"

URI_aarch64_rust-bit-vec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec+std-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec+std-devel}"
SRC_URI[aarch64_rust-bit-vec+std-devel.sha256sum] = "dba9012d17b3e9140d57258e85606888667aa727344342e092a7cf1c08fe9bbe"

URI_aarch64_rust-bit-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-bit-vec-devel-0.8.0-1.el10_0.noarch.rpm;name=aarch64_rust-bit-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-bit-vec-devel}"
SRC_URI[aarch64_rust-bit-vec-devel.sha256sum] = "85a1e6e27a8de93b5c6745114dc76b7bd4ce59bf4f8de4b1f502d2af795fcadc"

RDEPENDS:rust-bit-vec+default-devel = " \
 cargo \
 rust-bit-vec+std-devel \
 rust-bit-vec-devel \
 "
RDEPENDS:rust-bit-vec+serde-devel = " \
 cargo \
 rust-bit-vec-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bit-vec+serde_no_std-devel = " \
 cargo \
 rust-bit-vec-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bit-vec+serde_std-devel = " \
 cargo \
 rust-bit-vec+std-devel \
 rust-bit-vec-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-bit-vec+std-devel = " \
 cargo \
 rust-bit-vec-devel \
 "
RDEPENDS:rust-bit-vec-devel = " \
 cargo \
 "
