# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cryptsetup"
PV = "2.7.5"
PR = "2.el10"
PACKAGES = " \
 cryptsetup \
 cryptsetup-devel \
 cryptsetup-libs \
 integritysetup \
 veritysetup \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cryptsetup-2.7.5-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b181f0a6b22caedcd09250d9dcd648ba013ebd5129fc59cdcb8adf7094c9dc8f"

URI_x86_64_v2_cryptsetup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cryptsetup-2.7.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptsetup}"
SRC_URI[x86_64_v2_cryptsetup.sha256sum] = "6c1aaf898f356f35075c6d01e6c0ec7f9d8825e36961fa369f7de0eef2424374"

URI_x86_64_v2_cryptsetup-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cryptsetup-devel-2.7.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptsetup-devel}"
SRC_URI[x86_64_v2_cryptsetup-devel.sha256sum] = "e30f23c2790b6989f994e727b8ae15da31a9a33fdd4c268902765b070b1d4d46"

URI_x86_64_v2_cryptsetup-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cryptsetup-libs-2.7.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_cryptsetup-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cryptsetup-libs}"
SRC_URI[x86_64_v2_cryptsetup-libs.sha256sum] = "5d1e8f853b4d9d646204c59ca68d2a51c83db21bf0db6c48948b7e12b3fdd73a"

URI_x86_64_v2_integritysetup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/integritysetup-2.7.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_integritysetup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_integritysetup}"
SRC_URI[x86_64_v2_integritysetup.sha256sum] = "bf5fde57e03500395350d72ff05b3388c69b3a06638b48d05f8ec8b8015ac255"

URI_x86_64_v2_veritysetup = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/veritysetup-2.7.5-2.el10.x86_64_v2.rpm;name=x86_64_v2_veritysetup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_veritysetup}"
SRC_URI[x86_64_v2_veritysetup.sha256sum] = "cb6aa267092da67ca2a9c4881a208d0abbf52fc8d0ff865ffd887b6a6168f758"

URI_aarch64_cryptsetup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cryptsetup-2.7.5-2.el10.aarch64.rpm;name=aarch64_cryptsetup;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptsetup}"
SRC_URI[aarch64_cryptsetup.sha256sum] = "77d04e61621470be435c414909ab8df0448224467533bbaa98c007e958d949f1"

URI_aarch64_cryptsetup-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cryptsetup-devel-2.7.5-2.el10.aarch64.rpm;name=aarch64_cryptsetup-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptsetup-devel}"
SRC_URI[aarch64_cryptsetup-devel.sha256sum] = "326c17a3cb4eb3994bb07f77068baf0e1c21c217db8c57ef0892425c57216f5b"

URI_aarch64_cryptsetup-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cryptsetup-libs-2.7.5-2.el10.aarch64.rpm;name=aarch64_cryptsetup-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_cryptsetup-libs}"
SRC_URI[aarch64_cryptsetup-libs.sha256sum] = "72b3b25017d7661b5c7fcfc1a53f330b381a22f74f677b9315856b164b3603df"

URI_aarch64_integritysetup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/integritysetup-2.7.5-2.el10.aarch64.rpm;name=aarch64_integritysetup;unpack=0"
SRC_URI:append = " ${URI_aarch64_integritysetup}"
SRC_URI[aarch64_integritysetup.sha256sum] = "93c7b109463cfa0202e574fef946276a37462d0ce75c003c40068d9a4cc1bd09"

URI_aarch64_veritysetup = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/veritysetup-2.7.5-2.el10.aarch64.rpm;name=aarch64_veritysetup;unpack=0"
SRC_URI:append = " ${URI_aarch64_veritysetup}"
SRC_URI[aarch64_veritysetup.sha256sum] = "9b0eeda68ed5557a63e863d8bad15394090987332965b345918c7e45919f65b4"

RDEPENDS:cryptsetup = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libpwquality \
 libuuid \
 popt \
 "
RDEPENDS:cryptsetup-devel = " \
 cryptsetup-libs \
 device-mapper-devel \
 json-c-devel \
 libblkid-devel \
 libuuid-devel \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:cryptsetup-libs = " \
 device-mapper-libs \
 glibc \
 json-c \
 libblkid \
 libuuid \
 openssl-libs \
 "
RDEPENDS:integritysetup = " \
 cryptsetup-libs \
 glibc \
 libblkid \
 libuuid \
 popt \
 "
RDEPENDS:veritysetup = " \
 cryptsetup-libs \
 glibc \
 popt \
 "
