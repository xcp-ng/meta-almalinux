# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-thiserror-impl"
PV = "2.0.18"
PR = "1.el10_1"
PACKAGES = " \
 rust-thiserror-impl+default-devel \
 rust-thiserror-impl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-thiserror-impl-2.0.18-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f23741d75f83052e1ed5a92e239293714522cdedf54f3d201a461f2c09e8612"

URI_x86_64_v2_rust-thiserror-impl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl+default-devel-2.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-impl+default-devel}"
SRC_URI[x86_64_v2_rust-thiserror-impl+default-devel.sha256sum] = "e3550197c9facc48631c700c8530ad278d0c49ce7ce25cab412d43b176a29d71"

URI_x86_64_v2_rust-thiserror-impl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-thiserror-impl-devel-2.0.18-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-thiserror-impl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-thiserror-impl-devel}"
SRC_URI[x86_64_v2_rust-thiserror-impl-devel.sha256sum] = "daf09ef5913158de614c07153455c425dbca4016e8546cc2b0f3f374a275409c"

URI_aarch64_rust-thiserror-impl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl+default-devel-2.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-thiserror-impl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-impl+default-devel}"
SRC_URI[aarch64_rust-thiserror-impl+default-devel.sha256sum] = "31df4fcb4526bcb0f541ab0257a451e8a0c41173a180c47278d9c7f2f4fb78b7"

URI_aarch64_rust-thiserror-impl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-thiserror-impl-devel-2.0.18-1.el10_1.noarch.rpm;name=aarch64_rust-thiserror-impl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-thiserror-impl-devel}"
SRC_URI[aarch64_rust-thiserror-impl-devel.sha256sum] = "dfb08d52309b85350432609e1a50658911f895e3382df445729fb3d8eb2b3581"

RDEPENDS:rust-thiserror-impl+default-devel = " \
 cargo \
 rust-thiserror-impl-devel \
 "
RDEPENDS:rust-thiserror-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 "
