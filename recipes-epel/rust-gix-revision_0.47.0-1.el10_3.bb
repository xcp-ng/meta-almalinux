# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-revision"
PV = "0.47.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-gix-revision+default-devel \
 rust-gix-revision+describe-devel \
 rust-gix-revision+document-features-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision+serde-devel \
 rust-gix-revision+sha1-devel \
 rust-gix-revision+sha256-devel \
 rust-gix-revision-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-revision-0.47.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d5bc3227a5667364cc7b1da1322162b9dd809da89adef0f540af83552aaaceda"

URI_x86_64_v2_rust-gix-revision+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+default-devel-0.47.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+default-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+default-devel.sha256sum] = "84aca6b601dead782398ee68a1dae47bbf2a83a125766a24adadc9fd0764ae16"

URI_x86_64_v2_rust-gix-revision+describe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+describe-devel-0.47.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+describe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+describe-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+describe-devel.sha256sum] = "4b585d2cbbc0be9cee6c66038559fcbd5804b97dc71bacb924e5601327c44aa3"

URI_x86_64_v2_rust-gix-revision+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+document-features-devel-0.47.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+document-features-devel.sha256sum] = "03ffd1c4a77d5d403e0f3df88a8ee5ab519a5b84ae7235163ef8f50dd2286356"

URI_x86_64_v2_rust-gix-revision+merge_base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+merge_base-devel-0.47.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+merge_base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+merge_base-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+merge_base-devel.sha256sum] = "d7ef34bd136dfbcb1de3bf10f5fb30f106fa9cf1657fb39370c3311d7d506c0b"

URI_x86_64_v2_rust-gix-revision+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+serde-devel-0.47.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+serde-devel.sha256sum] = "ef40941ae082aabea5a6fb0e37640879e237a9f10e7aac9d78d88169f766222e"

URI_x86_64_v2_rust-gix-revision+sha1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+sha1-devel-0.47.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+sha1-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+sha1-devel.sha256sum] = "3c07ac643e4a6d33724c77b166b13584a688d81b54267184b009bd35d4fb14c1"

URI_x86_64_v2_rust-gix-revision+sha256-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision+sha256-devel-0.47.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision+sha256-devel}"
SRC_URI[x86_64_v2_rust-gix-revision+sha256-devel.sha256sum] = "e4cbd52381db413b1a82015aa0430055fbe6f2cd2ab2eeacc70193ea06e266c6"

URI_x86_64_v2_rust-gix-revision-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-revision-devel-0.47.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-revision-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-revision-devel}"
SRC_URI[x86_64_v2_rust-gix-revision-devel.sha256sum] = "32679e9e352b3462e185fa85ffe98428db696356278e16b4d426d4c2bfc8afa5"

URI_aarch64_rust-gix-revision+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+default-devel-0.47.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revision+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+default-devel}"
SRC_URI[aarch64_rust-gix-revision+default-devel.sha256sum] = "b4040687e12a61c46a94e74f01624886ea81544e5c23e4645655a2d513e9cc5b"

URI_aarch64_rust-gix-revision+describe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+describe-devel-0.47.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revision+describe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+describe-devel}"
SRC_URI[aarch64_rust-gix-revision+describe-devel.sha256sum] = "a324fd901cde829eba9181d3b4203342ceb507847931f06505f062509d6d568d"

URI_aarch64_rust-gix-revision+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+document-features-devel-0.47.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revision+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+document-features-devel}"
SRC_URI[aarch64_rust-gix-revision+document-features-devel.sha256sum] = "2b62aded44edcf847bd67c3adcc359614548dccd2412c8e2cb42c27eaabca3d4"

URI_aarch64_rust-gix-revision+merge_base-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+merge_base-devel-0.47.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revision+merge_base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+merge_base-devel}"
SRC_URI[aarch64_rust-gix-revision+merge_base-devel.sha256sum] = "330f66080b5dfe1cc647e37f0bbe1de794b623cf7c15b8d47f6c806a61710ac1"

URI_aarch64_rust-gix-revision+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+serde-devel-0.47.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revision+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+serde-devel}"
SRC_URI[aarch64_rust-gix-revision+serde-devel.sha256sum] = "e6e5244d5b026f0ba363e5e62a47d94e8ff17a36bed856a24df5977496f306e7"

URI_aarch64_rust-gix-revision+sha1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+sha1-devel-0.47.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revision+sha1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+sha1-devel}"
SRC_URI[aarch64_rust-gix-revision+sha1-devel.sha256sum] = "5fd127a33b57d415252e9868d8c40642fbfa8e2a48b0d69e94d9845e833be1e7"

URI_aarch64_rust-gix-revision+sha256-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision+sha256-devel-0.47.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revision+sha256-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision+sha256-devel}"
SRC_URI[aarch64_rust-gix-revision+sha256-devel.sha256sum] = "a834a1a9f38ecd305051fb128bf0433e893cbfa4efc644401e4655ddb0f50675"

URI_aarch64_rust-gix-revision-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-revision-devel-0.47.0-1.el10_3.noarch.rpm;name=aarch64_rust-gix-revision-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-revision-devel}"
SRC_URI[aarch64_rust-gix-revision-devel.sha256sum] = "a5d53fcbf6091d0f1ef240e20c93d45d3903c3a59191627fd8eb213fe130664f"

RDEPENDS:rust-gix-revision+default-devel = " \
 cargo \
 rust-gix-revision+describe-devel \
 rust-gix-revision+merge_base-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision+describe-devel = " \
 cargo \
 rust-gix-hashtable+default-devel \
 rust-gix-revision-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-revision+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision+merge_base-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-gix-revision-devel \
 rust-gix-trace+default-devel \
 "
RDEPENDS:rust-gix-revision+serde-devel = " \
 cargo \
 rust-gix-hash+serde-devel \
 rust-gix-object+serde-devel \
 rust-gix-revision-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-revision+sha1-devel = " \
 cargo \
 rust-gix-hash+sha1-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision+sha256-devel = " \
 cargo \
 rust-gix-hash+sha256-devel \
 rust-gix-revision-devel \
 "
RDEPENDS:rust-gix-revision-devel = " \
 cargo \
 rust \
 rust-bstr+std-devel \
 rust-bstr-devel \
 rust-gix-commitgraph+default-devel \
 rust-gix-date+default-devel \
 rust-gix-error+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-revwalk+default-devel \
 rust-nonempty+default-devel \
 "
