# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-cattrs"
PV = "24.1.3"
PR = "3.el10_1"
PACKAGES = " \
 python3-cattrs \
 python3-cattrs+bson \
 python3-cattrs+msgpack \
 python3-cattrs+orjson \
 python3-cattrs+pyyaml \
 python3-cattrs+tomlkit \
 python3-cattrs+ujson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-cattrs-24.1.3-3.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2972d433560af83e0c0dab459d02f797cbec7f6eb7e25f01fb32e104a0c1ecdd"

URI_x86_64_v2_python3-cattrs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs-24.1.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs}"
SRC_URI[x86_64_v2_python3-cattrs.sha256sum] = "e863fc9b9c271c7588796e8e3776e0f2dd5a1436b20f55e44e799385f38fbdb1"

URI_x86_64_v2_python3-cattrs+bson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+bson-24.1.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+bson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+bson}"
SRC_URI[x86_64_v2_python3-cattrs+bson.sha256sum] = "929d2e7d0ba46477bc8d5fe8b6be617ce886fee384c36ba550430b3c9ce4972c"

URI_x86_64_v2_python3-cattrs+msgpack = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+msgpack-24.1.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+msgpack;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+msgpack}"
SRC_URI[x86_64_v2_python3-cattrs+msgpack.sha256sum] = "069dfae41bcc73bf57c7cd902e95007d6706f7c035864de0677933cc54afc31f"

URI_x86_64_v2_python3-cattrs+orjson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+orjson-24.1.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+orjson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+orjson}"
SRC_URI[x86_64_v2_python3-cattrs+orjson.sha256sum] = "cafc859432e75f06fec343d5038fb3aad9079851d70234805f8a97cb9a7b2cbc"

URI_x86_64_v2_python3-cattrs+pyyaml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+pyyaml-24.1.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+pyyaml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+pyyaml}"
SRC_URI[x86_64_v2_python3-cattrs+pyyaml.sha256sum] = "736fc1809025ce879ea3853ef52bf475079966dd027702db4385ca1111b5715f"

URI_x86_64_v2_python3-cattrs+tomlkit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+tomlkit-24.1.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+tomlkit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+tomlkit}"
SRC_URI[x86_64_v2_python3-cattrs+tomlkit.sha256sum] = "b65f99a08b7f998cdaa15d1d67c33af4a8865ea512dd9426e9045933edf6376f"

URI_x86_64_v2_python3-cattrs+ujson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-cattrs+ujson-24.1.3-3.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-cattrs+ujson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-cattrs+ujson}"
SRC_URI[x86_64_v2_python3-cattrs+ujson.sha256sum] = "ef563efb7820d3a2661860798e3c283bd8cc1357a2351c1eebeb21ebcf7fd573"

URI_aarch64_python3-cattrs = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs-24.1.3-3.el10_1.noarch.rpm;name=aarch64_python3-cattrs;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs}"
SRC_URI[aarch64_python3-cattrs.sha256sum] = "488c1d9a1388964cce1c099bf16869d85fdac29faff896f872de67545e63c7b2"

URI_aarch64_python3-cattrs+bson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+bson-24.1.3-3.el10_1.noarch.rpm;name=aarch64_python3-cattrs+bson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+bson}"
SRC_URI[aarch64_python3-cattrs+bson.sha256sum] = "d5fce49fb0ea843c748b7792e86cbb6df975405e4b30761d1ecff94b36ffb5bc"

URI_aarch64_python3-cattrs+msgpack = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+msgpack-24.1.3-3.el10_1.noarch.rpm;name=aarch64_python3-cattrs+msgpack;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+msgpack}"
SRC_URI[aarch64_python3-cattrs+msgpack.sha256sum] = "70cefd66fe172972e0a5f84a3e81fd56275ae006715b8805ca5f97e66852b48a"

URI_aarch64_python3-cattrs+orjson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+orjson-24.1.3-3.el10_1.noarch.rpm;name=aarch64_python3-cattrs+orjson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+orjson}"
SRC_URI[aarch64_python3-cattrs+orjson.sha256sum] = "561e3a85f08b1d917f48fa4996a6e83b0e6ce6b9816ef389a17ac7d83e46a39e"

URI_aarch64_python3-cattrs+pyyaml = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+pyyaml-24.1.3-3.el10_1.noarch.rpm;name=aarch64_python3-cattrs+pyyaml;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+pyyaml}"
SRC_URI[aarch64_python3-cattrs+pyyaml.sha256sum] = "b19ae41292b2acee7295745b5c6aac5ea42ced67984b28a4c3e41b145c7ac2dc"

URI_aarch64_python3-cattrs+tomlkit = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+tomlkit-24.1.3-3.el10_1.noarch.rpm;name=aarch64_python3-cattrs+tomlkit;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+tomlkit}"
SRC_URI[aarch64_python3-cattrs+tomlkit.sha256sum] = "8255f12c9c7fc4ab05976aba81ecc25c863e03e7aaf4b5f6244d296d08c055fe"

URI_aarch64_python3-cattrs+ujson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-cattrs+ujson-24.1.3-3.el10_1.noarch.rpm;name=aarch64_python3-cattrs+ujson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-cattrs+ujson}"
SRC_URI[aarch64_python3-cattrs+ujson.sha256sum] = "4f663555fe909f7b56743586af5793f5cfdd08e12a01379424fbb317c09e8bd0"

RDEPENDS:python3-cattrs = " \
 python3 \
 python3-attrs \
 "
RDEPENDS:python3-cattrs+bson = " \
 python3 \
 python3-cattrs \
 python3-pymongo \
 "
RDEPENDS:python3-cattrs+msgpack = " \
 python3 \
 python3-cattrs \
 python3-msgpack \
 "
RDEPENDS:python3-cattrs+orjson = " \
 python3 \
 python3-cattrs \
 python3-orjson \
 "
RDEPENDS:python3-cattrs+pyyaml = " \
 python3 \
 python3-cattrs \
 python3-pyyaml \
 "
RDEPENDS:python3-cattrs+tomlkit = " \
 python3 \
 python3-cattrs \
 python3-tomlkit \
 "
RDEPENDS:python3-cattrs+ujson = " \
 python3 \
 python3-cattrs \
 python3-ujson \
 "
