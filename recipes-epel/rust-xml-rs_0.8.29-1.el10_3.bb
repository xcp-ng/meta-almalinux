# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xml-rs"
PV = "0.8.29"
PR = "1.el10_3"
PACKAGES = " \
 rust-xml-rs+default-devel \
 rust-xml-rs-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-xml-rs-0.8.29-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2363cc9bf1f48b770f3cb1e6bcaa45b39b6392d27d0c1a5aefc8e60b927290d1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xml-rs+default-devel-0.8.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xml-rs+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xml-rs+default-devel.sha256sum] = "e6a08785b1f226cb6947c803482e1c0fb4521a2faa32645315685740d8366a65"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xml-rs-devel-0.8.29-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xml-rs-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xml-rs-devel.sha256sum] = "64b208dc5102e7021a6da7d60a42acec499fa29c13e860ca6e1bd63c643addf5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xml-rs+default-devel-0.8.29-1.el10_3.noarch.rpm;name=aarch64_rust-xml-rs+default-devel;unpack=0"
SRC_URI[aarch64_rust-xml-rs+default-devel.sha256sum] = "5b7259d0ad58cc43162105b1f3659837e81998c42166f6aa7a3e86bb6b158fa4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xml-rs-devel-0.8.29-1.el10_3.noarch.rpm;name=aarch64_rust-xml-rs-devel;unpack=0"
SRC_URI[aarch64_rust-xml-rs-devel.sha256sum] = "eacc967ca0886e5513842774dad631342210217330f471cba38ffcf1b9b47dd6"

RDEPENDS:rust-xml-rs+default-devel = " \
 cargo \
 rust-xml-rs-devel \
 "
RDEPENDS:rust-xml-rs-devel = " \
 cargo \
 rust \
 "
