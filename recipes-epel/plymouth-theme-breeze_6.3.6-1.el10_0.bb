# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plymouth-theme-breeze"
PV = "6.3.6"
PR = "1.el10_0"
PACKAGES = " \
 plymouth-theme-breeze \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plymouth-theme-breeze-6.3.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5329f5e8e45b61c210ea3687bfd881cf3c56d1ae9d7db8114b52fae78f4cd2e7"

URI_x86_64_v2_plymouth-theme-breeze = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plymouth-theme-breeze-6.3.6-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plymouth-theme-breeze;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plymouth-theme-breeze}"
SRC_URI[x86_64_v2_plymouth-theme-breeze.sha256sum] = "8bec35f333eea7af7ed8d67db0ad4217615e3aa57a59f790ca6a33d9f07a06c8"

URI_aarch64_plymouth-theme-breeze = "${EPEL_MIRROR}/aarch64/Packages/p/plymouth-theme-breeze-6.3.6-1.el10_0.aarch64.rpm;name=aarch64_plymouth-theme-breeze;unpack=0"
SRC_URI:append = " ${URI_aarch64_plymouth-theme-breeze}"
SRC_URI[aarch64_plymouth-theme-breeze.sha256sum] = "7d304900c585a59004f84e453882c405010746faae72156ccb1bef978df7e24b"

RDEPENDS:plymouth-theme-breeze = " \
 glibc \
 plymouth \
 plymouth-core-libs \
 plymouth-plugin-script \
 "
