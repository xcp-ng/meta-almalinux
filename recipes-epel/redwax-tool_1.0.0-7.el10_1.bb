# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "redwax-tool"
PV = "1.0.0"
PR = "7.el10_1"
PACKAGES = " \
 redwax-tool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/redwax-tool-1.0.0-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b69add034f2aafa71e6520d94595ea6363ac499bb2cbaa109c5442ff1fe4bb63"

URI_x86_64_v2_redwax-tool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/redwax-tool-1.0.0-7.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_redwax-tool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redwax-tool}"
SRC_URI[x86_64_v2_redwax-tool.sha256sum] = "7fe6235b24b473845d63bb10436dd4f8c48b66bffeaedeccc1bcea6148cc54b8"

URI_aarch64_redwax-tool = "${EPEL_MIRROR}/aarch64/Packages/r/redwax-tool-1.0.0-7.el10_1.aarch64.rpm;name=aarch64_redwax-tool;unpack=0"
SRC_URI:append = " ${URI_aarch64_redwax-tool}"
SRC_URI[aarch64_redwax-tool.sha256sum] = "4b64ca9d16001a384fc5dcdb4cc628bf8586cf9560dea3b68ba0de601d519dea"

RDEPENDS:redwax-tool = " \
 apr \
 apr-util \
 glibc \
 ldns \
 libical \
 nspr \
 nss \
 openssl-libs \
 p11-kit \
 unbound-libs \
 "
