# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gram-client"
PV = "14.6"
PR = "8.el10_0"
PACKAGES = " \
 globus-gram-client \
 globus-gram-client-devel \
 globus-gram-client-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gram-client-14.6-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b33663218206ba2e15743e3c97c4a6557d37484cd419959bad4662fc29cfbbff"

URI_x86_64_v2_globus-gram-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-14.6-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client}"
SRC_URI[x86_64_v2_globus-gram-client.sha256sum] = "82dc4c0c87c8018ae59b2558c37394abfb76eab55b0e3c315765d07e0ea322b0"

URI_x86_64_v2_globus-gram-client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-devel-14.6-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gram-client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client-devel}"
SRC_URI[x86_64_v2_globus-gram-client-devel.sha256sum] = "6c71c89e876266a064229f5d33156051890732caf4fe6a2a65f2a28c46a5931a"

URI_x86_64_v2_globus-gram-client-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gram-client-doc-14.6-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gram-client-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gram-client-doc}"
SRC_URI[x86_64_v2_globus-gram-client-doc.sha256sum] = "4caec7cdce3962846cd681b643b9f33d0c0bb54fbf0d9aecdfa4b76533265e7e"

URI_aarch64_globus-gram-client = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-14.6-8.el10_0.aarch64.rpm;name=aarch64_globus-gram-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client}"
SRC_URI[aarch64_globus-gram-client.sha256sum] = "9c58ba1db861ec391c6e5e3d6578686c1a377f7748c21bde95be6ff57c8faa00"

URI_aarch64_globus-gram-client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-devel-14.6-8.el10_0.aarch64.rpm;name=aarch64_globus-gram-client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client-devel}"
SRC_URI[aarch64_globus-gram-client-devel.sha256sum] = "47ce27a538fa2255f3fd33c8bcfd9338641aa010b14ff7edb78e354d613cb651"

URI_aarch64_globus-gram-client-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gram-client-doc-14.6-8.el10_0.noarch.rpm;name=aarch64_globus-gram-client-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gram-client-doc}"
SRC_URI[aarch64_globus-gram-client-doc.sha256sum] = "90efc6cb2b5ce8582d13f3ce382cba339241d43f1000604aeb9863a958f611b0"

RDEPENDS:globus-gram-client = " \
 glibc \
 globus-common \
 globus-gram-protocol \
 globus-gss-assist \
 globus-io \
 globus-rsl \
 "
RDEPENDS:globus-gram-client-devel = " \
 globus-common-devel \
 globus-gram-client \
 globus-gram-protocol-devel \
 globus-gss-assist-devel \
 globus-io-devel \
 globus-rsl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gram-client-doc = " \
 "
