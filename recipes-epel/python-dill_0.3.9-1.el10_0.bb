# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dill"
PV = "0.3.9"
PR = "1.el10_0"
PACKAGES = " \
 python3-dill \
 python3-dill+readline \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-dill-0.3.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b164360667bc81d8e963cc0b2ea7549bcc5066a0ab84b21a2f4637fa413399d9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dill-0.3.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dill;unpack=0"
SRC_URI[x86_64_v2_python3-dill.sha256sum] = "1de8f938edb3dfd9fdc2fc65e6f186d9abcc11d8df686b3f376560eba3f15a98"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-dill+readline-0.3.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-dill+readline;unpack=0"
SRC_URI[x86_64_v2_python3-dill+readline.sha256sum] = "df366c4baf5e020bc0dc016adcc88318d668863875d9b2c7c31cfb1034ed1b6c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-dill-0.3.9-1.el10_0.noarch.rpm;name=aarch64_python3-dill;unpack=0"
SRC_URI[aarch64_python3-dill.sha256sum] = "38d60ffb13089386f76d853f4c9b4b4f0b921ea518352db8ed51ad7d8923430e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-dill+readline-0.3.9-1.el10_0.noarch.rpm;name=aarch64_python3-dill+readline;unpack=0"
SRC_URI[aarch64_python3-dill+readline.sha256sum] = "4f35bb62af0f695ebd418f4ba5c2f39a1d9676707a91fed4d97c51015d854e2b"

RDEPENDS:python3-dill = " \
 python3 \
 "
RDEPENDS:python3-dill+readline = " \
 python3 \
 python3-dill \
 "
