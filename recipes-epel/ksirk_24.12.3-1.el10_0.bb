# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksirk"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 ksirk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksirk-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2e87a85ca184fa8903449db99e7bb81cd175ffc4a772fe0806432bd80c53cda6"

URI_x86_64_v2_ksirk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksirk-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksirk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksirk}"
SRC_URI[x86_64_v2_ksirk.sha256sum] = "7a3aefa112b48305391823e0a92d570d50398580c362c8744517cc00abc81c70"

URI_aarch64_ksirk = "${EPEL_MIRROR}/aarch64/Packages/k/ksirk-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_ksirk;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksirk}"
SRC_URI[aarch64_ksirk.sha256sum] = "5b1b4b8a5ccfccc02475c48d4609cd848e5a44f8e98d67bffd9a8d04cb352e0a"

RDEPENDS:ksirk = " \
 glibc \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libgcc \
 libkdegames \
 libstdc++ \
 qca-qt6-ossl \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
