# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "azure-protected-vm-secrets"
PV = "1.0.9"
PR = "1.el10_3"
PACKAGES:x86_64_v2 = " \
 azure-protected-vm-secrets \
 azure-protected-vm-secrets-devel \
 azure-protected-vm-secrets-libs \
"
PACKAGES:aarch64 = " \
  \
"

SRC_URI = "${EPELSRC_MIRROR}/Packages/a/azure-protected-vm-secrets-1.0.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "20e466502479c5ebb67a3a6d48aff1f0a5312ad947ddb414ddaa013f0cf7fa71"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/azure-protected-vm-secrets-1.0.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_azure-protected-vm-secrets;unpack=0"
SRC_URI[x86_64_v2_azure-protected-vm-secrets.sha256sum] = "a28528a067f6c99462bbc2575f95ee59f7da8c2ed76ef75bb9662046e8802ec5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/azure-protected-vm-secrets-devel-1.0.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_azure-protected-vm-secrets-devel;unpack=0"
SRC_URI[x86_64_v2_azure-protected-vm-secrets-devel.sha256sum] = "a6e1a1d6c2bb3c5442a2f205cc908921c0c20e93de5286c31e93108176d7542b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/azure-protected-vm-secrets-libs-1.0.9-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_azure-protected-vm-secrets-libs;unpack=0"
SRC_URI[x86_64_v2_azure-protected-vm-secrets-libs.sha256sum] = "fabca41a80a07d43b409ba4cdb6a282f077d6f322ad84f9dabc6cfafdf11c572"

RDEPENDS:azure-protected-vm-secrets = " \
 azure-protected-vm-secrets-libs \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 "
RDEPENDS:azure-protected-vm-secrets-devel = " \
 azure-protected-vm-secrets-libs \
 "
RDEPENDS:azure-protected-vm-secrets-libs = " \
 glibc \
 libgcc \
 libstdc++ \
 openssl-libs \
 systemd-libs \
 tpm2-tss \
 "
