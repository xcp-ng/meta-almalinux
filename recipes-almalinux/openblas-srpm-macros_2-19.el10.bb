# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openblas-srpm-macros"
PV = "2"
PR = "19.el10"
PACKAGES = " \
 openblas-srpm-macros \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/openblas-srpm-macros-2-19.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5e2e50dd9cb052e4cfb31301e9c6f89a76a888724d07ce89782769addaaa0dd2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/openblas-srpm-macros-2-19.el10.noarch.rpm;name=x86_64_v2_openblas-srpm-macros;unpack=0"
SRC_URI[x86_64_v2_openblas-srpm-macros.sha256sum] = "aaab4436f0b991293a491f72e8704906c2c2608032c3490c3dc05c68cff9b0ce"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/openblas-srpm-macros-2-19.el10.noarch.rpm;name=aarch64_openblas-srpm-macros;unpack=0"
SRC_URI[aarch64_openblas-srpm-macros.sha256sum] = "aaab4436f0b991293a491f72e8704906c2c2608032c3490c3dc05c68cff9b0ce"

RDEPENDS:openblas-srpm-macros = " \
 "
