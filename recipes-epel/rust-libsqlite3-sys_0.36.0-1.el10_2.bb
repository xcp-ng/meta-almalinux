# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libsqlite3-sys"
PV = "0.36.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-libsqlite3-sys+bindgen-devel \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-libsqlite3-sys+column_metadata-devel \
 rust-libsqlite3-sys+default-devel \
 rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel \
 rust-libsqlite3-sys+pkg-config-devel \
 rust-libsqlite3-sys+preupdate_hook-devel \
 rust-libsqlite3-sys+session-devel \
 rust-libsqlite3-sys+unlock_notify-devel \
 rust-libsqlite3-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libsqlite3-sys-0.36.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ee9229db4f7bf0dc6bcae7cbc1ec3bd0d1676b688b1e62511f24d281e382bdee"

URI_x86_64_v2_rust-libsqlite3-sys+bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+bindgen-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+bindgen-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+bindgen-devel.sha256sum] = "202d119a3bf2fc9bce9ca857171dd755380ca6bcd71335243eade1e8dd624277"

URI_x86_64_v2_rust-libsqlite3-sys+buildtime_bindgen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+buildtime_bindgen-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+buildtime_bindgen-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+buildtime_bindgen-devel.sha256sum] = "244826c4df3374bab564e3ef8e704ab2f493d35dba8f8245f369cc323e6a0e2b"

URI_x86_64_v2_rust-libsqlite3-sys+column_metadata-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+column_metadata-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+column_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+column_metadata-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+column_metadata-devel.sha256sum] = "eec89046e0680d7e40a62191c3fcacc62c3e60df208ec38a22de9844b8f02a03"

URI_x86_64_v2_rust-libsqlite3-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+default-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+default-devel.sha256sum] = "a3004a5e435fe2532553d16a4025ff356366da788403f60e04008d08dcbb802c"

URI_x86_64_v2_rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel.sha256sum] = "d9209e5af4befab56cbfcdadeaf1a1a3a62962059966ff44c78fb7bc7af525da"

URI_x86_64_v2_rust-libsqlite3-sys+pkg-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+pkg-config-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+pkg-config-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+pkg-config-devel.sha256sum] = "28e6279f09bf199848285b293f11ed9fbf987058d0deb65f8e5ed01ba674b59e"

URI_x86_64_v2_rust-libsqlite3-sys+preupdate_hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+preupdate_hook-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+preupdate_hook-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+preupdate_hook-devel.sha256sum] = "cd6f3489fdf007bc3e8c5a5f0ce3160b0ee4470ef4b0ec3b105f5282df6bcd97"

URI_x86_64_v2_rust-libsqlite3-sys+session-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+session-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+session-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+session-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+session-devel.sha256sum] = "e0536342c656f8885471f77da7d2202493e5cce464a45ff51bd7416a6436b3e2"

URI_x86_64_v2_rust-libsqlite3-sys+unlock_notify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys+unlock_notify-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys+unlock_notify-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys+unlock_notify-devel.sha256sum] = "46a247f62b2fbdaf5798dc171aecfb0f4fc8acb29ce2f4b6f17ef82f577ae843"

URI_x86_64_v2_rust-libsqlite3-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libsqlite3-sys-devel-0.36.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libsqlite3-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libsqlite3-sys-devel}"
SRC_URI[x86_64_v2_rust-libsqlite3-sys-devel.sha256sum] = "a1d04f01178cae3f45f79cb25227e9028dbf7b3b877ba13a257e78f35932122c"

URI_aarch64_rust-libsqlite3-sys+bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+bindgen-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys+bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+bindgen-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+bindgen-devel.sha256sum] = "1f8dd5f22c5958ae8557def6499a44b2f566faea154ed68e79483acaa02cf461"

URI_aarch64_rust-libsqlite3-sys+buildtime_bindgen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+buildtime_bindgen-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys+buildtime_bindgen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+buildtime_bindgen-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+buildtime_bindgen-devel.sha256sum] = "bb88ee5f10cb0e02a530a55a7192486664f9bf90686587e801bd82d1a1d6af2b"

URI_aarch64_rust-libsqlite3-sys+column_metadata-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+column_metadata-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys+column_metadata-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+column_metadata-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+column_metadata-devel.sha256sum] = "206b4f86dc807d9ec265b89ab28ac4f52d9f74d6fae24ce83f1e549ca8671a0b"

URI_aarch64_rust-libsqlite3-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+default-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+default-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+default-devel.sha256sum] = "8759749476b99949364a4fefbee1181af3c289a323fbef6ba8f5cf6682fbcefe"

URI_aarch64_rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel.sha256sum] = "bbde74bfb56b4eb32e0b291d5260536a72d3f35e118b09838e5fa36836cc4935"

URI_aarch64_rust-libsqlite3-sys+pkg-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+pkg-config-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys+pkg-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+pkg-config-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+pkg-config-devel.sha256sum] = "803b38baab0b3c501679b18a5a11a873bf063e3f5a67445fb8755e3ad008ea11"

URI_aarch64_rust-libsqlite3-sys+preupdate_hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+preupdate_hook-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys+preupdate_hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+preupdate_hook-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+preupdate_hook-devel.sha256sum] = "9788e251e3de0dedc29bef3c34f2ceb76412ece3e5febee0705d3eafe9a6a7f7"

URI_aarch64_rust-libsqlite3-sys+session-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+session-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys+session-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+session-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+session-devel.sha256sum] = "22f2313c5e138c330cd3e3e55610fc6267cb361515344fa04b4c27b7337cd703"

URI_aarch64_rust-libsqlite3-sys+unlock_notify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys+unlock_notify-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys+unlock_notify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys+unlock_notify-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys+unlock_notify-devel.sha256sum] = "960347fb69c1a69dc8a0bbcf8390071c7b5ffad41719a2a81f52f3a95d911cc0"

URI_aarch64_rust-libsqlite3-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libsqlite3-sys-devel-0.36.0-1.el10_2.noarch.rpm;name=aarch64_rust-libsqlite3-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libsqlite3-sys-devel}"
SRC_URI[aarch64_rust-libsqlite3-sys-devel.sha256sum] = "7daed0dca37dcc76af5f5e70db4fe050d903ce7884060c5d37412bcb7f87a423"

RDEPENDS:rust-libsqlite3-sys+bindgen-devel = " \
 cargo \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+buildtime_bindgen-devel = " \
 cargo \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+column_metadata-devel = " \
 cargo \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+default-devel = " \
 cargo \
 rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+min_sqlite_version_3_34_1-devel = " \
 cargo \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+pkg-config-devel = " \
 cargo \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+preupdate_hook-devel = " \
 cargo \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+session-devel = " \
 cargo \
 rust-libsqlite3-sys+buildtime_bindgen-devel \
 rust-libsqlite3-sys+preupdate_hook-devel \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys+unlock_notify-devel = " \
 cargo \
 rust-libsqlite3-sys-devel \
 "
RDEPENDS:rust-libsqlite3-sys-devel = " \
 cargo \
 rust-bindgen+runtime-devel \
 rust-bindgen-devel \
 rust-pkg-config+default-devel \
 sqlite-devel \
 "
