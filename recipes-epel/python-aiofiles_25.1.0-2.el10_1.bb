# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-aiofiles"
PV = "25.1.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-aiofiles \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-aiofiles-25.1.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8369b38ae834dbae14bb4b54c37ed6af1f2dc79c817619e4f8d67177fb2769ac"

URI_x86_64_v2_python3-aiofiles = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-aiofiles-25.1.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-aiofiles;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-aiofiles}"
SRC_URI[x86_64_v2_python3-aiofiles.sha256sum] = "b3ca775ba42c5b368624a5d1f099ecd45d90745b5d84420865672f24d1e73530"

URI_aarch64_python3-aiofiles = "${EPEL_MIRROR}/aarch64/Packages/p/python3-aiofiles-25.1.0-2.el10_1.noarch.rpm;name=aarch64_python3-aiofiles;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-aiofiles}"
SRC_URI[aarch64_python3-aiofiles.sha256sum] = "fde0fe7bf2ebf4a9df3a979404039165907e7a7c9ab7743c25be80fa4f8dc777"

RDEPENDS:python3-aiofiles = " \
 python3 \
 "
