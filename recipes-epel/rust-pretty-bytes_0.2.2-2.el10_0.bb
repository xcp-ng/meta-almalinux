# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pretty-bytes"
PV = "0.2.2"
PR = "2.el10_0"
PACKAGES = " \
 pretty-bytes \
 rust-pretty-bytes+default-devel \
 rust-pretty-bytes-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pretty-bytes-0.2.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fafc28397e0a9e797286ec155632e545994ea119b3f9e37b093f8ac23a7e085a"

URI_x86_64_v2_pretty-bytes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pretty-bytes-0.2.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pretty-bytes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pretty-bytes}"
SRC_URI[x86_64_v2_pretty-bytes.sha256sum] = "dd2b99018d287c641a02f7fe4859e9e4dbae55da5022a85b4cdb7d5821032865"

URI_x86_64_v2_rust-pretty-bytes+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty-bytes+default-devel-0.2.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty-bytes+default-devel}"
SRC_URI[x86_64_v2_rust-pretty-bytes+default-devel.sha256sum] = "13b7090f8de3c78df9d0f34c2524148ca7b66fc2327bb4c4c678dc6a7741a249"

URI_x86_64_v2_rust-pretty-bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pretty-bytes-devel-0.2.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pretty-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pretty-bytes-devel}"
SRC_URI[x86_64_v2_rust-pretty-bytes-devel.sha256sum] = "fa2d177c9c9d9dd48973f0f303c68f40a98fc824f52889b4c68ea6c2354570af"

URI_aarch64_pretty-bytes = "${EPEL_MIRROR}/aarch64/Packages/p/pretty-bytes-0.2.2-2.el10_0.aarch64.rpm;name=aarch64_pretty-bytes;unpack=0"
SRC_URI:append = " ${URI_aarch64_pretty-bytes}"
SRC_URI[aarch64_pretty-bytes.sha256sum] = "4030ece0d17e1cbd13278eaff7c07a2652f03ef48163b7e6a7e22f21f70922c8"

URI_aarch64_rust-pretty-bytes+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty-bytes+default-devel-0.2.2-2.el10_0.noarch.rpm;name=aarch64_rust-pretty-bytes+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty-bytes+default-devel}"
SRC_URI[aarch64_rust-pretty-bytes+default-devel.sha256sum] = "948d28bf2bdb3568c3e9ccee38d7b1ca629f1d9ee7e1ee7a9eb640b835e67cbb"

URI_aarch64_rust-pretty-bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pretty-bytes-devel-0.2.2-2.el10_0.noarch.rpm;name=aarch64_rust-pretty-bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pretty-bytes-devel}"
SRC_URI[aarch64_rust-pretty-bytes-devel.sha256sum] = "e5644b8685cd6c2ca255845ad8d45b07f800995d0404479017b4068d9ad964fb"

RDEPENDS:pretty-bytes = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-pretty-bytes+default-devel = " \
 cargo \
 rust-pretty-bytes-devel \
 "
RDEPENDS:rust-pretty-bytes-devel = " \
 cargo \
 rust-atty+default-devel \
 rust-getopts+default-devel \
 "
