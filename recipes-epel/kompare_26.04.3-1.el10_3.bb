# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kompare"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kompare \
 kompare-devel \
 kompare-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kompare-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e1863eb154f4867fb93dff8d4bd40d19570c3906089e85b6a2332ccdb02701f"

URI_x86_64_v2_kompare = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare}"
SRC_URI[x86_64_v2_kompare.sha256sum] = "d85fb1d1fc50763823aadb164957d44295861494c2894fd37483ffa9651b0fc3"

URI_x86_64_v2_kompare-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-devel-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare-devel}"
SRC_URI[x86_64_v2_kompare-devel.sha256sum] = "5bec87f02f45b885486063abbe25018328e978208490f0d1987a2fc67ca4eed5"

URI_x86_64_v2_kompare-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kompare-libs-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kompare-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kompare-libs}"
SRC_URI[x86_64_v2_kompare-libs.sha256sum] = "cac78340266d86c25b9fb7e7011c85c06559e060346016fb4ddd185134c31913"

URI_aarch64_kompare = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kompare;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare}"
SRC_URI[aarch64_kompare.sha256sum] = "9fedd23d25942f4ad09d17c1d1988175ec82cd701acdc93978cf282c8e87f2ef"

URI_aarch64_kompare-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-devel-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kompare-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare-devel}"
SRC_URI[aarch64_kompare-devel.sha256sum] = "599ea3ffd4d2053610808fc685391feff75a393468a6a0dcf4c79d543ad3befc"

URI_aarch64_kompare-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kompare-libs-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kompare-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kompare-libs}"
SRC_URI[aarch64_kompare-libs.sha256sum] = "2cf7220f05bb65705387fc3be4821b08a9f1fcb31306df481a04344486a36b59"

RDEPENDS:kompare = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-ktexteditor \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kompare-libs \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kompare-devel = " \
 kompare-libs \
 qt6-qtbase-devel \
 "
RDEPENDS:kompare-libs = " \
 glibc \
 kf6-kcodecs \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkomparediff2 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
