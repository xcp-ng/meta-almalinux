# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "wcd"
PV = "6.0.7"
PR = "2.el10_3"
PACKAGES = " \
 wcd \
 wcd-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/w/wcd-6.0.7-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b2e7ee5c8fb4a132187e86b02c6cad53ce70e335f01efde2afbf493860b6d8a6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wcd-6.0.7-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_wcd;unpack=0"
SRC_URI[x86_64_v2_wcd.sha256sum] = "443346470368cc0bef418b7b6daf0e709a8f7bf6e92cfd7e1f4e5549d4e7948d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/wcd-doc-6.0.7-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_wcd-doc;unpack=0"
SRC_URI[x86_64_v2_wcd-doc.sha256sum] = "65c1a7823a7c60de19df3b1feb156b8d1c7e10c442ac94c15281a0d2bd315f6e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wcd-6.0.7-2.el10_3.aarch64.rpm;name=aarch64_wcd;unpack=0"
SRC_URI[aarch64_wcd.sha256sum] = "52375b8bb327c7135cd748f3ee379b4afa11dbf5de2f5a6e6362eb39758076af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/w/wcd-doc-6.0.7-2.el10_3.noarch.rpm;name=aarch64_wcd-doc;unpack=0"
SRC_URI[aarch64_wcd-doc.sha256sum] = "605dd998e4a481415da2385f8741366c5d0c01f9e992faf4d75c147ee5c22404"

RDEPENDS:wcd = " \
 glibc \
 libunistring \
 ncurses-libs \
 "
RDEPENDS:wcd-doc = " \
 "
