# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "editorconfig"
PV = "0.12.9"
PR = "3.el10"
PACKAGES = " \
 editorconfig \
 editorconfig-devel \
 editorconfig-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/editorconfig-0.12.9-3.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e99b3ec48ec7c1d7ccd8833fe70f85f7f71ceccba2efe76a9d109c85f53ffb7a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/editorconfig-0.12.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_editorconfig;unpack=0"
SRC_URI[x86_64_v2_editorconfig.sha256sum] = "1afe21b6cea091789391d8015c8d941519ac94b88443f9fd8051c503c36b9117"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/editorconfig-devel-0.12.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_editorconfig-devel;unpack=0"
SRC_URI[x86_64_v2_editorconfig-devel.sha256sum] = "866d1c17c166680803039dceb592e5504bb38d858aa93486e1cfc78e340a85eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/editorconfig-libs-0.12.9-3.el10.x86_64_v2.rpm;name=x86_64_v2_editorconfig-libs;unpack=0"
SRC_URI[x86_64_v2_editorconfig-libs.sha256sum] = "f92392e11e95753e225a40dfc79a1b060ee1b81fac9dddc7ad6ebb12e52daf8b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/editorconfig-0.12.9-3.el10.aarch64.rpm;name=aarch64_editorconfig;unpack=0"
SRC_URI[aarch64_editorconfig.sha256sum] = "319e26a65b57f075b444672478c5a7a3f40772ed48dcaa1967190da897451aec"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/editorconfig-devel-0.12.9-3.el10.aarch64.rpm;name=aarch64_editorconfig-devel;unpack=0"
SRC_URI[aarch64_editorconfig-devel.sha256sum] = "ad4ce523732ed8c162e44bc77df0e6a7ab5192abfbab8b21d242ec3d76c8ca45"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/editorconfig-libs-0.12.9-3.el10.aarch64.rpm;name=aarch64_editorconfig-libs;unpack=0"
SRC_URI[aarch64_editorconfig-libs.sha256sum] = "84820371e2781692088c38ba11cd5ccd4c892f32716b51c384e58d8556fbc5eb"

RDEPENDS:editorconfig = " \
 editorconfig-libs \
 glibc \
 "
RDEPENDS:editorconfig-devel = " \
 cmake \
 cmake-filesystem \
 editorconfig-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:editorconfig-libs = " \
 glibc \
 pcre2 \
 "
