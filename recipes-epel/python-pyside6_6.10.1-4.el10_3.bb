# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyside6"
PV = "6.10.1"
PR = "4.el10_3"
PACKAGES = " \
 pyside6-tools \
 python3-pyside6 \
 python3-pyside6-devel \
 python3-shiboken6 \
 python3-shiboken6-devel \
 shiboken6 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pyside6-6.10.1-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c3dd6e64b8833d92076f92ed6eecd6c7026088b6b7441c4bb7a1e96a3b25832"

URI_x86_64_v2_pyside6-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pyside6-tools-6.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_pyside6-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pyside6-tools}"
SRC_URI[x86_64_v2_pyside6-tools.sha256sum] = "9ce23056061a18bcf6f039c04c1eabed581d2318a956ce5b62df55e9b6121f21"

URI_x86_64_v2_python3-pyside6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyside6-6.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyside6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyside6}"
SRC_URI[x86_64_v2_python3-pyside6.sha256sum] = "536083a96a94cadbece926a683b1dc205f95e8ba4ecc15a7c25e8a682a637b5b"

URI_x86_64_v2_python3-pyside6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyside6-devel-6.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyside6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyside6-devel}"
SRC_URI[x86_64_v2_python3-pyside6-devel.sha256sum] = "4101c2cd7488ae432116370bf01ada2cd37c9141d75ef8c9de8b10db43ff5859"

URI_x86_64_v2_python3-shiboken6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shiboken6-6.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-shiboken6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shiboken6}"
SRC_URI[x86_64_v2_python3-shiboken6.sha256sum] = "fda2b7c979d964b72ba08be6baf5fd32cb93664a6e08847a24313315246de2c5"

URI_x86_64_v2_python3-shiboken6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-shiboken6-devel-6.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-shiboken6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-shiboken6-devel}"
SRC_URI[x86_64_v2_python3-shiboken6-devel.sha256sum] = "78567fbbccb7763f6ba4639318340feb2dceaa6bd420076bf89dfa4854713c38"

URI_x86_64_v2_shiboken6 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/shiboken6-6.10.1-4.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_shiboken6;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_shiboken6}"
SRC_URI[x86_64_v2_shiboken6.sha256sum] = "90baaec1e7d65a492ec5dd0d63cc92c79e054191fe46a6a0c8bcd8eabcb8f91f"

URI_aarch64_pyside6-tools = "${EPEL_MIRROR}/aarch64/Packages/p/pyside6-tools-6.10.1-4.el10_3.aarch64.rpm;name=aarch64_pyside6-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_pyside6-tools}"
SRC_URI[aarch64_pyside6-tools.sha256sum] = "f2988cf5178bc42ca201b12edbd572406b3b2118e6245378c50303c6f14cdf4f"

URI_aarch64_python3-pyside6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyside6-6.10.1-4.el10_3.aarch64.rpm;name=aarch64_python3-pyside6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyside6}"
SRC_URI[aarch64_python3-pyside6.sha256sum] = "331e58cc02a558af31ca4a50f29077d5972edb93748571de697affda65023ffb"

URI_aarch64_python3-pyside6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyside6-devel-6.10.1-4.el10_3.aarch64.rpm;name=aarch64_python3-pyside6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyside6-devel}"
SRC_URI[aarch64_python3-pyside6-devel.sha256sum] = "72b3ecc26cae37f393d3122a91fd9497921f10811962e55ce08b63fb1e1e54e3"

URI_aarch64_python3-shiboken6 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shiboken6-6.10.1-4.el10_3.aarch64.rpm;name=aarch64_python3-shiboken6;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shiboken6}"
SRC_URI[aarch64_python3-shiboken6.sha256sum] = "58bb43e866ab87be299bb3146d377ff0f79e17ba18370dc30c33e04275b18934"

URI_aarch64_python3-shiboken6-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-shiboken6-devel-6.10.1-4.el10_3.aarch64.rpm;name=aarch64_python3-shiboken6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-shiboken6-devel}"
SRC_URI[aarch64_python3-shiboken6-devel.sha256sum] = "dc27134beb3445d1c5fa35dcc80ed58230754fb6fa03dd5689c34859e0aad2c5"

URI_aarch64_shiboken6 = "${EPEL_MIRROR}/aarch64/Packages/s/shiboken6-6.10.1-4.el10_3.aarch64.rpm;name=aarch64_shiboken6;unpack=0"
SRC_URI:append = " ${URI_aarch64_shiboken6}"
SRC_URI[aarch64_shiboken6.sha256sum] = "a0f4073bc6cc9c5bc1d707119f3d998d62a236e53d7094097db13afbbdc40960"

RDEPENDS:pyside6-tools = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 qt6-assistant \
 qt6-designer \
 qt6-linguist \
 qt6-qtbase \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:python3-pyside6 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-shiboken6 \
 qt6-qt3d \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
 qt6-qtconnectivity \
 qt6-qtdatavis3d \
 qt6-qtdeclarative \
 qt6-qtgraphs \
 qt6-qthttpserver \
 qt6-qtlocation \
 qt6-qtmultimedia \
 qt6-qtnetworkauth \
 qt6-qtpdf \
 qt6-qtpositioning \
 qt6-qtquick3d \
 qt6-qtremoteobjects \
 qt6-qtscxml \
 qt6-qtsensors \
 qt6-qtserialbus \
 qt6-qtserialport \
 qt6-qtspeech \
 qt6-qtsvg \
 qt6-qttools \
 qt6-qttools-libs-designer \
 qt6-qttools-libs-help \
 qt6-qtwebchannel \
 qt6-qtwebengine \
 qt6-qtwebsockets \
 qt6-qtwebview \
 "
RDEPENDS:python3-pyside6-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 pyside6-tools \
 python3-pyside6 \
 python3-shiboken6-devel \
 shiboken6 \
 "
RDEPENDS:python3-shiboken6 = " \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 "
RDEPENDS:python3-shiboken6-devel = " \
 clang-libs \
 cmake-filesystem \
 glibc \
 libgcc \
 libstdc++ \
 libxml2 \
 libxslt \
 pkgconf-pkg-config \
 python3 \
 python3-shiboken6 \
 qt6-qtbase \
 shiboken6 \
 "
RDEPENDS:shiboken6 = " \
 cmake-filesystem \
 "
