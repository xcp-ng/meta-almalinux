# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam"
PV = "1.6.1"
PR = "11.el10"
PACKAGES = " \
 pam \
 pam-devel \
 pam-libs \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pam-1.6.1-11.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "59d9e645b943654af87ac1c5416420513142f0b148f7c58b62be2026dda290e1"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-1.6.1-11.el10.x86_64_v2.rpm;name=x86_64_v2_pam;unpack=0"
SRC_URI[x86_64_v2_pam.sha256sum] = "525c80ac13a11a9a5f02ebd97110cc58f16777340a77ea1c9c7d4d33da947ac0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam-devel-1.6.1-11.el10.x86_64_v2.rpm;name=x86_64_v2_pam-devel;unpack=0"
SRC_URI[x86_64_v2_pam-devel.sha256sum] = "455bd9042ee234d1cde124c42c97987cfb949a0d2eb1d5ab4ee74e20c50c3af2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-libs-1.6.1-11.el10.x86_64_v2.rpm;name=x86_64_v2_pam-libs;unpack=0"
SRC_URI[x86_64_v2_pam-libs.sha256sum] = "0436b3536c397c524abf7d8b5cda91493ff578f17d97a794a882af1865e32865"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-1.6.1-11.el10.aarch64.rpm;name=aarch64_pam;unpack=0"
SRC_URI[aarch64_pam.sha256sum] = "a71f2c3df4a49943a9d11a54c9ddce1d579f867f452161cdb645ea6c26693246"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam-devel-1.6.1-11.el10.aarch64.rpm;name=aarch64_pam-devel;unpack=0"
SRC_URI[aarch64_pam-devel.sha256sum] = "a449ceefc71f432625b8481f2bd90f64a4b7aa2971a9c21c666e6f4118d2f179"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-libs-1.6.1-11.el10.aarch64.rpm;name=aarch64_pam-libs;unpack=0"
SRC_URI[aarch64_pam-libs.sha256sum] = "24e9221d1f4234e550bc07b25b1349e9a2b7ec7d5f66bb9e1ba261538ee33ced"

RDEPENDS:pam = " \
 audit-libs \
 authselect \
 bash \
 gdbm \
 gdbm-libs \
 glibc \
 libeconf \
 libpwquality \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 setup \
 "
RDEPENDS:pam-devel = " \
 pam-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pam-libs = " \
 audit-libs \
 glibc \
 libeconf \
 "
