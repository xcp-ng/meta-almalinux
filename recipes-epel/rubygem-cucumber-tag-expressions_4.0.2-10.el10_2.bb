# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rubygem-cucumber-tag-expressions"
PV = "4.0.2"
PR = "10.el10_2"
PACKAGES = " \
 rubygem-cucumber-tag-expressions \
 rubygem-cucumber-tag-expressions-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rubygem-cucumber-tag-expressions-4.0.2-10.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dbfb8bd4bd8675859ecd9debc027601941f6e9190b387a4965dba2624c6221b8"

URI_x86_64_v2_rubygem-cucumber-tag-expressions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-tag-expressions-4.0.2-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-tag-expressions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-tag-expressions}"
SRC_URI[x86_64_v2_rubygem-cucumber-tag-expressions.sha256sum] = "b6684ffe6c550a457b51f20ffd42a287dddbb8141f0c8a99000ffaf6e66dee0b"

URI_x86_64_v2_rubygem-cucumber-tag-expressions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rubygem-cucumber-tag-expressions-doc-4.0.2-10.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rubygem-cucumber-tag-expressions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rubygem-cucumber-tag-expressions-doc}"
SRC_URI[x86_64_v2_rubygem-cucumber-tag-expressions-doc.sha256sum] = "b9b9ad41466a8bdb0eaa0f971cec1ce16b1979d20b05a57410ab91dcccdd804e"

URI_aarch64_rubygem-cucumber-tag-expressions = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-tag-expressions-4.0.2-10.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-tag-expressions;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-tag-expressions}"
SRC_URI[aarch64_rubygem-cucumber-tag-expressions.sha256sum] = "8dd13cdd63a112f8d5e131ef2a7e6dd52cc11124fa90a141f3d0a957337c59be"

URI_aarch64_rubygem-cucumber-tag-expressions-doc = "${EPEL_MIRROR}/aarch64/Packages/r/rubygem-cucumber-tag-expressions-doc-4.0.2-10.el10_2.noarch.rpm;name=aarch64_rubygem-cucumber-tag-expressions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_rubygem-cucumber-tag-expressions-doc}"
SRC_URI[aarch64_rubygem-cucumber-tag-expressions-doc.sha256sum] = "4b23d7c90b165ffc9076ced146acbf61522369e9d072366b28f86dcffd6367b8"

RDEPENDS:rubygem-cucumber-tag-expressions = " \
 rubygems \
 "
RDEPENDS:rubygem-cucumber-tag-expressions-doc = " \
 rubygem-cucumber-tag-expressions \
 "
