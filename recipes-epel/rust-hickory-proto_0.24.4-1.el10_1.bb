# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-proto"
PV = "0.24.4"
PR = "1.el10_1"
PACKAGES = " \
 rust-hickory-proto+backtrace-devel \
 rust-hickory-proto+bytes-devel \
 rust-hickory-proto+default-devel \
 rust-hickory-proto+dns-over-native-tls-devel \
 rust-hickory-proto+dns-over-openssl-devel \
 rust-hickory-proto+dns-over-tls-devel \
 rust-hickory-proto+dnssec-devel \
 rust-hickory-proto+dnssec-openssl-devel \
 rust-hickory-proto+mdns-devel \
 rust-hickory-proto+native-tls-devel \
 rust-hickory-proto+openssl-devel \
 rust-hickory-proto+serde-config-devel \
 rust-hickory-proto+serde-devel \
 rust-hickory-proto+socket2-devel \
 rust-hickory-proto+testing-devel \
 rust-hickory-proto+text-parsing-devel \
 rust-hickory-proto+tokio-devel \
 rust-hickory-proto+tokio-native-tls-devel \
 rust-hickory-proto+tokio-openssl-devel \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-proto-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-proto-0.24.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2a51218e949852ac0c7895e5b9472c70574d86bb5677976305526a431e375cf6"

URI_x86_64_v2_rust-hickory-proto+backtrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+backtrace-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+backtrace-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+backtrace-devel.sha256sum] = "24072d508564ba59186185d6c768d707789d614bcd4c7aa7668db73684b4e003"

URI_x86_64_v2_rust-hickory-proto+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+bytes-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+bytes-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+bytes-devel.sha256sum] = "bf17db8967f7e659fac8294378d37d4ee176e0c9659b6f27e147b7e2d82140e2"

URI_x86_64_v2_rust-hickory-proto+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+default-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+default-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+default-devel.sha256sum] = "767d77c0c97910856ed45e2e43b415507d6b0fe4f8cc1c311d8b8c514fc3a38c"

URI_x86_64_v2_rust-hickory-proto+dns-over-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dns-over-native-tls-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dns-over-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dns-over-native-tls-devel.sha256sum] = "5579f3bd001d32bd666cee679ecdcb80729bdcc65857483705e609ad9246aa8d"

URI_x86_64_v2_rust-hickory-proto+dns-over-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dns-over-openssl-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dns-over-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dns-over-openssl-devel.sha256sum] = "9a9f2b83cde814cfb94ec7e695635e7d422e7f64f861dc91f3a3ac366d7831b7"

URI_x86_64_v2_rust-hickory-proto+dns-over-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dns-over-tls-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dns-over-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dns-over-tls-devel.sha256sum] = "77a5929daf4e8e788175f7d648a97a02f8fe2e87c2f2e1f9a6e5076d5be7bacb"

URI_x86_64_v2_rust-hickory-proto+dnssec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dnssec-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dnssec-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dnssec-devel.sha256sum] = "bb61c98b795c631b7447b69cf9a8865eafaee09a03486cf6a315d48768d1134c"

URI_x86_64_v2_rust-hickory-proto+dnssec-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+dnssec-openssl-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+dnssec-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+dnssec-openssl-devel.sha256sum] = "e0f002f237cac679ca35564654149408958757dd7bd6379bda8086d0077ed62c"

URI_x86_64_v2_rust-hickory-proto+mdns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+mdns-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+mdns-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+mdns-devel.sha256sum] = "51569dbf045e94f049615755e2941912209326234d6c067c7f5867bd5da9032b"

URI_x86_64_v2_rust-hickory-proto+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+native-tls-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+native-tls-devel.sha256sum] = "6b893da2e986bc42ad18881061680c60ed78de321b87069aa9371da3f051bcc0"

URI_x86_64_v2_rust-hickory-proto+openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+openssl-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+openssl-devel.sha256sum] = "65d63acf47ddc9e113b730058bb99e25d2a254f17935678bcea472dadd44170d"

URI_x86_64_v2_rust-hickory-proto+serde-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+serde-config-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+serde-config-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+serde-config-devel.sha256sum] = "e9e08f0b95ce756638b44aee5a0559e0fee5a450504ea3e5221cf81af020aaff"

URI_x86_64_v2_rust-hickory-proto+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+serde-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+serde-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+serde-devel.sha256sum] = "c79bc66bc47617daa09d26de80396984ded3d432a79b44deb19675c0dcc5af24"

URI_x86_64_v2_rust-hickory-proto+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+socket2-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+socket2-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+socket2-devel.sha256sum] = "5d98ec289227d46ce543e4afcb5de699a24386997f6322df34bc8f35822d4088"

URI_x86_64_v2_rust-hickory-proto+testing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+testing-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+testing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+testing-devel.sha256sum] = "5e403433647947a5e46dfe626f2bfbe8b17fcf9a5d8b1d3135f92bd51077f29a"

URI_x86_64_v2_rust-hickory-proto+text-parsing-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+text-parsing-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+text-parsing-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+text-parsing-devel.sha256sum] = "a3ef2b3afdaa92dc557140fc3c763f732f1b61034da9427873c1084ab6d061d7"

URI_x86_64_v2_rust-hickory-proto+tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+tokio-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+tokio-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+tokio-devel.sha256sum] = "762ec1fad2f26be1139c15faa489ca7066527b0c8b3376da21008f15e462a582"

URI_x86_64_v2_rust-hickory-proto+tokio-native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+tokio-native-tls-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+tokio-native-tls-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+tokio-native-tls-devel.sha256sum] = "8baaa3eff6a722d8c9779f308b6a1580ec1caae755dca5c622b57cd2a503753b"

URI_x86_64_v2_rust-hickory-proto+tokio-openssl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+tokio-openssl-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+tokio-openssl-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+tokio-openssl-devel.sha256sum] = "b7f29080537d708edc3551c1734bf38fca7cbad95027c65ff4e86311b177c393"

URI_x86_64_v2_rust-hickory-proto+tokio-runtime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto+tokio-runtime-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto+tokio-runtime-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto+tokio-runtime-devel.sha256sum] = "d980b6dc625c1adfbb33bfb077d04db52dc5a2d2eb092e82996d9b117fdc15ce"

URI_x86_64_v2_rust-hickory-proto-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-proto-devel-0.24.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-proto-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hickory-proto-devel}"
SRC_URI[x86_64_v2_rust-hickory-proto-devel.sha256sum] = "7008fe08545cfbc2cd2ded93976358147b3da9b8392a045373c06754bd8cd579"

URI_aarch64_rust-hickory-proto+backtrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+backtrace-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+backtrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+backtrace-devel}"
SRC_URI[aarch64_rust-hickory-proto+backtrace-devel.sha256sum] = "156026295059343cf2c56b45aaa194b0e83f0c824c8ffac06b6c6f6f19136cee"

URI_aarch64_rust-hickory-proto+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+bytes-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+bytes-devel}"
SRC_URI[aarch64_rust-hickory-proto+bytes-devel.sha256sum] = "6dd3111e802330ede85de1871099c85a1a11fb0375612cc847766d60e2d5a057"

URI_aarch64_rust-hickory-proto+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+default-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+default-devel}"
SRC_URI[aarch64_rust-hickory-proto+default-devel.sha256sum] = "22fb6ef6df14b7881e090969a2b924859a521b7472ef52d90109d1d67ddff74f"

URI_aarch64_rust-hickory-proto+dns-over-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dns-over-native-tls-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+dns-over-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dns-over-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto+dns-over-native-tls-devel.sha256sum] = "409b12386543ec78e624a937b5a76e53bb2c946ba55ef9d3439bbdfb9a46cd41"

URI_aarch64_rust-hickory-proto+dns-over-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dns-over-openssl-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+dns-over-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dns-over-openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto+dns-over-openssl-devel.sha256sum] = "dca0b3eeebd90669c0618b8e37161820fcbff8a6c900ca5fa791ea2d9c43b7f9"

URI_aarch64_rust-hickory-proto+dns-over-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dns-over-tls-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+dns-over-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dns-over-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto+dns-over-tls-devel.sha256sum] = "5bf48df2650a82cc682fafc8bea7cd0d368b019c60a02fbbc1674a087c5dd821"

URI_aarch64_rust-hickory-proto+dnssec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dnssec-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+dnssec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dnssec-devel}"
SRC_URI[aarch64_rust-hickory-proto+dnssec-devel.sha256sum] = "96377940908547b4ffcb35c07823273034c64159fdbaec7536e1e3e129b0ed9e"

URI_aarch64_rust-hickory-proto+dnssec-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+dnssec-openssl-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+dnssec-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+dnssec-openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto+dnssec-openssl-devel.sha256sum] = "021a13cce6fe6ddb461d937ccaa363adcb671e294fd8477e5e0d10686246edb1"

URI_aarch64_rust-hickory-proto+mdns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+mdns-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+mdns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+mdns-devel}"
SRC_URI[aarch64_rust-hickory-proto+mdns-devel.sha256sum] = "4fdb86924e43bfe47520d23a8ae672a87304ee1215c120eb947520f6fc4321ee"

URI_aarch64_rust-hickory-proto+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+native-tls-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+native-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto+native-tls-devel.sha256sum] = "f22d442ba7879d27fc1338c2ea41e26daabbef6622c7f9375049d10361a52a91"

URI_aarch64_rust-hickory-proto+openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+openssl-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto+openssl-devel.sha256sum] = "b5663c161553fb3705662d207c5397558d957494ea4944d9ea93d5492ee516ff"

URI_aarch64_rust-hickory-proto+serde-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+serde-config-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+serde-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+serde-config-devel}"
SRC_URI[aarch64_rust-hickory-proto+serde-config-devel.sha256sum] = "a41de44f6083aae086460d0020cf577c6e9b683ced167dc261b556583d1d3ac6"

URI_aarch64_rust-hickory-proto+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+serde-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+serde-devel}"
SRC_URI[aarch64_rust-hickory-proto+serde-devel.sha256sum] = "e8e6aea8aad59f6e63a697d740e173a7fcf945d4719101e3e8d96ed828aa49d5"

URI_aarch64_rust-hickory-proto+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+socket2-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+socket2-devel}"
SRC_URI[aarch64_rust-hickory-proto+socket2-devel.sha256sum] = "e0fd1d7df7fafe33361000da156b6f4720897a793c28c940f2ce63905d74f716"

URI_aarch64_rust-hickory-proto+testing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+testing-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+testing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+testing-devel}"
SRC_URI[aarch64_rust-hickory-proto+testing-devel.sha256sum] = "e86ae6ff2d15a1bab0ccd4a6e83bd5df42e5b5a0718c4059c2d8654b57941d1d"

URI_aarch64_rust-hickory-proto+text-parsing-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+text-parsing-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+text-parsing-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+text-parsing-devel}"
SRC_URI[aarch64_rust-hickory-proto+text-parsing-devel.sha256sum] = "705a1edbd75277ed90542c74a258bdab0950134ad0e683ff0a38034204899843"

URI_aarch64_rust-hickory-proto+tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+tokio-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+tokio-devel}"
SRC_URI[aarch64_rust-hickory-proto+tokio-devel.sha256sum] = "5b34ff08fc5065368a0b0b254eac7cf488c996a9e9d8e9fac80fbef539e034d8"

URI_aarch64_rust-hickory-proto+tokio-native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+tokio-native-tls-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+tokio-native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+tokio-native-tls-devel}"
SRC_URI[aarch64_rust-hickory-proto+tokio-native-tls-devel.sha256sum] = "b121177bd5d02254c47341c6d9846aba21f42a4bc36e482a1a1e627ce637797c"

URI_aarch64_rust-hickory-proto+tokio-openssl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+tokio-openssl-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+tokio-openssl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+tokio-openssl-devel}"
SRC_URI[aarch64_rust-hickory-proto+tokio-openssl-devel.sha256sum] = "4b9aae6df6de14e8904f4183aeaabaf3747e4a9d286777bf4696d5049aa1c2d2"

URI_aarch64_rust-hickory-proto+tokio-runtime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto+tokio-runtime-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto+tokio-runtime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto+tokio-runtime-devel}"
SRC_URI[aarch64_rust-hickory-proto+tokio-runtime-devel.sha256sum] = "a9bdcd423736b265353209765a1c7310f92608f5b0a582fd1bce1abfbe92d3bd"

URI_aarch64_rust-hickory-proto-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-proto-devel-0.24.4-1.el10_1.noarch.rpm;name=aarch64_rust-hickory-proto-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hickory-proto-devel}"
SRC_URI[aarch64_rust-hickory-proto-devel.sha256sum] = "bb1aafc84d976cf60f73f36b0b83fd07fc9e9395009334ac176d91aa937a6547"

RDEPENDS:rust-hickory-proto+backtrace-devel = " \
 cargo \
 rust-backtrace+default-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+default-devel = " \
 cargo \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dns-over-native-tls-devel = " \
 cargo \
 rust-hickory-proto+dns-over-tls-devel \
 rust-hickory-proto+native-tls-devel \
 rust-hickory-proto+tokio-native-tls-devel \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dns-over-openssl-devel = " \
 cargo \
 rust-hickory-proto+dns-over-tls-devel \
 rust-hickory-proto+openssl-devel \
 rust-hickory-proto+tokio-openssl-devel \
 rust-hickory-proto+tokio-runtime-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dns-over-tls-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dnssec-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+dnssec-openssl-devel = " \
 cargo \
 rust-hickory-proto+dnssec-devel \
 rust-hickory-proto+openssl-devel \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+mdns-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-socket2_0.5+all-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto+native-tls-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-native-tls+default-devel \
 "
RDEPENDS:rust-hickory-proto+openssl-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-openssl+default-devel \
 rust-openssl+v102-devel \
 rust-openssl+v110-devel \
 "
RDEPENDS:rust-hickory-proto+serde-config-devel = " \
 cargo \
 rust-hickory-proto+serde-devel \
 rust-hickory-proto-devel \
 rust-url+serde-devel \
 "
RDEPENDS:rust-hickory-proto+serde-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-hickory-proto+socket2-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-socket2_0.5+default-devel \
 "
RDEPENDS:rust-hickory-proto+testing-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+text-parsing-devel = " \
 cargo \
 rust-hickory-proto-devel \
 "
RDEPENDS:rust-hickory-proto+tokio-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-hickory-proto+tokio-native-tls-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-hickory-proto+tokio-openssl-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-tokio-openssl+default-devel \
 "
RDEPENDS:rust-hickory-proto+tokio-runtime-devel = " \
 cargo \
 rust-hickory-proto-devel \
 rust-tokio+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+net-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+time-devel \
 "
RDEPENDS:rust-hickory-proto-devel = " \
 cargo \
 rust \
 rust-async-trait+default-devel \
 rust-cfg-if+default-devel \
 rust-data-encoding+default-devel \
 rust-enum-as-inner+default-devel \
 rust-futures-channel+std-devel \
 rust-futures-channel-devel \
 rust-futures-io+std-devel \
 rust-futures-io-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-idna+default-devel \
 rust-ipnet+default-devel \
 rust-once_cell+default-devel \
 rust-rand0.8+default-devel \
 rust-thiserror1+default-devel \
 rust-tinyvec+alloc-devel \
 rust-tinyvec+default-devel \
 rust-tracing+default-devel \
 rust-url+default-devel \
 "
