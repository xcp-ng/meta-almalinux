# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "findutils"
PE = "1"
PV = "4.10.0"
PR = "5.el10"
PACKAGES = " \
 findutils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/findutils-4.10.0-5.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7ba2dbc22d3335840d831e7feec863d6aee3a244d4133341f0e8f21dc2875dd0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/findutils-4.10.0-5.el10.x86_64_v2.rpm;name=x86_64_v2_findutils;unpack=0"
SRC_URI[x86_64_v2_findutils.sha256sum] = "0d86cc13b34e26c0f7a3a77488ec38b216fe9b26e7cd89d0cf704ceeda72c733"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/findutils-4.10.0-5.el10.aarch64.rpm;name=aarch64_findutils;unpack=0"
SRC_URI[aarch64_findutils.sha256sum] = "b7cb3db7cd69ae0e15be7e11d50a4be923100e38fba411aaf37f5de2dbaf1540"

RDEPENDS:findutils = " \
 glibc \
 libselinux \
 "
