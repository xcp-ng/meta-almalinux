# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-phf_codegen0.11"
PV = "0.11.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-phf_codegen0.11+default-devel \
 rust-phf_codegen0.11-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-phf_codegen0.11-0.11.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "acf26af401bc5c900755a00df9d1bb0163d4363a5f56e2faa5e19c006b14c4dd"

URI_x86_64_v2_rust-phf_codegen0.11+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_codegen0.11+default-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_codegen0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_codegen0.11+default-devel}"
SRC_URI[x86_64_v2_rust-phf_codegen0.11+default-devel.sha256sum] = "86e77494cd583f3413fb90909e3fd1e476b5e5bfcef9173ae11c83391fc7f09f"

URI_x86_64_v2_rust-phf_codegen0.11-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-phf_codegen0.11-devel-0.11.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-phf_codegen0.11-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-phf_codegen0.11-devel}"
SRC_URI[x86_64_v2_rust-phf_codegen0.11-devel.sha256sum] = "344ae3eb008701895d352b8f0e0251c7d30b0cf906ff6873cd17d5facb708bc4"

URI_aarch64_rust-phf_codegen0.11+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_codegen0.11+default-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_codegen0.11+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_codegen0.11+default-devel}"
SRC_URI[aarch64_rust-phf_codegen0.11+default-devel.sha256sum] = "e8fb38a1a11772f0c06184958cb6884c209b8a560c79864f6cdbb9934a4c9a30"

URI_aarch64_rust-phf_codegen0.11-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-phf_codegen0.11-devel-0.11.3-1.el10_2.noarch.rpm;name=aarch64_rust-phf_codegen0.11-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-phf_codegen0.11-devel}"
SRC_URI[aarch64_rust-phf_codegen0.11-devel.sha256sum] = "0e56c8e9fb76cd536e2d31f8d52fde2eb6aacc02907b189f428ea65f74daf082"

RDEPENDS:rust-phf_codegen0.11+default-devel = " \
 cargo \
 rust-phf_codegen0.11-devel \
 "
RDEPENDS:rust-phf_codegen0.11-devel = " \
 cargo \
 rust \
 rust-phf_generator0.11+default-devel \
 rust-phf_shared0.11+default-devel \
 "
