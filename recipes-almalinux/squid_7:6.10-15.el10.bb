# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squid"
PE = "7"
PV = "6.10"
PR = "15.el10"
PACKAGES = " \
 squid \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/squid-6.10-15.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de4d080649135d37cc32efc709cdf538e00d55963478df636aea033ce3d7edd2"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - squid: libcap.so.2()(64bit)

URI_x86_64_v2_squid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/squid-6.10-15.el10.x86_64_v2.rpm;name=x86_64_v2_squid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squid}"
SRC_URI[x86_64_v2_squid.sha256sum] = "a2676ab7a3c4e9a4050e71f1ddf5cd30d65b98135c9e357f5dfd2cf8f387e38d"

URI_aarch64_squid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/squid-6.10-15.el10.aarch64.rpm;name=aarch64_squid;unpack=0"
SRC_URI:append = " ${URI_aarch64_squid}"
SRC_URI[aarch64_squid.sha256sum] = "8bd483ebea68bb8f6f03bad7c93f079075831b9e0abfdabe228a73554d6a4d84"

RDEPENDS:squid:x86_64_v2 = " \
 bash \
 cyrus-sasl-lib \
 gawk \
 glibc \
 httpd-filesystem \
 krb5-libs \
 libcap \
 libcom_err \
 libecap \
 libgcc \
 libstdc++ \
 libtdb \
 libtool-ltdl \
 libxcrypt \
 openldap \
 openssl-libs \
 pam-libs \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-English \
 perl-File-Basename \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IPC-Open3 \
 perl-Pod-Usage \
 perl-URI \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-vars \
 shadow-utils \
 systemd \
 systemd-libs \
"
RDEPENDS:squid:aarch64 = " \
 bash \
 cyrus-sasl-lib \
 gawk \
 glibc \
 httpd-filesystem \
 krb5-libs \
 libcom_err \
 libecap \
 libgcc \
 libstdc++ \
 libtdb \
 libtool-ltdl \
 libxcrypt \
 openldap \
 openssl-libs \
 pam-libs \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-English \
 perl-File-Basename \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IPC-Open3 \
 perl-Pod-Usage \
 perl-URI \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-vars \
 shadow-utils \
 systemd \
 systemd-libs \
"
