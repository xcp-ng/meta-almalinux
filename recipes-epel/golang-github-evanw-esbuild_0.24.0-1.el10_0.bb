# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-evanw-esbuild"
PV = "0.24.0"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-evanw-esbuild \
 golang-github-evanw-esbuild-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-evanw-esbuild-0.24.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "686adef19dc16a93c41e61e6d3225eca8711bace954e521533292e0b16128596"

URI_x86_64_v2_golang-github-evanw-esbuild = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-evanw-esbuild-0.24.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_golang-github-evanw-esbuild;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-evanw-esbuild}"
SRC_URI[x86_64_v2_golang-github-evanw-esbuild.sha256sum] = "4c02764d3593202de1cf4f4fd7b961f1a97c2ee792e7d436aaa979e4648459bb"

URI_x86_64_v2_golang-github-evanw-esbuild-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-evanw-esbuild-devel-0.24.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-evanw-esbuild-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-evanw-esbuild-devel}"
SRC_URI[x86_64_v2_golang-github-evanw-esbuild-devel.sha256sum] = "57890dcde48f083d2b900a1f1794b9c050f29f64f4c98bf0a600bd429a2ad7fb"

URI_aarch64_golang-github-evanw-esbuild = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-evanw-esbuild-0.24.0-1.el10_0.aarch64.rpm;name=aarch64_golang-github-evanw-esbuild;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-evanw-esbuild}"
SRC_URI[aarch64_golang-github-evanw-esbuild.sha256sum] = "e2d662d7ffb2a2cfea2f827f9925a8407b448b7c5732d2873e2cb53ca73be7b6"

URI_aarch64_golang-github-evanw-esbuild-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-evanw-esbuild-devel-0.24.0-1.el10_0.noarch.rpm;name=aarch64_golang-github-evanw-esbuild-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-evanw-esbuild-devel}"
SRC_URI[aarch64_golang-github-evanw-esbuild-devel.sha256sum] = "1d94d37df7912f323f3f2ea6a89be3e967f5bf8643f94d9a8e39c9659c0e8d90"

RDEPENDS:golang-github-evanw-esbuild = " \
 glibc \
 "
RDEPENDS:golang-github-evanw-esbuild-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
