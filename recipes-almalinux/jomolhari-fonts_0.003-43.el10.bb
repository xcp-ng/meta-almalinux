# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "jomolhari-fonts"
PV = "0.003"
PR = "43.el10"
PACKAGES = " \
 jomolhari-fonts \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/jomolhari-fonts-0.003-43.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1b69a58977dc43799c7dcf77ece8de0a5feb1bd439a2cde47564a53ec169bef7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/jomolhari-fonts-0.003-43.el10.noarch.rpm;name=x86_64_v2_jomolhari-fonts;unpack=0"
SRC_URI[x86_64_v2_jomolhari-fonts.sha256sum] = "5c5edabf9aac058ba1f63ca9597ee8e0e39e012122fcf20b96e1bb91ac421ec7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/jomolhari-fonts-0.003-43.el10.noarch.rpm;name=aarch64_jomolhari-fonts;unpack=0"
SRC_URI[aarch64_jomolhari-fonts.sha256sum] = "5c5edabf9aac058ba1f63ca9597ee8e0e39e012122fcf20b96e1bb91ac421ec7"

RDEPENDS:jomolhari-fonts = " \
 fonts-filesystem \
 "
