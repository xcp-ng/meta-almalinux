# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-owo-colors"
PV = "4.4.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-owo-colors+alloc-devel \
 rust-owo-colors+default-devel \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors+supports-colors-devel \
 rust-owo-colors-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-owo-colors-4.4.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "13e5b780dd94b596ca22b7f01393b936b3ffc38c2171fd77e762e1eb8674797e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+alloc-devel-4.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors+alloc-devel.sha256sum] = "74518ffef3b013ff335294c90bc3685ebfd0772871d00c421dd933a3f11928b5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+default-devel-4.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors+default-devel.sha256sum] = "4f02bc56adf7c933379a28d1e77411d68bfe8f6a95298d5da894f673069c3809"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-color-devel-4.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors+supports-color-devel.sha256sum] = "bfffa4412eea4fb6bd03c5b7ffd1dc4b599f8259829b1b1808828eba057de9fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors+supports-colors-devel-4.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors+supports-colors-devel.sha256sum] = "a961c183619edb4a63d5f59ae0ee5cbeb21bb1a602903061373f8c0b0f907742"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-owo-colors-devel-4.4.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-owo-colors-devel;unpack=0"
SRC_URI[x86_64_v2_rust-owo-colors-devel.sha256sum] = "7402d674278fb69975caddbdefe1b78cc181a8dbf8cda48a3069ed3c41df9c30"
RPROVIDES:rust-owo-colors-devel:append:x86_64_v2 = " virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+alloc-devel-4.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors+alloc-devel.sha256sum] = "a6999bc4110c434a7dd26e3f1b69069a182d5ec060c502789b5f2d3a60ecc9f7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+default-devel-4.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors+default-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors+default-devel.sha256sum] = "a9a533662f039d8d3c27a8c181694591fbe9cdca952a44809148ad04353ef2b5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-color-devel-4.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors+supports-color-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors+supports-color-devel.sha256sum] = "19e1656ca430254c7cea7a88d74ba86b438bbeda778cd3c0fc60ccadb6e27380"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors+supports-colors-devel-4.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors+supports-colors-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors+supports-colors-devel.sha256sum] = "871addd64dea26e32680a8e4fbfeb655ef0055729e65dce635c1f8cfd31bcbcc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-owo-colors-devel-4.4.0-1.el10_3.noarch.rpm;name=aarch64_rust-owo-colors-devel;unpack=0"
SRC_URI[aarch64_rust-owo-colors-devel.sha256sum] = "d247a4d3963ec0f7b811517c1b03e66cebd04d5ac60bf6896b860e42550efc22"
RPROVIDES:rust-owo-colors-devel:append:aarch64 = " virtual/crate_owo-colors__ge_3.5.0_with_crate_owo-colors__lt_5.0.0~"

RDEPENDS:rust-owo-colors+alloc-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+default-devel = " \
 cargo \
 rust-owo-colors-devel \
 "
RDEPENDS:rust-owo-colors+supports-color-devel = " \
 cargo \
 rust-owo-colors-devel \
 rust-supports-color+default-devel \
 "
RDEPENDS:rust-owo-colors+supports-colors-devel = " \
 cargo \
 rust-owo-colors+supports-color-devel \
 rust-owo-colors-devel \
 rust-supports-color2+default-devel \
 "
RDEPENDS:rust-owo-colors-devel = " \
 cargo \
 rust \
 "
