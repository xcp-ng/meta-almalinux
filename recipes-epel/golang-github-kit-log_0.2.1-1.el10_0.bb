# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-kit-log"
PV = "0.2.1"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-kit-log-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-kit-log-0.2.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0b43deb67117277525b9de7caeb31366f5d39e95bebf1481aa8f253945f79a4b"

URI_x86_64_v2_golang-github-kit-log-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-kit-log-devel-0.2.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-kit-log-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-kit-log-devel}"
SRC_URI[x86_64_v2_golang-github-kit-log-devel.sha256sum] = "5ef869a262c30b3e8420d8af4ded9d3f35a5fe8a51b035abb78193a3d5d05522"

URI_aarch64_golang-github-kit-log-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-kit-log-devel-0.2.1-1.el10_0.noarch.rpm;name=aarch64_golang-github-kit-log-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-kit-log-devel}"
SRC_URI[aarch64_golang-github-kit-log-devel.sha256sum] = "5c29519b2f2f63bce2b44c35919c0c360bd5db2ac333f372715537bd9a47d1a5"

RDEPENDS:golang-github-kit-log-devel = " \
 go-filesystem \
 golang-github-logfmt-devel \
 "
