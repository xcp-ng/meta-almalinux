# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "snapraid"
PV = "12.4"
PR = "1.el10_1"
PACKAGES = " \
 snapraid \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/snapraid-12.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "32eb90218a38c64ae8d60560defe0aca52e1355f91a1226ae8a0a6209ab3bb8b"

URI_x86_64_v2_snapraid = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/snapraid-12.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_snapraid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_snapraid}"
SRC_URI[x86_64_v2_snapraid.sha256sum] = "91927c79f30b1a305ed03d1142fa581f89c9e15d898e3137572024c0aa56d285"

URI_aarch64_snapraid = "${EPEL_MIRROR}/aarch64/Packages/s/snapraid-12.4-1.el10_1.aarch64.rpm;name=aarch64_snapraid;unpack=0"
SRC_URI:append = " ${URI_aarch64_snapraid}"
SRC_URI[aarch64_snapraid.sha256sum] = "b329e27277e4c0e51df3ac0d07cfe47dda52971d470e9f9be9a3e912cbf55161"

RDEPENDS:snapraid = " \
 glibc \
 libblkid \
 "
