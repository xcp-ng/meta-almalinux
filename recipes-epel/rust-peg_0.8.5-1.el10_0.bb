# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-peg"
PV = "0.8.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-peg+default-devel \
 rust-peg+std-devel \
 rust-peg+trace-devel \
 rust-peg+unstable-devel \
 rust-peg-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-peg-0.8.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7129c6c4f89d62d0495916653129f40514431843af2ff1d3e1ff1ef3add3bfda"

URI_x86_64_v2_rust-peg+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg+default-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg+default-devel}"
SRC_URI[x86_64_v2_rust-peg+default-devel.sha256sum] = "cc64c0c2fc8d1ea2ffbb3af519044e3c5fb56e0b46878d634dd3c3445675ce29"

URI_x86_64_v2_rust-peg+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg+std-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg+std-devel}"
SRC_URI[x86_64_v2_rust-peg+std-devel.sha256sum] = "fc9a6917317936d87f98529438be90e87fac74fc1ed9aa9c6160eb62acc5daf9"

URI_x86_64_v2_rust-peg+trace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg+trace-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg+trace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg+trace-devel}"
SRC_URI[x86_64_v2_rust-peg+trace-devel.sha256sum] = "a282e80a579d870d84dd5f29f47e7455a366f7b483cc85f18d14e4ab58b275e5"

URI_x86_64_v2_rust-peg+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg+unstable-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg+unstable-devel}"
SRC_URI[x86_64_v2_rust-peg+unstable-devel.sha256sum] = "f8763fdcc20a66bca4e4a746f43189f500dcd5154134fc685bab35d6a0593c85"

URI_x86_64_v2_rust-peg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-peg-devel-0.8.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-peg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-peg-devel}"
SRC_URI[x86_64_v2_rust-peg-devel.sha256sum] = "44f739803df1b2cd9e8872e799a915ffd22db53bf9229ada234af7c7fa02a5e2"

URI_aarch64_rust-peg+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg+default-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg+default-devel}"
SRC_URI[aarch64_rust-peg+default-devel.sha256sum] = "dfaed59fef8f41acf59a9272ee2533830d33d92dee1a1244d3b2c5fb4e1e7fa2"

URI_aarch64_rust-peg+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg+std-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg+std-devel}"
SRC_URI[aarch64_rust-peg+std-devel.sha256sum] = "73fff25d899ccbe6efc62f6e9b07b25f49789fb9691188631bb462b02ffe1d2e"

URI_aarch64_rust-peg+trace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg+trace-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg+trace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg+trace-devel}"
SRC_URI[aarch64_rust-peg+trace-devel.sha256sum] = "83a6bf126e16ed6a6ee491de1a40a8ba2da9bc0b9c1147da86a6ddf79936483a"

URI_aarch64_rust-peg+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg+unstable-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg+unstable-devel}"
SRC_URI[aarch64_rust-peg+unstable-devel.sha256sum] = "924e8b60c1aec868fe36e82ed733cced5edbe018fd3ccfc98616c6ce4b6b0d7a"

URI_aarch64_rust-peg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-peg-devel-0.8.5-1.el10_0.noarch.rpm;name=aarch64_rust-peg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-peg-devel}"
SRC_URI[aarch64_rust-peg-devel.sha256sum] = "239d38c2895413fe385a5299282239db64563e578dfdc753b7eec836995bca09"

RDEPENDS:rust-peg+default-devel = " \
 cargo \
 rust-peg+std-devel \
 rust-peg-devel \
 "
RDEPENDS:rust-peg+std-devel = " \
 cargo \
 rust-peg-devel \
 rust-peg-runtime+std-devel \
 "
RDEPENDS:rust-peg+trace-devel = " \
 cargo \
 rust-peg-devel \
 rust-peg-macros+trace-devel \
 "
RDEPENDS:rust-peg+unstable-devel = " \
 cargo \
 rust-peg-devel \
 rust-peg-runtime+unstable-devel \
 "
RDEPENDS:rust-peg-devel = " \
 bash \
 cargo \
 rust \
 rust-peg-macros+default-devel \
 rust-peg-runtime+default-devel \
 "
