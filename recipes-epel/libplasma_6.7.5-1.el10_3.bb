# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libplasma"
PV = "6.7.5"
PR = "1.el10_3"
PACKAGES = " \
 libplasma \
 libplasma-devel \
 libplasma-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/libplasma-6.7.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "1ec5d49ab716d56ee1b39f2b7477262a3439a942b0260945a8cc6d0dc4729e0e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma;unpack=0"
SRC_URI[x86_64_v2_libplasma.sha256sum] = "8d66b48780ea75a76e13611d38de8a7a5abd81590da35f7fc6f9700436acf864"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-devel-6.7.5-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libplasma-devel;unpack=0"
SRC_URI[x86_64_v2_libplasma-devel.sha256sum] = "33cb5a9bedfce4914c7f56207e6b2158112126ddb78eb6b3e7ff04b5763056fd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libplasma-doc-6.7.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_libplasma-doc;unpack=0"
SRC_URI[x86_64_v2_libplasma-doc.sha256sum] = "226781239f2b727e8dca581cd179c200b52fa675efe986b06f60bddab5a421df"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libplasma-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_libplasma;unpack=0"
SRC_URI[aarch64_libplasma.sha256sum] = "a511afe5f86f2b04c5134b146a58b51ea94e6ed5eab3562bb0f1c14e0c8de727"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libplasma-devel-6.7.5-1.el10_3.aarch64.rpm;name=aarch64_libplasma-devel;unpack=0"
SRC_URI[aarch64_libplasma-devel.sha256sum] = "f2feb2b658b0364772f109f1de0a48b4bf79f390eaf89bd5af205f12beef2456"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/libplasma-doc-6.7.5-1.el10_3.noarch.rpm;name=aarch64_libplasma-doc;unpack=0"
SRC_URI[aarch64_libplasma-doc.sha256sum] = "020595653177e5e4183e09043ed357db2476ee34a169463788ba96529274d8cb"

RDEPENDS:libplasma = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-knotifications \
 kf6-kpackage \
 kf6-ksvg \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libX11 \
 libglvnd-egl \
 libglvnd-glx \
 libglvnd-opengl \
 libstdc++ \
 libwayland-client \
 libxcb \
 plasma-activities \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:libplasma-devel = " \
 cmake-filesystem \
 kf6-kirigami-devel \
 kf6-kpackage-devel \
 kf6-kwindowsystem-devel \
 libplasma \
 qt6-qtbase-devel \
 qt6-qtdeclarative-devel \
 "
RDEPENDS:libplasma-doc = " \
 "
