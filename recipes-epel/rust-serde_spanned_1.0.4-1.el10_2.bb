# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_spanned"
PV = "1.0.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-serde_spanned+std-devel \
 rust-serde_spanned-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_spanned-1.0.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f37424670ea7c467d97927f9462e3d24068acea81aeb7da2cea241c9ad4ce205"

URI_x86_64_v2_rust-serde_spanned+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+alloc-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+alloc-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+alloc-devel.sha256sum] = "823bb9df7fa53380f7d37472ea822e43d63e8d25db345080846763686d398074"

URI_x86_64_v2_rust-serde_spanned+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+default-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+default-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+default-devel.sha256sum] = "ebb3f67a7ade43761a7306d2c52b5a1b57162983ea7c2c2fd07ec21e24ce47b5"

URI_x86_64_v2_rust-serde_spanned+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+serde-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+serde-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+serde-devel.sha256sum] = "a866c8236f1fdac87d0bf26c05885938414075edd6a3e233822ef68b45430402"

URI_x86_64_v2_rust-serde_spanned+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned+std-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned+std-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned+std-devel.sha256sum] = "aec45424774ead20d524221c1d909f8157411a2a5d1bd6ed2f9ee4ac1aa1f8f7"

URI_x86_64_v2_rust-serde_spanned-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_spanned-devel-1.0.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_spanned-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_spanned-devel}"
SRC_URI[x86_64_v2_rust-serde_spanned-devel.sha256sum] = "fdc9bf2178d942dde4647df60ca4366a6be28a34c7445d049f15b29e6a410f1e"

URI_aarch64_rust-serde_spanned+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+alloc-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-serde_spanned+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+alloc-devel}"
SRC_URI[aarch64_rust-serde_spanned+alloc-devel.sha256sum] = "14c3ad59326a5e82b300de97d56836d39b37f72246cfa066a5b31e0870e2edc1"

URI_aarch64_rust-serde_spanned+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+default-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-serde_spanned+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+default-devel}"
SRC_URI[aarch64_rust-serde_spanned+default-devel.sha256sum] = "113962e461c9eaf887fd80459d6bd3b18117546b24d4724bde6c78125437c7db"

URI_aarch64_rust-serde_spanned+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+serde-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-serde_spanned+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+serde-devel}"
SRC_URI[aarch64_rust-serde_spanned+serde-devel.sha256sum] = "5a43b3d4b683568806259c895efa9be668a37025f3a1d75488d789712d718e34"

URI_aarch64_rust-serde_spanned+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned+std-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-serde_spanned+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned+std-devel}"
SRC_URI[aarch64_rust-serde_spanned+std-devel.sha256sum] = "c99876c8f91aa73e553e25a7904fd4f98ac6bd54a6fc066372a89af6cf50b388"

URI_aarch64_rust-serde_spanned-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_spanned-devel-1.0.4-1.el10_2.noarch.rpm;name=aarch64_rust-serde_spanned-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_spanned-devel}"
SRC_URI[aarch64_rust-serde_spanned-devel.sha256sum] = "71acff1d96e314006887f82ee634f21119ad285118ee7c745da124f7c622f01e"

RDEPENDS:rust-serde_spanned+alloc-devel = " \
 cargo \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+default-devel = " \
 cargo \
 rust-serde_spanned+serde-devel \
 rust-serde_spanned+std-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+serde-devel = " \
 cargo \
 rust-serde_core-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned+std-devel = " \
 cargo \
 rust-serde_core+std-devel \
 rust-serde_core-devel \
 rust-serde_spanned+alloc-devel \
 rust-serde_spanned-devel \
 "
RDEPENDS:rust-serde_spanned-devel = " \
 cargo \
 rust \
 "
