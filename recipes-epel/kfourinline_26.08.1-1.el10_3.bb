# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kfourinline"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kfourinline \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kfourinline-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a62d3a0cae9e398cccf769b45e614fdec1440f436cc59dd506a6626e815f633a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfourinline-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfourinline;unpack=0"
SRC_URI[x86_64_v2_kfourinline.sha256sum] = "26fcd40cbfb5a12ed18ef65a4769f843d9a57592eea78a4d395d0a1dcaf850f9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kfourinline-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kfourinline;unpack=0"
SRC_URI[aarch64_kfourinline.sha256sum] = "0eadf23d498563d0dc619d143eadd1f3b399bfbede2e4ef725b7dae0f05ae14d"

RDEPENDS:kfourinline = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kdnssd \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
