# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "net-snmp"
PE = "1"
PV = "5.9.4"
PR = "15.el10_0"
PACKAGES = " \
 net-snmp \
 net-snmp-agent-libs \
 net-snmp-devel \
 net-snmp-libs \
 net-snmp-perl \
 net-snmp-perl-module \
 net-snmp-utils \
 python3-net-snmp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/net-snmp-5.9.4-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f1270e7e8b0ef3c97dc2e9f8236a1ce6675f607eb417e705ea24c80cab97338"

URI_x86_64_v2_net-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-5.9.4-15.el10_0.x86_64_v2.rpm;name=x86_64_v2_net-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp}"
SRC_URI[x86_64_v2_net-snmp.sha256sum] = "b8fad94a86f8c6791e7dec091581763d188827e05bb635e9ee22eca73cb3f29f"

URI_x86_64_v2_net-snmp-agent-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-agent-libs-5.9.4-15.el10_0.x86_64_v2.rpm;name=x86_64_v2_net-snmp-agent-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-agent-libs}"
SRC_URI[x86_64_v2_net-snmp-agent-libs.sha256sum] = "c60d1b37ed9a2a712cad28a41e495081a0250f933d6c51f53f2a1c8c0ced6df5"

URI_x86_64_v2_net-snmp-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-devel-5.9.4-15.el10_0.x86_64_v2.rpm;name=x86_64_v2_net-snmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-devel}"
SRC_URI[x86_64_v2_net-snmp-devel.sha256sum] = "98c8316020d52d1be55e389e8c01b457509a9866e49bfc6417c5c47fae43653b"

URI_x86_64_v2_net-snmp-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-libs-5.9.4-15.el10_0.x86_64_v2.rpm;name=x86_64_v2_net-snmp-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-libs}"
SRC_URI[x86_64_v2_net-snmp-libs.sha256sum] = "48d5e61a054259e9e536431ea75a613e674e221d54f52642db7d1706f5eb461c"

URI_x86_64_v2_net-snmp-perl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-perl-5.9.4-15.el10_0.x86_64_v2.rpm;name=x86_64_v2_net-snmp-perl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-perl}"
SRC_URI[x86_64_v2_net-snmp-perl.sha256sum] = "89c0150b267fa01b0dfef034f66a16d6897dad4a9e4fd40b74deb323f13c591e"

URI_x86_64_v2_net-snmp-perl-module = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-perl-module-5.9.4-15.el10_0.x86_64_v2.rpm;name=x86_64_v2_net-snmp-perl-module;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-perl-module}"
SRC_URI[x86_64_v2_net-snmp-perl-module.sha256sum] = "591d625a65ed20316479d8234a30d682d127d85aa18917ca4b1d8ea78a221b0b"

URI_x86_64_v2_net-snmp-utils = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/net-snmp-utils-5.9.4-15.el10_0.x86_64_v2.rpm;name=x86_64_v2_net-snmp-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_net-snmp-utils}"
SRC_URI[x86_64_v2_net-snmp-utils.sha256sum] = "225877d60746bd1230fc183c79ae3f32495e99cac15e6f601df8bb9e3696891b"

URI_x86_64_v2_python3-net-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-net-snmp-5.9.4-15.el10_0.x86_64_v2.rpm;name=x86_64_v2_python3-net-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-net-snmp}"
SRC_URI[x86_64_v2_python3-net-snmp.sha256sum] = "6c9ac8593e685b891c17efbc7bed7df039c3e1d1588fd74efe8299ec2e2c14b9"

URI_aarch64_net-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-5.9.4-15.el10_0.aarch64.rpm;name=aarch64_net-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp}"
SRC_URI[aarch64_net-snmp.sha256sum] = "d6ce43ceebbcae90bd7cef11bb8604427f09f03ebaf7dbe0d1ecf7bbd0640221"

URI_aarch64_net-snmp-agent-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-agent-libs-5.9.4-15.el10_0.aarch64.rpm;name=aarch64_net-snmp-agent-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-agent-libs}"
SRC_URI[aarch64_net-snmp-agent-libs.sha256sum] = "175625668d0b3a7719da725fad5d5851946da307cda8aa5507cffd9f3433e0b5"

URI_aarch64_net-snmp-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-devel-5.9.4-15.el10_0.aarch64.rpm;name=aarch64_net-snmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-devel}"
SRC_URI[aarch64_net-snmp-devel.sha256sum] = "dbc040d52cdf2db734747795d32f63f763f6214e274a56f6c808a11437083742"

URI_aarch64_net-snmp-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-libs-5.9.4-15.el10_0.aarch64.rpm;name=aarch64_net-snmp-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-libs}"
SRC_URI[aarch64_net-snmp-libs.sha256sum] = "ecbd5ae4eee1b7a163db2f82d8de461b653aa1abe6eed6a6486912bc835606b8"

URI_aarch64_net-snmp-perl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-perl-5.9.4-15.el10_0.aarch64.rpm;name=aarch64_net-snmp-perl;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-perl}"
SRC_URI[aarch64_net-snmp-perl.sha256sum] = "95b75ee6ee0ddd518b06b243d4d0dbd0489104d3bf29586f61ac247b7e80787a"

URI_aarch64_net-snmp-perl-module = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-perl-module-5.9.4-15.el10_0.aarch64.rpm;name=aarch64_net-snmp-perl-module;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-perl-module}"
SRC_URI[aarch64_net-snmp-perl-module.sha256sum] = "79315c2e5806f5df27058fdaa74b281f78d3e9b7fa12735394cb59a2659e9289"

URI_aarch64_net-snmp-utils = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/net-snmp-utils-5.9.4-15.el10_0.aarch64.rpm;name=aarch64_net-snmp-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_net-snmp-utils}"
SRC_URI[aarch64_net-snmp-utils.sha256sum] = "e3ee4c7d29a8e0f2bd5687ae3078837a93d85aa4aede1901cccc9c4b82fecb80"

URI_aarch64_python3-net-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-net-snmp-5.9.4-15.el10_0.aarch64.rpm;name=aarch64_python3-net-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-net-snmp}"
SRC_URI[aarch64_python3-net-snmp.sha256sum] = "ed2c44fb8d5d2b7dbcd13f71b0781a0020d9d3644f97ccfeb3799691fd60d2a1"

RDEPENDS:net-snmp = " \
 bash \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 perl-Data-Dumper \
 perl-File-Copy \
 perl-Getopt-Std \
 perl-IO \
 perl-Term-ReadLine \
 perl-interpreter \
 systemd \
 "
RDEPENDS:net-snmp-agent-libs = " \
 glibc \
 libxcrypt \
 lm_sensors-libs \
 mariadb-connector-c \
 net-snmp-libs \
 openssl-libs \
 perl-libs \
 rpm-libs \
 "
RDEPENDS:net-snmp-devel = " \
 bash \
 elfutils-devel \
 elfutils-libelf-devel \
 lm_sensors-devel \
 net-snmp-agent-libs \
 net-snmp-libs \
 openssl-devel \
 perl-devel \
 pkgconf-pkg-config \
 redhat-rpm-config \
 rpm-devel \
 "
RDEPENDS:net-snmp-libs = " \
 glibc \
 openssl-libs \
 "
RDEPENDS:net-snmp-perl = " \
 bash \
 net-snmp-agent-libs \
 net-snmp-devel \
 net-snmp-libs \
 net-snmp-perl-module \
 perl-Carp \
 perl-Data-Dumper \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Path \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-JSON \
 perl-POSIX \
 perl-PathTools \
 perl-Sys-Hostname \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-vars \
 "
RDEPENDS:net-snmp-perl-module = " \
 glibc \
 net-snmp-agent-libs \
 net-snmp-libs \
 net-snmp-perl-module \
 perl-AutoLoader \
 perl-Carp \
 perl-Data-Dumper \
 perl-DynaLoader \
 perl-Exporter \
 perl-interpreter \
 perl-libs \
 perl-overload \
 perl-vars \
 "
RDEPENDS:net-snmp-utils = " \
 glibc \
 net-snmp-libs \
 openssl-libs \
 "
RDEPENDS:python3-net-snmp = " \
 glibc \
 net-snmp-libs \
 python3 \
 "
