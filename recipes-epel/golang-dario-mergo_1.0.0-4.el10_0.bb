# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-dario-mergo"
PV = "1.0.0"
PR = "4.el10_0"
PACKAGES = " \
 compat-golang-github-imdario-mergo-devel \
 golang-dario-mergo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-dario-mergo-1.0.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d9e9a7902a72a073ab977c0c6fdca4aba76b4b3cf2c3b74c8da039f3ee7e0ec2"

URI_x86_64_v2_compat-golang-github-imdario-mergo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/compat-golang-github-imdario-mergo-devel-1.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_compat-golang-github-imdario-mergo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_compat-golang-github-imdario-mergo-devel}"
SRC_URI[x86_64_v2_compat-golang-github-imdario-mergo-devel.sha256sum] = "56074e6a2f7a3034869ed81685735a63c22a3c36713125e8ab9924d2fa7f9e46"

URI_x86_64_v2_golang-dario-mergo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-dario-mergo-devel-1.0.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-dario-mergo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-dario-mergo-devel}"
SRC_URI[x86_64_v2_golang-dario-mergo-devel.sha256sum] = "ddc2f40d4393b1dcfb83e62b61444110a51dae8889f732bccccb5a559c9ff015"

URI_aarch64_compat-golang-github-imdario-mergo-devel = "${EPEL_MIRROR}/aarch64/Packages/c/compat-golang-github-imdario-mergo-devel-1.0.0-4.el10_0.noarch.rpm;name=aarch64_compat-golang-github-imdario-mergo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_compat-golang-github-imdario-mergo-devel}"
SRC_URI[aarch64_compat-golang-github-imdario-mergo-devel.sha256sum] = "b32ebdab16fd5f5c0a962e98475377ff2f0c7aca4b3b3edddfbfd2b2fc7a7cbd"

URI_aarch64_golang-dario-mergo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-dario-mergo-devel-1.0.0-4.el10_0.noarch.rpm;name=aarch64_golang-dario-mergo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-dario-mergo-devel}"
SRC_URI[aarch64_golang-dario-mergo-devel.sha256sum] = "a8a7c84117dab146225c73084bab629b3e46c64ce3619f9ab8bbc00017455447"

RDEPENDS:compat-golang-github-imdario-mergo-devel = " \
 go-filesystem \
 golang-dario-mergo-devel \
 "
RDEPENDS:golang-dario-mergo-devel = " \
 go-filesystem \
 "
