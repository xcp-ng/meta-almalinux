# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "desktop-file-utils"
PV = "0.26"
PR = "15.el10"
PACKAGES = " \
 desktop-file-utils \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/desktop-file-utils-0.26-15.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "739909d044625537230be28fcd3696f362e3a1e32143e5febc58c9153b1e7cd7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/desktop-file-utils-0.26-15.el10.x86_64_v2.rpm;name=x86_64_v2_desktop-file-utils;unpack=0"
SRC_URI[x86_64_v2_desktop-file-utils.sha256sum] = "f4165fa511700e1f2108b417a2c286aaa5ab7da508319a83e236f82abd17da27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/desktop-file-utils-0.26-15.el10.aarch64.rpm;name=aarch64_desktop-file-utils;unpack=0"
SRC_URI[aarch64_desktop-file-utils.sha256sum] = "f421bca8c78fa309b54a724e1485ce998defb6cc5fff613c55c739b700e50872"

RDEPENDS:desktop-file-utils = " \
 bash \
 emacs-filesystem \
 glib2 \
 glibc \
 "
