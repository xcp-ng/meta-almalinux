# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-OWSLib"
PV = "0.32.0"
PR = "1.el10_0"
PACKAGES = " \
 python-OWSLib-doc \
 python3-OWSLib \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-OWSLib-0.32.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5d5150928043adbd7923efc61faaf845c5e616882a82643357b763be3e359a0d"

URI_x86_64_v2_python-OWSLib-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-OWSLib-doc-0.32.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python-OWSLib-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-OWSLib-doc}"
SRC_URI[x86_64_v2_python-OWSLib-doc.sha256sum] = "ea38a0fb624b385f68a5975921030f01274c1703a43b5d000b1480e4bc51b34f"

URI_x86_64_v2_python3-OWSLib = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-OWSLib-0.32.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-OWSLib;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-OWSLib}"
SRC_URI[x86_64_v2_python3-OWSLib.sha256sum] = "03e534327be292ff90c69ca6d14e1c9ec59ab2a4a1cbd12bfff8df03f39b1a52"

URI_aarch64_python-OWSLib-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-OWSLib-doc-0.32.0-1.el10_0.noarch.rpm;name=aarch64_python-OWSLib-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-OWSLib-doc}"
SRC_URI[aarch64_python-OWSLib-doc.sha256sum] = "87095c614360c0175b8d7dbba67481cf0f30cdaa877420762b06bee475190bce"

URI_aarch64_python3-OWSLib = "${EPEL_MIRROR}/aarch64/Packages/p/python3-OWSLib-0.32.0-1.el10_0.noarch.rpm;name=aarch64_python3-OWSLib;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-OWSLib}"
SRC_URI[aarch64_python3-OWSLib.sha256sum] = "3b67df5f60cf243178470781781e0dc67b2f0208a378ef89c6e2ead4a72458d3"

RDEPENDS:python-OWSLib-doc = " \
 "
RDEPENDS:python3-OWSLib = " \
 python3 \
 python3-dateutil \
 python3-lxml \
 python3-pyyaml \
 python3-requests \
 "
