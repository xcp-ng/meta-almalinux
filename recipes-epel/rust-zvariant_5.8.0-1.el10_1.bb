# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zvariant"
PV = "5.8.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-zvariant+arrayvec-devel \
 rust-zvariant+camino-devel \
 rust-zvariant+chrono-devel \
 rust-zvariant+default-devel \
 rust-zvariant+enumflags2-devel \
 rust-zvariant+gvariant-devel \
 rust-zvariant+option-as-array-devel \
 rust-zvariant+ostree-tests-devel \
 rust-zvariant+serde_bytes-devel \
 rust-zvariant+time-devel \
 rust-zvariant+url-devel \
 rust-zvariant+uuid-devel \
 rust-zvariant-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zvariant-5.8.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "34e88ff4fdd0a0dcbddedbda6a78bf21be5943ecc5b6b3aaeac2c3942d69389f"

URI_x86_64_v2_rust-zvariant+arrayvec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+arrayvec-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+arrayvec-devel}"
SRC_URI[x86_64_v2_rust-zvariant+arrayvec-devel.sha256sum] = "c836319b616f965cfe41cf54fd89ebd16122b09abe220b08a3f6b12da077029b"

URI_x86_64_v2_rust-zvariant+camino-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+camino-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+camino-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+camino-devel}"
SRC_URI[x86_64_v2_rust-zvariant+camino-devel.sha256sum] = "7f286aeec0d01696f6c6e2c37feb95cd5d66a8b0742f05aff1f2320185a1c0a1"

URI_x86_64_v2_rust-zvariant+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+chrono-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+chrono-devel}"
SRC_URI[x86_64_v2_rust-zvariant+chrono-devel.sha256sum] = "9a5df5e452bfd2d03a2f268d8ec2458650c349e37a8d36ef0efc15ea455a90e2"

URI_x86_64_v2_rust-zvariant+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+default-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+default-devel}"
SRC_URI[x86_64_v2_rust-zvariant+default-devel.sha256sum] = "22a5e6073e2a81257ca9f82e8bb5f21e777a65c2688a51ea3e05dac45dd78fcb"

URI_x86_64_v2_rust-zvariant+enumflags2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+enumflags2-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+enumflags2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+enumflags2-devel}"
SRC_URI[x86_64_v2_rust-zvariant+enumflags2-devel.sha256sum] = "b4a26c553024fd5765b26f429e2a3824b264de1515ed6e8886cab2dcd6f9d1c3"

URI_x86_64_v2_rust-zvariant+gvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+gvariant-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+gvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant+gvariant-devel.sha256sum] = "1dcb4215947e56bcc9b42c065e72c67532274ad56c9b61477e479317cf18c59f"

URI_x86_64_v2_rust-zvariant+option-as-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+option-as-array-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+option-as-array-devel}"
SRC_URI[x86_64_v2_rust-zvariant+option-as-array-devel.sha256sum] = "76bd64f8e0c018114afd0fe88d44b077141d024edfec250ccdc3879d2be7668a"

URI_x86_64_v2_rust-zvariant+ostree-tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+ostree-tests-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+ostree-tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+ostree-tests-devel}"
SRC_URI[x86_64_v2_rust-zvariant+ostree-tests-devel.sha256sum] = "8a3361249f25850a441f0e37543d76936e4ec48602a48c3d6bbc9468a60acbf6"

URI_x86_64_v2_rust-zvariant+serde_bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+serde_bytes-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+serde_bytes-devel}"
SRC_URI[x86_64_v2_rust-zvariant+serde_bytes-devel.sha256sum] = "da8f61e96c86e9dd3b440c8e9f5420249492cf20d0a1add9c5c8581e73fb90f6"

URI_x86_64_v2_rust-zvariant+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+time-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+time-devel}"
SRC_URI[x86_64_v2_rust-zvariant+time-devel.sha256sum] = "1d28100f74a594bd3503cd0fb2a51446af14cca1cf452abe1ddfbaf5c52372aa"

URI_x86_64_v2_rust-zvariant+url-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+url-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+url-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+url-devel}"
SRC_URI[x86_64_v2_rust-zvariant+url-devel.sha256sum] = "ecc2b05ad571f1c4d6a695ca7492a8c1593698f2578ece9679ac9786b5c27118"

URI_x86_64_v2_rust-zvariant+uuid-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant+uuid-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant+uuid-devel}"
SRC_URI[x86_64_v2_rust-zvariant+uuid-devel.sha256sum] = "17ba5a57d130da38d349a21daa21fed8fabd7e6544124f6a00d39aec6093cf91"

URI_x86_64_v2_rust-zvariant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zvariant-devel-5.8.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zvariant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zvariant-devel}"
SRC_URI[x86_64_v2_rust-zvariant-devel.sha256sum] = "5fd0b282536fde9cbd14fcb738be0430780cb378f5407c46ba416b8ce49f3083"

URI_aarch64_rust-zvariant+arrayvec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+arrayvec-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+arrayvec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+arrayvec-devel}"
SRC_URI[aarch64_rust-zvariant+arrayvec-devel.sha256sum] = "07f06e8f6641a419955567d9a3c0d6e424eb3529c699869738ac1e0f16da45b3"

URI_aarch64_rust-zvariant+camino-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+camino-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+camino-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+camino-devel}"
SRC_URI[aarch64_rust-zvariant+camino-devel.sha256sum] = "02bde177b8c3d34dbd768ee400ba2b581d94975e1e530bf2efb6d562ada9dcbb"

URI_aarch64_rust-zvariant+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+chrono-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+chrono-devel}"
SRC_URI[aarch64_rust-zvariant+chrono-devel.sha256sum] = "b0bc62371f2c87ade1afe5e554ede4d045a257ce2afec25eda83927d27756688"

URI_aarch64_rust-zvariant+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+default-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+default-devel}"
SRC_URI[aarch64_rust-zvariant+default-devel.sha256sum] = "f45d165c310ed330fc21696daa36828c5958cf3adb92d9b254ee3bec55dd28f2"

URI_aarch64_rust-zvariant+enumflags2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+enumflags2-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+enumflags2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+enumflags2-devel}"
SRC_URI[aarch64_rust-zvariant+enumflags2-devel.sha256sum] = "f4724a5cf2441c5c333b4937dd740dee7259ffa9a38dbe114131bfd53fefb400"

URI_aarch64_rust-zvariant+gvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+gvariant-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+gvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+gvariant-devel}"
SRC_URI[aarch64_rust-zvariant+gvariant-devel.sha256sum] = "21bd24e859adffb6cdbedb4a0794bcbb9c86e7c0e7b7c4aa5127fa444712de45"

URI_aarch64_rust-zvariant+option-as-array-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+option-as-array-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+option-as-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+option-as-array-devel}"
SRC_URI[aarch64_rust-zvariant+option-as-array-devel.sha256sum] = "57172d25b3358a1b498dcaec29bee2d656bd11936fb200df8dbfb6960348b4b4"

URI_aarch64_rust-zvariant+ostree-tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+ostree-tests-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+ostree-tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+ostree-tests-devel}"
SRC_URI[aarch64_rust-zvariant+ostree-tests-devel.sha256sum] = "585c7a0a5517755c1d6c051c6fb393cf4791c9df94145e6ddaf481b519ad7b3d"

URI_aarch64_rust-zvariant+serde_bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+serde_bytes-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+serde_bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+serde_bytes-devel}"
SRC_URI[aarch64_rust-zvariant+serde_bytes-devel.sha256sum] = "0c45b5b24ec9335ebef8b196df12d9828018c2c81b3898987bb46df718022aae"

URI_aarch64_rust-zvariant+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+time-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+time-devel}"
SRC_URI[aarch64_rust-zvariant+time-devel.sha256sum] = "412d0ef46618d8c6d89c0d9e8851a62654eb7d09717d8dd303cb92ed000511d9"

URI_aarch64_rust-zvariant+url-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+url-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+url-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+url-devel}"
SRC_URI[aarch64_rust-zvariant+url-devel.sha256sum] = "96f0245dcd3a313bfa5bc029347867ee39dffc0542c43b88781e681f677c10d5"

URI_aarch64_rust-zvariant+uuid-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant+uuid-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant+uuid-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant+uuid-devel}"
SRC_URI[aarch64_rust-zvariant+uuid-devel.sha256sum] = "02e25895cb8fd33d0429afd627a0152fd2388178d0a035be7c7713875adbb2d4"

URI_aarch64_rust-zvariant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zvariant-devel-5.8.0-1.el10_1.noarch.rpm;name=aarch64_rust-zvariant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zvariant-devel}"
SRC_URI[aarch64_rust-zvariant-devel.sha256sum] = "83f2a74020eadc3c1020b536a9027b75ccf1d8ebd666a8c409cfc9bf6f46b87e"

RDEPENDS:rust-zvariant+arrayvec-devel = " \
 cargo \
 rust-arrayvec+default-devel \
 rust-arrayvec+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+camino-devel = " \
 cargo \
 rust-camino+default-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+chrono-devel = " \
 cargo \
 rust-chrono+serde-devel \
 rust-chrono-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+default-devel = " \
 cargo \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+enumflags2-devel = " \
 cargo \
 rust-enumflags2+default-devel \
 rust-enumflags2+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+gvariant-devel = " \
 cargo \
 rust-zvariant-devel \
 rust-zvariant_derive+gvariant-devel \
 rust-zvariant_utils+gvariant-devel \
 "
RDEPENDS:rust-zvariant+option-as-array-devel = " \
 cargo \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+ostree-tests-devel = " \
 cargo \
 rust-zvariant+gvariant-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+serde_bytes-devel = " \
 cargo \
 rust-serde_bytes+default-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+time-devel = " \
 cargo \
 rust-time+default-devel \
 rust-time+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+url-devel = " \
 cargo \
 rust-url+default-devel \
 rust-url+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant+uuid-devel = " \
 cargo \
 rust-uuid+default-devel \
 rust-uuid+serde-devel \
 rust-zvariant-devel \
 "
RDEPENDS:rust-zvariant-devel = " \
 cargo \
 rust \
 rust-endi+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-winnow+default-devel \
 rust-zvariant_derive+default-devel \
 rust-zvariant_utils+default-devel \
 "
