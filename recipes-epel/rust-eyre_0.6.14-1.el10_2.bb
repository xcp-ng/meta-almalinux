# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-eyre"
PV = "0.6.14"
PR = "1.el10_2"
PACKAGES = " \
 rust-eyre+auto-install-devel \
 rust-eyre+default-devel \
 rust-eyre+track-caller-devel \
 rust-eyre-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-eyre-0.6.14-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f1cd1dc2a5ca8c8d3718f82af7c41121ff5730a42e9f02912cdb26219856b940"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre+auto-install-devel-0.6.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre+auto-install-devel;unpack=0"
SRC_URI[x86_64_v2_rust-eyre+auto-install-devel.sha256sum] = "efb62c0c7df6a985ada96d60ed50086ae4570e430066c713b6e9849a3273f0af"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre+default-devel-0.6.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-eyre+default-devel.sha256sum] = "6e7a84a4cd90634de96c39b7b5d5103a1a7eb7bb29fedd53f131f377c39eef35"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre+track-caller-devel-0.6.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre+track-caller-devel;unpack=0"
SRC_URI[x86_64_v2_rust-eyre+track-caller-devel.sha256sum] = "f07982e5040f53e924a3306bdd6b461353ec6776955819b07161e7b460996da6"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-eyre-devel-0.6.14-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-eyre-devel;unpack=0"
SRC_URI[x86_64_v2_rust-eyre-devel.sha256sum] = "22a3d588282335e43f8117f16407741a88a722f0c77dc7439f1e76c22a976a29"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre+auto-install-devel-0.6.14-1.el10_2.noarch.rpm;name=aarch64_rust-eyre+auto-install-devel;unpack=0"
SRC_URI[aarch64_rust-eyre+auto-install-devel.sha256sum] = "e8c444be354939fa3ba8dceb835cdfd9b3bf6c47d45ad3afb2367d905d9fb4f0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre+default-devel-0.6.14-1.el10_2.noarch.rpm;name=aarch64_rust-eyre+default-devel;unpack=0"
SRC_URI[aarch64_rust-eyre+default-devel.sha256sum] = "79e223fd056bc5c84a5dcd6d6b86f751d8628fee6f34753501dac3ad07029c16"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre+track-caller-devel-0.6.14-1.el10_2.noarch.rpm;name=aarch64_rust-eyre+track-caller-devel;unpack=0"
SRC_URI[aarch64_rust-eyre+track-caller-devel.sha256sum] = "e59b7dc57246c00eae51ebba9debd77a7d81caeae36d9bf34c0f9350aee6f30f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-eyre-devel-0.6.14-1.el10_2.noarch.rpm;name=aarch64_rust-eyre-devel;unpack=0"
SRC_URI[aarch64_rust-eyre-devel.sha256sum] = "736778e64483182841b663b6a7f201c6a22c6d30ee6dc14a3e2384df21fe8137"

RDEPENDS:rust-eyre+auto-install-devel = " \
 cargo \
 rust-eyre-devel \
 "
RDEPENDS:rust-eyre+default-devel = " \
 cargo \
 rust-eyre+auto-install-devel \
 rust-eyre+track-caller-devel \
 rust-eyre-devel \
 "
RDEPENDS:rust-eyre+track-caller-devel = " \
 cargo \
 rust-eyre-devel \
 "
RDEPENDS:rust-eyre-devel = " \
 cargo \
 rust \
 rust-autocfg+default-devel \
 rust-indenter+default-devel \
 rust-once_cell+default-devel \
 "
