# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqwest"
PV = "0.13.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-reqwest+__native-tls-alpn-devel \
 rust-reqwest+__native-tls-devel \
 rust-reqwest+__rustls-devel \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest+blocking-devel \
 rust-reqwest+brotli-devel \
 rust-reqwest+charset-devel \
 rust-reqwest+cookies-devel \
 rust-reqwest+default-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+deflate-devel \
 rust-reqwest+form-devel \
 rust-reqwest+gzip-devel \
 rust-reqwest+hickory-dns-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+json-devel \
 rust-reqwest+multipart-devel \
 rust-reqwest+native-tls-devel \
 rust-reqwest+native-tls-no-alpn-devel \
 rust-reqwest+query-devel \
 rust-reqwest+rustls-devel \
 rust-reqwest+rustls-no-provider-devel \
 rust-reqwest+socks-devel \
 rust-reqwest+stream-devel \
 rust-reqwest+system-proxy-devel \
 rust-reqwest+zstd-devel \
 rust-reqwest-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqwest-0.13.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7cdf231d3f681dd4df674f1e3816223efe7f2976bd32488dc9a7900cefd49cd8"

URI_x86_64_v2_rust-reqwest+__native-tls-alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__native-tls-alpn-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__native-tls-alpn-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__native-tls-alpn-devel.sha256sum] = "b531a889ad383f2b0217688cc4b7f039eda7367d826cfbc2bf806effc4a66c3d"

URI_x86_64_v2_rust-reqwest+__native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__native-tls-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__native-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__native-tls-devel.sha256sum] = "0271a7e927b7945547ebeffb45337ca17e0e1f68390c3376cff0fa336bc72b57"

URI_x86_64_v2_rust-reqwest+__rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__rustls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-devel.sha256sum] = "c6b6484e6d9f3386b0c4376bebfe0411f5421c60fedaa69b8511e47cfb18cb22"

URI_x86_64_v2_rust-reqwest+__rustls-ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__rustls-ring-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__rustls-ring-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__rustls-ring-devel.sha256sum] = "846c702c0ea1008c1f7a2e024cd114d6bfe81fa0aacc76695187842d4700f08e"

URI_x86_64_v2_rust-reqwest+__tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+__tls-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+__tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+__tls-devel.sha256sum] = "cbcfb45710b727b3024956d0ef04a6d34a84bffc7f4737e6bee965203b7d6bdd"

URI_x86_64_v2_rust-reqwest+blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+blocking-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+blocking-devel}"
SRC_URI[x86_64_v2_rust-reqwest+blocking-devel.sha256sum] = "a6f3420b94438c11bc3e8e187b5488a57f823f69a4dc0eb5eb1ec9a723922590"

URI_x86_64_v2_rust-reqwest+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+brotli-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+brotli-devel}"
SRC_URI[x86_64_v2_rust-reqwest+brotli-devel.sha256sum] = "b3cfd40e9b1471e352e9e6b1b5ae42c32c8f9b0f317d3e999664b9c7012669aa"

URI_x86_64_v2_rust-reqwest+charset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+charset-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+charset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+charset-devel}"
SRC_URI[x86_64_v2_rust-reqwest+charset-devel.sha256sum] = "2f9a68d433209fb1050484bfb43a6851f4370c2e4ad8e0d27b3e2096477513ce"

URI_x86_64_v2_rust-reqwest+cookies-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+cookies-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+cookies-devel}"
SRC_URI[x86_64_v2_rust-reqwest+cookies-devel.sha256sum] = "37176ea1d6764b63f3a102871c32e0aab55672308ce3e144238b174d0f08fa2d"

URI_x86_64_v2_rust-reqwest+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+default-devel}"
SRC_URI[x86_64_v2_rust-reqwest+default-devel.sha256sum] = "49cc459e5db62bb5722e5d29958277a2e981f9113487f8829476b16938b013ca"

URI_x86_64_v2_rust-reqwest+default-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+default-tls-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+default-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+default-tls-devel.sha256sum] = "b531fabf344f8acada3b4d0f7c1b16f052041b1252edbf7fb9e5c117a4c6dd52"

URI_x86_64_v2_rust-reqwest+deflate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+deflate-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+deflate-devel}"
SRC_URI[x86_64_v2_rust-reqwest+deflate-devel.sha256sum] = "7ee576f2ec2629d7699007bc2e658ee52c4e42da1b9d887bbed9d960571b2ba3"

URI_x86_64_v2_rust-reqwest+form-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+form-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+form-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+form-devel}"
SRC_URI[x86_64_v2_rust-reqwest+form-devel.sha256sum] = "96be4c7e4626c4402caa4ee2f600022447bc53f8f29af3ae91ab9ad13b78d57f"

URI_x86_64_v2_rust-reqwest+gzip-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+gzip-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+gzip-devel}"
SRC_URI[x86_64_v2_rust-reqwest+gzip-devel.sha256sum] = "e199694fc408fed33eae6e13ad11e4b5cc6ae9e887b47178d9052388cf628168"

URI_x86_64_v2_rust-reqwest+hickory-dns-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+hickory-dns-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+hickory-dns-devel}"
SRC_URI[x86_64_v2_rust-reqwest+hickory-dns-devel.sha256sum] = "15882753348c880b0bc912dc3845ea898293ef52caab523c9bcc78eef618215f"

URI_x86_64_v2_rust-reqwest+http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+http2-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+http2-devel}"
SRC_URI[x86_64_v2_rust-reqwest+http2-devel.sha256sum] = "9bb660f42b4bbfdecd409a0b535da5842fd1737bbb74d9e37aa327cc8c40b125"

URI_x86_64_v2_rust-reqwest+json-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+json-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+json-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+json-devel}"
SRC_URI[x86_64_v2_rust-reqwest+json-devel.sha256sum] = "da26f52c8487281e0ed6dd0075ef578da9907ffee32df685fbfead9e0157cb4f"

URI_x86_64_v2_rust-reqwest+multipart-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+multipart-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+multipart-devel}"
SRC_URI[x86_64_v2_rust-reqwest+multipart-devel.sha256sum] = "7f7e51801a3324a675f89f41d918ff50603fa8ef2d065a1a623bb479129b0fa1"

URI_x86_64_v2_rust-reqwest+native-tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+native-tls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-devel.sha256sum] = "a3141ae84f04ee0d75d4458d3a7449f929bf07dd1aeb3f36a544e6900dc329db"

URI_x86_64_v2_rust-reqwest+native-tls-no-alpn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+native-tls-no-alpn-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+native-tls-no-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+native-tls-no-alpn-devel}"
SRC_URI[x86_64_v2_rust-reqwest+native-tls-no-alpn-devel.sha256sum] = "842bfcaea54aac33e01ac374bcbed2e487117b6a948269b5216057622f2afb9c"

URI_x86_64_v2_rust-reqwest+query-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+query-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+query-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+query-devel}"
SRC_URI[x86_64_v2_rust-reqwest+query-devel.sha256sum] = "67d24bf6305a4fcdbc4e356e91c5121cf022ee968f8222b073545e1e01aaeb89"

URI_x86_64_v2_rust-reqwest+rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-devel.sha256sum] = "e26ab026e9c93a15219032a776b572d451c7945b16866acf899f067735a55a68"

URI_x86_64_v2_rust-reqwest+rustls-no-provider-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+rustls-no-provider-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+rustls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+rustls-no-provider-devel}"
SRC_URI[x86_64_v2_rust-reqwest+rustls-no-provider-devel.sha256sum] = "047bd07342ef05ce9c4ecb8927fad996c326b6f4824b856e477a20d7aad322bc"

URI_x86_64_v2_rust-reqwest+socks-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+socks-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+socks-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+socks-devel}"
SRC_URI[x86_64_v2_rust-reqwest+socks-devel.sha256sum] = "81d7866cfd98a49fc8b1e27d18b43f9e6addf98e9a23c834f541dd9e5764cf4e"

URI_x86_64_v2_rust-reqwest+stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+stream-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+stream-devel}"
SRC_URI[x86_64_v2_rust-reqwest+stream-devel.sha256sum] = "638139e9e77eb8e377f5dd5cb460262e52ecc47f6a72a96f2e09d6b1091157bb"

URI_x86_64_v2_rust-reqwest+system-proxy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+system-proxy-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+system-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+system-proxy-devel}"
SRC_URI[x86_64_v2_rust-reqwest+system-proxy-devel.sha256sum] = "d1f210391a7881c93547cb54a78e14f459a388119f3b9b2c03474fea2e11c424"

URI_x86_64_v2_rust-reqwest+zstd-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest+zstd-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest+zstd-devel}"
SRC_URI[x86_64_v2_rust-reqwest+zstd-devel.sha256sum] = "ed7ffbd9f9145ad70efd33b738e4a7c2dab69d8a9670e113861e092b4ddefdca"

URI_x86_64_v2_rust-reqwest-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqwest-devel-0.13.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqwest-devel}"
SRC_URI[x86_64_v2_rust-reqwest-devel.sha256sum] = "ddbef05c9063da1fc50b97935ec300631cb4d70c36582be115e8f40675fb5f61"

URI_aarch64_rust-reqwest+__native-tls-alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__native-tls-alpn-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+__native-tls-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__native-tls-alpn-devel}"
SRC_URI[aarch64_rust-reqwest+__native-tls-alpn-devel.sha256sum] = "7327217429b95b25831d61fc055c50398e4f6edd4b267f2560d186a6f13c8f9d"

URI_aarch64_rust-reqwest+__native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__native-tls-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+__native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__native-tls-devel}"
SRC_URI[aarch64_rust-reqwest+__native-tls-devel.sha256sum] = "5bbbf0bbcd141c6a24c46553c517681ed78412873aa10b3ee63c49a26ea1483c"

URI_aarch64_rust-reqwest+__rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+__rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__rustls-devel}"
SRC_URI[aarch64_rust-reqwest+__rustls-devel.sha256sum] = "13f5f6278d59ad1f6e093b1731495cd361bd907327c1e73fa9113ec05c61c215"

URI_aarch64_rust-reqwest+__rustls-ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__rustls-ring-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+__rustls-ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__rustls-ring-devel}"
SRC_URI[aarch64_rust-reqwest+__rustls-ring-devel.sha256sum] = "d93edbf6d6c85aa266a5096ef56ec86e1d8811c2d813063a31228107d704171d"

URI_aarch64_rust-reqwest+__tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+__tls-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+__tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+__tls-devel}"
SRC_URI[aarch64_rust-reqwest+__tls-devel.sha256sum] = "5776793ad80555c1729ad365be1ac536d929df7da075969173535dc64a8b0da4"

URI_aarch64_rust-reqwest+blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+blocking-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+blocking-devel}"
SRC_URI[aarch64_rust-reqwest+blocking-devel.sha256sum] = "a8a56fed972426f5ca65de7b8dfd8d99790097df5c45cd9fa54cf938c2f26df9"

URI_aarch64_rust-reqwest+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+brotli-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+brotli-devel}"
SRC_URI[aarch64_rust-reqwest+brotli-devel.sha256sum] = "1523384fb76fdf9cef7b0b25a1cb11f9724d2247d3240c7daad467af9024b895"

URI_aarch64_rust-reqwest+charset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+charset-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+charset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+charset-devel}"
SRC_URI[aarch64_rust-reqwest+charset-devel.sha256sum] = "78aacf9b564c3e59b8844f308107543c52c8b43f71c3a9c8b2c36987ab0cea34"

URI_aarch64_rust-reqwest+cookies-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+cookies-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+cookies-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+cookies-devel}"
SRC_URI[aarch64_rust-reqwest+cookies-devel.sha256sum] = "a888a364465b2e47c35443bfa82daa962b0e46a738fdaea34ea1b0985149a7f1"

URI_aarch64_rust-reqwest+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+default-devel}"
SRC_URI[aarch64_rust-reqwest+default-devel.sha256sum] = "896b1b39625067a357c05eeafc085311ecc6b1269ab8bdbd2d2239040014019e"

URI_aarch64_rust-reqwest+default-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+default-tls-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+default-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+default-tls-devel}"
SRC_URI[aarch64_rust-reqwest+default-tls-devel.sha256sum] = "c1a13986ab02ca163d031406946f070ea20adf761e21a481ecc82b51953f3b91"

URI_aarch64_rust-reqwest+deflate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+deflate-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+deflate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+deflate-devel}"
SRC_URI[aarch64_rust-reqwest+deflate-devel.sha256sum] = "3de17e0fcb519c514f0fa8d2a9454ed15289d63c38e0755bae69ad297d82ae1f"

URI_aarch64_rust-reqwest+form-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+form-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+form-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+form-devel}"
SRC_URI[aarch64_rust-reqwest+form-devel.sha256sum] = "c134ccba4afeb5d3da30aa136a247abdd4a6df733bb313ab3689fb22d23bc4dc"

URI_aarch64_rust-reqwest+gzip-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+gzip-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+gzip-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+gzip-devel}"
SRC_URI[aarch64_rust-reqwest+gzip-devel.sha256sum] = "4b778a1f45c8b089a8434808fe508c1f3f6ec996f30fd9a2479892eef81ca5dd"

URI_aarch64_rust-reqwest+hickory-dns-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+hickory-dns-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+hickory-dns-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+hickory-dns-devel}"
SRC_URI[aarch64_rust-reqwest+hickory-dns-devel.sha256sum] = "cda61af3943c63ddb64ab5531f478a65c5b5ffaa31ba4b30d9406422056baf6d"

URI_aarch64_rust-reqwest+http2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+http2-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+http2-devel}"
SRC_URI[aarch64_rust-reqwest+http2-devel.sha256sum] = "c56d76dc7206c266e83bbd579673a749ba04697653fb225177ec82a88dfa26bb"

URI_aarch64_rust-reqwest+json-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+json-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+json-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+json-devel}"
SRC_URI[aarch64_rust-reqwest+json-devel.sha256sum] = "1583fbdcca583a74384bcc18227ccdc0aa56e825041af70dc0cd71b727dd540a"

URI_aarch64_rust-reqwest+multipart-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+multipart-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+multipart-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+multipart-devel}"
SRC_URI[aarch64_rust-reqwest+multipart-devel.sha256sum] = "b75f44691824b01202a2e355fb2f535555c4038d36a9106e7abb1a72c547389d"

URI_aarch64_rust-reqwest+native-tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+native-tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+native-tls-devel}"
SRC_URI[aarch64_rust-reqwest+native-tls-devel.sha256sum] = "dde8d48bf1a2e9d955ae5be6be32030916dcac9a0a11c967c35601ea85ddc436"

URI_aarch64_rust-reqwest+native-tls-no-alpn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+native-tls-no-alpn-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+native-tls-no-alpn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+native-tls-no-alpn-devel}"
SRC_URI[aarch64_rust-reqwest+native-tls-no-alpn-devel.sha256sum] = "71639a2bd9faf69edbe775a3488ef64a1ec404a00d7848b6335e8c7c1cf70500"

URI_aarch64_rust-reqwest+query-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+query-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+query-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+query-devel}"
SRC_URI[aarch64_rust-reqwest+query-devel.sha256sum] = "34b3c28a28d2e0f26295e0fb6fba69e5122020f6e9abb4421c7e70037993f436"

URI_aarch64_rust-reqwest+rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-devel.sha256sum] = "190d499774ddcb49d0ea5d000dd4586cf41d5a1981139b101a0ea7ea57eded7e"

URI_aarch64_rust-reqwest+rustls-no-provider-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+rustls-no-provider-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+rustls-no-provider-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+rustls-no-provider-devel}"
SRC_URI[aarch64_rust-reqwest+rustls-no-provider-devel.sha256sum] = "834eda61ec5207c63d520741eec2f3291da916769329f06c98336d25c1976e89"

URI_aarch64_rust-reqwest+socks-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+socks-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+socks-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+socks-devel}"
SRC_URI[aarch64_rust-reqwest+socks-devel.sha256sum] = "a7cafc5a13d619898a6fb71ef08dac9b3f8e835a5c0713cbdae19f122296d9b6"

URI_aarch64_rust-reqwest+stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+stream-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+stream-devel}"
SRC_URI[aarch64_rust-reqwest+stream-devel.sha256sum] = "0781734d5fea046d532ae8ffeb27abb389af5477430abbfbe9c3b82e8bf31a32"

URI_aarch64_rust-reqwest+system-proxy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+system-proxy-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+system-proxy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+system-proxy-devel}"
SRC_URI[aarch64_rust-reqwest+system-proxy-devel.sha256sum] = "1bb611d1b0cdf30a9bd4deec8e37f38397c2f270c1afc9f7d9d2925d8ef3febb"

URI_aarch64_rust-reqwest+zstd-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest+zstd-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest+zstd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest+zstd-devel}"
SRC_URI[aarch64_rust-reqwest+zstd-devel.sha256sum] = "eeeb39105bbdf4f984904ece727a9bef6d2f5654e33df5f06bf7a882d6ec8c98"

URI_aarch64_rust-reqwest-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqwest-devel-0.13.3-1.el10_2.noarch.rpm;name=aarch64_rust-reqwest-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqwest-devel}"
SRC_URI[aarch64_rust-reqwest-devel.sha256sum] = "1f1da045f432886d8ce5861cf476f152be43d74c9f15ee26278157043ad3ba9e"

RDEPENDS:rust-reqwest+__native-tls-alpn-devel = " \
 cargo \
 rust-hyper-tls+alpn-devel \
 rust-hyper-tls+default-devel \
 rust-native-tls+alpn-devel \
 rust-native-tls+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+__native-tls-devel = " \
 cargo \
 rust-hyper-tls+default-devel \
 rust-native-tls+default-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-tokio-native-tls+default-devel \
 "
RDEPENDS:rust-reqwest+__rustls-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest+__tls-devel \
 rust-reqwest-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__rustls-ring-devel = " \
 cargo \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+ring-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-reqwest-devel \
 rust-rustls+ring-devel \
 rust-rustls+std-devel \
 rust-rustls+tls12-devel \
 rust-rustls-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-reqwest+__tls-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-rustls-pki-types+default-devel \
 rust-rustls-pki-types+std-devel \
 rust-tokio+io-util-devel \
 "
RDEPENDS:rust-reqwest+blocking-devel = " \
 cargo \
 rust-futures-channel+default-devel \
 rust-futures-channel+sink-devel \
 rust-futures-util+io-devel \
 rust-futures-util+sink-devel \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio+sync-devel \
 "
RDEPENDS:rust-reqwest+brotli-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-br-devel \
 "
RDEPENDS:rust-reqwest+charset-devel = " \
 cargo \
 rust-encoding_rs+default-devel \
 rust-mime+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+cookies-devel = " \
 cargo \
 rust-cookie+default-devel \
 rust-cookie_store+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-devel = " \
 cargo \
 rust-reqwest+charset-devel \
 rust-reqwest+default-tls-devel \
 rust-reqwest+http2-devel \
 rust-reqwest+system-proxy-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+default-tls-devel = " \
 cargo \
 rust-reqwest+native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+deflate-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-deflate-devel \
 "
RDEPENDS:rust-reqwest+form-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-reqwest+gzip-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-gzip-devel \
 "
RDEPENDS:rust-reqwest+hickory-dns-devel = " \
 cargo \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+tokio-devel \
 rust-once_cell+default-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+http2-devel = " \
 cargo \
 rust-h2+default-devel \
 rust-hyper+http2-devel \
 rust-hyper-rustls+http1-devel \
 rust-hyper-rustls+http2-devel \
 rust-hyper-rustls+tls12-devel \
 rust-hyper-rustls-devel \
 rust-hyper-util+http2-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+json-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 "
RDEPENDS:rust-reqwest+multipart-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-mime_guess-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-devel = " \
 cargo \
 rust-reqwest+__native-tls-alpn-devel \
 rust-reqwest+__native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+native-tls-no-alpn-devel = " \
 cargo \
 rust-reqwest+__native-tls-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+query-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-serde+default-devel \
 rust-serde_urlencoded+default-devel \
 "
RDEPENDS:rust-reqwest+rustls-devel = " \
 cargo \
 rust-reqwest+__rustls-devel \
 rust-reqwest+__rustls-ring-devel \
 rust-reqwest-devel \
 rust-rustls-platform-verifier+default-devel \
 "
RDEPENDS:rust-reqwest+rustls-no-provider-devel = " \
 cargo \
 rust-reqwest+__rustls-devel \
 rust-reqwest-devel \
 rust-rustls-platform-verifier+default-devel \
 "
RDEPENDS:rust-reqwest+socks-devel = " \
 cargo \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+stream-devel = " \
 cargo \
 rust-futures-util-devel \
 rust-reqwest-devel \
 rust-tokio+fs-devel \
 rust-tokio-util+io-devel \
 rust-tokio-util-devel \
 "
RDEPENDS:rust-reqwest+system-proxy-devel = " \
 cargo \
 rust-hyper-util+client-proxy-system-devel \
 rust-reqwest-devel \
 "
RDEPENDS:rust-reqwest+zstd-devel = " \
 cargo \
 rust-reqwest-devel \
 rust-tower-http+decompression-zstd-devel \
 "
RDEPENDS:rust-reqwest-devel = " \
 cargo \
 rust \
 rust-base64+default-devel \
 rust-bytes+default-devel \
 rust-futures-core-devel \
 rust-http+default-devel \
 rust-http-body+default-devel \
 rust-http-body-util+default-devel \
 rust-hyper+client-devel \
 rust-hyper+default-devel \
 rust-hyper+http1-devel \
 rust-hyper-util+client-devel \
 rust-hyper-util+client-legacy-devel \
 rust-hyper-util+client-proxy-devel \
 rust-hyper-util+default-devel \
 rust-hyper-util+http1-devel \
 rust-hyper-util+tokio-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-pin-project-lite+default-devel \
 rust-sync_wrapper+default-devel \
 rust-sync_wrapper+futures-devel \
 rust-tokio+net-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 rust-tower+retry-devel \
 rust-tower+timeout-devel \
 rust-tower+util-devel \
 rust-tower-devel \
 rust-tower-http+follow-redirect-devel \
 rust-tower-http-devel \
 rust-tower-service+default-devel \
 rust-url+default-devel \
 "
