# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "flatpak-rpm-macros"
PV = "40"
PR = "6.el10"
PACKAGES = " \
 flatpak-rpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/flatpak-rpm-macros-40-6.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0fb0aecea392275ca431b53a91ca5f9ead741b3773531ed10fd0e7cfaeac9dbb"

URI_x86_64_v2_flatpak-rpm-macros = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/flatpak-rpm-macros-40-6.el10.x86_64_v2.rpm;name=x86_64_v2_flatpak-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_flatpak-rpm-macros}"
SRC_URI[x86_64_v2_flatpak-rpm-macros.sha256sum] = "78dd79820d612ad7ebfda82e1bb0072e64e5f28a338f11ed2da6548a488e505a"

URI_aarch64_flatpak-rpm-macros = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/flatpak-rpm-macros-40-6.el10.aarch64.rpm;name=aarch64_flatpak-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_flatpak-rpm-macros}"
SRC_URI[aarch64_flatpak-rpm-macros.sha256sum] = "b5be40e5a356799fe82e21e12dc1c44b714c642973dff1c0f50ccdabf46abe17"

RDEPENDS:flatpak-rpm-macros = " \
 bash \
 "
