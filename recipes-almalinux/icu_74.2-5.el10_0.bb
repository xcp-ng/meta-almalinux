# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "icu"
PV = "74.2"
PR = "5.el10_0"
PACKAGES = " \
 icu \
 libicu \
 libicu-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/icu-74.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "918141828861cac1cf6e3a171a33f984b6f1928b52553bf2d548ba0d7b28822c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/icu-74.2-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_icu;unpack=0"
SRC_URI[x86_64_v2_icu.sha256sum] = "14dd672cbca744c06e47607a3ce95089f05d4cc8aebeb45bd8ed58af1f0ce8a3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libicu-74.2-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_libicu;unpack=0"
SRC_URI[x86_64_v2_libicu.sha256sum] = "9cfd087e77da931ea76af6a825dcb0e29a36bbe11295ad8a8994b121242f5fc8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libicu-devel-74.2-5.el10_0.x86_64_v2.rpm;name=x86_64_v2_libicu-devel;unpack=0"
SRC_URI[x86_64_v2_libicu-devel.sha256sum] = "fab8ed71b550ef77f5ceb5c4f3017b6720c98548d5e287b1a0c90c8950ae0636"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/icu-74.2-5.el10_0.aarch64.rpm;name=aarch64_icu;unpack=0"
SRC_URI[aarch64_icu.sha256sum] = "1fd49273e36350c1e8988ecda7d0703ced339d457f16b03c08a42187a7ffe7a2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libicu-74.2-5.el10_0.aarch64.rpm;name=aarch64_libicu;unpack=0"
SRC_URI[aarch64_libicu.sha256sum] = "0b5ddcb9dd4a62967a8c9017188d83c916721c6c8f13549d57a58aa8b7fbe55f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libicu-devel-74.2-5.el10_0.aarch64.rpm;name=aarch64_libicu-devel;unpack=0"
SRC_URI[aarch64_libicu-devel.sha256sum] = "f033d7e4b608e30a8ad470f73e78628e6fa9a9e21bdbce5d69a73f85921a2cbb"

RDEPENDS:icu = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 "
RDEPENDS:libicu = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libicu-devel = " \
 bash \
 glibc \
 libicu \
 libicu-devel \
 pkgconf-pkg-config \
 "
