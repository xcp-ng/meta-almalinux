# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pykmip"
PV = "0.10.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-pykmip \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pykmip-0.10.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6e8ead898bc44bd09d46b7214299a1d66602af5c73d3dcc6cfeec710f5c2ed5a"

URI_x86_64_v2_python3-pykmip = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pykmip-0.10.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pykmip;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pykmip}"
SRC_URI[x86_64_v2_python3-pykmip.sha256sum] = "50d223e750ac79ecd555607236db080c326a37078f176eb937d4422731f11dfb"

URI_aarch64_python3-pykmip = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pykmip-0.10.0-2.el10_1.noarch.rpm;name=aarch64_python3-pykmip;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pykmip}"
SRC_URI[aarch64_python3-pykmip.sha256sum] = "c84c28896e69fabddba984f5a72d566a5e9e535dea9ef13a4f27e9e0c579679b"

RDEPENDS:python3-pykmip = " \
 python3 \
 python3-cryptography \
 python3-requests \
 python3-six \
 python3-sqlalchemy \
 "
