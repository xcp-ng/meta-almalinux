# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vorbis-tools"
PE = "1"
PV = "1.4.2"
PR = "14.el10_1"
PACKAGES = " \
 vorbis-tools \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vorbis-tools-1.4.2-14.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "57e047f6fb351cc0f899f7af46624edf6fc58be849b643bf278c781decd6c1de"

URI_x86_64_v2_vorbis-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vorbis-tools-1.4.2-14.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_vorbis-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vorbis-tools}"
SRC_URI[x86_64_v2_vorbis-tools.sha256sum] = "8ca4ebe24fb047f071d2ee90c4c876f3b90d356794963d078dd87ffc06fd6f0f"

URI_aarch64_vorbis-tools = "${EPEL_MIRROR}/aarch64/Packages/v/vorbis-tools-1.4.2-14.el10_1.aarch64.rpm;name=aarch64_vorbis-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_vorbis-tools}"
SRC_URI[aarch64_vorbis-tools.sha256sum] = "36954fb6c5540eadb26f2d605d579ab7945f0846b58b030ace8a96ec7502aa2a"

RDEPENDS:vorbis-tools = " \
 flac-libs \
 glibc \
 libao \
 libgcc \
 libogg \
 libvorbis \
 speex \
 virtual/libcurl.so.4___64bit_ \
 "
