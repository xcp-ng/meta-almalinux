# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-schemars_derive"
PV = "1.2.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-schemars_derive+default-devel \
 rust-schemars_derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-schemars_derive-1.2.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "016c088a6383c60fe9d738be7502e7cf84be5cd2ecee66524709a7af3d1c4223"

URI_x86_64_v2_rust-schemars_derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive+default-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive+default-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive+default-devel.sha256sum] = "f99dc9700e3a68c0c339ef862da5e8fa6f24e5b2f73111d88d623c321648bbdc"

URI_x86_64_v2_rust-schemars_derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-schemars_derive-devel-1.2.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-schemars_derive-devel}"
SRC_URI[x86_64_v2_rust-schemars_derive-devel.sha256sum] = "b07a5c1454caa8bfd95442baf07c20b9e00c844a33544b27af9c8f22db675c6f"

URI_aarch64_rust-schemars_derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive+default-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars_derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive+default-devel}"
SRC_URI[aarch64_rust-schemars_derive+default-devel.sha256sum] = "974273f278d70bb9cd16e3166725d58c74011d0d923407f37861d2735e4faaef"

URI_aarch64_rust-schemars_derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-schemars_derive-devel-1.2.0-1.el10_1.noarch.rpm;name=aarch64_rust-schemars_derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-schemars_derive-devel}"
SRC_URI[aarch64_rust-schemars_derive-devel.sha256sum] = "65e78ba4153bd242d21f12940664481bb1193f1c501bd4ccad07f3e11335050e"

RDEPENDS:rust-schemars_derive+default-devel = " \
 cargo \
 rust-schemars_derive-devel \
 "
RDEPENDS:rust-schemars_derive-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-serde_derive_internals+default-devel \
 rust-syn+default-devel \
 "
