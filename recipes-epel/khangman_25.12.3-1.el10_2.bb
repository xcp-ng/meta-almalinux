# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "khangman"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 khangman \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/khangman-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "abec925a7d09d9f745cc1b8202767db7af605ad7b81e5f1e47c6c84625570420"

URI_x86_64_v2_khangman = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/khangman-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_khangman;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_khangman}"
SRC_URI[x86_64_v2_khangman.sha256sum] = "e90f713757e9430ca589811cfa7ca7c16aa4407e955ffe8324029d31c5e53b5f"

URI_aarch64_khangman = "${EPEL_MIRROR}/aarch64/Packages/k/khangman-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_khangman;unpack=0"
SRC_URI:append = " ${URI_aarch64_khangman}"
SRC_URI[aarch64_khangman.sha256sum] = "87ab41a4c8a5671fae9102b333ed7070d71707d56a1f73c2649fe298f5bd92b0"

RDEPENDS:khangman = " \
 dustin-domestic-manners-fonts \
 dustin-dustismo-roman-fonts \
 glibc \
 kdeedu-data \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 libkeduvocdocument \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
