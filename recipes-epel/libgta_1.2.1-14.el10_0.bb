# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libgta"
PV = "1.2.1"
PR = "14.el10_0"
PACKAGES = " \
 libgta \
 libgta-devel \
 libgta-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libgta-1.2.1-14.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d175fc43d99301337ffe56a0d074dd7633a4bce629a3611825a48b3e54a4635a"

URI_x86_64_v2_libgta = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgta-1.2.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgta;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgta}"
SRC_URI[x86_64_v2_libgta.sha256sum] = "99203b1e1c85da58a6f7cf189f917c3109389fff43f5f60c8ef18dc845984771"

URI_x86_64_v2_libgta-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgta-devel-1.2.1-14.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libgta-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgta-devel}"
SRC_URI[x86_64_v2_libgta-devel.sha256sum] = "b7ec51f6df131d0c36954bb18528505afd1814b4db65f16427cd7d2ab15c18d7"

URI_x86_64_v2_libgta-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libgta-doc-1.2.1-14.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libgta-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libgta-doc}"
SRC_URI[x86_64_v2_libgta-doc.sha256sum] = "38e66d015c69b234b01f9bfd09b015ff32cfa5437325b0c4f838c73c53fe93b7"

URI_aarch64_libgta = "${EPEL_MIRROR}/aarch64/Packages/l/libgta-1.2.1-14.el10_0.aarch64.rpm;name=aarch64_libgta;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgta}"
SRC_URI[aarch64_libgta.sha256sum] = "d4d8e87b5aed8ba7ccd27bcf92947c505929fba8d0826871bd6d698f20d8b695"

URI_aarch64_libgta-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libgta-devel-1.2.1-14.el10_0.aarch64.rpm;name=aarch64_libgta-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgta-devel}"
SRC_URI[aarch64_libgta-devel.sha256sum] = "3bb28cf7beb8fe462e5e2ef632e964db00c62f541a8dd6737155a48e32b575e8"

URI_aarch64_libgta-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libgta-doc-1.2.1-14.el10_0.noarch.rpm;name=aarch64_libgta-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libgta-doc}"
SRC_URI[aarch64_libgta-doc.sha256sum] = "9cb704301359bf6edc84f50b88cc0bed4d2c62d377bce9c790baa4c36ceaebfd"

RDEPENDS:libgta = " \
 glibc \
 "
RDEPENDS:libgta-devel = " \
 cmake-filesystem \
 libgta \
 pkgconf-pkg-config \
 "
RDEPENDS:libgta-doc = " \
 libgta \
 "
