# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager"
PE = "1"
PV = "1.56.0"
PR = "2.el10_2"
PACKAGES = " \
 NetworkManager \
 NetworkManager-adsl \
 NetworkManager-bluetooth \
 NetworkManager-cloud-setup \
 NetworkManager-config-connectivity-redhat \
 NetworkManager-config-server \
 NetworkManager-libnm \
 NetworkManager-libnm-devel \
 NetworkManager-ovs \
 NetworkManager-ppp \
 NetworkManager-tui \
 NetworkManager-wifi \
 NetworkManager-wwan \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/NetworkManager-1.56.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d0a45aa739fb70e25e4f4d08df7faf9a3c5c05bfcc3fce6a442f3c582dc2a57b"

URI_x86_64_v2_NetworkManager = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager}"
SRC_URI[x86_64_v2_NetworkManager.sha256sum] = "4429e56907222ef03d3eeaf835af15900772df9a90ef54eada7333998a940479"

URI_x86_64_v2_NetworkManager-adsl = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-adsl-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-adsl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-adsl}"
SRC_URI[x86_64_v2_NetworkManager-adsl.sha256sum] = "f899033657fa880db6d9496d980292cde73e8df94dc93f9bfa38b8d3b6903801"

URI_x86_64_v2_NetworkManager-bluetooth = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-bluetooth-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-bluetooth;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-bluetooth}"
SRC_URI[x86_64_v2_NetworkManager-bluetooth.sha256sum] = "1f093cc3d7ab4038dc12c07c553256911508826f10874c7dd5122a5f9deb95b4"

URI_x86_64_v2_NetworkManager-cloud-setup = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-cloud-setup-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-cloud-setup;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-cloud-setup}"
SRC_URI[x86_64_v2_NetworkManager-cloud-setup.sha256sum] = "6a4ccca7bf32389e1948c24b1add4e85d16ca8ffea21ce16d11861426255e108"

URI_x86_64_v2_NetworkManager-config-connectivity-redhat = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-config-connectivity-redhat-1.56.0-2.el10_2.noarch.rpm;name=x86_64_v2_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-config-connectivity-redhat}"
SRC_URI[x86_64_v2_NetworkManager-config-connectivity-redhat.sha256sum] = "f694b5228f3c542d4141741662f4dab3248decae042c0074f2ce2a6c8811ba87"

URI_x86_64_v2_NetworkManager-config-server = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-config-server-1.56.0-2.el10_2.noarch.rpm;name=x86_64_v2_NetworkManager-config-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-config-server}"
SRC_URI[x86_64_v2_NetworkManager-config-server.sha256sum] = "394699c885e9b8f92318f4029a1446f925a519a241165f0ef5d2627547c68b19"

URI_x86_64_v2_NetworkManager-libnm = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-libnm-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libnm}"
SRC_URI[x86_64_v2_NetworkManager-libnm.sha256sum] = "c7c427b64fabe35d815e00588536c98be2a82687373ebd7a35728e9d08939c45"

URI_x86_64_v2_NetworkManager-libnm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/NetworkManager-libnm-devel-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libnm-devel}"
SRC_URI[x86_64_v2_NetworkManager-libnm-devel.sha256sum] = "87e2b998b0e33864dc84786d64ad126cf2cecbabb6d2534f7bc4858afa1aacec"

URI_x86_64_v2_NetworkManager-ovs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ovs-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ovs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-ovs}"
SRC_URI[x86_64_v2_NetworkManager-ovs.sha256sum] = "28d92f405a7643abddc399bf227df72d96fdec1bd9bdf7fd8639295f826f0b83"

URI_x86_64_v2_NetworkManager-ppp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ppp-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ppp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-ppp}"
SRC_URI[x86_64_v2_NetworkManager-ppp.sha256sum] = "f445e9501de4191d3272f825201cfc1c227a0156b6342e1b09f5bb45f2af4b56"

URI_x86_64_v2_NetworkManager-tui = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-tui-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-tui;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-tui}"
SRC_URI[x86_64_v2_NetworkManager-tui.sha256sum] = "d7e4a2230730d49614d7dac840af3bc9319215861590c9b39fde7b07aba136c0"

URI_x86_64_v2_NetworkManager-wifi = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wifi-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wifi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-wifi}"
SRC_URI[x86_64_v2_NetworkManager-wifi.sha256sum] = "7a1f5b44a56052420865a12801bd474503eedd0164fd5baa0d482a18305015a6"

URI_x86_64_v2_NetworkManager-wwan = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wwan-1.56.0-2.el10_2.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wwan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-wwan}"
SRC_URI[x86_64_v2_NetworkManager-wwan.sha256sum] = "0b56781176972f597713e833d67336af14cc66f83ec33b419f31305d9ee069ac"

URI_aarch64_NetworkManager = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager}"
SRC_URI[aarch64_NetworkManager.sha256sum] = "d3300cc2dd1aaef72eef823f452615ef270d1017e4507b04a3959ad1535f0979"

URI_aarch64_NetworkManager-adsl = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-adsl-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-adsl;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-adsl}"
SRC_URI[aarch64_NetworkManager-adsl.sha256sum] = "797fa516dfb27d2e0ef043276950bfecf752d1e08fd06061aa51c0e3604397e6"

URI_aarch64_NetworkManager-bluetooth = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-bluetooth-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-bluetooth;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-bluetooth}"
SRC_URI[aarch64_NetworkManager-bluetooth.sha256sum] = "34555bfc710e5c1a0844126f2103e5a6c81426fc217b5fd698907856722881fe"

URI_aarch64_NetworkManager-cloud-setup = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-cloud-setup-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-cloud-setup;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-cloud-setup}"
SRC_URI[aarch64_NetworkManager-cloud-setup.sha256sum] = "614920d31b6d7b2b5122a0f487966852200626ebee5ed24794afe2be71355983"

URI_aarch64_NetworkManager-config-connectivity-redhat = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-config-connectivity-redhat-1.56.0-2.el10_2.noarch.rpm;name=aarch64_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-config-connectivity-redhat}"
SRC_URI[aarch64_NetworkManager-config-connectivity-redhat.sha256sum] = "f694b5228f3c542d4141741662f4dab3248decae042c0074f2ce2a6c8811ba87"

URI_aarch64_NetworkManager-config-server = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-config-server-1.56.0-2.el10_2.noarch.rpm;name=aarch64_NetworkManager-config-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-config-server}"
SRC_URI[aarch64_NetworkManager-config-server.sha256sum] = "394699c885e9b8f92318f4029a1446f925a519a241165f0ef5d2627547c68b19"

URI_aarch64_NetworkManager-libnm = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-libnm-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-libnm;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libnm}"
SRC_URI[aarch64_NetworkManager-libnm.sha256sum] = "78e530800ce06f25545e24f24f25c6fc6af5817ec8b5546ff6e345a94e7d1a73"

URI_aarch64_NetworkManager-libnm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/NetworkManager-libnm-devel-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-libnm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libnm-devel}"
SRC_URI[aarch64_NetworkManager-libnm-devel.sha256sum] = "f174d5b33df9a52515222f830546731b69bcbc01713d8e0a2090363c3171f42b"

URI_aarch64_NetworkManager-ovs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ovs-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-ovs;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-ovs}"
SRC_URI[aarch64_NetworkManager-ovs.sha256sum] = "50f9b59abdb2ba4f5922e5aebd24ac1e3d80d5496a44710c8a06370aead50666"

URI_aarch64_NetworkManager-ppp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ppp-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-ppp;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-ppp}"
SRC_URI[aarch64_NetworkManager-ppp.sha256sum] = "475d7cb752a286b4c466e6130c3dfd8128191a32c4041d79b5913fef6948f058"

URI_aarch64_NetworkManager-tui = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-tui-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-tui;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-tui}"
SRC_URI[aarch64_NetworkManager-tui.sha256sum] = "f9873addee6d0dba9693a52b57c06df56c8c4df605f3b003188d3d1fe10092e8"

URI_aarch64_NetworkManager-wifi = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wifi-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-wifi;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-wifi}"
SRC_URI[aarch64_NetworkManager-wifi.sha256sum] = "f951607c74d4354d52f9692e327f392a30e0d058084d2174e43965f652748ba1"

URI_aarch64_NetworkManager-wwan = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wwan-1.56.0-2.el10_2.aarch64.rpm;name=aarch64_NetworkManager-wwan;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-wwan}"
SRC_URI[aarch64_NetworkManager-wwan.sha256sum] = "37d731f7c0edb15cb6ef1f30880a9436e0d4917f9b8137f1752fd7c19d4a2cef"

RDEPENDS:NetworkManager = " \
 NetworkManager-libnm \
 alternatives \
 audit-libs \
 bash \
 dbus \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 libndp \
 libselinux \
 readline \
 systemd \
 systemd-libs \
 systemd-udev \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-adsl = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-bluetooth = " \
 NetworkManager \
 NetworkManager-wwan \
 bluez \
 bluez-libs \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-cloud-setup = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 glib2 \
 glibc \
 jansson \
 libgcc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-config-connectivity-redhat = " \
 "
RDEPENDS:NetworkManager-config-server = " \
 "
RDEPENDS:NetworkManager-libnm = " \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 systemd-libs \
 "
RDEPENDS:NetworkManager-libnm-devel = " \
 NetworkManager-libnm \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:NetworkManager-ovs = " \
 NetworkManager \
 glib2 \
 glibc \
 jansson \
 libgcc \
 "
RDEPENDS:NetworkManager-ppp = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 ppp \
 "
RDEPENDS:NetworkManager-tui = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 libgcc \
 newt \
 "
RDEPENDS:NetworkManager-wifi = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 wireless-regdb \
 wpa_supplicant \
 "
RDEPENDS:NetworkManager-wwan = " \
 ModemManager \
 ModemManager-glib \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 systemd-libs \
 "
