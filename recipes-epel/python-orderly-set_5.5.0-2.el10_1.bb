# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-orderly-set"
PV = "5.5.0"
PR = "2.el10_1"
PACKAGES = " \
 python3-orderly-set \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-orderly-set-5.5.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e294846f52c2eec27ca1f61a24ba93a7dadf4b386b7340d8f617f12d28e2bd87"

URI_x86_64_v2_python3-orderly-set = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-orderly-set-5.5.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-orderly-set;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-orderly-set}"
SRC_URI[x86_64_v2_python3-orderly-set.sha256sum] = "376977821282962df30267095ee04ef1d34ebfc9f4ac6ac2876536c4e2a204cf"

URI_aarch64_python3-orderly-set = "${EPEL_MIRROR}/aarch64/Packages/p/python3-orderly-set-5.5.0-2.el10_1.noarch.rpm;name=aarch64_python3-orderly-set;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-orderly-set}"
SRC_URI[aarch64_python3-orderly-set.sha256sum] = "ca28c7708cecaa9a2eb29ee0738a319a2ede63b2361814aa554eb094c5a17c30"

RDEPENDS:python3-orderly-set = " \
 python3 \
 "
