# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-base16ct"
PV = "1.0.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-base16ct+alloc-devel \
 rust-base16ct+default-devel \
 rust-base16ct-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-base16ct-1.0.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46351df67636c00214e696b20c35653df9276e37bfd72e2832aba19372d6d347"

URI_x86_64_v2_rust-base16ct+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base16ct+alloc-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base16ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base16ct+alloc-devel}"
SRC_URI[x86_64_v2_rust-base16ct+alloc-devel.sha256sum] = "c1441c5ec7171772199a8e223e1df7584be76d03194ea4699f7559b944d50473"

URI_x86_64_v2_rust-base16ct+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base16ct+default-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base16ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base16ct+default-devel}"
SRC_URI[x86_64_v2_rust-base16ct+default-devel.sha256sum] = "b653e84f2e8f6cb12f8a7df012af9464a14b8dfd52cf5e0450c1de682d6205f3"

URI_x86_64_v2_rust-base16ct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-base16ct-devel-1.0.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-base16ct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-base16ct-devel}"
SRC_URI[x86_64_v2_rust-base16ct-devel.sha256sum] = "88c8b891d0546388ca3147641e62cfb59b8ceb768cb2a2a5a24058d248cef594"

URI_aarch64_rust-base16ct+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base16ct+alloc-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-base16ct+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base16ct+alloc-devel}"
SRC_URI[aarch64_rust-base16ct+alloc-devel.sha256sum] = "960b6b7d31d8d7c44071f4648bbbf817f93aeef27822e677971d1cbef658f4a8"

URI_aarch64_rust-base16ct+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base16ct+default-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-base16ct+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base16ct+default-devel}"
SRC_URI[aarch64_rust-base16ct+default-devel.sha256sum] = "9819815810a14ff7869dfb3175313ba4a38fc585d0b21f19c15d1c4ced72fa2a"

URI_aarch64_rust-base16ct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-base16ct-devel-1.0.0-1.el10_3.noarch.rpm;name=aarch64_rust-base16ct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-base16ct-devel}"
SRC_URI[aarch64_rust-base16ct-devel.sha256sum] = "9150f9c82b3feca4b53a453c451b6029b9d1006b535a8840bf265fad76bdf71f"

RDEPENDS:rust-base16ct+alloc-devel = " \
 cargo \
 rust-base16ct-devel \
 "
RDEPENDS:rust-base16ct+default-devel = " \
 cargo \
 rust-base16ct-devel \
 "
RDEPENDS:rust-base16ct-devel = " \
 cargo \
 rust \
 "
