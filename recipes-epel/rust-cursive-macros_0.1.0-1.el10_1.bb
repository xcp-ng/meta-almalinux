# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cursive-macros"
PV = "0.1.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-cursive-macros+builder-devel \
 rust-cursive-macros+default-devel \
 rust-cursive-macros+find-crate-devel \
 rust-cursive-macros+quote-devel \
 rust-cursive-macros+syn-devel \
 rust-cursive-macros-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cursive-macros-0.1.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "158ddd44bb9b922e62a835855833006e5953d959a2301b9c2d5dc10a08d8720e"

URI_x86_64_v2_rust-cursive-macros+builder-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+builder-devel-0.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+builder-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+builder-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+builder-devel.sha256sum] = "13cbc60f04b184bbe59e4343294e39acb3bcd840bbe5d4bb60fc8370d2adf1e2"

URI_x86_64_v2_rust-cursive-macros+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+default-devel-0.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+default-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+default-devel.sha256sum] = "071b8e5e303b935c998e5b72e982ff0ef6a0f8646980df1d2e656e5dc28b31fb"

URI_x86_64_v2_rust-cursive-macros+find-crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+find-crate-devel-0.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+find-crate-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+find-crate-devel.sha256sum] = "ccde9682f79887995b3dea7acfe9d08ce57af8c2a4bcdb84fca9425dbeefe83a"

URI_x86_64_v2_rust-cursive-macros+quote-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+quote-devel-0.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+quote-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+quote-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+quote-devel.sha256sum] = "a6bd9ac077130270fcfd2238cb0afe4e0bc69133cc9e7520124df93f1fc3c653"

URI_x86_64_v2_rust-cursive-macros+syn-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros+syn-devel-0.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros+syn-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros+syn-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros+syn-devel.sha256sum] = "612e9914b465a99b2025e70330a26887ddbd5583da8dd6b47d365998cbeb7cde"

URI_x86_64_v2_rust-cursive-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cursive-macros-devel-0.1.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cursive-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cursive-macros-devel}"
SRC_URI[x86_64_v2_rust-cursive-macros-devel.sha256sum] = "50a2d601203c578575187873cbe45e54225419012fb045c347bb8dc575947302"

URI_aarch64_rust-cursive-macros+builder-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+builder-devel-0.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursive-macros+builder-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+builder-devel}"
SRC_URI[aarch64_rust-cursive-macros+builder-devel.sha256sum] = "7b339e417b70eb895b26289ad14258e7b8db5ff25b1faa2e729b7efb979a5683"

URI_aarch64_rust-cursive-macros+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+default-devel-0.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursive-macros+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+default-devel}"
SRC_URI[aarch64_rust-cursive-macros+default-devel.sha256sum] = "a274fbf6ab5b38fa69b0cecc2720fa3ce6e61ac570d1b689f6ca724da3816196"

URI_aarch64_rust-cursive-macros+find-crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+find-crate-devel-0.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursive-macros+find-crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+find-crate-devel}"
SRC_URI[aarch64_rust-cursive-macros+find-crate-devel.sha256sum] = "6c5d9cc34d96e39b241e44348799d077c03fc5e52e53bcc7292c8604c374b885"

URI_aarch64_rust-cursive-macros+quote-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+quote-devel-0.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursive-macros+quote-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+quote-devel}"
SRC_URI[aarch64_rust-cursive-macros+quote-devel.sha256sum] = "cc559335becf59d6921c6ba6f8f904ec3bf4367700254a32f5c7141787454060"

URI_aarch64_rust-cursive-macros+syn-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros+syn-devel-0.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursive-macros+syn-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros+syn-devel}"
SRC_URI[aarch64_rust-cursive-macros+syn-devel.sha256sum] = "b920ea9fcde097884e747f217b2c6e54785edaa0a7aa3f4cf59ab6011736e803"

URI_aarch64_rust-cursive-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cursive-macros-devel-0.1.0-1.el10_1.noarch.rpm;name=aarch64_rust-cursive-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cursive-macros-devel}"
SRC_URI[aarch64_rust-cursive-macros-devel.sha256sum] = "5b002e0bb23f2d5a8bb554bf15d59819dc2b4c3c4eb0be692456748069414960"

RDEPENDS:rust-cursive-macros+builder-devel = " \
 cargo \
 rust-cursive-macros+find-crate-devel \
 rust-cursive-macros+quote-devel \
 rust-cursive-macros+syn-devel \
 rust-cursive-macros-devel \
 "
RDEPENDS:rust-cursive-macros+default-devel = " \
 cargo \
 rust-cursive-macros-devel \
 "
RDEPENDS:rust-cursive-macros+find-crate-devel = " \
 cargo \
 rust-cursive-macros-devel \
 rust-find-crate+default-devel \
 "
RDEPENDS:rust-cursive-macros+quote-devel = " \
 cargo \
 rust-cursive-macros-devel \
 rust-quote+default-devel \
 "
RDEPENDS:rust-cursive-macros+syn-devel = " \
 cargo \
 rust-cursive-macros-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 rust-syn2+full-devel \
 "
RDEPENDS:rust-cursive-macros-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 "
