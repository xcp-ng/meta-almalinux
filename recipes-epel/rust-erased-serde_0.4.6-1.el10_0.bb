# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-erased-serde"
PV = "0.4.6"
PR = "1.el10_0"
PACKAGES = " \
 rust-erased-serde+alloc-devel \
 rust-erased-serde+default-devel \
 rust-erased-serde+std-devel \
 rust-erased-serde+unstable-debug-devel \
 rust-erased-serde-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-erased-serde-0.4.6-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dcaa4f1faa89d6ca64659c0eea849b7d8f22bc449b9ace03635d5bbf0bb8500a"

URI_x86_64_v2_rust-erased-serde+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+alloc-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+alloc-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+alloc-devel.sha256sum] = "33010fac620d57a256733e6e14b91b3adff84d58a08b77561bb90c2082f5554d"

URI_x86_64_v2_rust-erased-serde+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+default-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+default-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+default-devel.sha256sum] = "87500701834737977868254796259fcf95a60eb5af13691c94275b3f35b35a03"

URI_x86_64_v2_rust-erased-serde+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+std-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+std-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+std-devel.sha256sum] = "d561a2b51e9d49dcf1fdf17e11bc8c7ef7ce0821af27c9f8fc3ed8bd771f5470"

URI_x86_64_v2_rust-erased-serde+unstable-debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde+unstable-debug-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde+unstable-debug-devel}"
SRC_URI[x86_64_v2_rust-erased-serde+unstable-debug-devel.sha256sum] = "4f8199ac8a51a63e40f07f457dd7790dc354fc1ee7d22489b6d6373d3bda97b2"

URI_x86_64_v2_rust-erased-serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-erased-serde-devel-0.4.6-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-erased-serde-devel}"
SRC_URI[x86_64_v2_rust-erased-serde-devel.sha256sum] = "371e6e09e3d48abcd809e1fb4e26fe79978308fe6063000b792cd4acd325f9d7"

URI_aarch64_rust-erased-serde+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+alloc-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-erased-serde+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+alloc-devel}"
SRC_URI[aarch64_rust-erased-serde+alloc-devel.sha256sum] = "05c6f837c08a1e30dd88004fc0949cf93e369b0e551d5ff2b212beb04d570940"

URI_aarch64_rust-erased-serde+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+default-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-erased-serde+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+default-devel}"
SRC_URI[aarch64_rust-erased-serde+default-devel.sha256sum] = "813d6f56d6c91f46291e489b467f436fdf5151389d04d939824a461216a471b7"

URI_aarch64_rust-erased-serde+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+std-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-erased-serde+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+std-devel}"
SRC_URI[aarch64_rust-erased-serde+std-devel.sha256sum] = "c63f7dca5917449b3a8c790ae70a7d9d8667ef0575a207adb1081b92c1ecc300"

URI_aarch64_rust-erased-serde+unstable-debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde+unstable-debug-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-erased-serde+unstable-debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde+unstable-debug-devel}"
SRC_URI[aarch64_rust-erased-serde+unstable-debug-devel.sha256sum] = "69a936f69721983a1017d046ba066f271f4d1e96d2a4c55b3a46a78112179cc3"

URI_aarch64_rust-erased-serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-erased-serde-devel-0.4.6-1.el10_0.noarch.rpm;name=aarch64_rust-erased-serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-erased-serde-devel}"
SRC_URI[aarch64_rust-erased-serde-devel.sha256sum] = "044e8ed6ada7c7788cdf16c33e46793a3f2fe380361c8859ae7aa016fe9155f4"

RDEPENDS:rust-erased-serde+alloc-devel = " \
 cargo \
 rust-erased-serde-devel \
 rust-serde+alloc-devel \
 "
RDEPENDS:rust-erased-serde+default-devel = " \
 cargo \
 rust-erased-serde+std-devel \
 rust-erased-serde-devel \
 "
RDEPENDS:rust-erased-serde+std-devel = " \
 cargo \
 rust-erased-serde+alloc-devel \
 rust-erased-serde-devel \
 rust-serde+std-devel \
 "
RDEPENDS:rust-erased-serde+unstable-debug-devel = " \
 cargo \
 rust-erased-serde-devel \
 "
RDEPENDS:rust-erased-serde-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-typeid+default-devel \
 "
