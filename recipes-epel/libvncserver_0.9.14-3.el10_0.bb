# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libvncserver"
PV = "0.9.14"
PR = "3.el10_0"
PACKAGES = " \
 libvncserver \
 libvncserver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libvncserver-0.9.14-3.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aa80a750c6fe8d44a71f696c52a263c35a5dc65ed3b8986e4404a5312103430c"

URI_x86_64_v2_libvncserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvncserver-0.9.14-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvncserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvncserver}"
SRC_URI[x86_64_v2_libvncserver.sha256sum] = "fba4be924289f97f0237fe9df0c308a1639c7cd231d9cb7c17d62d3f2b942f86"

URI_x86_64_v2_libvncserver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libvncserver-devel-0.9.14-3.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libvncserver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libvncserver-devel}"
SRC_URI[x86_64_v2_libvncserver-devel.sha256sum] = "e196702efaf12dea1a1a9c272f58fd47b98bd0d59e255763a7cc6931172b2cc4"

URI_aarch64_libvncserver = "${EPEL_MIRROR}/aarch64/Packages/l/libvncserver-0.9.14-3.el10_0.aarch64.rpm;name=aarch64_libvncserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvncserver}"
SRC_URI[aarch64_libvncserver.sha256sum] = "7763e6b7a49b51b523fa98b74731156ef9ba54fae58887780b809ea88e1b0f00"

URI_aarch64_libvncserver-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libvncserver-devel-0.9.14-3.el10_0.aarch64.rpm;name=aarch64_libvncserver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libvncserver-devel}"
SRC_URI[aarch64_libvncserver-devel.sha256sum] = "fdaacda8ffc8d414fb534085036e9cae32a350ce533448a2d75e66d64dd65f60"

RDEPENDS:libvncserver = " \
 glibc \
 gnutls \
 libgcrypt \
 libjpeg-turbo \
 libpng \
 lzo \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:libvncserver-devel = " \
 cmake-filesystem \
 libvncserver \
 pkgconf-pkg-config \
 virtual/coreutils \
 zlib-ng-compat-devel \
 "
