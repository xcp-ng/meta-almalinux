# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mesa"
PV = "25.0.7"
PR = "6.el10_1.alma.1"
PACKAGES:x86_64_v2 = " \
 mesa-dri-drivers \
 mesa-filesystem \
 mesa-libEGL \
 mesa-libEGL-devel \
 mesa-libGL \
 mesa-libGL-devel \
 mesa-libOSMesa \
 mesa-libOSMesa-devel \
 mesa-libgbm \
 mesa-libgbm-devel \
 mesa-libxatracker \
 mesa-vulkan-drivers \
"
PACKAGES:aarch64 = " \
 mesa-dri-drivers \
 mesa-filesystem \
 mesa-libEGL \
 mesa-libEGL-devel \
 mesa-libGL \
 mesa-libGL-devel \
 mesa-libOSMesa \
 mesa-libOSMesa-devel \
 mesa-libgbm \
 mesa-libgbm-devel \
 mesa-vulkan-drivers \
"

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mesa-25.0.7-6.el10_1.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "48cef1908a13d3435fa7b255afab4ec7738c13367d7afaf8726a087145498ebc"

URI_x86_64_v2_mesa-dri-drivers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-dri-drivers-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-dri-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-dri-drivers}"
SRC_URI[x86_64_v2_mesa-dri-drivers.sha256sum] = "220456db6b30528d89485b61f52e5a06269fb7c56f3aa6c6fe6da74c17b25053"

URI_x86_64_v2_mesa-filesystem = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-filesystem-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-filesystem}"
SRC_URI[x86_64_v2_mesa-filesystem.sha256sum] = "afdde48d90e1ad034899c3afc98ed860b0d323b37bbd640c6705f23afe719b9b"

URI_x86_64_v2_mesa-libEGL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libEGL}"
SRC_URI[x86_64_v2_mesa-libEGL.sha256sum] = "a234906ca385e4d00d9decc93a8d94f26b8e9cc886e33ba2ae24f06dd8bebc74"

URI_x86_64_v2_mesa-libEGL-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libEGL-devel-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libEGL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libEGL-devel}"
SRC_URI[x86_64_v2_mesa-libEGL-devel.sha256sum] = "bdc943fde1f29ea095e911d7f4951f0c5423a682d058857090c4c13af4574a1f"

URI_x86_64_v2_mesa-libGL = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGL}"
SRC_URI[x86_64_v2_mesa-libGL.sha256sum] = "1cc53c682f27d75d0f9c285cda9fe7a148bdb92a016f7a94368f6774af380a9c"

URI_x86_64_v2_mesa-libGL-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libGL-devel-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libGL-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libGL-devel}"
SRC_URI[x86_64_v2_mesa-libGL-devel.sha256sum] = "267e436d60b439b6867b96aa0fb65a70ff72e24ea7adc85bc5de4f7f440a5e0e"

URI_x86_64_v2_mesa-libOSMesa = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mesa-libOSMesa-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libOSMesa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libOSMesa}"
SRC_URI[x86_64_v2_mesa-libOSMesa.sha256sum] = "01e85685a7a8479d87969c6d7b27449bdc5cfccdb210f14c44914dcdb604a67a"

URI_x86_64_v2_mesa-libOSMesa-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/mesa-libOSMesa-devel-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libOSMesa-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libOSMesa-devel}"
SRC_URI[x86_64_v2_mesa-libOSMesa-devel.sha256sum] = "3beeec5dcf131a99af9857efd2f4ed1525f28179356e35794c38fa908fbc7985"

URI_x86_64_v2_mesa-libgbm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libgbm}"
SRC_URI[x86_64_v2_mesa-libgbm.sha256sum] = "426bac780bf9d763d96e9494fb3ac22b8fbb51d6f5e54fef0679ff9ab926c108"

URI_x86_64_v2_mesa-libgbm-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libgbm-devel-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libgbm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libgbm-devel}"
SRC_URI[x86_64_v2_mesa-libgbm-devel.sha256sum] = "aaaa481df4b1bf33ab28667c26d05db81a1da94fb66ccb13512a7075f6f7c78d"

URI_x86_64_v2_mesa-libxatracker = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-libxatracker-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-libxatracker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-libxatracker}"
SRC_URI[x86_64_v2_mesa-libxatracker.sha256sum] = "8a00ffbd180c0ca598713838b6e8c4b26793877423a5b14d2bead530d7df87e6"

URI_x86_64_v2_mesa-vulkan-drivers = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mesa-vulkan-drivers-25.0.7-6.el10_1.alma.1.x86_64_v2.rpm;name=x86_64_v2_mesa-vulkan-drivers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mesa-vulkan-drivers}"
SRC_URI[x86_64_v2_mesa-vulkan-drivers.sha256sum] = "679105c8e36e5b97eca0073da65c1364b373dd336f3e9d061b0190183e437d03"

URI_aarch64_mesa-dri-drivers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-dri-drivers-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-dri-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-dri-drivers}"
SRC_URI[aarch64_mesa-dri-drivers.sha256sum] = "e5744be37a69ff784469556170f766bfd9c9999c2f377d936301dd42bf56d22f"

URI_aarch64_mesa-filesystem = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-filesystem-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-filesystem}"
SRC_URI[aarch64_mesa-filesystem.sha256sum] = "36d18a7ff320b242806169d75f92244977361da955f8e42aa1aba905dfa29281"

URI_aarch64_mesa-libEGL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-libEGL;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libEGL}"
SRC_URI[aarch64_mesa-libEGL.sha256sum] = "7417207ad73809808533655a965b58b92c2840f41ae8662c3d7716e3be0791e2"

URI_aarch64_mesa-libEGL-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libEGL-devel-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-libEGL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libEGL-devel}"
SRC_URI[aarch64_mesa-libEGL-devel.sha256sum] = "24ed81f4e14fab231840db03877155b890bc25874e5b7e859abcd17a3443f51f"

URI_aarch64_mesa-libGL = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-libGL;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGL}"
SRC_URI[aarch64_mesa-libGL.sha256sum] = "8593147cd13462e8dcb53e619d140e5e712cf119e1f1b4849a42757dfc11a8b2"

URI_aarch64_mesa-libGL-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libGL-devel-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-libGL-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libGL-devel}"
SRC_URI[aarch64_mesa-libGL-devel.sha256sum] = "871f0c6059d28674fd0398e4bc58d9b425d0b19d4faf21752c6f85a395b319db"

URI_aarch64_mesa-libOSMesa = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mesa-libOSMesa-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-libOSMesa;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libOSMesa}"
SRC_URI[aarch64_mesa-libOSMesa.sha256sum] = "7d887d4bb6ad3fb2f6c5a025214c56b3f2d3743a695b187c5b51a6e15184a91d"

URI_aarch64_mesa-libOSMesa-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/mesa-libOSMesa-devel-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-libOSMesa-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libOSMesa-devel}"
SRC_URI[aarch64_mesa-libOSMesa-devel.sha256sum] = "0250950242a692e06f5de33e130c4408de740289800df30f6e388296480bdbe9"

URI_aarch64_mesa-libgbm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-libgbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libgbm}"
SRC_URI[aarch64_mesa-libgbm.sha256sum] = "915784731815f9d23012b1947b06e62a498d2865f96dc022bce558ab4512dbd1"

URI_aarch64_mesa-libgbm-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-libgbm-devel-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-libgbm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-libgbm-devel}"
SRC_URI[aarch64_mesa-libgbm-devel.sha256sum] = "7b975578a13b4fd85613c3a38360c4fbdfeba8384f86986d680fa54c4bb2870a"

URI_aarch64_mesa-vulkan-drivers = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mesa-vulkan-drivers-25.0.7-6.el10_1.alma.1.aarch64.rpm;name=aarch64_mesa-vulkan-drivers;unpack=0"
SRC_URI:append = " ${URI_aarch64_mesa-vulkan-drivers}"
SRC_URI[aarch64_mesa-vulkan-drivers.sha256sum] = "9aa463582d62cad6ca642da4f860085d4e4824767ffe15d6b111a7b845de5ca0"

RDEPENDS:mesa-dri-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libX11-xcb \
 libdrm \
 libgcc \
 libstdc++ \
 libwayland-server \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 mesa-libgbm \
 spirv-tools-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-filesystem = " \
 "
RDEPENDS:mesa-libEGL = " \
 expat \
 glibc \
 libX11-xcb \
 libdrm \
 libglvnd-egl \
 libwayland-client \
 libwayland-server \
 libxcb \
 mesa-dri-drivers \
 mesa-libgbm \
 "
RDEPENDS:mesa-libEGL-devel = " \
 libglvnd-devel \
 mesa-libEGL \
 "
RDEPENDS:mesa-libGL = " \
 expat \
 glibc \
 libX11 \
 libX11-xcb \
 libXext \
 libXxf86vm \
 libdrm \
 libglvnd-glx \
 libxcb \
 mesa-dri-drivers \
 "
RDEPENDS:mesa-libGL-devel = " \
 libdrm-devel \
 libglvnd-devel \
 mesa-libGL \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-libOSMesa = " \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 spirv-tools-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-libOSMesa-devel = " \
 mesa-libOSMesa \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-libgbm = " \
 expat \
 glibc \
 libdrm \
 mesa-dri-drivers \
 "
RDEPENDS:mesa-libgbm-devel = " \
 mesa-libgbm \
 pkgconf-pkg-config \
 "
RDEPENDS:mesa-libxatracker = " \
 expat \
 glibc \
 libdrm \
 libgcc \
 libstdc++ \
 libzstd \
 llvm-libs \
 zlib-ng-compat \
 "
RDEPENDS:mesa-vulkan-drivers = " \
 elfutils-libelf \
 expat \
 glibc \
 libX11-xcb \
 libdrm \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 libxshmfence \
 libzstd \
 llvm-libs \
 mesa-filesystem \
 spirv-tools-libs \
 vulkan-loader \
 zlib-ng-compat \
 "
