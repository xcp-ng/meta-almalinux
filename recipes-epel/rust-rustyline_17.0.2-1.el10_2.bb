# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustyline"
PV = "17.0.2"
PR = "1.el10_2"
PACKAGES = " \
 rust-rustyline+case_insensitive_history_search-devel \
 rust-rustyline+custom-bindings-devel \
 rust-rustyline+default-devel \
 rust-rustyline+derive-devel \
 rust-rustyline+fd-lock-devel \
 rust-rustyline+home-devel \
 rust-rustyline+radix_trie-devel \
 rust-rustyline+regex-devel \
 rust-rustyline+rusqlite-devel \
 rust-rustyline+rustyline-derive-devel \
 rust-rustyline+signal-hook-devel \
 rust-rustyline+termios-devel \
 rust-rustyline+with-dirs-devel \
 rust-rustyline+with-file-history-devel \
 rust-rustyline+with-sqlite-history-devel \
 rust-rustyline-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rustyline-17.0.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "80c45c110c70165fe2825fa69430535d97bce1cf8ddce7e342e849f466d0a478"

URI_x86_64_v2_rust-rustyline+case_insensitive_history_search-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+case_insensitive_history_search-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+case_insensitive_history_search-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+case_insensitive_history_search-devel}"
SRC_URI[x86_64_v2_rust-rustyline+case_insensitive_history_search-devel.sha256sum] = "062535233427f7322eaf7839fd59c2647c2365048ae96f3f192cc5480021a247"

URI_x86_64_v2_rust-rustyline+custom-bindings-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+custom-bindings-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+custom-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+custom-bindings-devel}"
SRC_URI[x86_64_v2_rust-rustyline+custom-bindings-devel.sha256sum] = "bc50e35789e8a8483f71c40c72b24359f94e2b58634b72d97c931c775203d875"

URI_x86_64_v2_rust-rustyline+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+default-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+default-devel}"
SRC_URI[x86_64_v2_rust-rustyline+default-devel.sha256sum] = "8d6aea319d98dc9ed16401306fadcb39db856adfd9200b484d0f5c92cc0e95b1"

URI_x86_64_v2_rust-rustyline+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+derive-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+derive-devel}"
SRC_URI[x86_64_v2_rust-rustyline+derive-devel.sha256sum] = "5735259e9686e6b83c18d1fa59e2dbb7de646d700a78694cfc578ff0dab2de89"

URI_x86_64_v2_rust-rustyline+fd-lock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+fd-lock-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+fd-lock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+fd-lock-devel}"
SRC_URI[x86_64_v2_rust-rustyline+fd-lock-devel.sha256sum] = "db114ec0199080b5d98867538cf662418d672cb78d88e19129c5a34cfa668d10"

URI_x86_64_v2_rust-rustyline+home-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+home-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+home-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+home-devel}"
SRC_URI[x86_64_v2_rust-rustyline+home-devel.sha256sum] = "c4672438c190d89e1b611215e542dbcf46dbaef1ebe04f2c037651926168f380"

URI_x86_64_v2_rust-rustyline+radix_trie-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+radix_trie-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+radix_trie-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+radix_trie-devel}"
SRC_URI[x86_64_v2_rust-rustyline+radix_trie-devel.sha256sum] = "9bd883ba3cadb76ff7dbc8e7688510f52f92578b982d065e6212472bedb1123d"

URI_x86_64_v2_rust-rustyline+regex-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+regex-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+regex-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+regex-devel}"
SRC_URI[x86_64_v2_rust-rustyline+regex-devel.sha256sum] = "036d7567a91f20c04cccd7657f207dab7abf723da1cdeabc884db13dc34063cb"

URI_x86_64_v2_rust-rustyline+rusqlite-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+rusqlite-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+rusqlite-devel}"
SRC_URI[x86_64_v2_rust-rustyline+rusqlite-devel.sha256sum] = "3460b7391d5c1bfd71586c30a52acd3591b8f3325159c8617a9c1dfca7663ccd"

URI_x86_64_v2_rust-rustyline+rustyline-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+rustyline-derive-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+rustyline-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+rustyline-derive-devel}"
SRC_URI[x86_64_v2_rust-rustyline+rustyline-derive-devel.sha256sum] = "04ad4579ab4e1fcdbf470ad5dbf03a408c98755a0799bc1eefe6df5ca9f27a9e"

URI_x86_64_v2_rust-rustyline+signal-hook-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+signal-hook-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+signal-hook-devel}"
SRC_URI[x86_64_v2_rust-rustyline+signal-hook-devel.sha256sum] = "f51ebdf0c6c1fb0f0e33d662f2f0c35bc6fea9e8ce3c404226325ec1c362b909"

URI_x86_64_v2_rust-rustyline+termios-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+termios-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+termios-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+termios-devel}"
SRC_URI[x86_64_v2_rust-rustyline+termios-devel.sha256sum] = "a2c4710b8d380d686cf171cbfae4c6090e636b06e170a364b00fcd774bc44f55"

URI_x86_64_v2_rust-rustyline+with-dirs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+with-dirs-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+with-dirs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+with-dirs-devel}"
SRC_URI[x86_64_v2_rust-rustyline+with-dirs-devel.sha256sum] = "d7355cae4abdf0afb15f1d9b37bf4540ecc303fa475a627b945b37c5c858259f"

URI_x86_64_v2_rust-rustyline+with-file-history-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+with-file-history-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+with-file-history-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+with-file-history-devel}"
SRC_URI[x86_64_v2_rust-rustyline+with-file-history-devel.sha256sum] = "c68720116b3918ff3e19b22cfe8f059cb20e1d300436f2025e934540c87304f3"

URI_x86_64_v2_rust-rustyline+with-sqlite-history-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline+with-sqlite-history-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline+with-sqlite-history-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline+with-sqlite-history-devel}"
SRC_URI[x86_64_v2_rust-rustyline+with-sqlite-history-devel.sha256sum] = "1f36931588ff03717c2367921775f17dd1920959aa27ddce512948f9b68d8250"

URI_x86_64_v2_rust-rustyline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustyline-devel-17.0.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustyline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rustyline-devel}"
SRC_URI[x86_64_v2_rust-rustyline-devel.sha256sum] = "06c62686823b9a1edfe31849323e19288292d6b28f64f023729d53edd3f6b1eb"

URI_aarch64_rust-rustyline+case_insensitive_history_search-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+case_insensitive_history_search-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+case_insensitive_history_search-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+case_insensitive_history_search-devel}"
SRC_URI[aarch64_rust-rustyline+case_insensitive_history_search-devel.sha256sum] = "e3628edfe55537b4587bc002acecf4e6519f6a7b8d3cf14dbd22147fef2f30f0"

URI_aarch64_rust-rustyline+custom-bindings-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+custom-bindings-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+custom-bindings-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+custom-bindings-devel}"
SRC_URI[aarch64_rust-rustyline+custom-bindings-devel.sha256sum] = "206bcd73ed6285bbc1a015558a67aea52583c66f1f0fa99513163702c06d3b78"

URI_aarch64_rust-rustyline+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+default-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+default-devel}"
SRC_URI[aarch64_rust-rustyline+default-devel.sha256sum] = "c0f2edf93137a2e9a6b07c8af7238a655ce062121a124b9ee4147f57f03f54dc"

URI_aarch64_rust-rustyline+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+derive-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+derive-devel}"
SRC_URI[aarch64_rust-rustyline+derive-devel.sha256sum] = "a426000f2f22680cd7295f8cbf0437f04d19949538e671152647ceaea360c8e1"

URI_aarch64_rust-rustyline+fd-lock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+fd-lock-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+fd-lock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+fd-lock-devel}"
SRC_URI[aarch64_rust-rustyline+fd-lock-devel.sha256sum] = "3a70a04e3fe860ce952a0f971a33d3bb1e6ae388beb25a9fa596da5cfeef027b"

URI_aarch64_rust-rustyline+home-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+home-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+home-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+home-devel}"
SRC_URI[aarch64_rust-rustyline+home-devel.sha256sum] = "18ba6f7182f050b74a229786d8982be06f66ba3476686dfeb91120d3eb97990d"

URI_aarch64_rust-rustyline+radix_trie-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+radix_trie-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+radix_trie-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+radix_trie-devel}"
SRC_URI[aarch64_rust-rustyline+radix_trie-devel.sha256sum] = "c39f9f12296e987456dc2bd3c1b3d227c62f0fcd50d80f49f7ac05eea50bf828"

URI_aarch64_rust-rustyline+regex-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+regex-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+regex-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+regex-devel}"
SRC_URI[aarch64_rust-rustyline+regex-devel.sha256sum] = "96d57735053f8150f82099e2ff8e87009599e9ced20e699ed23457054d9720c3"

URI_aarch64_rust-rustyline+rusqlite-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+rusqlite-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+rusqlite-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+rusqlite-devel}"
SRC_URI[aarch64_rust-rustyline+rusqlite-devel.sha256sum] = "823aeaabd66a00bba2859793abd6afc3049694154f27311489b499d667f8b691"

URI_aarch64_rust-rustyline+rustyline-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+rustyline-derive-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+rustyline-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+rustyline-derive-devel}"
SRC_URI[aarch64_rust-rustyline+rustyline-derive-devel.sha256sum] = "27eb02f567aeca4caeef63b127de950d13647090b4cf6634ca4b7179037aacc8"

URI_aarch64_rust-rustyline+signal-hook-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+signal-hook-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+signal-hook-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+signal-hook-devel}"
SRC_URI[aarch64_rust-rustyline+signal-hook-devel.sha256sum] = "07361cd4452b61a54a7066b9a71bfa03c61c841c07cbd3a7cdab3708ee47f496"

URI_aarch64_rust-rustyline+termios-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+termios-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+termios-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+termios-devel}"
SRC_URI[aarch64_rust-rustyline+termios-devel.sha256sum] = "30b5575ebbe78d69b73e47c4e9612d15d471b4496d836d185acdd16246e7bd18"

URI_aarch64_rust-rustyline+with-dirs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+with-dirs-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+with-dirs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+with-dirs-devel}"
SRC_URI[aarch64_rust-rustyline+with-dirs-devel.sha256sum] = "3387da2d3941a0ccd7692e821a297190c865226c0892222547e4a8f1587b6bed"

URI_aarch64_rust-rustyline+with-file-history-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+with-file-history-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+with-file-history-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+with-file-history-devel}"
SRC_URI[aarch64_rust-rustyline+with-file-history-devel.sha256sum] = "90c0040845be13acd7ddd1942cc87ed10374bd082670e9953c99a8ce4543b7d5"

URI_aarch64_rust-rustyline+with-sqlite-history-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline+with-sqlite-history-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline+with-sqlite-history-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline+with-sqlite-history-devel}"
SRC_URI[aarch64_rust-rustyline+with-sqlite-history-devel.sha256sum] = "c983a49d903f435298b5563968a8afb1b2aa281e5e0c7649e79e58afaabfb664"

URI_aarch64_rust-rustyline-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rustyline-devel-17.0.2-1.el10_2.noarch.rpm;name=aarch64_rust-rustyline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rustyline-devel}"
SRC_URI[aarch64_rust-rustyline-devel.sha256sum] = "ebc97e48d8649d57e28857190a31d7cb3d8a56064360ba10a3ce60fec4cc3bef"

RDEPENDS:rust-rustyline+case_insensitive_history_search-devel = " \
 cargo \
 rust-rustyline+regex-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+custom-bindings-devel = " \
 cargo \
 rust-rustyline+radix_trie-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+default-devel = " \
 cargo \
 rust-rustyline+custom-bindings-devel \
 rust-rustyline+with-dirs-devel \
 rust-rustyline+with-file-history-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+derive-devel = " \
 cargo \
 rust-rustyline+rustyline-derive-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+fd-lock-devel = " \
 cargo \
 rust-fd-lock+default-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+home-devel = " \
 cargo \
 rust-home+default-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+radix_trie-devel = " \
 cargo \
 rust-radix_trie+default-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+regex-devel = " \
 cargo \
 rust-regex+default-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+rusqlite-devel = " \
 cargo \
 rust-rusqlite0.31+backup-devel \
 rust-rusqlite0.31-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+rustyline-derive-devel = " \
 cargo \
 rust-rustyline-derive+default-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+signal-hook-devel = " \
 cargo \
 rust-rustyline-devel \
 rust-signal-hook-devel \
 "
RDEPENDS:rust-rustyline+termios-devel = " \
 cargo \
 rust-rustyline-devel \
 rust-termios+default-devel \
 "
RDEPENDS:rust-rustyline+with-dirs-devel = " \
 cargo \
 rust-rustyline+home-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+with-file-history-devel = " \
 cargo \
 rust-rustyline+fd-lock-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline+with-sqlite-history-devel = " \
 cargo \
 rust-rustyline+rusqlite-devel \
 rust-rustyline-devel \
 "
RDEPENDS:rust-rustyline-devel = " \
 cargo \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-libc+default-devel \
 rust-log+default-devel \
 rust-memchr+default-devel \
 rust-nix0.30+fs-devel \
 rust-nix0.30+ioctl-devel \
 rust-nix0.30+poll-devel \
 rust-nix0.30+signal-devel \
 rust-nix0.30+term-devel \
 rust-nix0.30-devel \
 rust-unicode-segmentation+default-devel \
 rust-unicode-width+default-devel \
 rust-utf8parse+default-devel \
 "
