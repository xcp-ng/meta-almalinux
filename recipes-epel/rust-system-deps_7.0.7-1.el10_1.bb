# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-system-deps"
PV = "7.0.7"
PR = "1.el10_1"
PACKAGES = " \
 rust-system-deps+default-devel \
 rust-system-deps-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-system-deps-7.0.7-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd807bd8e78830cb96ccb27689a0f31614796b3d65ac962e4788d2cba0e48a3f"

URI_x86_64_v2_rust-system-deps+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-system-deps+default-devel-7.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-system-deps+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-system-deps+default-devel}"
SRC_URI[x86_64_v2_rust-system-deps+default-devel.sha256sum] = "81cf9968660cf6259158ae5c17fa3ef862d6bc23472a0d720b44ab443860cf43"

URI_x86_64_v2_rust-system-deps-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-system-deps-devel-7.0.7-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-system-deps-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-system-deps-devel}"
SRC_URI[x86_64_v2_rust-system-deps-devel.sha256sum] = "15356c459a704cb4597deb61e57c4ca783c681478478464af6d91fdccbe7e5f2"

URI_aarch64_rust-system-deps+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-system-deps+default-devel-7.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-system-deps+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-system-deps+default-devel}"
SRC_URI[aarch64_rust-system-deps+default-devel.sha256sum] = "13d1c4d4b2e6649850351022a2941ba691e9c8aeeed06b974df5b3dc419f675a"

URI_aarch64_rust-system-deps-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-system-deps-devel-7.0.7-1.el10_1.noarch.rpm;name=aarch64_rust-system-deps-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-system-deps-devel}"
SRC_URI[aarch64_rust-system-deps-devel.sha256sum] = "9f251c6629ecc944be52498a3e11585510b2d683d7a4472f37214b709733b533"

RDEPENDS:rust-system-deps+default-devel = " \
 cargo \
 rust-system-deps-devel \
 "
RDEPENDS:rust-system-deps-devel = " \
 cargo \
 rust \
 rust-heck+default-devel \
 rust-pkg-config+default-devel \
 rust-toml+parse-devel \
 rust-toml+std-devel \
 rust-toml-devel \
 rust-version-compare+default-devel \
 virtual/crate_cfg-expr/default__ge_0.17.0_with_crate_cfg-expr/default__lt_0.21.0~ \
 virtual/crate_cfg-expr/targets__ge_0.17.0_with_crate_cfg-expr/targets__lt_0.21.0~ \
 "
