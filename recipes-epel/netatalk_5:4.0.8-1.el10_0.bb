# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netatalk"
PE = "5"
PV = "4.0.8"
PR = "1.el10_0"
PACKAGES = " \
 netatalk \
 netatalk-afptest \
 netatalk-devel \
 netatalk-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/n/netatalk-4.0.8-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "bef46f9a7398a09450519073ff3b4a2f5d933e04f0cb6d065fc5367400b636dd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-4.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk;unpack=0"
SRC_URI[x86_64_v2_netatalk.sha256sum] = "c461938c4e00d2cf14cc0a38dc9b60a92697646050be112d26bd68f3f94e76d0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-afptest-4.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk-afptest;unpack=0"
SRC_URI[x86_64_v2_netatalk-afptest.sha256sum] = "42d26083bc27239d2a1a89dd4c09cb554750cc58ddef6a015d467cfdf64544ff"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-devel-4.0.8-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_netatalk-devel;unpack=0"
SRC_URI[x86_64_v2_netatalk-devel.sha256sum] = "345dab4ba7ff27f545943fae94df1995257956382aeb88f96509eef1da7eca77"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/netatalk-doc-4.0.8-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_netatalk-doc;unpack=0"
SRC_URI[x86_64_v2_netatalk-doc.sha256sum] = "b9c3032be2ec1a287cbac2db317f1938d2cce2f8d2c6fa6b52113d978a03d976"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netatalk-4.0.8-1.el10_0.aarch64.rpm;name=aarch64_netatalk;unpack=0"
SRC_URI[aarch64_netatalk.sha256sum] = "43f4e2a82b9e7cdc0a1e6886246127c6b3d0df7c8824f51b09184e7db8ccfd0d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netatalk-afptest-4.0.8-1.el10_0.aarch64.rpm;name=aarch64_netatalk-afptest;unpack=0"
SRC_URI[aarch64_netatalk-afptest.sha256sum] = "b613a093705fd153ba09321eb9c5e63ae72f1ee951dd774119af8b8640aee46c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netatalk-devel-4.0.8-1.el10_0.aarch64.rpm;name=aarch64_netatalk-devel;unpack=0"
SRC_URI[aarch64_netatalk-devel.sha256sum] = "98c185b1934a3a991769d42887e330e5586efbd6f5fc30fee272ef6548b3d9d7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/n/netatalk-doc-4.0.8-1.el10_0.noarch.rpm;name=aarch64_netatalk-doc;unpack=0"
SRC_URI[aarch64_netatalk-doc.sha256sum] = "f9e1053c0524cbeeb53083b1b28b9f42a302034243064738f51c5a85798d0354"

RDEPENDS:netatalk = " \
 avahi-libs \
 bash \
 cracklib \
 dconf \
 glib2 \
 glibc \
 krb5-libs \
 libacl \
 libdb \
 libevent \
 libgcrypt \
 libtalloc \
 libtirpc \
 libtracker-sparql \
 libxcrypt \
 mariadb-connector-c \
 openldap \
 pam-libs \
 perl-File-Basename \
 perl-File-Temp \
 perl-IO-Socket-IP \
 perl-IPC-Open3 \
 perl-Net-DBus \
 perl-PathTools \
 perl-Socket \
 perl-bignum \
 perl-interpreter \
 perl-libs \
 perl-vars \
 python3-dbus \
 systemd \
 "
RDEPENDS:netatalk-afptest = " \
 glibc \
 netatalk \
 "
RDEPENDS:netatalk-devel = " \
 netatalk \
 "
RDEPENDS:netatalk-doc = " \
 "
