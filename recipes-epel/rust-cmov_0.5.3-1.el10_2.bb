# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cmov"
PV = "0.5.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-cmov+default-devel \
 rust-cmov-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cmov-0.5.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ca059b052796ef78f2222e842a9bd67d4ca306f573a41fb87e76792c54aca005"

URI_x86_64_v2_rust-cmov+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmov+default-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmov+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmov+default-devel}"
SRC_URI[x86_64_v2_rust-cmov+default-devel.sha256sum] = "57c6865ae53d1f56e78159179176fd6363b0fd5fe6c7c741360b8803f881ac0e"

URI_x86_64_v2_rust-cmov-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cmov-devel-0.5.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cmov-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cmov-devel}"
SRC_URI[x86_64_v2_rust-cmov-devel.sha256sum] = "fb1e8f255728f02b3b26d54e339515f45c2b2d1adaf67b84fc33bbf53199cd9a"

URI_aarch64_rust-cmov+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmov+default-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-cmov+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmov+default-devel}"
SRC_URI[aarch64_rust-cmov+default-devel.sha256sum] = "cf48d35c67768dfe82623c11742e06edd052e044dfb1ae2b4fa572f92c14e66c"

URI_aarch64_rust-cmov-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cmov-devel-0.5.3-1.el10_2.noarch.rpm;name=aarch64_rust-cmov-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cmov-devel}"
SRC_URI[aarch64_rust-cmov-devel.sha256sum] = "2fac3aa6f27e0af0a45ee60da9cd764336f65d8e307cea6a5feb83503e031a8f"

RDEPENDS:rust-cmov+default-devel = " \
 cargo \
 rust-cmov-devel \
 "
RDEPENDS:rust-cmov-devel = " \
 cargo \
 rust \
 "
