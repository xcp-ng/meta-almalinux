# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-voluptuous"
PV = "0.16.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-voluptuous \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-voluptuous-0.16.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "46d7b88ff821a9994b284c27a1a103a15f451a6abc0a329faef3b22396a150f4"

URI_x86_64_v2_python3-voluptuous = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-voluptuous-0.16.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-voluptuous;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-voluptuous}"
SRC_URI[x86_64_v2_python3-voluptuous.sha256sum] = "086a0c76b76c14ee2315a93425915a006fca730ecc634503468a3ff7ac1d49a4"

URI_aarch64_python3-voluptuous = "${EPEL_MIRROR}/aarch64/Packages/p/python3-voluptuous-0.16.0-1.el10_1.noarch.rpm;name=aarch64_python3-voluptuous;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-voluptuous}"
SRC_URI[aarch64_python3-voluptuous.sha256sum] = "f86f2b8ef304c5fa7d402bbb296d977a53b92a4dabdb08c2d9a28c466c70429e"

RDEPENDS:python3-voluptuous = " \
 python3 \
 "
