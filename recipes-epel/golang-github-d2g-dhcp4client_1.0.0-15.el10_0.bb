# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-d2g-dhcp4client"
PV = "1.0.0"
PR = "15.el10_0"
PACKAGES = " \
 golang-github-d2g-dhcp4client-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-d2g-dhcp4client-1.0.0-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d4fb0f19e66346d45079e3b6dd1f52d2c25befb2929726402fb0ab99e9b5496"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - golang-github-d2g-dhcp4client-devel: golang(github.com/d2g/dhcp4)

URI_x86_64_v2_golang-github-d2g-dhcp4client-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-d2g-dhcp4client-devel-1.0.0-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-d2g-dhcp4client-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-d2g-dhcp4client-devel}"
SRC_URI[x86_64_v2_golang-github-d2g-dhcp4client-devel.sha256sum] = "c17e835a83b000b65d9cc53f4012b20548bdca02aa6e01c60652cdb463b64b43"

URI_aarch64_golang-github-d2g-dhcp4client-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-d2g-dhcp4client-devel-1.0.0-15.el10_0.noarch.rpm;name=aarch64_golang-github-d2g-dhcp4client-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-d2g-dhcp4client-devel}"
SRC_URI[aarch64_golang-github-d2g-dhcp4client-devel.sha256sum] = "901cd9d1f3a8cdafa4d03ff33b4c5c3a9a8b350c984411b58b52560a3f4d9b5b"

RDEPENDS:golang-github-d2g-dhcp4client-devel:x86_64_v2 = " \
 go-filesystem \
 golang-x-sys-devel \
"
RDEPENDS:golang-github-d2g-dhcp4client-devel:aarch64 = " \
 go-filesystem \
 golang-github-d2g-dhcp4-devel \
 golang-x-sys-devel \
"
