# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yara-epel"
PV = "4.5.2"
PR = "2.el10_1"
PACKAGES = " \
 yara-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yara-epel-4.5.2-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b38e822530d56ab707568a5f9e36e26039e335820fdb03b69e5ce141eb4205ea"

URI_x86_64_v2_yara-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yara-devel-4.5.2-2.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yara-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yara-devel}"
SRC_URI[x86_64_v2_yara-devel.sha256sum] = "a1e32cb44c331b869a624f6c337f84458a7d6f3c98dc16e0dadd2e3d9c74adc3"

URI_aarch64_yara-devel = "${EPEL_MIRROR}/aarch64/Packages/y/yara-devel-4.5.2-2.el10_1.aarch64.rpm;name=aarch64_yara-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_yara-devel}"
SRC_URI[aarch64_yara-devel.sha256sum] = "e42bccb4a88e745bcda949dd8856af4466d39a335a9cea2593b5510a4b227440"

RDEPENDS:yara-devel = " \
 jansson-devel \
 openssl-devel \
 pkgconf-pkg-config \
 protobuf-c-devel \
 yara \
 "
