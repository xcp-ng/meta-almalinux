# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dnsdist"
PV = "2.0.7"
PR = "1.el10_3"
PACKAGES = " \
 dnsdist \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dnsdist-2.0.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05a61e40e552827cb06934a8e47892c575effd9bc8614a1023486a26e2246139"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - dnsdist: libcap.so.2()(64bit)

URI_x86_64_v2_dnsdist = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dnsdist-2.0.7-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_dnsdist;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dnsdist}"
SRC_URI[x86_64_v2_dnsdist.sha256sum] = "d0315f0c582b109da016d733ad66eb4fd4bfc04947d666dfc11c71c973460c21"

URI_aarch64_dnsdist = "${EPEL_MIRROR}/aarch64/Packages/d/dnsdist-2.0.7-1.el10_3.aarch64.rpm;name=aarch64_dnsdist;unpack=0"
SRC_URI:append = " ${URI_aarch64_dnsdist}"
SRC_URI[aarch64_dnsdist.sha256sum] = "5567d2f29433ae81068c1207e8b153c128b1fe6dfcecfad0a1b53e9963479ad0"

RDEPENDS:dnsdist:x86_64_v2 = " \
 bash \
 fstrm \
 glibc \
 libcap \
 libedit \
 libgcc \
 libnghttp2 \
 libsodium \
 libstdc++ \
 lmdb-libs \
 luajit \
 openssl-libs \
 re2 \
 shadow-utils \
 systemd \
 systemd-libs \
 tinycdb \
"
RDEPENDS:dnsdist:aarch64 = " \
 bash \
 fstrm \
 glibc \
 libedit \
 libgcc \
 libnghttp2 \
 libsodium \
 libstdc++ \
 lmdb-libs \
 luajit \
 openssl-libs \
 re2 \
 shadow-utils \
 systemd \
 systemd-libs \
 tinycdb \
"
