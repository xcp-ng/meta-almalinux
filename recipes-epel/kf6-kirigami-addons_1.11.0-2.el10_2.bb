# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kirigami-addons"
PV = "1.11.0"
PR = "2.el10_2"
PACKAGES = " \
 kf6-kirigami-addons \
 kf6-kirigami-addons-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kirigami-addons-1.11.0-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c687062b93d0ca75da761325225229f58f80e4c7225a0cdae66a44749426668"

URI_x86_64_v2_kf6-kirigami-addons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-1.11.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-addons}"
SRC_URI[x86_64_v2_kf6-kirigami-addons.sha256sum] = "469fec351f5140b61815f7de68311e4b10ee074dba6ffe659d625034be6531df"

URI_x86_64_v2_kf6-kirigami-addons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kirigami-addons-devel-1.11.0-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kirigami-addons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kirigami-addons-devel}"
SRC_URI[x86_64_v2_kf6-kirigami-addons-devel.sha256sum] = "54f557f54cc32b7069baa59e91440a230a16c012c0c915492459d5d20476eb21"

URI_aarch64_kf6-kirigami-addons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-1.11.0-2.el10_2.aarch64.rpm;name=aarch64_kf6-kirigami-addons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-addons}"
SRC_URI[aarch64_kf6-kirigami-addons.sha256sum] = "15b9fc9526ebd4ee83dbbcc420e90430a12c022ca0f46a7dd3d1b2323275656c"

URI_aarch64_kf6-kirigami-addons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kirigami-addons-devel-1.11.0-2.el10_2.aarch64.rpm;name=aarch64_kf6-kirigami-addons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kirigami-addons-devel}"
SRC_URI[aarch64_kf6-kirigami-addons-devel.sha256sum] = "385bb6b585e24ac23b0cacd1bccb1debddf4463eba044063ce97797c582f1ff4"

RDEPENDS:kf6-kirigami-addons = " \
 glibc \
 kf6-filesystem \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kirigami-addons-devel = " \
 cmake-filesystem \
 kf6-kirigami-addons \
 "
