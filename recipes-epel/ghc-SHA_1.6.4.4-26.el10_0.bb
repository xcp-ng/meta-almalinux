# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-SHA"
PV = "1.6.4.4"
PR = "26.el10_0"
PACKAGES = " \
 ghc-SHA \
 ghc-SHA-devel \
 ghc-SHA-doc \
 ghc-SHA-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-SHA-1.6.4.4-26.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "43ec4b67c5183e2e9a49cd86fcd423ea7bd39e9b696f19db38a8f12f16eb5339"

URI_x86_64_v2_ghc-SHA = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-SHA-1.6.4.4-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-SHA;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-SHA}"
SRC_URI[x86_64_v2_ghc-SHA.sha256sum] = "9e7f566b5aed6413c4153e3b936e5ad1db4ac021f0be2812e5ebabb16b76547d"

URI_x86_64_v2_ghc-SHA-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-SHA-devel-1.6.4.4-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-SHA-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-SHA-devel}"
SRC_URI[x86_64_v2_ghc-SHA-devel.sha256sum] = "a0f9d326c0946cb164b26fc1b51edebbd9dbaef6c82287ed680c5fe64a1cd0b1"

URI_x86_64_v2_ghc-SHA-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-SHA-doc-1.6.4.4-26.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-SHA-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-SHA-doc}"
SRC_URI[x86_64_v2_ghc-SHA-doc.sha256sum] = "b58d783476b4a2089348e8346f9b10b3d41d7c49962bef6b4915194da53a1865"

URI_x86_64_v2_ghc-SHA-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-SHA-prof-1.6.4.4-26.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-SHA-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-SHA-prof}"
SRC_URI[x86_64_v2_ghc-SHA-prof.sha256sum] = "aeb1dc1593212abf1f06ee6992615e18d38172d978f213b86fad3431ac6edf33"

URI_aarch64_ghc-SHA = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-SHA-1.6.4.4-26.el10_0.aarch64.rpm;name=aarch64_ghc-SHA;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-SHA}"
SRC_URI[aarch64_ghc-SHA.sha256sum] = "5948c83a20818025c3772b9cc65471108ca30bedda149753f7ce94b0cebb4416"

URI_aarch64_ghc-SHA-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-SHA-devel-1.6.4.4-26.el10_0.aarch64.rpm;name=aarch64_ghc-SHA-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-SHA-devel}"
SRC_URI[aarch64_ghc-SHA-devel.sha256sum] = "acfb7eef702d07f7cf7336b6ca080a32c5ba56f997a62c1c3b60aa0768711167"

URI_aarch64_ghc-SHA-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-SHA-doc-1.6.4.4-26.el10_0.noarch.rpm;name=aarch64_ghc-SHA-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-SHA-doc}"
SRC_URI[aarch64_ghc-SHA-doc.sha256sum] = "b95ad4247af2e699c07e2e7f5f3fc650d5650d666c1f1d886b45ad576826864a"

URI_aarch64_ghc-SHA-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-SHA-prof-1.6.4.4-26.el10_0.aarch64.rpm;name=aarch64_ghc-SHA-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-SHA-prof}"
SRC_URI[aarch64_ghc-SHA-prof.sha256sum] = "c776b0c47f27afc0b508c5fe0095ad2958317d81e9d9d10ff796d5450ac14574"

RDEPENDS:ghc-SHA = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc-SHA-devel = " \
 ghc-SHA \
 ghc-array-devel \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 "
RDEPENDS:ghc-SHA-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-SHA-prof = " \
 ghc-SHA-devel \
 ghc-array-prof \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 "
