# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-bad-free"
PV = "1.26.7"
PR = "2.el10_2.7"
PACKAGES = " \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-bad-free-1.26.7-2.el10_2.7.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "08f7d5a005cfb29564cc4cfab67164e0af5b5cc0797018287246dbadf29cc1f7"

URI_x86_64_v2_gstreamer1-plugins-bad-free = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-1.26.7-2.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free.sha256sum] = "8d3ce15ca3055c2271ddcd624cb448be79c61fe09a4a05c9df232321d70d4f1d"

URI_x86_64_v2_gstreamer1-plugins-bad-free-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-devel-1.26.7-2.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free-devel}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-devel.sha256sum] = "5f30ad6b613f44a626f1fe0f566ffd06cb64427408bb8835f148d8a40e022db0"

URI_x86_64_v2_gstreamer1-plugins-bad-free-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-bad-free-libs-1.26.7-2.el10_2.7.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gstreamer1-plugins-bad-free-libs}"
SRC_URI[x86_64_v2_gstreamer1-plugins-bad-free-libs.sha256sum] = "18d6f7bb62222a97c63ce08d04dbff283ef89ac1b582cbe7f501164dde80fffa"

URI_aarch64_gstreamer1-plugins-bad-free = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-1.26.7-2.el10_2.7.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free.sha256sum] = "721bbba0f067ac8dc37033b70dd175730ceee44ba621034fe30e29a4a3b3d744"

URI_aarch64_gstreamer1-plugins-bad-free-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gstreamer1-plugins-bad-free-devel-1.26.7-2.el10_2.7.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free-devel}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-devel.sha256sum] = "50e370b8c7fce2763a6099d92efe92310410ec7a4d863a980f64829c44952d7b"

URI_aarch64_gstreamer1-plugins-bad-free-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-bad-free-libs-1.26.7-2.el10_2.7.aarch64.rpm;name=aarch64_gstreamer1-plugins-bad-free-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_gstreamer1-plugins-bad-free-libs}"
SRC_URI[aarch64_gstreamer1-plugins-bad-free-libs.sha256sum] = "2f8619523ff2d65eedd9cdb891769f7c595cb9a524f753fd8d59cad660c7e014"

RDEPENDS:gstreamer1-plugins-bad-free = " \
 bzip2-libs \
 cairo \
 fdk-aac-free \
 glib2 \
 glibc \
 gsm \
 gstreamer1 \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base \
 gtk3 \
 json-glib \
 lcms2 \
 libdrm \
 libdvdnav \
 libdvdread \
 libgcc \
 libgudev \
 liblc3 \
 librsvg2 \
 libsndfile \
 libsrtp \
 libstdc++ \
 libusb1 \
 libva \
 libwayland-client \
 libwebp \
 libxml2 \
 openjpeg2 \
 openssl-libs \
 opus \
 orc \
 pango \
 soundtouch \
 vulkan-loader \
 webrtc-audio-processing \
 "
RDEPENDS:gstreamer1-plugins-bad-free-devel = " \
 glib2-devel \
 gstreamer1-devel \
 gstreamer1-plugins-bad-free \
 gstreamer1-plugins-bad-free-devel \
 gstreamer1-plugins-bad-free-libs \
 gstreamer1-plugins-base-devel \
 libdrm-devel \
 libva-devel \
 pkgconf-pkg-config \
 vulkan-loader-devel \
 wayland-devel \
 "
RDEPENDS:gstreamer1-plugins-bad-free-libs = " \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 libdrm \
 libgcc \
 libstdc++ \
 libva \
 libwayland-client \
 vulkan-loader \
 "
