# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc9.10"
PV = "9.10.3"
PR = "11.el10_2"
PACKAGES:x86_64_v2 = " \
 ghc9.10 \
 ghc9.10-Cabal \
 ghc9.10-Cabal-devel \
 ghc9.10-Cabal-doc \
 ghc9.10-Cabal-syntax \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-Cabal-syntax-doc \
 ghc9.10-array \
 ghc9.10-array-devel \
 ghc9.10-array-doc \
 ghc9.10-base \
 ghc9.10-base-devel \
 ghc9.10-base-doc \
 ghc9.10-binary \
 ghc9.10-binary-devel \
 ghc9.10-binary-doc \
 ghc9.10-bytestring \
 ghc9.10-bytestring-devel \
 ghc9.10-bytestring-doc \
 ghc9.10-compiler \
 ghc9.10-compiler-default \
 ghc9.10-containers \
 ghc9.10-containers-devel \
 ghc9.10-containers-doc \
 ghc9.10-deepseq \
 ghc9.10-deepseq-devel \
 ghc9.10-deepseq-doc \
 ghc9.10-devel \
 ghc9.10-directory \
 ghc9.10-directory-devel \
 ghc9.10-directory-doc \
 ghc9.10-doc \
 ghc9.10-doc-index \
 ghc9.10-exceptions \
 ghc9.10-exceptions-devel \
 ghc9.10-exceptions-doc \
 ghc9.10-filepath \
 ghc9.10-filepath-devel \
 ghc9.10-filepath-doc \
 ghc9.10-filesystem \
 ghc9.10-ghc \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-bignum-devel \
 ghc9.10-ghc-bignum-doc \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-boot-doc \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-ghc-boot-th-doc \
 ghc9.10-ghc-compact \
 ghc9.10-ghc-compact-devel \
 ghc9.10-ghc-compact-doc \
 ghc9.10-ghc-devel \
 ghc9.10-ghc-doc \
 ghc9.10-ghc-experimental \
 ghc9.10-ghc-experimental-devel \
 ghc9.10-ghc-experimental-doc \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghc-heap-doc \
 ghc9.10-ghc-platform \
 ghc9.10-ghc-platform-devel \
 ghc9.10-ghc-platform-doc \
 ghc9.10-ghc-toolchain \
 ghc9.10-ghc-toolchain-devel \
 ghc9.10-ghc-toolchain-doc \
 ghc9.10-ghci \
 ghc9.10-ghci-devel \
 ghc9.10-ghci-doc \
 ghc9.10-hadrian \
 ghc9.10-haskeline \
 ghc9.10-haskeline-devel \
 ghc9.10-haskeline-doc \
 ghc9.10-hpc \
 ghc9.10-hpc-devel \
 ghc9.10-hpc-doc \
 ghc9.10-manual \
 ghc9.10-mtl \
 ghc9.10-mtl-devel \
 ghc9.10-mtl-doc \
 ghc9.10-os-string \
 ghc9.10-os-string-devel \
 ghc9.10-os-string-doc \
 ghc9.10-parsec \
 ghc9.10-parsec-devel \
 ghc9.10-parsec-doc \
 ghc9.10-pretty \
 ghc9.10-pretty-devel \
 ghc9.10-pretty-doc \
 ghc9.10-process \
 ghc9.10-process-devel \
 ghc9.10-process-doc \
 ghc9.10-semaphore-compat \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-semaphore-compat-doc \
 ghc9.10-stm \
 ghc9.10-stm-devel \
 ghc9.10-stm-doc \
 ghc9.10-template-haskell \
 ghc9.10-template-haskell-devel \
 ghc9.10-template-haskell-doc \
 ghc9.10-terminfo \
 ghc9.10-terminfo-devel \
 ghc9.10-terminfo-doc \
 ghc9.10-text \
 ghc9.10-text-devel \
 ghc9.10-text-doc \
 ghc9.10-time \
 ghc9.10-time-devel \
 ghc9.10-time-doc \
 ghc9.10-transformers \
 ghc9.10-transformers-devel \
 ghc9.10-transformers-doc \
 ghc9.10-unix \
 ghc9.10-unix-devel \
 ghc9.10-unix-doc \
 ghc9.10-xhtml \
 ghc9.10-xhtml-devel \
 ghc9.10-xhtml-doc \
"
PACKAGES:aarch64 = " \
 ghc9.10 \
 ghc9.10-Cabal \
 ghc9.10-Cabal-devel \
 ghc9.10-Cabal-doc \
 ghc9.10-Cabal-prof \
 ghc9.10-Cabal-syntax \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-Cabal-syntax-doc \
 ghc9.10-Cabal-syntax-prof \
 ghc9.10-array \
 ghc9.10-array-devel \
 ghc9.10-array-doc \
 ghc9.10-array-prof \
 ghc9.10-base \
 ghc9.10-base-devel \
 ghc9.10-base-doc \
 ghc9.10-base-prof \
 ghc9.10-binary \
 ghc9.10-binary-devel \
 ghc9.10-binary-doc \
 ghc9.10-binary-prof \
 ghc9.10-bytestring \
 ghc9.10-bytestring-devel \
 ghc9.10-bytestring-doc \
 ghc9.10-bytestring-prof \
 ghc9.10-compiler \
 ghc9.10-compiler-default \
 ghc9.10-containers \
 ghc9.10-containers-devel \
 ghc9.10-containers-doc \
 ghc9.10-containers-prof \
 ghc9.10-deepseq \
 ghc9.10-deepseq-devel \
 ghc9.10-deepseq-doc \
 ghc9.10-deepseq-prof \
 ghc9.10-devel \
 ghc9.10-directory \
 ghc9.10-directory-devel \
 ghc9.10-directory-doc \
 ghc9.10-directory-prof \
 ghc9.10-doc \
 ghc9.10-doc-index \
 ghc9.10-exceptions \
 ghc9.10-exceptions-devel \
 ghc9.10-exceptions-doc \
 ghc9.10-exceptions-prof \
 ghc9.10-filepath \
 ghc9.10-filepath-devel \
 ghc9.10-filepath-doc \
 ghc9.10-filepath-prof \
 ghc9.10-filesystem \
 ghc9.10-ghc \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-bignum-devel \
 ghc9.10-ghc-bignum-doc \
 ghc9.10-ghc-bignum-prof \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-boot-doc \
 ghc9.10-ghc-boot-prof \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-ghc-boot-th-doc \
 ghc9.10-ghc-boot-th-prof \
 ghc9.10-ghc-compact \
 ghc9.10-ghc-compact-devel \
 ghc9.10-ghc-compact-doc \
 ghc9.10-ghc-compact-prof \
 ghc9.10-ghc-devel \
 ghc9.10-ghc-doc \
 ghc9.10-ghc-experimental \
 ghc9.10-ghc-experimental-devel \
 ghc9.10-ghc-experimental-doc \
 ghc9.10-ghc-experimental-prof \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghc-heap-doc \
 ghc9.10-ghc-heap-prof \
 ghc9.10-ghc-platform \
 ghc9.10-ghc-platform-devel \
 ghc9.10-ghc-platform-doc \
 ghc9.10-ghc-platform-prof \
 ghc9.10-ghc-prof \
 ghc9.10-ghc-toolchain \
 ghc9.10-ghc-toolchain-devel \
 ghc9.10-ghc-toolchain-doc \
 ghc9.10-ghc-toolchain-prof \
 ghc9.10-ghci \
 ghc9.10-ghci-devel \
 ghc9.10-ghci-doc \
 ghc9.10-ghci-prof \
 ghc9.10-hadrian \
 ghc9.10-haskeline \
 ghc9.10-haskeline-devel \
 ghc9.10-haskeline-doc \
 ghc9.10-haskeline-prof \
 ghc9.10-hpc \
 ghc9.10-hpc-devel \
 ghc9.10-hpc-doc \
 ghc9.10-hpc-prof \
 ghc9.10-manual \
 ghc9.10-mtl \
 ghc9.10-mtl-devel \
 ghc9.10-mtl-doc \
 ghc9.10-mtl-prof \
 ghc9.10-os-string \
 ghc9.10-os-string-devel \
 ghc9.10-os-string-doc \
 ghc9.10-os-string-prof \
 ghc9.10-parsec \
 ghc9.10-parsec-devel \
 ghc9.10-parsec-doc \
 ghc9.10-parsec-prof \
 ghc9.10-pretty \
 ghc9.10-pretty-devel \
 ghc9.10-pretty-doc \
 ghc9.10-pretty-prof \
 ghc9.10-process \
 ghc9.10-process-devel \
 ghc9.10-process-doc \
 ghc9.10-process-prof \
 ghc9.10-prof \
 ghc9.10-semaphore-compat \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-semaphore-compat-doc \
 ghc9.10-semaphore-compat-prof \
 ghc9.10-stm \
 ghc9.10-stm-devel \
 ghc9.10-stm-doc \
 ghc9.10-stm-prof \
 ghc9.10-template-haskell \
 ghc9.10-template-haskell-devel \
 ghc9.10-template-haskell-doc \
 ghc9.10-template-haskell-prof \
 ghc9.10-terminfo \
 ghc9.10-terminfo-devel \
 ghc9.10-terminfo-doc \
 ghc9.10-terminfo-prof \
 ghc9.10-text \
 ghc9.10-text-devel \
 ghc9.10-text-doc \
 ghc9.10-text-prof \
 ghc9.10-time \
 ghc9.10-time-devel \
 ghc9.10-time-doc \
 ghc9.10-time-prof \
 ghc9.10-transformers \
 ghc9.10-transformers-devel \
 ghc9.10-transformers-doc \
 ghc9.10-transformers-prof \
 ghc9.10-unix \
 ghc9.10-unix-devel \
 ghc9.10-unix-doc \
 ghc9.10-unix-prof \
 ghc9.10-xhtml \
 ghc9.10-xhtml-devel \
 ghc9.10-xhtml-doc \
 ghc9.10-xhtml-prof \
"

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc9.10-9.10.3-11.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "00f25126bbfe31d461659cebce51d32479e8694bb53e2dd295d41227ba73ad14"

URI_x86_64_v2_ghc9.10 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10}"
SRC_URI[x86_64_v2_ghc9.10.sha256sum] = "9ed63d0110e5106ff82bb31a8948a02d25dc1d677f688ac8ba096bbd3d7f36dd"

URI_x86_64_v2_ghc9.10-Cabal = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-3.12.1.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal}"
SRC_URI[x86_64_v2_ghc9.10-Cabal.sha256sum] = "4e52595a3b3d0d96021ba05ebe12891562b0592eab344ae640f8cb0607c68d17"

URI_x86_64_v2_ghc9.10-Cabal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-devel-3.12.1.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-devel}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-devel.sha256sum] = "53c4c623403afc22bd9fc28e46b7c670adbf1120fb8c2fcd474682ee1f84171f"

URI_x86_64_v2_ghc9.10-Cabal-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-doc-3.12.1.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-doc}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-doc.sha256sum] = "fa2a9a7d02a9c501004bbad1035bd24713adeadc23b4371614b3dc83cc0de867"

URI_x86_64_v2_ghc9.10-Cabal-syntax = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-3.12.1.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax.sha256sum] = "8e508089f62da73bf58a56b1b62950a28a25b1b36b24fce52114cf04d198e36d"

URI_x86_64_v2_ghc9.10-Cabal-syntax-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-devel-3.12.1.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax-devel}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax-devel.sha256sum] = "073751d52c709d0b4186375f8802607b018c77dac79661cfe9dc11e9edc76df9"

URI_x86_64_v2_ghc9.10-Cabal-syntax-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-Cabal-syntax-doc-3.12.1.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-Cabal-syntax-doc}"
SRC_URI[x86_64_v2_ghc9.10-Cabal-syntax-doc.sha256sum] = "7b524de9dd5c4bbf570f58e6767b1a3b31afb34e6e21351a51ad06c13d843ad3"

URI_x86_64_v2_ghc9.10-array = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-0.5.8.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-array;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array}"
SRC_URI[x86_64_v2_ghc9.10-array.sha256sum] = "4d368456d7aeb8b5388011900a8ab964e2eb831305591fc1a4c00b35cb8deb13"

URI_x86_64_v2_ghc9.10-array-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-devel-0.5.8.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-array-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array-devel}"
SRC_URI[x86_64_v2_ghc9.10-array-devel.sha256sum] = "dfb28a09ca9c3fa1bf5f845311317109b3b197a746b048651cb9ba549f4aff12"

URI_x86_64_v2_ghc9.10-array-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-array-doc-0.5.8.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-array-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-array-doc}"
SRC_URI[x86_64_v2_ghc9.10-array-doc.sha256sum] = "37c8dda4b9ade91bbed0f78d2dc3d272847dfdc3045486ee3a00db3db05af92e"

URI_x86_64_v2_ghc9.10-base = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-4.20.2.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-base;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base}"
SRC_URI[x86_64_v2_ghc9.10-base.sha256sum] = "0dd95eb094c8917f2e2bdb9ff7e58aaa82fd7737d14aeb9c0f789b39261052d0"

URI_x86_64_v2_ghc9.10-base-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-devel-4.20.2.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-base-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base-devel}"
SRC_URI[x86_64_v2_ghc9.10-base-devel.sha256sum] = "2920a065eee912be2d8cc49e82862707dffeae4228ffa8b1b44e07380a0589a4"

URI_x86_64_v2_ghc9.10-base-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-base-doc-4.20.2.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-base-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-base-doc}"
SRC_URI[x86_64_v2_ghc9.10-base-doc.sha256sum] = "e9d1e1c217f9f1203c3d07c11c14fa646da1b28b7a73c686e99325f75ba9a00b"

URI_x86_64_v2_ghc9.10-binary = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-0.8.9.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-binary;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary}"
SRC_URI[x86_64_v2_ghc9.10-binary.sha256sum] = "9675a21a936e42ef1c6f26d9f876d2dbfe7917e8e306201877d794decdf01453"

URI_x86_64_v2_ghc9.10-binary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-devel-0.8.9.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-binary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary-devel}"
SRC_URI[x86_64_v2_ghc9.10-binary-devel.sha256sum] = "a202d277d43d10326207e1b50145dd83472e2e61e177c39466681c844a231f07"

URI_x86_64_v2_ghc9.10-binary-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-binary-doc-0.8.9.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-binary-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-binary-doc}"
SRC_URI[x86_64_v2_ghc9.10-binary-doc.sha256sum] = "9ca4d1817d41468db29aca8dd98737dd18f5ea4526342c39e3e87c04dc965db8"

URI_x86_64_v2_ghc9.10-bytestring = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-0.12.2.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-bytestring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring}"
SRC_URI[x86_64_v2_ghc9.10-bytestring.sha256sum] = "6871c20fbc2cdd804074d494c62f7ff2695a895813d80e6524b8f446628f2e9d"

URI_x86_64_v2_ghc9.10-bytestring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-devel-0.12.2.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring-devel}"
SRC_URI[x86_64_v2_ghc9.10-bytestring-devel.sha256sum] = "8525eb31cfd79be0910db5309bbab586170043f90c29a8bb1f97348a745b4912"

URI_x86_64_v2_ghc9.10-bytestring-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-bytestring-doc-0.12.2.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-bytestring-doc}"
SRC_URI[x86_64_v2_ghc9.10-bytestring-doc.sha256sum] = "c54c5349b29c607d03099ee6c9ed0997fd8fc3f688d357553fcd27e820f12c09"

URI_x86_64_v2_ghc9.10-compiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-compiler-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-compiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-compiler}"
SRC_URI[x86_64_v2_ghc9.10-compiler.sha256sum] = "a2017345a6ecb2d795448b3d6e3008769711e73baaea66a096dbdd9ee7ec0335"

URI_x86_64_v2_ghc9.10-compiler-default = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-compiler-default-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-compiler-default;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-compiler-default}"
SRC_URI[x86_64_v2_ghc9.10-compiler-default.sha256sum] = "3d4b69292f8af362414e47381fde6e9a41e104c8d3406664302ebcf6658e2d5d"

URI_x86_64_v2_ghc9.10-containers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-0.7-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-containers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers}"
SRC_URI[x86_64_v2_ghc9.10-containers.sha256sum] = "96c9b4296235d2cec595f10ca69a5f3180cbba0debe034e1071ec69e722b70d7"

URI_x86_64_v2_ghc9.10-containers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-devel-0.7-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-containers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers-devel}"
SRC_URI[x86_64_v2_ghc9.10-containers-devel.sha256sum] = "b599c9fc49e8bee79f5293d088f9bab6919fa2e86a550c5fe1e03bd12b431025"

URI_x86_64_v2_ghc9.10-containers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-containers-doc-0.7-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-containers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-containers-doc}"
SRC_URI[x86_64_v2_ghc9.10-containers-doc.sha256sum] = "87d1e5b378f7e52a1c50f0a342baacfc269233e2a96b5cd65bb7da8e89bb7de8"

URI_x86_64_v2_ghc9.10-deepseq = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-1.5.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-deepseq;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq}"
SRC_URI[x86_64_v2_ghc9.10-deepseq.sha256sum] = "0150499bf921cfdeb43d6e5025304da91058671af9437172f284aa22353614ee"

URI_x86_64_v2_ghc9.10-deepseq-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-devel-1.5.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq-devel}"
SRC_URI[x86_64_v2_ghc9.10-deepseq-devel.sha256sum] = "4d53df2225e08b4599b55e7efcdcc0c12906019a22c873f0458a9409501ea92c"

URI_x86_64_v2_ghc9.10-deepseq-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-deepseq-doc-1.5.0.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-deepseq-doc}"
SRC_URI[x86_64_v2_ghc9.10-deepseq-doc.sha256sum] = "68a4e314c8e717f5c802c0c8fba7be35ea07cfd3020f8ed303f6fbcecd39b84b"

URI_x86_64_v2_ghc9.10-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-devel-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-devel}"
SRC_URI[x86_64_v2_ghc9.10-devel.sha256sum] = "0860eebc88c0d6399193d930ced4d09209f55ac5882f246010ea32406e247b45"

URI_x86_64_v2_ghc9.10-directory = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-1.3.8.5-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-directory;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory}"
SRC_URI[x86_64_v2_ghc9.10-directory.sha256sum] = "6250f526d77b14057955dd6926d3bead9177284bf3e220a60ee6df6870b3a50d"

URI_x86_64_v2_ghc9.10-directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-devel-1.3.8.5-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory-devel}"
SRC_URI[x86_64_v2_ghc9.10-directory-devel.sha256sum] = "bdbc1e7c684d5b41dbf7795ea3f867d88f14335e0871f4b683f91cf715b8f55f"

URI_x86_64_v2_ghc9.10-directory-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-directory-doc-1.3.8.5-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-directory-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-directory-doc}"
SRC_URI[x86_64_v2_ghc9.10-directory-doc.sha256sum] = "85b2c1af2feb8055a2ad51e82e6d95fe1f4ef6caaa294ccf0d2d444a27c0fbd6"

URI_x86_64_v2_ghc9.10-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-doc-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-doc}"
SRC_URI[x86_64_v2_ghc9.10-doc.sha256sum] = "472381048311599bc36cc7f12ef5009e58a16aea5f520130855d378707a70a8d"

URI_x86_64_v2_ghc9.10-doc-index = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-doc-index-9.10.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-doc-index;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-doc-index}"
SRC_URI[x86_64_v2_ghc9.10-doc-index.sha256sum] = "1132ec8115c1209dfc06bc64433e63506ac081f80fc21e7f2caf5149b0c3df60"

URI_x86_64_v2_ghc9.10-exceptions = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-0.10.9-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-exceptions;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions}"
SRC_URI[x86_64_v2_ghc9.10-exceptions.sha256sum] = "ae9948820a943fd607c3c906d0db70d135ca24840da69af3b52a21928cb349b6"

URI_x86_64_v2_ghc9.10-exceptions-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-devel-0.10.9-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions-devel}"
SRC_URI[x86_64_v2_ghc9.10-exceptions-devel.sha256sum] = "c65963c1c2b96fe5c5f39dc8f1cbcffae782ae71d5e2d075ec741cf75b3dc48b"

URI_x86_64_v2_ghc9.10-exceptions-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-exceptions-doc-0.10.9-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-exceptions-doc}"
SRC_URI[x86_64_v2_ghc9.10-exceptions-doc.sha256sum] = "0c9ca7664db1e6d71a1a3a4bcb15206846c300dfafae58f14daf275ce4d5cf08"

URI_x86_64_v2_ghc9.10-filepath = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-1.5.4.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filepath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath}"
SRC_URI[x86_64_v2_ghc9.10-filepath.sha256sum] = "de8571ed75d6e58f06c5036c487ecf9594139e382f8264362ccc27807422b1ed"

URI_x86_64_v2_ghc9.10-filepath-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-devel-1.5.4.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath-devel}"
SRC_URI[x86_64_v2_ghc9.10-filepath-devel.sha256sum] = "223fe05b517703aeefa1e5b64b67f3822fcb71d34a58d73a870748321108cf31"

URI_x86_64_v2_ghc9.10-filepath-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filepath-doc-1.5.4.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filepath-doc}"
SRC_URI[x86_64_v2_ghc9.10-filepath-doc.sha256sum] = "358bb158ce797f7f14690c9738abc18c8824e5aaff838cddff3facacd58eaa75"

URI_x86_64_v2_ghc9.10-filesystem = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-filesystem-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-filesystem;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-filesystem}"
SRC_URI[x86_64_v2_ghc9.10-filesystem.sha256sum] = "2f4f1de021092c9abd4684b3841fcaa493b3bd6098489d14098f8ce6296d8003"

URI_x86_64_v2_ghc9.10-ghc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc}"
SRC_URI[x86_64_v2_ghc9.10-ghc.sha256sum] = "20983663f9a7087e86fb33ec2b09c5e87c4a2ff27bdc093d1eee34e588960345"

URI_x86_64_v2_ghc9.10-ghc-bignum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-1.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum.sha256sum] = "ad5278c9b90ee4ded5069f4a4835182aad7b0c1a66f324f8feef006d677e8059"

URI_x86_64_v2_ghc9.10-ghc-bignum-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-devel-1.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum-devel.sha256sum] = "b6e87f8c52f3842d2e8772a51202e5ab426441ff4a8ddec93180c5d038de8daa"

URI_x86_64_v2_ghc9.10-ghc-bignum-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-bignum-doc-1.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-bignum-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-bignum-doc.sha256sum] = "940b1b0ab57475487b5906ae4692704987f73de91d644b7667fc57ee224af9e9"

URI_x86_64_v2_ghc9.10-ghc-boot = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot.sha256sum] = "727e3fd106da590679f4817223748d0a7cf1ddb650fedd112e01e4457d08265d"

URI_x86_64_v2_ghc9.10-ghc-boot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-devel-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-devel.sha256sum] = "a8171fc8ae82ad126a936f20bebe707bd8cd66e7a10236e7c8d8fd2da4fd7ff8"

URI_x86_64_v2_ghc9.10-ghc-boot-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-doc-9.10.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-doc.sha256sum] = "475ca0a9fbf9d6d4cb3bbe08fe234f5e4d2828abab12e0651b5c1f83df0cae74"

URI_x86_64_v2_ghc9.10-ghc-boot-th = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th.sha256sum] = "ae75093c661f2f3e177f3203ba7b99188037f58eb337ca4bb4fcd60f405b0b07"

URI_x86_64_v2_ghc9.10-ghc-boot-th-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-devel-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th-devel.sha256sum] = "9537ed42384b1c9eb38cc67f7a8d197dc7847fae1039b1db3e284c2ff9a4e03c"

URI_x86_64_v2_ghc9.10-ghc-boot-th-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-boot-th-doc-9.10.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-boot-th-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-boot-th-doc.sha256sum] = "12277798e4dc0fdd1510a8a36bd3573705ece56ed2d2ccc452b17d1543b093f1"

URI_x86_64_v2_ghc9.10-ghc-compact = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-0.1.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact.sha256sum] = "2c3e86b62cf9138472e22ac8982855c8419448d11a93bb3ee71df2202083a857"

URI_x86_64_v2_ghc9.10-ghc-compact-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-devel-0.1.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact-devel.sha256sum] = "3689977766f8370e7a8d5e5da2b01f48e3b3a95565b2138a26e6062e95f86121"

URI_x86_64_v2_ghc9.10-ghc-compact-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-compact-doc-0.1.0.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-compact-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-compact-doc.sha256sum] = "d78b59222f8056b3ffe3135e3225f6ade9641b081fa0f2526f44946965ad5313"

URI_x86_64_v2_ghc9.10-ghc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-devel-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-devel.sha256sum] = "965f8eac48e083184de876569b63681bb550cf3a950ddd5da14754137a8de484"

URI_x86_64_v2_ghc9.10-ghc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-doc-9.10.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-doc.sha256sum] = "4e9a7d58e1f932185d06431f100ad4fea6b2c3e6ad3b495969dc51d6a32c945f"

URI_x86_64_v2_ghc9.10-ghc-experimental = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-9.1003.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental.sha256sum] = "dee77501d040a38327a177d023c9ca483a5171b34ecd9d39d09c496ae669245d"

URI_x86_64_v2_ghc9.10-ghc-experimental-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-devel-9.1003.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental-devel.sha256sum] = "7cc88b271fe8d6da3f1393055dd0b7611d6bd9c3254ffaf74963f28ef5311993"

URI_x86_64_v2_ghc9.10-ghc-experimental-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-experimental-doc-9.1003.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-experimental-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-experimental-doc.sha256sum] = "f014286f9040a1f63510d2a416552fea3f7794e289091f59c164f95475a6486f"

URI_x86_64_v2_ghc9.10-ghc-heap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap.sha256sum] = "0847c6a5663f193ade7d518a1a926a64b9e8777c75e7af87e17f3a4a171a08c3"

URI_x86_64_v2_ghc9.10-ghc-heap-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-devel-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap-devel.sha256sum] = "4bc3aed454d812f545367cbbc03fcf9443f28fc8676c7a925df9d5dfbf393dd2"

URI_x86_64_v2_ghc9.10-ghc-heap-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-heap-doc-9.10.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-heap-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-heap-doc.sha256sum] = "2b042e53e7fb32e8458539fd499aa2f4eec102b844f34ac9b04155f96336cc0c"

URI_x86_64_v2_ghc9.10-ghc-platform = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-0.1.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform.sha256sum] = "24090bfba59758c9adb473f70d25df34744897ca6c5f6964befc7f8f12375c8a"

URI_x86_64_v2_ghc9.10-ghc-platform-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-devel-0.1.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform-devel.sha256sum] = "b76daae95253370854f5aa9b354a81f93b382627c6bb7302e2f34030c2acda54"

URI_x86_64_v2_ghc9.10-ghc-platform-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-platform-doc-0.1.0.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-platform-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-platform-doc.sha256sum] = "413b16ac0b56919a3c7ce5665db1837f8afcaff99a27eb298d2bb9f1b50bfd20"

URI_x86_64_v2_ghc9.10-ghc-toolchain = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-0.1.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain.sha256sum] = "42d753325f08fb249a056ca80a48b8a4e228d8b154005ac857c33fdc85f20940"

URI_x86_64_v2_ghc9.10-ghc-toolchain-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-devel-0.1.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain-devel.sha256sum] = "d9871cd706c8bf71bde38cf301f733e91006e9b23e08b26bd3c6085bfbc9aa11"

URI_x86_64_v2_ghc9.10-ghc-toolchain-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghc-toolchain-doc-0.1.0.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghc-toolchain-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghc-toolchain-doc.sha256sum] = "0393052756c79d1d28f2bda1e5765a9d6ee5a9320b19f99428c9bff87a31295b"

URI_x86_64_v2_ghc9.10-ghci = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghci;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci}"
SRC_URI[x86_64_v2_ghc9.10-ghci.sha256sum] = "be5851df9d6031b2d22695a8211086baa2f81ba454e828c59f6a41eb93c2bc05"

URI_x86_64_v2_ghc9.10-ghci-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-devel-9.10.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci-devel}"
SRC_URI[x86_64_v2_ghc9.10-ghci-devel.sha256sum] = "19011c877a123043c02cc835c712d0ea65b5ebdd16c7e70824c9ecad30b200da"

URI_x86_64_v2_ghc9.10-ghci-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-ghci-doc-9.10.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-ghci-doc}"
SRC_URI[x86_64_v2_ghc9.10-ghci-doc.sha256sum] = "8d96af5baaa1c0c3ec70411885be53e3f3e89aea0aeb82faf06cdd7bd63f1e81"

URI_x86_64_v2_ghc9.10-hadrian = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hadrian-0.1.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hadrian;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hadrian}"
SRC_URI[x86_64_v2_ghc9.10-hadrian.sha256sum] = "5717fa785e8195355e4a2dd1dbc18d3c470a703e2cfb92cbb104b12b3e70b1d8"

URI_x86_64_v2_ghc9.10-haskeline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-0.8.2.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-haskeline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline}"
SRC_URI[x86_64_v2_ghc9.10-haskeline.sha256sum] = "a630147f45ef180f113804872d5978eb46c853c567dad171cea3cf7e07644034"

URI_x86_64_v2_ghc9.10-haskeline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-devel-0.8.2.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline-devel}"
SRC_URI[x86_64_v2_ghc9.10-haskeline-devel.sha256sum] = "d011541a6385ea9279135d8cc001a10248c224c049d88d086fbb3a1e2004ef6b"

URI_x86_64_v2_ghc9.10-haskeline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-haskeline-doc-0.8.2.1-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-haskeline-doc}"
SRC_URI[x86_64_v2_ghc9.10-haskeline-doc.sha256sum] = "bfb375923cd568871f1d971bd84f3ae496e4a8fd4711f2f6455ec291e2e9f04d"

URI_x86_64_v2_ghc9.10-hpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-0.7.0.2-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc}"
SRC_URI[x86_64_v2_ghc9.10-hpc.sha256sum] = "44db0c8d030ae524bb710da9c71097b9a32e454981c0641ea78cd744fa4c0e9e"

URI_x86_64_v2_ghc9.10-hpc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-devel-0.7.0.2-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc-devel}"
SRC_URI[x86_64_v2_ghc9.10-hpc-devel.sha256sum] = "459fb3be1bbd3dba66b4b658d040ce02807d4f63884d391367de26d329728d21"

URI_x86_64_v2_ghc9.10-hpc-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-hpc-doc-0.7.0.2-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-hpc-doc}"
SRC_URI[x86_64_v2_ghc9.10-hpc-doc.sha256sum] = "4824d1a365b89a688df64fa3b95c7c841b28307102eed024e939f042f46dd238"

URI_x86_64_v2_ghc9.10-manual = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-manual-9.10.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-manual}"
SRC_URI[x86_64_v2_ghc9.10-manual.sha256sum] = "adba969fc243099e3ee1c4c6d93e824ffd5994de209cf32aaca9fbde1b0d722f"

URI_x86_64_v2_ghc9.10-mtl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-2.3.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-mtl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl}"
SRC_URI[x86_64_v2_ghc9.10-mtl.sha256sum] = "43b66c0f3918a84622cbc1616a91703db7b493b98359bed12d4b5651497c5519"

URI_x86_64_v2_ghc9.10-mtl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-devel-2.3.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl-devel}"
SRC_URI[x86_64_v2_ghc9.10-mtl-devel.sha256sum] = "05c3d5c7a5161c460e5a5f0728edb226890785cbfeb3d3a2d9a96e78ae008303"

URI_x86_64_v2_ghc9.10-mtl-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-mtl-doc-2.3.1-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-mtl-doc}"
SRC_URI[x86_64_v2_ghc9.10-mtl-doc.sha256sum] = "85ea2be4c1b2189305bbc1f873a5ea5a52bac5e70cd370a66dc2cdf8f8d829ad"

URI_x86_64_v2_ghc9.10-os-string = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-2.0.7-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-os-string;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string}"
SRC_URI[x86_64_v2_ghc9.10-os-string.sha256sum] = "f35042cee9ace50f1b8a7f65259553c8066ce6338879221a1c835499409c983c"

URI_x86_64_v2_ghc9.10-os-string-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-devel-2.0.7-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string-devel}"
SRC_URI[x86_64_v2_ghc9.10-os-string-devel.sha256sum] = "35433d30740b28580ccb74398b43c4f9e641f28a37b6889e7bf2bd1a611bbeb9"

URI_x86_64_v2_ghc9.10-os-string-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-os-string-doc-2.0.7-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-os-string-doc}"
SRC_URI[x86_64_v2_ghc9.10-os-string-doc.sha256sum] = "d6c56806b7feb479897397b889531f309ba8451583f5cd5c495c402ee8f78dcf"

URI_x86_64_v2_ghc9.10-parsec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-3.1.18.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-parsec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec}"
SRC_URI[x86_64_v2_ghc9.10-parsec.sha256sum] = "80593aeebc5d00042092a841be529c97ab5c01b5e35fcc41d57d191706daee22"

URI_x86_64_v2_ghc9.10-parsec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-devel-3.1.18.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec-devel}"
SRC_URI[x86_64_v2_ghc9.10-parsec-devel.sha256sum] = "1330336eab83894c5e6260ce7b2f0caec9c4d765a8a92cbd95544ea99f563e9c"

URI_x86_64_v2_ghc9.10-parsec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-parsec-doc-3.1.18.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-parsec-doc}"
SRC_URI[x86_64_v2_ghc9.10-parsec-doc.sha256sum] = "673d9cff41c824cb999bbdd333e1b51611b488c9636b791e8be9c415135dbf62"

URI_x86_64_v2_ghc9.10-pretty = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-1.1.3.6-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-pretty;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty}"
SRC_URI[x86_64_v2_ghc9.10-pretty.sha256sum] = "f140ceeaf14e7e427c8c131776f442f31473b2c17bf144e9fdca631ba67e69f1"

URI_x86_64_v2_ghc9.10-pretty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-devel-1.1.3.6-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty-devel}"
SRC_URI[x86_64_v2_ghc9.10-pretty-devel.sha256sum] = "58510bac47dbe720a4c1f102b089ee011e44f5b95f16d4de4b4f64fb573c6cf6"

URI_x86_64_v2_ghc9.10-pretty-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-pretty-doc-1.1.3.6-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-pretty-doc}"
SRC_URI[x86_64_v2_ghc9.10-pretty-doc.sha256sum] = "13bcfe20fb50272bcd75c7a7f47d2e555c762da0955db6a102cd06203d4aff11"

URI_x86_64_v2_ghc9.10-process = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-1.6.26.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process}"
SRC_URI[x86_64_v2_ghc9.10-process.sha256sum] = "7812b349c310a0dd323191487cbe3b416d79f9011d490d5dd152da6cdf3955de"

URI_x86_64_v2_ghc9.10-process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-devel-1.6.26.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process-devel}"
SRC_URI[x86_64_v2_ghc9.10-process-devel.sha256sum] = "898785c0d24d08c04a9bf87254c2c4b2d098c892897883fde711f33729c9ead0"

URI_x86_64_v2_ghc9.10-process-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-process-doc-1.6.26.1-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-process-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-process-doc}"
SRC_URI[x86_64_v2_ghc9.10-process-doc.sha256sum] = "07df444f58226f8490278042042ec221776245331bf02287e77c4d93f36cd863"

URI_x86_64_v2_ghc9.10-semaphore-compat = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-1.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat.sha256sum] = "cdc6074c0542ce7d2c22937133a5e4adbc7cf06c360bb07a83ab61c16a5bebf8"

URI_x86_64_v2_ghc9.10-semaphore-compat-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-devel-1.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat-devel}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat-devel.sha256sum] = "ee5a9c4f6da97e96bb6824bcf386e33a2cf075390e7becc1fcdc0b1c0225fd3b"

URI_x86_64_v2_ghc9.10-semaphore-compat-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-semaphore-compat-doc-1.0.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-semaphore-compat-doc}"
SRC_URI[x86_64_v2_ghc9.10-semaphore-compat-doc.sha256sum] = "53dc68845f2002b0649eedb036c4e90b81ef6f9db5c7c0306a0d787edfbb816b"

URI_x86_64_v2_ghc9.10-stm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-2.5.3.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-stm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm}"
SRC_URI[x86_64_v2_ghc9.10-stm.sha256sum] = "1c39358eb1860c746312259c3e381c7bf1256c9055d5ce96946b55badedb4d1d"

URI_x86_64_v2_ghc9.10-stm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-devel-2.5.3.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-stm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm-devel}"
SRC_URI[x86_64_v2_ghc9.10-stm-devel.sha256sum] = "70181894250699ed4d33394624609547f57d2ab0e3321f5550807c97f77dd264"

URI_x86_64_v2_ghc9.10-stm-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-stm-doc-2.5.3.1-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-stm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-stm-doc}"
SRC_URI[x86_64_v2_ghc9.10-stm-doc.sha256sum] = "f10f16370d8782026d364923998f9ff223e3bb4b4e26afc8eeee9084db830b58"

URI_x86_64_v2_ghc9.10-template-haskell = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-2.22.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-template-haskell;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell.sha256sum] = "9043aa4f4b5cbd662316490a66cbfbdf1cc7d06d3718226c602bd428c34ba21f"

URI_x86_64_v2_ghc9.10-template-haskell-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-devel-2.22.0.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell-devel}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell-devel.sha256sum] = "900091985a3b44233f5a24c0dc6cfd14ab82bbb4938389c76a865d9ffcd5010e"

URI_x86_64_v2_ghc9.10-template-haskell-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-template-haskell-doc-2.22.0.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-template-haskell-doc}"
SRC_URI[x86_64_v2_ghc9.10-template-haskell-doc.sha256sum] = "5d52303e7e96482121c95c4d0a2d0254d670b2049cc563d1deaeb99315807a0a"

URI_x86_64_v2_ghc9.10-terminfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-0.4.1.7-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-terminfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo}"
SRC_URI[x86_64_v2_ghc9.10-terminfo.sha256sum] = "da23fe7cedc18bb912d61d5c8fc4cde716d2d00b4f206466e3f23ec575a6e4a2"

URI_x86_64_v2_ghc9.10-terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-devel-0.4.1.7-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo-devel}"
SRC_URI[x86_64_v2_ghc9.10-terminfo-devel.sha256sum] = "57a34117480ceb9b37e816acddbda708958b883e95ab58fefab92ebc934185e9"

URI_x86_64_v2_ghc9.10-terminfo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-terminfo-doc-0.4.1.7-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-terminfo-doc}"
SRC_URI[x86_64_v2_ghc9.10-terminfo-doc.sha256sum] = "88bbc048ba3f2ff632be5905fc640fee311541940246f8909a15589f5ea4e6ec"

URI_x86_64_v2_ghc9.10-text = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-2.1.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-text;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text}"
SRC_URI[x86_64_v2_ghc9.10-text.sha256sum] = "c02f21dbd76081d3b11fc1b67d3fd369932e00e62214d242c5dac7a05f693e8e"

URI_x86_64_v2_ghc9.10-text-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-devel-2.1.3-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-text-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text-devel}"
SRC_URI[x86_64_v2_ghc9.10-text-devel.sha256sum] = "dd67f528fdb1b25d2ff6a8a2e4e6653c4fcc037798316d15a76e4cd1d0e7a548"

URI_x86_64_v2_ghc9.10-text-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-text-doc-2.1.3-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-text-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-text-doc}"
SRC_URI[x86_64_v2_ghc9.10-text-doc.sha256sum] = "a6733f3db6f3f48cc319fad6bcf65fa5ebe1598567465b3057fe0c28a3151da2"

URI_x86_64_v2_ghc9.10-time = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-1.12.2-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-time;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time}"
SRC_URI[x86_64_v2_ghc9.10-time.sha256sum] = "d26364a1a4936af1bb064057566cf5f5a8af3804e01b3f35635938b53c50103c"

URI_x86_64_v2_ghc9.10-time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-devel-1.12.2-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time-devel}"
SRC_URI[x86_64_v2_ghc9.10-time-devel.sha256sum] = "64a131e2916dd423da295be08c9e1ead228cbd7db0d9e8d092da0673341989cb"

URI_x86_64_v2_ghc9.10-time-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-time-doc-1.12.2-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-time-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-time-doc}"
SRC_URI[x86_64_v2_ghc9.10-time-doc.sha256sum] = "f6828b005e3a8e7c912da9bc8558ebda99402a9ac441e4c6a36a62dda8854dda"

URI_x86_64_v2_ghc9.10-transformers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-0.6.1.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-transformers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers}"
SRC_URI[x86_64_v2_ghc9.10-transformers.sha256sum] = "868fb2359da5cf00957ea49b113e5a9d94a860112c5a64d8963bf406a4839e51"

URI_x86_64_v2_ghc9.10-transformers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-devel-0.6.1.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers-devel}"
SRC_URI[x86_64_v2_ghc9.10-transformers-devel.sha256sum] = "b0824a4aa29833d97a17790654b447071981c991b3e9e227b1445a03487fe4d9"

URI_x86_64_v2_ghc9.10-transformers-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-transformers-doc-0.6.1.1-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-transformers-doc}"
SRC_URI[x86_64_v2_ghc9.10-transformers-doc.sha256sum] = "e56badadaa8b0c9f3ca934a6e8b4bbb91e612b185c57c577e5d857b33f180bde"

URI_x86_64_v2_ghc9.10-unix = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-2.8.7.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-unix;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix}"
SRC_URI[x86_64_v2_ghc9.10-unix.sha256sum] = "a9b5c01e5cd3bbeb693526fbc3fe351e2cb1dd085fed45bd7212e5a9081274cf"

URI_x86_64_v2_ghc9.10-unix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-devel-2.8.7.0-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-unix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix-devel}"
SRC_URI[x86_64_v2_ghc9.10-unix-devel.sha256sum] = "1486d6b0d6863e7b08e6dd31bbab59ebe61f021a672e44a127ee4cf7a53b45e1"

URI_x86_64_v2_ghc9.10-unix-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-unix-doc-2.8.7.0-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-unix-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-unix-doc}"
SRC_URI[x86_64_v2_ghc9.10-unix-doc.sha256sum] = "df234f77da213b79f70b491808a936adb9e62defdaccc849e9e0ff1bd1f83799"

URI_x86_64_v2_ghc9.10-xhtml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-3000.2.2.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-xhtml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml}"
SRC_URI[x86_64_v2_ghc9.10-xhtml.sha256sum] = "73da4f0d769ec2be330bd94fcd82609e2b5a59016b6bcc22adbd36e8d1b9733e"

URI_x86_64_v2_ghc9.10-xhtml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-devel-3000.2.2.1-11.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc9.10-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml-devel}"
SRC_URI[x86_64_v2_ghc9.10-xhtml-devel.sha256sum] = "e25b498ad52fff79f234e108e6c32f5b6ec17510ae03d309f8e2c79a4ab5020d"

URI_x86_64_v2_ghc9.10-xhtml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc9.10-xhtml-doc-3000.2.2.1-11.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_ghc9.10-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc9.10-xhtml-doc}"
SRC_URI[x86_64_v2_ghc9.10-xhtml-doc.sha256sum] = "c6abbcdb1ce28c948f58e768f0573bae29ae1357c15a34f0268e41cf084a6fac"

URI_aarch64_ghc9.10 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10}"
SRC_URI[aarch64_ghc9.10.sha256sum] = "69fcf4c8a526e9e238a7adc0751ea5a2870437018473a687550941332db0ee45"

URI_aarch64_ghc9.10-Cabal = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-3.12.1.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-Cabal;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal}"
SRC_URI[aarch64_ghc9.10-Cabal.sha256sum] = "89219bb67e12d1ea68914914f767d239c0e83082c14f015bd51789b762d3b1ca"

URI_aarch64_ghc9.10-Cabal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-devel-3.12.1.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-Cabal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-devel}"
SRC_URI[aarch64_ghc9.10-Cabal-devel.sha256sum] = "1866c91f4e5c978df91e67a873278a7ea046aa284a17bf2dd04c849e82ce743a"

URI_aarch64_ghc9.10-Cabal-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-doc-3.12.1.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-Cabal-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-doc}"
SRC_URI[aarch64_ghc9.10-Cabal-doc.sha256sum] = "1b0da0dc3e395321b6d41e6989785a52a2299e624d7b82ad84c292b47c1990bf"

URI_aarch64_ghc9.10-Cabal-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-prof-3.12.1.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-Cabal-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-prof}"
SRC_URI[aarch64_ghc9.10-Cabal-prof.sha256sum] = "327cd730f008f060ee3fb9dab06d61412b8ecc96afdd0607e4b2fc294fd16894"

URI_aarch64_ghc9.10-Cabal-syntax = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-3.12.1.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-Cabal-syntax;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax.sha256sum] = "4981d32dac7ac78ea2613a5b013ca8e078f815e59371e4c61441a3d84839ca6c"

URI_aarch64_ghc9.10-Cabal-syntax-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-devel-3.12.1.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-Cabal-syntax-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax-devel}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax-devel.sha256sum] = "6f637d261aa30e4fe566b12325fae3bac9c87854a827a4fb2364f43cbc1bd94e"

URI_aarch64_ghc9.10-Cabal-syntax-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-doc-3.12.1.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-Cabal-syntax-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax-doc}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax-doc.sha256sum] = "9bdb37bf5fff9c03ade7ebab528c82abd65ff6fc58b7c9b2398024b54be24dd6"

URI_aarch64_ghc9.10-Cabal-syntax-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-Cabal-syntax-prof-3.12.1.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-Cabal-syntax-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-Cabal-syntax-prof}"
SRC_URI[aarch64_ghc9.10-Cabal-syntax-prof.sha256sum] = "4266d297363fe0743df3a25bd42367704c05badde3a10383388764bf82077037"

URI_aarch64_ghc9.10-array = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-0.5.8.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-array;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array}"
SRC_URI[aarch64_ghc9.10-array.sha256sum] = "44598cc96c8923a14421a21ec418a6772dfeaffdfd961dbebd7dc37e70494ebd"

URI_aarch64_ghc9.10-array-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-devel-0.5.8.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-array-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array-devel}"
SRC_URI[aarch64_ghc9.10-array-devel.sha256sum] = "fe55cafaea8822f51c65747f7137f9f6c65951348195e7667f4c9d836cb2c1a8"

URI_aarch64_ghc9.10-array-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-doc-0.5.8.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-array-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array-doc}"
SRC_URI[aarch64_ghc9.10-array-doc.sha256sum] = "a48a75d3e921eaacdee858ede6c1aeaecb99fb70889752265ac529ddd1934c03"

URI_aarch64_ghc9.10-array-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-array-prof-0.5.8.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-array-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-array-prof}"
SRC_URI[aarch64_ghc9.10-array-prof.sha256sum] = "b9e69f8fee3eaa4d5a62fea94ce96a284fda2b92681be5a6e69636bbd24ef6d2"

URI_aarch64_ghc9.10-base = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-4.20.2.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-base;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base}"
SRC_URI[aarch64_ghc9.10-base.sha256sum] = "7de052c0484198bd36e599c666a34e4281b7e10c9409bd8a4c1b613030e4a392"

URI_aarch64_ghc9.10-base-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-devel-4.20.2.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-base-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base-devel}"
SRC_URI[aarch64_ghc9.10-base-devel.sha256sum] = "31779d2dad4ae9763a3d64f210c4ae9afcd0cf8f6702f0930585bee3d5b0c9fa"

URI_aarch64_ghc9.10-base-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-doc-4.20.2.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-base-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base-doc}"
SRC_URI[aarch64_ghc9.10-base-doc.sha256sum] = "c95f9504da0a5fbae5aebe75ef39d7f574abb857c1d2299247cfa555a0db1b8d"

URI_aarch64_ghc9.10-base-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-base-prof-4.20.2.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-base-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-base-prof}"
SRC_URI[aarch64_ghc9.10-base-prof.sha256sum] = "bbdf3e4cd7bf4c4f2a39c115f730791a93da2c2851481c394a4103365231b942"

URI_aarch64_ghc9.10-binary = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-0.8.9.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-binary;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary}"
SRC_URI[aarch64_ghc9.10-binary.sha256sum] = "138e6e9e552802fe5718f24e7143c79342e95a6427eed6c7d6b15e4ccb71a702"

URI_aarch64_ghc9.10-binary-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-devel-0.8.9.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-binary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary-devel}"
SRC_URI[aarch64_ghc9.10-binary-devel.sha256sum] = "8c4d4f1851e182e6682201563071659e90ee5790482d70716b68066e8490f2be"

URI_aarch64_ghc9.10-binary-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-doc-0.8.9.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-binary-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary-doc}"
SRC_URI[aarch64_ghc9.10-binary-doc.sha256sum] = "9aed652afee2458937a8308be46ed6b1e4e3c2eac249ade44263b2b17785a4ae"

URI_aarch64_ghc9.10-binary-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-binary-prof-0.8.9.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-binary-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-binary-prof}"
SRC_URI[aarch64_ghc9.10-binary-prof.sha256sum] = "55b671aaf0ee62301f1e2ffd9aaf78531bf64a80acfb622d0e10cd801ec001ae"

URI_aarch64_ghc9.10-bytestring = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-0.12.2.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-bytestring;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring}"
SRC_URI[aarch64_ghc9.10-bytestring.sha256sum] = "70708b49a419bf1fe0912ec737ad860fa1a53879833ebc87ef8a84f2892436e3"

URI_aarch64_ghc9.10-bytestring-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-devel-0.12.2.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-bytestring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring-devel}"
SRC_URI[aarch64_ghc9.10-bytestring-devel.sha256sum] = "62161a0be1b56385547b3a2ea50a6f95ccff3c085d3f608e60c915e7271fd67b"

URI_aarch64_ghc9.10-bytestring-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-doc-0.12.2.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-bytestring-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring-doc}"
SRC_URI[aarch64_ghc9.10-bytestring-doc.sha256sum] = "7388a4eb2630af68ebb959a2837e953c13b00c63f63885bba740367bd13cdb21"

URI_aarch64_ghc9.10-bytestring-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-bytestring-prof-0.12.2.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-bytestring-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-bytestring-prof}"
SRC_URI[aarch64_ghc9.10-bytestring-prof.sha256sum] = "b86cc304f4430396be9bc42fd2c2ebc446e83c1e6a10416a208b5cef2c16f21e"

URI_aarch64_ghc9.10-compiler = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-compiler-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-compiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-compiler}"
SRC_URI[aarch64_ghc9.10-compiler.sha256sum] = "9c0e360275e06b528eeee9c4b824b06c7b6d6a6675d86a6b2e888c20157d4dee"

URI_aarch64_ghc9.10-compiler-default = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-compiler-default-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-compiler-default;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-compiler-default}"
SRC_URI[aarch64_ghc9.10-compiler-default.sha256sum] = "7c85b9f58ea5212f876d5628c367186956916f9d888e51f37ce6126f24baa7f4"

URI_aarch64_ghc9.10-containers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-0.7-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-containers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers}"
SRC_URI[aarch64_ghc9.10-containers.sha256sum] = "d10e8da5f306f1b463db295572a815d08ab134fc17c5e0a786dd3453e94750a5"

URI_aarch64_ghc9.10-containers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-devel-0.7-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-containers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers-devel}"
SRC_URI[aarch64_ghc9.10-containers-devel.sha256sum] = "4efb58bdf01ee529b0fcd1c6d634943fa7741d172ccb5ea88883892661978af6"

URI_aarch64_ghc9.10-containers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-doc-0.7-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-containers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers-doc}"
SRC_URI[aarch64_ghc9.10-containers-doc.sha256sum] = "a8d968eb2c8dc1f755045b073524dc0aeb7315c7d3948ec72362aea3108ff5b0"

URI_aarch64_ghc9.10-containers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-containers-prof-0.7-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-containers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-containers-prof}"
SRC_URI[aarch64_ghc9.10-containers-prof.sha256sum] = "59bdfd32ffcac234cbb8429b3d20662229531805d5dca022758c167478170ae0"

URI_aarch64_ghc9.10-deepseq = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-1.5.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-deepseq;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq}"
SRC_URI[aarch64_ghc9.10-deepseq.sha256sum] = "c3538b6dad958ced8142c62ef4b197eeed43ef3832da888f68c12935fb13c169"

URI_aarch64_ghc9.10-deepseq-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-devel-1.5.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-deepseq-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq-devel}"
SRC_URI[aarch64_ghc9.10-deepseq-devel.sha256sum] = "2a56cbf72b2accd1e9ee765780fd456eb3e521c93d2dfebc14543291315a9be9"

URI_aarch64_ghc9.10-deepseq-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-doc-1.5.0.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-deepseq-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq-doc}"
SRC_URI[aarch64_ghc9.10-deepseq-doc.sha256sum] = "d165c158f6f25488077196ed0be6dca9eaecfd0005974f88ab690909c3d07a9a"

URI_aarch64_ghc9.10-deepseq-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-deepseq-prof-1.5.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-deepseq-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-deepseq-prof}"
SRC_URI[aarch64_ghc9.10-deepseq-prof.sha256sum] = "d44467145e5b16a093e0a3b1a870f813ceadbaaff6d38d2009b58962dab8e430"

URI_aarch64_ghc9.10-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-devel-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-devel}"
SRC_URI[aarch64_ghc9.10-devel.sha256sum] = "8107677735bbbb6e367d4bcd2e9c6b27df1e6cb6178c3377e8b3767516aac53e"

URI_aarch64_ghc9.10-directory = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-1.3.8.5-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-directory;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory}"
SRC_URI[aarch64_ghc9.10-directory.sha256sum] = "7694bb3f41705394c7378126553abb192eb52dba9472aa6a2a3c0a75662db35b"

URI_aarch64_ghc9.10-directory-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-devel-1.3.8.5-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory-devel}"
SRC_URI[aarch64_ghc9.10-directory-devel.sha256sum] = "a08517b1c24af9bab81870a1db36e9d8a19d22f787719f822b863f517cfb1515"

URI_aarch64_ghc9.10-directory-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-doc-1.3.8.5-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-directory-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory-doc}"
SRC_URI[aarch64_ghc9.10-directory-doc.sha256sum] = "8768683253044265b6f4545d85609b5588eb42c96cd77f386c0ccdf0c32557c0"

URI_aarch64_ghc9.10-directory-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-directory-prof-1.3.8.5-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-directory-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-directory-prof}"
SRC_URI[aarch64_ghc9.10-directory-prof.sha256sum] = "4ad54367bccecda6dfcd5ba0da976ede07d0310f45b00c92365b02f75e2060f8"

URI_aarch64_ghc9.10-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-doc-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-doc}"
SRC_URI[aarch64_ghc9.10-doc.sha256sum] = "cf5867f2e0bea76f905d75ee8db0fe291328add31d292e7b5b482d48005e1336"

URI_aarch64_ghc9.10-doc-index = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-doc-index-9.10.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-doc-index;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-doc-index}"
SRC_URI[aarch64_ghc9.10-doc-index.sha256sum] = "4fdaa0a4b61d190bc4965c58d3d5b192f8c2dabf8b7cb5261bc44418d2a4861a"

URI_aarch64_ghc9.10-exceptions = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-0.10.9-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-exceptions;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions}"
SRC_URI[aarch64_ghc9.10-exceptions.sha256sum] = "1919f26727d8d757cf8122806082fdb637b512ae97d252ac4bda0d5331de7f58"

URI_aarch64_ghc9.10-exceptions-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-devel-0.10.9-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-exceptions-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions-devel}"
SRC_URI[aarch64_ghc9.10-exceptions-devel.sha256sum] = "608b95e71516e6aeb6a3ebb89e556d13b1181178db5d96011120b89a175d259d"

URI_aarch64_ghc9.10-exceptions-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-doc-0.10.9-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-exceptions-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions-doc}"
SRC_URI[aarch64_ghc9.10-exceptions-doc.sha256sum] = "df9ecd0831659efea09d1622aba4b3abe2eeebcd81ad952aaf9eeea4ec03b030"

URI_aarch64_ghc9.10-exceptions-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-exceptions-prof-0.10.9-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-exceptions-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-exceptions-prof}"
SRC_URI[aarch64_ghc9.10-exceptions-prof.sha256sum] = "3fe976c1df96623a8085c734db5cf10ff2983982bf2f9f2fe07f1a13f0ed4f59"

URI_aarch64_ghc9.10-filepath = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-1.5.4.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-filepath;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath}"
SRC_URI[aarch64_ghc9.10-filepath.sha256sum] = "74c170bd19e92799c79694f3d3bc8cb0ad7baab47f7996ce3968bbfaaf8c317b"

URI_aarch64_ghc9.10-filepath-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-devel-1.5.4.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-filepath-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath-devel}"
SRC_URI[aarch64_ghc9.10-filepath-devel.sha256sum] = "5d563e3e449f93e4e9d425e22ad2162c1d81936b287a13d1b99d00cf7bd26039"

URI_aarch64_ghc9.10-filepath-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-doc-1.5.4.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-filepath-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath-doc}"
SRC_URI[aarch64_ghc9.10-filepath-doc.sha256sum] = "1300fc9ae7d0b94c031da2098423786b193decdafd48b00ff8a107674a178483"

URI_aarch64_ghc9.10-filepath-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filepath-prof-1.5.4.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-filepath-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filepath-prof}"
SRC_URI[aarch64_ghc9.10-filepath-prof.sha256sum] = "70fcc53d09648a2bd01cf9ed5e22fbf5f9e6d15dfbe1a38a644c1ec15ac647ab"

URI_aarch64_ghc9.10-filesystem = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-filesystem-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-filesystem;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-filesystem}"
SRC_URI[aarch64_ghc9.10-filesystem.sha256sum] = "3bc7bd44bc2ea17794302ba232696ee96fbabc3f8eb313370adcdfcc26fb066a"

URI_aarch64_ghc9.10-ghc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc}"
SRC_URI[aarch64_ghc9.10-ghc.sha256sum] = "19ca1ed10f2875d03aa51fe12c78c9863753bc2e22dde0c335f64892cd335b5c"

URI_aarch64_ghc9.10-ghc-bignum = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-1.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-bignum;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum}"
SRC_URI[aarch64_ghc9.10-ghc-bignum.sha256sum] = "2d7abac274ea79b1c6ffe77625b15abd17198e8697d1daf61caa309dfbfe965e"

URI_aarch64_ghc9.10-ghc-bignum-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-devel-1.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-bignum-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum-devel}"
SRC_URI[aarch64_ghc9.10-ghc-bignum-devel.sha256sum] = "45f9329e398bc06852b4f5767c82c23122f47e52600a7625d5a8688bd1420418"

URI_aarch64_ghc9.10-ghc-bignum-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-doc-1.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghc-bignum-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum-doc}"
SRC_URI[aarch64_ghc9.10-ghc-bignum-doc.sha256sum] = "4e8e7c43aa3a2b29d1d12794499ca588913144ccf60b255051d7b4c7ac71151f"

URI_aarch64_ghc9.10-ghc-bignum-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-bignum-prof-1.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-bignum-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-bignum-prof}"
SRC_URI[aarch64_ghc9.10-ghc-bignum-prof.sha256sum] = "53a85272bf6ffbfe4059c4c5b695bf7bad8367bf68a6413f383edf811337ea8b"

URI_aarch64_ghc9.10-ghc-boot = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot}"
SRC_URI[aarch64_ghc9.10-ghc-boot.sha256sum] = "85fcfe1e9608bbe71843aee410703e36d5936acc7f74ec33adacb959253482bf"

URI_aarch64_ghc9.10-ghc-boot-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-devel-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-devel}"
SRC_URI[aarch64_ghc9.10-ghc-boot-devel.sha256sum] = "6a5eafef3bc081c3ff32a762dc4fb2720f8af371c88dc14d04ebebffde178cd2"

URI_aarch64_ghc9.10-ghc-boot-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-doc-9.10.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghc-boot-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-doc}"
SRC_URI[aarch64_ghc9.10-ghc-boot-doc.sha256sum] = "1dc3e986ccc3af02e12364e25b60e710b10bd9e3e9e9f1517d5d07ca11cb9c46"

URI_aarch64_ghc9.10-ghc-boot-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-prof-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-prof}"
SRC_URI[aarch64_ghc9.10-ghc-boot-prof.sha256sum] = "599b5fa7b00fc97f22748614036d2c359a68c9a8b79ebb5e194657ae0abf50c6"

URI_aarch64_ghc9.10-ghc-boot-th = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-th;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th.sha256sum] = "adae351eb4f4a49dbe5b46c347f29a003af6b93d246fcf8c95dd380fc9704710"

URI_aarch64_ghc9.10-ghc-boot-th-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-devel-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-th-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th-devel}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th-devel.sha256sum] = "326f64b661b87a4b0cde9556bf46e985c5a2d9fb3c87e6adbdffbeda425fa903"

URI_aarch64_ghc9.10-ghc-boot-th-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-doc-9.10.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghc-boot-th-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th-doc}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th-doc.sha256sum] = "5bab3846bfa7092c090ce54ecc22369a469d83c54a79b73584fa5e84017289f6"

URI_aarch64_ghc9.10-ghc-boot-th-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-boot-th-prof-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-boot-th-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-boot-th-prof}"
SRC_URI[aarch64_ghc9.10-ghc-boot-th-prof.sha256sum] = "08fbff0d2114719d3bbf9b80be88c2d3e6037c6f0026be83f17f938df6a4cc66"

URI_aarch64_ghc9.10-ghc-compact = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-compact;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact}"
SRC_URI[aarch64_ghc9.10-ghc-compact.sha256sum] = "6a6b3afd0f8b1edf51bdbc849e40d343cd8bc41e04e3d9e3029156d106fcb831"

URI_aarch64_ghc9.10-ghc-compact-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-devel-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-compact-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact-devel}"
SRC_URI[aarch64_ghc9.10-ghc-compact-devel.sha256sum] = "e413d364bef5453c9529c271b59d1588f9e3675355b955b85ef7b6540b1dc569"

URI_aarch64_ghc9.10-ghc-compact-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-doc-0.1.0.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghc-compact-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact-doc}"
SRC_URI[aarch64_ghc9.10-ghc-compact-doc.sha256sum] = "68d71a8d359ea55b923b0fc48b3abe03d9c5deec50c053e69ae4bbead8fe0669"

URI_aarch64_ghc9.10-ghc-compact-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-compact-prof-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-compact-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-compact-prof}"
SRC_URI[aarch64_ghc9.10-ghc-compact-prof.sha256sum] = "efa3c518fe474ed7902d4fe626b6bde79b5ea22041d1c0a417c2595ebc3025ef"

URI_aarch64_ghc9.10-ghc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-devel-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-devel}"
SRC_URI[aarch64_ghc9.10-ghc-devel.sha256sum] = "8abcf6377259653193098ba3a6785824f6ffc2d60869d4c13e7d20e0f79ddf4d"

URI_aarch64_ghc9.10-ghc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-doc-9.10.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-doc}"
SRC_URI[aarch64_ghc9.10-ghc-doc.sha256sum] = "6b78fc1a92a3eeff053e44847119cef0a2fcaa155553987374411df121530318"

URI_aarch64_ghc9.10-ghc-experimental = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-9.1003.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-experimental;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental}"
SRC_URI[aarch64_ghc9.10-ghc-experimental.sha256sum] = "3204a832a9e58d6bf1d442b654cc802d48f85acf120c004e068f00d609569156"

URI_aarch64_ghc9.10-ghc-experimental-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-devel-9.1003.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-experimental-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental-devel}"
SRC_URI[aarch64_ghc9.10-ghc-experimental-devel.sha256sum] = "b4dc42aa2eb36825c655aab3fd3c4bcc205728acc3014f500136f48905751ff5"

URI_aarch64_ghc9.10-ghc-experimental-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-doc-9.1003.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghc-experimental-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental-doc}"
SRC_URI[aarch64_ghc9.10-ghc-experimental-doc.sha256sum] = "441d83433560b56048accb460de9014b86fea75bc6375e619a24063b21457e99"

URI_aarch64_ghc9.10-ghc-experimental-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-experimental-prof-9.1003.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-experimental-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-experimental-prof}"
SRC_URI[aarch64_ghc9.10-ghc-experimental-prof.sha256sum] = "80c05e654b2040a5518aefab692d3ffb4462d12f1329fde2a15a749bf46486f9"

URI_aarch64_ghc9.10-ghc-heap = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-heap;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap}"
SRC_URI[aarch64_ghc9.10-ghc-heap.sha256sum] = "781e35b5b000d44668a5812ae9b0f00be4a0eb67ac36fd2828b98d5d41c14d2f"

URI_aarch64_ghc9.10-ghc-heap-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-devel-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-heap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap-devel}"
SRC_URI[aarch64_ghc9.10-ghc-heap-devel.sha256sum] = "9b531d18684acfcf2fc0a39d081b202d021e676163c9a108d6a6585d16c1794a"

URI_aarch64_ghc9.10-ghc-heap-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-doc-9.10.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghc-heap-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap-doc}"
SRC_URI[aarch64_ghc9.10-ghc-heap-doc.sha256sum] = "98bf11a42b18772561392260bb8aab417a6689eef51fab02b382ea86654c4858"

URI_aarch64_ghc9.10-ghc-heap-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-heap-prof-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-heap-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-heap-prof}"
SRC_URI[aarch64_ghc9.10-ghc-heap-prof.sha256sum] = "2331a11813c7db93504806d282a70ef859b3f3208da9484816c2a0c1b04be033"

URI_aarch64_ghc9.10-ghc-platform = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-platform;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform}"
SRC_URI[aarch64_ghc9.10-ghc-platform.sha256sum] = "debdf927f81bedb8dcb11217cffa31aa591fc2f3c7566f3e77457233099eb5c6"

URI_aarch64_ghc9.10-ghc-platform-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-devel-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-platform-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform-devel}"
SRC_URI[aarch64_ghc9.10-ghc-platform-devel.sha256sum] = "9663f6d90074a5d5fed5944eb0c7bff6b2bd4064f46f308914096f9aaa95eb71"

URI_aarch64_ghc9.10-ghc-platform-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-doc-0.1.0.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghc-platform-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform-doc}"
SRC_URI[aarch64_ghc9.10-ghc-platform-doc.sha256sum] = "f2aaba75bc175d4fc5d4201354a5a3f149efb7cc9e596216e4bf397943cff598"

URI_aarch64_ghc9.10-ghc-platform-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-platform-prof-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-platform-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-platform-prof}"
SRC_URI[aarch64_ghc9.10-ghc-platform-prof.sha256sum] = "2ec4488ed8735482038b68e530a314318de6e7fdf8e80689a19e70199ad8f8c6"

URI_aarch64_ghc9.10-ghc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-prof-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-prof}"
SRC_URI[aarch64_ghc9.10-ghc-prof.sha256sum] = "f1a2823102d8cdb0db25d0a8319c5e9ae6e462a537c8b5216d5f9b0559f19f5f"

URI_aarch64_ghc9.10-ghc-toolchain = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-toolchain;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain.sha256sum] = "fbe8c5df8a59a435d59d4960556c5a3b725d314b5662474acc99c87c36849a76"

URI_aarch64_ghc9.10-ghc-toolchain-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-devel-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-toolchain-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain-devel}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain-devel.sha256sum] = "ca9de9c2521b3b909e4bfc725f89f1566b19afdb815fbf721f84a92228999b8f"

URI_aarch64_ghc9.10-ghc-toolchain-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-doc-0.1.0.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghc-toolchain-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain-doc}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain-doc.sha256sum] = "21d8e917a7a8b459e9d5ef5ce293dd19cb2917d341fe03d346b8c5e3dd46ae77"

URI_aarch64_ghc9.10-ghc-toolchain-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghc-toolchain-prof-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghc-toolchain-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghc-toolchain-prof}"
SRC_URI[aarch64_ghc9.10-ghc-toolchain-prof.sha256sum] = "3e949b2adc05bbe148a30d96a23fa9500b01fa766370eaa5c38f4dec9086ca01"

URI_aarch64_ghc9.10-ghci = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghci;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci}"
SRC_URI[aarch64_ghc9.10-ghci.sha256sum] = "e4e204c2d7ac1d7dcb0b858badb402891574459d55cb921dd0553aed0b95ff2e"

URI_aarch64_ghc9.10-ghci-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-devel-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghci-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci-devel}"
SRC_URI[aarch64_ghc9.10-ghci-devel.sha256sum] = "b3212a3954986670636e8cff994e9f394e8d7f1e85ab83b4017d59dae7f59f41"

URI_aarch64_ghc9.10-ghci-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-doc-9.10.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-ghci-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci-doc}"
SRC_URI[aarch64_ghc9.10-ghci-doc.sha256sum] = "fccb1d4d0ce6c7bd978ca5f4355c2d6050740a824e8d289c5099cd6dc95c338f"

URI_aarch64_ghc9.10-ghci-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-ghci-prof-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-ghci-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-ghci-prof}"
SRC_URI[aarch64_ghc9.10-ghci-prof.sha256sum] = "74f7bbf03bf9cc87b60af05948bd62bebd1bad87c0fdd41b4f8fc4b260288712"

URI_aarch64_ghc9.10-hadrian = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hadrian-0.1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-hadrian;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hadrian}"
SRC_URI[aarch64_ghc9.10-hadrian.sha256sum] = "4f7f486bb4a46d206d6cb3558d8d577abfdab811736f2257a6dc7edc420d18e0"

URI_aarch64_ghc9.10-haskeline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-0.8.2.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-haskeline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline}"
SRC_URI[aarch64_ghc9.10-haskeline.sha256sum] = "4c8b8e116bf47c384827752250075d4da8e82c544ca83337ca04c9c865de2271"

URI_aarch64_ghc9.10-haskeline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-devel-0.8.2.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-haskeline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline-devel}"
SRC_URI[aarch64_ghc9.10-haskeline-devel.sha256sum] = "e687fdb7ed9d878266480608207004714e53f8e66ecce27bd6cef702026f1058"

URI_aarch64_ghc9.10-haskeline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-doc-0.8.2.1-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-haskeline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline-doc}"
SRC_URI[aarch64_ghc9.10-haskeline-doc.sha256sum] = "e2895d0a3029621c2537a792eb4ce75dbea64ec5aeb145778985fe34731bde2f"

URI_aarch64_ghc9.10-haskeline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-haskeline-prof-0.8.2.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-haskeline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-haskeline-prof}"
SRC_URI[aarch64_ghc9.10-haskeline-prof.sha256sum] = "e879bfbc2bb0fb7430d8ced7e95e2e073d4d4e48ba4b566c6608b42bb3490717"

URI_aarch64_ghc9.10-hpc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-0.7.0.2-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-hpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc}"
SRC_URI[aarch64_ghc9.10-hpc.sha256sum] = "e332b0bec9622dda44f14fee21951a3c0b480ca995c0490ef721f17222958757"

URI_aarch64_ghc9.10-hpc-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-devel-0.7.0.2-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-hpc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc-devel}"
SRC_URI[aarch64_ghc9.10-hpc-devel.sha256sum] = "ce012641cc0d9b58a88577154831388558825aaa90002990d896fabe1ee951d7"

URI_aarch64_ghc9.10-hpc-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-doc-0.7.0.2-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-hpc-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc-doc}"
SRC_URI[aarch64_ghc9.10-hpc-doc.sha256sum] = "13261b8bbc37c8f314010e66a0825d176b04ee47784c4633882df709447024e1"

URI_aarch64_ghc9.10-hpc-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-hpc-prof-0.7.0.2-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-hpc-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-hpc-prof}"
SRC_URI[aarch64_ghc9.10-hpc-prof.sha256sum] = "66de3bfd7dd7fa3859a5c93d1330fbead28cec3a5f8ce6cc4710f89a3c1e3464"

URI_aarch64_ghc9.10-manual = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-manual-9.10.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-manual}"
SRC_URI[aarch64_ghc9.10-manual.sha256sum] = "a197002689712900595244e6bc71a47a32bd73a3711085ebad3c97c90da94dcd"

URI_aarch64_ghc9.10-mtl = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-2.3.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-mtl;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl}"
SRC_URI[aarch64_ghc9.10-mtl.sha256sum] = "3aebe40d1cfac3618abe0ca01bd937e3fca8ade9abb032eebb8dd973464e77fb"

URI_aarch64_ghc9.10-mtl-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-devel-2.3.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-mtl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl-devel}"
SRC_URI[aarch64_ghc9.10-mtl-devel.sha256sum] = "a232656e1f65f7f8969148d37054f8c2e43e6936705b4000841cd77e3aaefe2e"

URI_aarch64_ghc9.10-mtl-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-doc-2.3.1-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-mtl-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl-doc}"
SRC_URI[aarch64_ghc9.10-mtl-doc.sha256sum] = "ab6dc219da6c4fad7cd97132a8c5cbb9362c1bb48236eedb9b626f96055a0116"

URI_aarch64_ghc9.10-mtl-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-mtl-prof-2.3.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-mtl-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-mtl-prof}"
SRC_URI[aarch64_ghc9.10-mtl-prof.sha256sum] = "f825a4a406f597675efdec5a89012980e1ae86f7a62b03a895574b922bda4e39"

URI_aarch64_ghc9.10-os-string = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-2.0.7-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-os-string;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string}"
SRC_URI[aarch64_ghc9.10-os-string.sha256sum] = "9fa04c5c6b319546e1a296c8e006b22283ba76e3c5a17257166746fb2f52acd6"

URI_aarch64_ghc9.10-os-string-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-devel-2.0.7-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-os-string-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string-devel}"
SRC_URI[aarch64_ghc9.10-os-string-devel.sha256sum] = "10f81e19d701f88009c2297be9408e56aa8eeb8899163d96baaf62711f5df941"

URI_aarch64_ghc9.10-os-string-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-doc-2.0.7-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-os-string-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string-doc}"
SRC_URI[aarch64_ghc9.10-os-string-doc.sha256sum] = "a3af785efe15358f5cb8d55bdf4c234be23c86e80d27eaf79d9ee95d5b4598ba"

URI_aarch64_ghc9.10-os-string-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-os-string-prof-2.0.7-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-os-string-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-os-string-prof}"
SRC_URI[aarch64_ghc9.10-os-string-prof.sha256sum] = "43fef614e1891abfae0b935e4e258675d43d19ff59065c71e187929078ecaf0c"

URI_aarch64_ghc9.10-parsec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-3.1.18.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-parsec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec}"
SRC_URI[aarch64_ghc9.10-parsec.sha256sum] = "19fbf5d8920dc25870c2afe459f59831ee3e109ca252501fb30ae3969e9552ac"

URI_aarch64_ghc9.10-parsec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-devel-3.1.18.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-parsec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec-devel}"
SRC_URI[aarch64_ghc9.10-parsec-devel.sha256sum] = "01afb3de6a749ee6fc539693739c0bb39955a32eca8928b230d0fbbf649c2c02"

URI_aarch64_ghc9.10-parsec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-doc-3.1.18.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-parsec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec-doc}"
SRC_URI[aarch64_ghc9.10-parsec-doc.sha256sum] = "da4f7677527d83953269718eeb581bb1e70185eb7096dd27f8864bff08d6eac2"

URI_aarch64_ghc9.10-parsec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-parsec-prof-3.1.18.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-parsec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-parsec-prof}"
SRC_URI[aarch64_ghc9.10-parsec-prof.sha256sum] = "a03388fe5bcb8034e86a90fd1d0398526c302f3819dab45db87b226647d400e7"

URI_aarch64_ghc9.10-pretty = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-1.1.3.6-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-pretty;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty}"
SRC_URI[aarch64_ghc9.10-pretty.sha256sum] = "9c79c83c825755111df446063d84e46f4f4913792b441036f6e18eccaef31284"

URI_aarch64_ghc9.10-pretty-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-devel-1.1.3.6-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-pretty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty-devel}"
SRC_URI[aarch64_ghc9.10-pretty-devel.sha256sum] = "c69a56cdc13940111c2bf02f6cee7beca12529abbf8b5b33b06d9d6b27b7c56b"

URI_aarch64_ghc9.10-pretty-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-doc-1.1.3.6-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-pretty-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty-doc}"
SRC_URI[aarch64_ghc9.10-pretty-doc.sha256sum] = "2afd1ec28459d535b519f4c23b4a9f9e8967f87d1d3aa0092147d8ab5c3fa508"

URI_aarch64_ghc9.10-pretty-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-pretty-prof-1.1.3.6-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-pretty-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-pretty-prof}"
SRC_URI[aarch64_ghc9.10-pretty-prof.sha256sum] = "84b3547083dacf6f725dc0d6f8706622f733f3e50f0b9bcaec670f9529a088c8"

URI_aarch64_ghc9.10-process = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-1.6.26.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process}"
SRC_URI[aarch64_ghc9.10-process.sha256sum] = "c449e5f5aa60a69584b91bceb2951e80089c06f46d3c1fc38d71d6bb5b592c8d"

URI_aarch64_ghc9.10-process-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-devel-1.6.26.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process-devel}"
SRC_URI[aarch64_ghc9.10-process-devel.sha256sum] = "bdb5b5782b358fff446d19bb4c53da76ca694f6ef39e1f3989f708e92554b114"

URI_aarch64_ghc9.10-process-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-doc-1.6.26.1-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-process-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process-doc}"
SRC_URI[aarch64_ghc9.10-process-doc.sha256sum] = "6359dc3574e530eb655aed221e7bb1e3702aa6bc17843ef95559daa5df682e2f"

URI_aarch64_ghc9.10-process-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-process-prof-1.6.26.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-process-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-process-prof}"
SRC_URI[aarch64_ghc9.10-process-prof.sha256sum] = "a9528c79625a7f5f9cdc1906b56cef6c5c8d18c31c1a7a75eab9bd9038f8771e"

URI_aarch64_ghc9.10-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-prof-9.10.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-prof}"
SRC_URI[aarch64_ghc9.10-prof.sha256sum] = "90df6ea8f6ef87aaa9d3fb93f53be51117c4c9f15295e9bff1c09c87db30a323"

URI_aarch64_ghc9.10-semaphore-compat = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-semaphore-compat;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat}"
SRC_URI[aarch64_ghc9.10-semaphore-compat.sha256sum] = "582243781591ea95f55720257721668b55e284c44c201075e2c87ff6eff67dcc"

URI_aarch64_ghc9.10-semaphore-compat-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-devel-1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-semaphore-compat-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat-devel}"
SRC_URI[aarch64_ghc9.10-semaphore-compat-devel.sha256sum] = "76a45b03649912e2261551cd0724efca31f4e77ba114efe948bba678564e6172"

URI_aarch64_ghc9.10-semaphore-compat-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-doc-1.0.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-semaphore-compat-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat-doc}"
SRC_URI[aarch64_ghc9.10-semaphore-compat-doc.sha256sum] = "ff9a1991dad002d1ac9ff04dac4f0e7b8a861e2cac5e68bff530df4973c50e26"

URI_aarch64_ghc9.10-semaphore-compat-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-semaphore-compat-prof-1.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-semaphore-compat-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-semaphore-compat-prof}"
SRC_URI[aarch64_ghc9.10-semaphore-compat-prof.sha256sum] = "2c4bf91a8371bc25fbf0eac7697a93814326ccc02c73ceccf64debc01c3e9e3f"

URI_aarch64_ghc9.10-stm = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-2.5.3.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-stm;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm}"
SRC_URI[aarch64_ghc9.10-stm.sha256sum] = "7677a01a0e92c6cade0bd9da7d864cd4c723058020aa02d7747e8f4acf11bd1b"

URI_aarch64_ghc9.10-stm-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-devel-2.5.3.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-stm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm-devel}"
SRC_URI[aarch64_ghc9.10-stm-devel.sha256sum] = "ecc920b275f0416a8569018d4331c8cbc0d3a40bcd629dac8d57487017e7b12c"

URI_aarch64_ghc9.10-stm-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-doc-2.5.3.1-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-stm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm-doc}"
SRC_URI[aarch64_ghc9.10-stm-doc.sha256sum] = "2a73e671343790b0291d3eefcfb924dfe16fd85be59758fbff06efe9b0508c0f"

URI_aarch64_ghc9.10-stm-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-stm-prof-2.5.3.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-stm-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-stm-prof}"
SRC_URI[aarch64_ghc9.10-stm-prof.sha256sum] = "31b4c84ca0aa42c983400aca3783e1920689604d6359c008fa0dbe31495f4fde"

URI_aarch64_ghc9.10-template-haskell = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-2.22.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-template-haskell;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell}"
SRC_URI[aarch64_ghc9.10-template-haskell.sha256sum] = "fc17c2bff6951175cfaed6be11d210fd1d957bf4a3239f1c248c070f1d70e71b"

URI_aarch64_ghc9.10-template-haskell-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-devel-2.22.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-template-haskell-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell-devel}"
SRC_URI[aarch64_ghc9.10-template-haskell-devel.sha256sum] = "7909c81fa04f7636df7c238a44d4beaec2bbd9b45e5da5ac35717561a07aa01a"

URI_aarch64_ghc9.10-template-haskell-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-doc-2.22.0.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-template-haskell-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell-doc}"
SRC_URI[aarch64_ghc9.10-template-haskell-doc.sha256sum] = "a910ace7e668e2628f229e40ce3e2382887e80d6f6495a249a8ec7348f22b71a"

URI_aarch64_ghc9.10-template-haskell-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-template-haskell-prof-2.22.0.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-template-haskell-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-template-haskell-prof}"
SRC_URI[aarch64_ghc9.10-template-haskell-prof.sha256sum] = "86199f20739aaededa5336a442344b1e940eab671deef3283b4bb662314cdbfb"

URI_aarch64_ghc9.10-terminfo = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-0.4.1.7-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-terminfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo}"
SRC_URI[aarch64_ghc9.10-terminfo.sha256sum] = "0c0487502c66f0eb751e5845af209205dd9e000a2bbecf0d1c0ef6d7b5f1fa7d"

URI_aarch64_ghc9.10-terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-devel-0.4.1.7-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo-devel}"
SRC_URI[aarch64_ghc9.10-terminfo-devel.sha256sum] = "a45fd78f4d5ab74d0ad7aea737a2ee4d9729bef8db035e66d50c47d3d76fcdcc"

URI_aarch64_ghc9.10-terminfo-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-doc-0.4.1.7-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-terminfo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo-doc}"
SRC_URI[aarch64_ghc9.10-terminfo-doc.sha256sum] = "79d867a26a6cffbae6cf0470352e31da7a27293c11b5782d2f37630d1cc421b3"

URI_aarch64_ghc9.10-terminfo-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-terminfo-prof-0.4.1.7-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-terminfo-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-terminfo-prof}"
SRC_URI[aarch64_ghc9.10-terminfo-prof.sha256sum] = "79ecd740f11f905ffe99d59560e4bc6b0ecf3bd833dc15e3c44249a6f00144cb"

URI_aarch64_ghc9.10-text = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-2.1.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-text;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text}"
SRC_URI[aarch64_ghc9.10-text.sha256sum] = "f02d3ffd8a2c3a136822653762a58fd0293a24f536f7004e73bfcc819d92668c"

URI_aarch64_ghc9.10-text-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-devel-2.1.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-text-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text-devel}"
SRC_URI[aarch64_ghc9.10-text-devel.sha256sum] = "d3044074420e387bacdc05d6845a84729e083ad0f71d84df02854d5b1b4bf0f8"

URI_aarch64_ghc9.10-text-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-doc-2.1.3-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-text-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text-doc}"
SRC_URI[aarch64_ghc9.10-text-doc.sha256sum] = "eb8a986d406991e3a446fadb9c6fcc2b32ca7d2b8dad9952bcea525e20160afd"

URI_aarch64_ghc9.10-text-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-text-prof-2.1.3-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-text-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-text-prof}"
SRC_URI[aarch64_ghc9.10-text-prof.sha256sum] = "9af17bc376b3a51898c8859178f864b821c37c6b05d372a38d9fedc53d2b3599"

URI_aarch64_ghc9.10-time = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-1.12.2-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-time;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time}"
SRC_URI[aarch64_ghc9.10-time.sha256sum] = "78d7e28d1dd91e80509749aa8fe54a4ecf2a43dd6a120d35eb8dc84f680195b2"

URI_aarch64_ghc9.10-time-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-devel-1.12.2-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time-devel}"
SRC_URI[aarch64_ghc9.10-time-devel.sha256sum] = "5b00168dfad7c8d9c72fd9e5ac52a6989068c75b4594daae147795a8ca98b700"

URI_aarch64_ghc9.10-time-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-doc-1.12.2-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-time-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time-doc}"
SRC_URI[aarch64_ghc9.10-time-doc.sha256sum] = "e5dbc2c5c408f2beb35ac7f57e30fa95552a3960c0463281fba1060ea3c8dadb"

URI_aarch64_ghc9.10-time-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-time-prof-1.12.2-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-time-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-time-prof}"
SRC_URI[aarch64_ghc9.10-time-prof.sha256sum] = "ed0c934813d9f4b79602ffcc7606f8df254961198bf4c8f124904c06c5fcb023"

URI_aarch64_ghc9.10-transformers = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-0.6.1.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-transformers;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers}"
SRC_URI[aarch64_ghc9.10-transformers.sha256sum] = "e1c3b1db2919de4b929539dc658585e41e78deffc111885f7ea8b34e344a0299"

URI_aarch64_ghc9.10-transformers-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-devel-0.6.1.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-transformers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers-devel}"
SRC_URI[aarch64_ghc9.10-transformers-devel.sha256sum] = "b84a6d1b716fe5c97aeb353340ccee62373bf248954785c52095985f617362b2"

URI_aarch64_ghc9.10-transformers-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-doc-0.6.1.1-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-transformers-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers-doc}"
SRC_URI[aarch64_ghc9.10-transformers-doc.sha256sum] = "c084fc3a8839b97b52d7b18dc07024af4e89a8b42f9dc20fdf3cd87eef63ae27"

URI_aarch64_ghc9.10-transformers-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-transformers-prof-0.6.1.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-transformers-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-transformers-prof}"
SRC_URI[aarch64_ghc9.10-transformers-prof.sha256sum] = "07563943fcafb525a6255ce17b213f394a93a8bd5976779b19d73b51f350373c"

URI_aarch64_ghc9.10-unix = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-2.8.7.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-unix;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix}"
SRC_URI[aarch64_ghc9.10-unix.sha256sum] = "b1fb83955b4b1565396b6f50e426ce0b987d96bb8a163280f14a176cf9a2d077"

URI_aarch64_ghc9.10-unix-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-devel-2.8.7.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-unix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix-devel}"
SRC_URI[aarch64_ghc9.10-unix-devel.sha256sum] = "b54fa3b3474de8571ad1181518a2e706e7ac161e51ee0c571a6003392dc240b6"

URI_aarch64_ghc9.10-unix-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-doc-2.8.7.0-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-unix-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix-doc}"
SRC_URI[aarch64_ghc9.10-unix-doc.sha256sum] = "c9aca09856601210547592dacad579cc7a882ee52c8bef5e750f626037ea0740"

URI_aarch64_ghc9.10-unix-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-unix-prof-2.8.7.0-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-unix-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-unix-prof}"
SRC_URI[aarch64_ghc9.10-unix-prof.sha256sum] = "b935426bb380db00d027a1c1e43aabe142a57220d24676c9e2ce2137e55bc0a5"

URI_aarch64_ghc9.10-xhtml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-3000.2.2.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-xhtml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml}"
SRC_URI[aarch64_ghc9.10-xhtml.sha256sum] = "fba517d57c45b88dde4ae43ce1be65a807b4e813680834b8debe8593439da3c2"

URI_aarch64_ghc9.10-xhtml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-devel-3000.2.2.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-xhtml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml-devel}"
SRC_URI[aarch64_ghc9.10-xhtml-devel.sha256sum] = "2b897a0ff6411e57559413927e2af9acac98963c8ffd0ed46abf24cf1d334fa9"

URI_aarch64_ghc9.10-xhtml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-doc-3000.2.2.1-11.el10_2.noarch.rpm;name=aarch64_ghc9.10-xhtml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml-doc}"
SRC_URI[aarch64_ghc9.10-xhtml-doc.sha256sum] = "be1eb68f5c2dbc0998e1b3d3ef2a17a684330fb5ed2539e9fd40f14944c7d881"

URI_aarch64_ghc9.10-xhtml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc9.10-xhtml-prof-3000.2.2.1-11.el10_2.aarch64.rpm;name=aarch64_ghc9.10-xhtml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc9.10-xhtml-prof}"
SRC_URI[aarch64_ghc9.10-xhtml-prof.sha256sum] = "323bc3914629a5eac1b2ec05d8e1735e7a19f33aa63dfc6fe19ba540c1197881"

RDEPENDS:ghc9.10 = " \
 ghc9.10-compiler \
 ghc9.10-devel \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-compact-devel \
 ghc9.10-ghc-devel \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghci-devel \
 ghc9.10-hpc-devel \
 "
RDEPENDS:ghc9.10-Cabal = " \
 ghc9.10-Cabal-syntax \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-parsec \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-Cabal-devel = " \
 ghc9.10-Cabal \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-mtl-devel \
 ghc9.10-parsec-devel \
 ghc9.10-pretty-devel \
 ghc9.10-process-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-Cabal-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-Cabal-syntax = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-parsec \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-Cabal-syntax-devel = " \
 ghc9.10-Cabal-syntax \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-mtl-devel \
 ghc9.10-parsec-devel \
 ghc9.10-pretty-devel \
 ghc9.10-text-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-Cabal-syntax-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-array = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-array-devel = " \
 ghc9.10-array \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-array-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-base = " \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.10-base-devel = " \
 ghc9.10-base \
 ghc9.10-compiler \
 ghc9.10-ghc-bignum-devel \
 gmp-devel \
 libffi-devel \
 numactl-devel \
 "
RDEPENDS:ghc9.10-base-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-binary = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-binary-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 "
RDEPENDS:ghc9.10-binary-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-bytestring = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-bytestring-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-bytestring-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-compiler = " \
 bash \
 binutils \
 gcc \
 ghc9.10-Cabal \
 ghc9.10-Cabal-syntax \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-base-devel \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-filesystem \
 ghc9.10-ghc \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-platform \
 ghc9.10-ghc-toolchain \
 ghc9.10-ghci \
 ghc9.10-haskeline \
 ghc9.10-hpc \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-parsec \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-semaphore-compat \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-terminfo \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 ghc9.10-xhtml \
 glibc \
 gmp \
 libffi \
 ncurses-libs \
 numactl-libs \
 "
RDEPENDS:ghc9.10-compiler-default = " \
 bash \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-containers = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-containers-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-containers \
 ghc9.10-deepseq-devel \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-containers-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-deepseq = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-deepseq-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq \
 "
RDEPENDS:ghc9.10-deepseq-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-devel = " \
 ghc9.10-Cabal-devel \
 ghc9.10-Cabal-syntax-devel \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-haskeline-devel \
 ghc9.10-mtl-devel \
 ghc9.10-os-string-devel \
 ghc9.10-parsec-devel \
 ghc9.10-pretty-devel \
 ghc9.10-process-devel \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-stm-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-terminfo-devel \
 ghc9.10-text-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 ghc9.10-xhtml-devel \
 "
RDEPENDS:ghc9.10-directory = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-directory-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-directory \
 ghc9.10-filepath-devel \
 ghc9.10-os-string-devel \
 ghc9.10-time-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-directory-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-doc = " \
 "
RDEPENDS:ghc9.10-doc-index = " \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-exceptions = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-exceptions-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-exceptions \
 ghc9.10-mtl-devel \
 ghc9.10-stm-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-exceptions-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-filepath = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-filepath-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath \
 ghc9.10-os-string-devel \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-filepath-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-filesystem = " \
 "
RDEPENDS:ghc9.10-ghc = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-platform \
 ghc9.10-ghci \
 ghc9.10-hpc \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-semaphore-compat \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-bignum = " \
 ghc9.10-base \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-bignum-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-bignum \
 "
RDEPENDS:ghc9.10-ghc-bignum-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-boot = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-platform \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-boot-devel = " \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-ghc-platform-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-ghc-boot-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-boot-th = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-boot-th-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-boot-th \
 "
RDEPENDS:ghc9.10-ghc-boot-th-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-compact = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-compact-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-compact \
 "
RDEPENDS:ghc9.10-ghc-compact-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghci-devel \
 ghc9.10-hpc-devel \
 ghc9.10-process-devel \
 ghc9.10-semaphore-compat-devel \
 ghc9.10-stm-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-time-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-ghc-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-experimental = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-experimental-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-experimental \
 "
RDEPENDS:ghc9.10-ghc-experimental-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-heap = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-heap-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-ghc-heap \
 "
RDEPENDS:ghc9.10-ghc-heap-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-platform = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-platform-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-platform \
 "
RDEPENDS:ghc9.10-ghc-platform-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghc-toolchain = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-platform \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghc-toolchain-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-platform-devel \
 ghc9.10-ghc-toolchain \
 ghc9.10-process-devel \
 ghc9.10-text-devel \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-ghc-toolchain-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-ghci = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot \
 ghc9.10-ghc-boot-th \
 ghc9.10-ghc-heap \
 ghc9.10-ghc-platform \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-ghci-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-filepath-devel \
 ghc9.10-ghc-boot-devel \
 ghc9.10-ghc-heap-devel \
 ghc9.10-ghci \
 ghc9.10-template-haskell-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-ghci-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-hadrian = " \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc9.10-haskeline = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-process \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-terminfo \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.10-haskeline-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-directory-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-filepath-devel \
 ghc9.10-haskeline \
 ghc9.10-process-devel \
 ghc9.10-stm-devel \
 ghc9.10-terminfo-devel \
 ghc9.10-transformers-devel \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-haskeline-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-hpc = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-hpc-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-containers-devel \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-hpc \
 ghc9.10-time-devel \
 "
RDEPENDS:ghc9.10-hpc-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-manual = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-mtl = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-mtl-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-mtl \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-mtl-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-os-string = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-os-string-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-exceptions-devel \
 ghc9.10-os-string \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-os-string-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-parsec = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 ghc9.10-text \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-parsec-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-mtl-devel \
 ghc9.10-parsec \
 ghc9.10-text-devel \
 "
RDEPENDS:ghc9.10-parsec-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-pretty = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-pretty-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-pretty \
 "
RDEPENDS:ghc9.10-pretty-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-process = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-directory \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-process-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-directory-devel \
 ghc9.10-filepath-devel \
 ghc9.10-os-string-devel \
 ghc9.10-process \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-process-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-semaphore-compat = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 ghc9.10-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-semaphore-compat-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-exceptions-devel \
 ghc9.10-semaphore-compat \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-semaphore-compat-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-stm = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-stm-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-stm \
 "
RDEPENDS:ghc9.10-stm-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-template-haskell = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-template-haskell-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-ghc-boot-th-devel \
 ghc9.10-pretty-devel \
 ghc9.10-template-haskell \
 "
RDEPENDS:ghc9.10-template-haskell-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-terminfo = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 ncurses-libs \
 "
RDEPENDS:ghc9.10-terminfo-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-terminfo \
 ncurses-devel \
 "
RDEPENDS:ghc9.10-terminfo-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-text = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-binary \
 ghc9.10-bytestring \
 ghc9.10-containers \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-pretty \
 ghc9.10-template-haskell \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-text-devel = " \
 ghc9.10-array-devel \
 ghc9.10-base-devel \
 ghc9.10-binary-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-template-haskell-devel \
 ghc9.10-text \
 "
RDEPENDS:ghc9.10-text-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-time = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-deepseq \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-time-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-deepseq-devel \
 ghc9.10-time \
 "
RDEPENDS:ghc9.10-time-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-transformers = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-transformers-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-transformers \
 "
RDEPENDS:ghc9.10-transformers-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-unix = " \
 ghc9.10-array \
 ghc9.10-base \
 ghc9.10-bytestring \
 ghc9.10-deepseq \
 ghc9.10-exceptions \
 ghc9.10-filepath \
 ghc9.10-ghc-bignum \
 ghc9.10-ghc-boot-th \
 ghc9.10-mtl \
 ghc9.10-os-string \
 ghc9.10-pretty \
 ghc9.10-stm \
 ghc9.10-template-haskell \
 ghc9.10-time \
 ghc9.10-transformers \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-unix-devel = " \
 ghc9.10-base-devel \
 ghc9.10-bytestring-devel \
 ghc9.10-compiler \
 ghc9.10-filepath-devel \
 ghc9.10-os-string-devel \
 ghc9.10-time-devel \
 ghc9.10-unix \
 "
RDEPENDS:ghc9.10-unix-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-xhtml = " \
 ghc9.10-base \
 ghc9.10-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc9.10-xhtml-devel = " \
 ghc9.10-base-devel \
 ghc9.10-compiler \
 ghc9.10-xhtml \
 "
RDEPENDS:ghc9.10-xhtml-doc = " \
 ghc9.10-filesystem \
 "
RDEPENDS:ghc9.10-Cabal-prof = " \
 ghc9.10-Cabal-devel \
 "
RDEPENDS:ghc9.10-Cabal-syntax-prof = " \
 ghc9.10-Cabal-syntax-devel \
 "
RDEPENDS:ghc9.10-array-prof = " \
 ghc9.10-array-devel \
 "
RDEPENDS:ghc9.10-base-prof = " \
 ghc9.10-base-devel \
 glibc \
 gmp \
 libffi \
 numactl-libs \
 "
RDEPENDS:ghc9.10-binary-prof = " \
 ghc9.10-binary-devel \
 "
RDEPENDS:ghc9.10-bytestring-prof = " \
 ghc9.10-bytestring-devel \
 "
RDEPENDS:ghc9.10-containers-prof = " \
 ghc9.10-containers-devel \
 "
RDEPENDS:ghc9.10-deepseq-prof = " \
 ghc9.10-deepseq-devel \
 "
RDEPENDS:ghc9.10-directory-prof = " \
 ghc9.10-directory-devel \
 "
RDEPENDS:ghc9.10-exceptions-prof = " \
 ghc9.10-exceptions-devel \
 "
RDEPENDS:ghc9.10-filepath-prof = " \
 ghc9.10-filepath-devel \
 "
RDEPENDS:ghc9.10-ghc-bignum-prof = " \
 ghc9.10-ghc-bignum-devel \
 "
RDEPENDS:ghc9.10-ghc-boot-prof = " \
 ghc9.10-ghc-boot-devel \
 "
RDEPENDS:ghc9.10-ghc-boot-th-prof = " \
 ghc9.10-ghc-boot-th-devel \
 "
RDEPENDS:ghc9.10-ghc-compact-prof = " \
 ghc9.10-ghc-compact-devel \
 "
RDEPENDS:ghc9.10-ghc-experimental-prof = " \
 ghc9.10-ghc-experimental-devel \
 "
RDEPENDS:ghc9.10-ghc-heap-prof = " \
 ghc9.10-ghc-heap-devel \
 "
RDEPENDS:ghc9.10-ghc-platform-prof = " \
 ghc9.10-ghc-platform-devel \
 "
RDEPENDS:ghc9.10-ghc-prof = " \
 ghc9.10-ghc-devel \
 "
RDEPENDS:ghc9.10-ghc-toolchain-prof = " \
 ghc9.10-ghc-toolchain-devel \
 "
RDEPENDS:ghc9.10-ghci-prof = " \
 ghc9.10-ghci-devel \
 "
RDEPENDS:ghc9.10-haskeline-prof = " \
 ghc9.10-haskeline-devel \
 "
RDEPENDS:ghc9.10-hpc-prof = " \
 ghc9.10-hpc-devel \
 "
RDEPENDS:ghc9.10-mtl-prof = " \
 ghc9.10-mtl-devel \
 "
RDEPENDS:ghc9.10-os-string-prof = " \
 ghc9.10-os-string-devel \
 "
RDEPENDS:ghc9.10-parsec-prof = " \
 ghc9.10-parsec-devel \
 "
RDEPENDS:ghc9.10-pretty-prof = " \
 ghc9.10-pretty-devel \
 "
RDEPENDS:ghc9.10-process-prof = " \
 ghc9.10-process-devel \
 "
RDEPENDS:ghc9.10-prof = " \
 ghc9.10-compiler \
 "
RDEPENDS:ghc9.10-semaphore-compat-prof = " \
 ghc9.10-semaphore-compat-devel \
 "
RDEPENDS:ghc9.10-stm-prof = " \
 ghc9.10-stm-devel \
 "
RDEPENDS:ghc9.10-template-haskell-prof = " \
 ghc9.10-template-haskell-devel \
 "
RDEPENDS:ghc9.10-terminfo-prof = " \
 ghc9.10-terminfo-devel \
 "
RDEPENDS:ghc9.10-text-prof = " \
 ghc9.10-text-devel \
 "
RDEPENDS:ghc9.10-time-prof = " \
 ghc9.10-time-devel \
 "
RDEPENDS:ghc9.10-transformers-prof = " \
 ghc9.10-transformers-devel \
 "
RDEPENDS:ghc9.10-unix-prof = " \
 ghc9.10-unix-devel \
 "
RDEPENDS:ghc9.10-xhtml-prof = " \
 ghc9.10-xhtml-devel \
 "
