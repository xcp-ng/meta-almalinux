# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sord"
PV = "0.16.18"
PR = "1.el10_0"
PACKAGES = " \
 sord \
 sord-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sord-0.16.18-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "678de5da4ba49a14453f6faa583a7df1c766abc66486a2c36673bc412525edda"

URI_x86_64_v2_sord = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sord-0.16.18-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sord;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sord}"
SRC_URI[x86_64_v2_sord.sha256sum] = "aa2e92722ccce810a70212ec7a244558e9cf56a2fe8699eaedb8d2b1feeba03f"

URI_x86_64_v2_sord-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sord-devel-0.16.18-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sord-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sord-devel}"
SRC_URI[x86_64_v2_sord-devel.sha256sum] = "4e901dcfa9d789521b541f4ea08740453af3dfa448444f740f8d1c828ddc156e"

URI_aarch64_sord = "${EPEL_MIRROR}/aarch64/Packages/s/sord-0.16.18-1.el10_0.aarch64.rpm;name=aarch64_sord;unpack=0"
SRC_URI:append = " ${URI_aarch64_sord}"
SRC_URI[aarch64_sord.sha256sum] = "71f436ece3dbd068c29f6da305d89073e464836df087d09781979bd19ff5636a"

URI_aarch64_sord-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sord-devel-0.16.18-1.el10_0.aarch64.rpm;name=aarch64_sord-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sord-devel}"
SRC_URI[aarch64_sord-devel.sha256sum] = "07b6c9ded100becbde17cef8797c4425e49d76e095b5088e1253e9fd275dbffe"

RDEPENDS:sord = " \
 glibc \
 pcre2 \
 serd \
 zix \
 "
RDEPENDS:sord-devel = " \
 pkgconf-pkg-config \
 serd-devel \
 sord \
 zix-devel \
 "
