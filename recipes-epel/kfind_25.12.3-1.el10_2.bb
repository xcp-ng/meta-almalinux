# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kfind"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 kfind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kfind-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cb87ff801099fb2058c2902594639166d9e78b265d9410b4f4b2a19011d5a00"

URI_x86_64_v2_kfind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfind-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kfind}"
SRC_URI[x86_64_v2_kfind.sha256sum] = "e4b0e5ed32c78d0756849452d938299965d6a4be8be804ad1f912380539dbf3c"

URI_aarch64_kfind = "${EPEL_MIRROR}/aarch64/Packages/k/kfind-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_kfind;unpack=0"
SRC_URI:append = " ${URI_aarch64_kfind}"
SRC_URI[aarch64_kfind.sha256sum] = "91eea36f7c1ca72303a1305db9f75b13222c8287aa5b2264c5986fa39eeacd74"

RDEPENDS:kfind = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
