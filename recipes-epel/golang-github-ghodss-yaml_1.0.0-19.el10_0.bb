# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-ghodss-yaml"
PV = "1.0.0"
PR = "19.el10_0"
PACKAGES = " \
 golang-github-ghodss-yaml-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-ghodss-yaml-1.0.0-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc753caac9c7163424a8f2bfa6a26d238c13b249dabdd339352616c196c23b12"

URI_x86_64_v2_golang-github-ghodss-yaml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-ghodss-yaml-devel-1.0.0-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-ghodss-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-ghodss-yaml-devel}"
SRC_URI[x86_64_v2_golang-github-ghodss-yaml-devel.sha256sum] = "fb4f14c9bfe7bf55490bbffd7ed77867e1afd54df13dcf7e8d21da1222c54792"

URI_aarch64_golang-github-ghodss-yaml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-ghodss-yaml-devel-1.0.0-19.el10_0.noarch.rpm;name=aarch64_golang-github-ghodss-yaml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-ghodss-yaml-devel}"
SRC_URI[aarch64_golang-github-ghodss-yaml-devel.sha256sum] = "5e602c13f39e9bda1da5f29831f1c67d5f911530645333942beafd64b7a2dff7"

RDEPENDS:golang-github-ghodss-yaml-devel = " \
 go-filesystem \
 golang-gopkg-yaml-2-devel \
 "
