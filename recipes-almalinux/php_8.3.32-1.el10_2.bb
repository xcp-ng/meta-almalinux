# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "php"
PV = "8.3.32"
PR = "1.el10_2"
PACKAGES = " \
 php \
 php-bcmath \
 php-cli \
 php-common \
 php-dba \
 php-dbg \
 php-devel \
 php-embedded \
 php-enchant \
 php-ffi \
 php-fpm \
 php-gd \
 php-gmp \
 php-intl \
 php-ldap \
 php-mbstring \
 php-mysqlnd \
 php-odbc \
 php-opcache \
 php-pdo \
 php-pgsql \
 php-process \
 php-snmp \
 php-soap \
 php-xml \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/php-8.3.32-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0bfd28efdb7dec0788c28b7534d6c3584d056481c9e285e59ff0f371ea69c110"

URI_x86_64_v2_php = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php}"
SRC_URI[x86_64_v2_php.sha256sum] = "757151fa20f07447e96af5ef5cda933dce0d9fde9df1be0afacf0dc685cebee8"
RPROVIDES:php:x86_64_v2 = "virtual/php"

URI_x86_64_v2_php-bcmath = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-bcmath-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-bcmath;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-bcmath}"
SRC_URI[x86_64_v2_php-bcmath.sha256sum] = "02b3f85af26c7b70c71544f00443199b81a53ed0095a2f26acc9c7c24d972696"
RPROVIDES:php-bcmath:x86_64_v2 = "virtual/php-bcmath"

URI_x86_64_v2_php-cli = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-cli-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-cli;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-cli}"
SRC_URI[x86_64_v2_php-cli.sha256sum] = "3213d8f43fba84a1545a8923149fbb4469f8b66f55c4d80f2049c756aa4fddb4"
RPROVIDES:php-cli:x86_64_v2 = "virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

URI_x86_64_v2_php-common = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-common-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-common}"
SRC_URI[x86_64_v2_php-common.sha256sum] = "2b2ffb65897c613a8a3aa313e8723067508c51148c08bf83f1cb470e499ebc7c"
RPROVIDES:php-common:x86_64_v2 = "virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_x86-64_ virtual/php-json virtual/php-json_x86-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_x86-64_ virtual/php-spl virtual/php-spl_x86-64_ virtual/php-tokenizer virtual/php-tokenizer_x86-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

URI_x86_64_v2_php-dba = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dba-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-dba;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-dba}"
SRC_URI[x86_64_v2_php-dba.sha256sum] = "58e6d9a00e94bbdab0404bfbd998e784d9d85513d933d6eeca1c69dcea1c92a9"

URI_x86_64_v2_php-dbg = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-dbg-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-dbg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-dbg}"
SRC_URI[x86_64_v2_php-dbg.sha256sum] = "29c374779bfbe11facb92fd973e3cd0af572b8dd684f8f9265a84a1c647e65d1"

URI_x86_64_v2_php-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-devel-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-devel}"
SRC_URI[x86_64_v2_php-devel.sha256sum] = "d5e4f68029613a88aa53a29e6a066efae1581eb73d59e75e279388d7e9b241f5"
RPROVIDES:php-devel:x86_64_v2 = "virtual/php-devel_x86-64_ virtual/php-devel_x86-64__ge_5.3.0"

URI_x86_64_v2_php-embedded = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-embedded-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-embedded;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-embedded}"
SRC_URI[x86_64_v2_php-embedded.sha256sum] = "8d4a897ccf7d19406214d4991a552817aa26b9251619b1c55ef2687badcdf2ad"

URI_x86_64_v2_php-enchant = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-enchant-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-enchant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-enchant}"
SRC_URI[x86_64_v2_php-enchant.sha256sum] = "0e0a869051a07179a9d0dafbb11a285e0c30b0cc150ffd1378fbdb8ec4b2b883"

URI_x86_64_v2_php-ffi = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ffi-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-ffi;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ffi}"
SRC_URI[x86_64_v2_php-ffi.sha256sum] = "9c93c765fb8302f247aa7aeb820fcef7fa6ceec41b8742e67e40efe7eba95ed9"

URI_x86_64_v2_php-fpm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-fpm-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-fpm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-fpm}"
SRC_URI[x86_64_v2_php-fpm.sha256sum] = "1af87c327989cfd417766a0affcb3bf31fdfe8b01c10139379bbff61be2e373b"
RPROVIDES:php-fpm:x86_64_v2 = "virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

URI_x86_64_v2_php-gd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gd-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-gd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-gd}"
SRC_URI[x86_64_v2_php-gd.sha256sum] = "7682125bd33c3e75f66311076c6bfc49b9b45e0ade1b8c7c9d27d80c7b230793"
RPROVIDES:php-gd:x86_64_v2 = "virtual/php-gd virtual/php-gd_x86-64_"

URI_x86_64_v2_php-gmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-gmp-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-gmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-gmp}"
SRC_URI[x86_64_v2_php-gmp.sha256sum] = "0a36c803ea788e2e31388dabbd5d235a26c60f40438f6491b5ca65491be90e01"
RPROVIDES:php-gmp:x86_64_v2 = "virtual/php-gmp"

URI_x86_64_v2_php-intl = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-intl-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-intl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-intl}"
SRC_URI[x86_64_v2_php-intl.sha256sum] = "c87cdd96cca4c3f54125f818f62ede16d60c780136f4fe2398d2824ef39bfd76"
RPROVIDES:php-intl:x86_64_v2 = "virtual/php-intl"

URI_x86_64_v2_php-ldap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-ldap-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-ldap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-ldap}"
SRC_URI[x86_64_v2_php-ldap.sha256sum] = "997ab90c460dae0ae499f974d667605182bc6e7a45868ace49dfba6b4f6dc7bf"
RPROVIDES:php-ldap:x86_64_v2 = "virtual/php-ldap"

URI_x86_64_v2_php-mbstring = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mbstring-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-mbstring;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mbstring}"
SRC_URI[x86_64_v2_php-mbstring.sha256sum] = "f3669416c212f8689267c962d2d0f78e11a09544529a0abeab45e8d283b3a08b"
RPROVIDES:php-mbstring:x86_64_v2 = "virtual/php-mbstring"

URI_x86_64_v2_php-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-mysqlnd-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-mysqlnd}"
SRC_URI[x86_64_v2_php-mysqlnd.sha256sum] = "df743599c5360e482435d115fe5894b7cd3f0934cd968e04e50de82dc09f23de"
RPROVIDES:php-mysqlnd:x86_64_v2 = "virtual/php-mysqli virtual/php-mysqlnd"

URI_x86_64_v2_php-odbc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-odbc-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-odbc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-odbc}"
SRC_URI[x86_64_v2_php-odbc.sha256sum] = "cc77d24f51b57f2d5269990379fd0701377f0bd001ddb0362e5a4d50cd7101a6"

URI_x86_64_v2_php-opcache = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-opcache-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-opcache;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-opcache}"
SRC_URI[x86_64_v2_php-opcache.sha256sum] = "1962b0cdc958d0d541218c6761355967de81cb6ca283eb679b87cdfea38b7d13"
RPROVIDES:php-opcache:x86_64_v2 = "virtual/php-opcache"

URI_x86_64_v2_php-pdo = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pdo-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-pdo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pdo}"
SRC_URI[x86_64_v2_php-pdo.sha256sum] = "6f61b63bed90aaab7394db304e3fdf2022ab38fbdfa34057730e3d200cf92a5b"
RPROVIDES:php-pdo:x86_64_v2 = "virtual/php-pdo virtual/php-sqlite3"

URI_x86_64_v2_php-pgsql = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-pgsql-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-pgsql;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-pgsql}"
SRC_URI[x86_64_v2_php-pgsql.sha256sum] = "cdc91fb5a27e382f7d021e45489a722310bccfa226a1c64803ddea4621c3186d"
RPROVIDES:php-pgsql:x86_64_v2 = "virtual/php-pgsql"

URI_x86_64_v2_php-process = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-process-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-process;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-process}"
SRC_URI[x86_64_v2_php-process.sha256sum] = "7516b3c7dfc40ffb12473238eb781a467f8b32f15de6f4991897a422f409d536"
RPROVIDES:php-process:x86_64_v2 = "virtual/php-posix virtual/php-process"

URI_x86_64_v2_php-snmp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-snmp-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-snmp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-snmp}"
SRC_URI[x86_64_v2_php-snmp.sha256sum] = "4ccf65ae6981da322f9e53668d9ae8bdbf904b1063fe3d6c1308b57079219959"

URI_x86_64_v2_php-soap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-soap-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-soap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-soap}"
SRC_URI[x86_64_v2_php-soap.sha256sum] = "d5cedb4de6c7a05ba87c97b6854a9cecbe7660fb3473e026002c829ac2748e09"

URI_x86_64_v2_php-xml = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/php-xml-8.3.32-1.el10_2.x86_64_v2.rpm;name=x86_64_v2_php-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_php-xml}"
SRC_URI[x86_64_v2_php-xml.sha256sum] = "7929f6734a558502a022471dc3afbaeec6184c58d783a1994f14841f8497474a"
RPROVIDES:php-xml:x86_64_v2 = "virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

URI_aarch64_php = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php;unpack=0"
SRC_URI:append = " ${URI_aarch64_php}"
SRC_URI[aarch64_php.sha256sum] = "89e57a7651798cb6ccb072f0bdbc2e4f06d8a24ba3e5efd55266559e947cb658"
RPROVIDES:php:aarch64 = "virtual/php"

URI_aarch64_php-bcmath = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-bcmath-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-bcmath;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-bcmath}"
SRC_URI[aarch64_php-bcmath.sha256sum] = "dae0ddcb3c6318dbc628fc5dd19b9e3b01242aa88ab2b934c68b75a91610d2bc"
RPROVIDES:php-bcmath:aarch64 = "virtual/php-bcmath"

URI_aarch64_php-cli = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-cli-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-cli}"
SRC_URI[aarch64_php-cli.sha256sum] = "dc17768246da18c993df8f04e16fb8438ebf461bd73bf79aa8688122ff6e9d6a"
RPROVIDES:php-cli:aarch64 = "virtual//usr/bin/php virtual/php-cli virtual/php-pcntl"

URI_aarch64_php-common = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-common-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-common}"
SRC_URI[aarch64_php-common.sha256sum] = "1f2d6d252226fb7a0efd3d747a8da396d521e54c323e75282225beb64427f274"
RPROVIDES:php-common:aarch64 = "virtual/php-bz2 virtual/php-ctype virtual/php-curl virtual/php-date virtual/php-exif virtual/php-fileinfo virtual/php-filter virtual/php-ftp virtual/php-gettext virtual/php-hash virtual/php-iconv virtual/php-iconv_aarch-64_ virtual/php-json virtual/php-json_aarch-64_ virtual/php-libxml virtual/php-mhash virtual/php-openssl virtual/php-pcre virtual/php-phar virtual/php-reflection virtual/php-session virtual/php-sockets virtual/php-sockets_aarch-64_ virtual/php-spl virtual/php-spl_aarch-64_ virtual/php-tokenizer virtual/php-tokenizer_aarch-64_ virtual/php-zlib virtual/php_language__ge_5.3.0 virtual/php_language__ge_5.3.1 virtual/php_language__ge_5.3.3 virtual/php_language__ge_7.1 virtual/php_language__ge_7.2 virtual/php_language__ge_7.2.5 virtual/php_language__ge_7.3 virtual/php_language__ge_7.4 virtual/php_language__ge_8.1 virtual/php_language__gt_5.3 virtual/php_language__gt_5.4"

URI_aarch64_php-dba = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dba-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-dba;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-dba}"
SRC_URI[aarch64_php-dba.sha256sum] = "13a15fc104485ba91ad19a6b26f8f4079d76f2f35d4af4c31429f547de2b7c5c"

URI_aarch64_php-dbg = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-dbg-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-dbg;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-dbg}"
SRC_URI[aarch64_php-dbg.sha256sum] = "ccc9a1a61bc805521fb70f453f1e7653b87c1864102ce94f93a01e98057fab88"

URI_aarch64_php-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-devel-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-devel}"
SRC_URI[aarch64_php-devel.sha256sum] = "5a977a91d84e3b2109711bc87be068f27544e32ee10c278627a48e699b6b27b8"
RPROVIDES:php-devel:aarch64 = "virtual/php-devel_aarch-64_ virtual/php-devel_aarch-64__ge_5.3.0"

URI_aarch64_php-embedded = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-embedded-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-embedded;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-embedded}"
SRC_URI[aarch64_php-embedded.sha256sum] = "eae3e60a9db9140c46d4ee5ffb34cdf97084527b396d41f5ad44aa88831bdc9d"

URI_aarch64_php-enchant = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-enchant-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-enchant;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-enchant}"
SRC_URI[aarch64_php-enchant.sha256sum] = "9bbde44bf56f4aa7c8a2f6e81ac76c0a13232213194f5f890b298fa88e75d4b0"

URI_aarch64_php-ffi = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ffi-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-ffi;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ffi}"
SRC_URI[aarch64_php-ffi.sha256sum] = "d430281a71721ec4b48431565a22d5b25d068f5fd8cbdfaec4a897781f239e4a"

URI_aarch64_php-fpm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-fpm-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-fpm;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-fpm}"
SRC_URI[aarch64_php-fpm.sha256sum] = "d5c369d8047478216c6cab6bfc35c1b4e9ca0917d307efd27e09e65b882c3f43"
RPROVIDES:php-fpm:aarch64 = "virtual/php-fpm virtual/php-fpm_ge_8.0 virtual/php_httpd_"

URI_aarch64_php-gd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gd-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-gd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-gd}"
SRC_URI[aarch64_php-gd.sha256sum] = "5c72590b8660d443c12f35ee87e2592dd0ad91d95338723113167878284969d9"
RPROVIDES:php-gd:aarch64 = "virtual/php-gd virtual/php-gd_aarch-64_"

URI_aarch64_php-gmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-gmp-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-gmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-gmp}"
SRC_URI[aarch64_php-gmp.sha256sum] = "05908b3b98134c906f32eab7a82a71d169be81baac47ad06eda60cf69e9b9b3f"
RPROVIDES:php-gmp:aarch64 = "virtual/php-gmp"

URI_aarch64_php-intl = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-intl-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-intl;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-intl}"
SRC_URI[aarch64_php-intl.sha256sum] = "73428e44e574f23e1e3f89418d4eb0d1110cc358ed3701ae45880c32bad27baf"
RPROVIDES:php-intl:aarch64 = "virtual/php-intl"

URI_aarch64_php-ldap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-ldap-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-ldap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-ldap}"
SRC_URI[aarch64_php-ldap.sha256sum] = "907d14117a4b950e056aa1fae20cc28a7ad8acf4265d9050c9a1abe2fb5ef7dc"
RPROVIDES:php-ldap:aarch64 = "virtual/php-ldap"

URI_aarch64_php-mbstring = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mbstring-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-mbstring;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mbstring}"
SRC_URI[aarch64_php-mbstring.sha256sum] = "78ccc7d65efd1f35d7b1ce829b87216b4541f7d83e972273a04d44039889221d"
RPROVIDES:php-mbstring:aarch64 = "virtual/php-mbstring"

URI_aarch64_php-mysqlnd = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-mysqlnd-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-mysqlnd;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-mysqlnd}"
SRC_URI[aarch64_php-mysqlnd.sha256sum] = "29dce74c0db782a6c92eef90f9ec8a03b86724b430c808dfdcb159bc49ad1aab"
RPROVIDES:php-mysqlnd:aarch64 = "virtual/php-mysqli virtual/php-mysqlnd"

URI_aarch64_php-odbc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-odbc-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-odbc;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-odbc}"
SRC_URI[aarch64_php-odbc.sha256sum] = "f596b18001b8c6f79e480a9e6ef64fd7b8dc4058e0b375c0c01dfd48d8143d0e"

URI_aarch64_php-opcache = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-opcache-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-opcache;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-opcache}"
SRC_URI[aarch64_php-opcache.sha256sum] = "bdd124faeeec0982a5c1c6cc8883639f4de2e45b174e7799cdd9d971955fd847"
RPROVIDES:php-opcache:aarch64 = "virtual/php-opcache"

URI_aarch64_php-pdo = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pdo-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-pdo;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pdo}"
SRC_URI[aarch64_php-pdo.sha256sum] = "64b7499e5880b2c9ae3a24f712130d410b36e57249bfa6beaf2fb0c81288f7af"
RPROVIDES:php-pdo:aarch64 = "virtual/php-pdo virtual/php-sqlite3"

URI_aarch64_php-pgsql = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-pgsql-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-pgsql;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-pgsql}"
SRC_URI[aarch64_php-pgsql.sha256sum] = "775fa50a71cb47d6ebbd803be22b182707475d5a88f704fc7c64919aaed33a0c"
RPROVIDES:php-pgsql:aarch64 = "virtual/php-pgsql"

URI_aarch64_php-process = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-process-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-process;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-process}"
SRC_URI[aarch64_php-process.sha256sum] = "c81303afa64f6951f6593d81b19b85cd265ad4edbe1d888fc3566d8d63d17c5a"
RPROVIDES:php-process:aarch64 = "virtual/php-posix virtual/php-process"

URI_aarch64_php-snmp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-snmp-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-snmp;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-snmp}"
SRC_URI[aarch64_php-snmp.sha256sum] = "7e59c263c2ff0d3552bb5a6b927a0930094cc0b611ea0322410fcd78296ab6c3"

URI_aarch64_php-soap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-soap-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-soap;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-soap}"
SRC_URI[aarch64_php-soap.sha256sum] = "1ebf9bdac863eee73702b9ba26f51132eaa70b356548758e5337f78f0760fa5b"

URI_aarch64_php-xml = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/php-xml-8.3.32-1.el10_2.aarch64.rpm;name=aarch64_php-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_php-xml}"
SRC_URI[aarch64_php-xml.sha256sum] = "2a3e54b51143f89c56c490c1c90fd0c76527b869b4400d8d2ab8d3aef8d6c423"
RPROVIDES:php-xml:aarch64 = "virtual/php-dom virtual/php-simplexml virtual/php-xml virtual/php-xmlreader virtual/php-xmlwriter virtual/php-xsl"

RDEPENDS:php = " \
 php-common \
 "
RDEPENDS:php-bcmath = " \
 glibc \
 php-common \
 "
RDEPENDS:php-cli = " \
 bash \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-common = " \
 bzip2-libs \
 glibc \
 openssl-libs \
 tzdata \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:php-dba = " \
 glibc \
 lmdb-libs \
 php-common \
 tokyocabinet \
 "
RDEPENDS:php-dbg = " \
 glibc \
 libedit \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-devel = " \
 autoconf \
 automake \
 bash \
 gcc \
 gcc-c++ \
 krb5-devel \
 libtool \
 libxml2-devel \
 make \
 openssl-devel \
 pcre2-devel \
 php-cli \
 zlib-ng-compat-devel \
 "
RDEPENDS:php-embedded = " \
 glibc \
 krb5-libs \
 libcom_err \
 libxcrypt \
 libxml2 \
 openssl-libs \
 pcre2 \
 php-common \
 zlib-ng-compat \
 "
RDEPENDS:php-enchant = " \
 enchant2 \
 glibc \
 php-common \
 "
RDEPENDS:php-ffi = " \
 glibc \
 libffi \
 php-common \
 "
RDEPENDS:php-fpm = " \
 bash \
 glibc \
 httpd-filesystem \
 libacl \
 libselinux \
 libxcrypt \
 libxml2 \
 nginx-filesystem \
 openssl-libs \
 pcre2 \
 php-common \
 systemd \
 systemd-libs \
 zlib-ng-compat \
 "
RDEPENDS:php-gd = " \
 gd \
 glibc \
 php-common \
 "
RDEPENDS:php-gmp = " \
 glibc \
 gmp \
 php-common \
 "
RDEPENDS:php-intl = " \
 glibc \
 libgcc \
 libicu \
 libstdc++ \
 php-common \
 "
RDEPENDS:php-ldap = " \
 cyrus-sasl-lib \
 glibc \
 openldap \
 php-common \
 "
RDEPENDS:php-mbstring = " \
 glibc \
 oniguruma \
 php-common \
 "
RDEPENDS:php-mysqlnd = " \
 glibc \
 php-pdo \
 "
RDEPENDS:php-odbc = " \
 glibc \
 php-pdo \
 unixODBC \
 "
RDEPENDS:php-opcache:x86_64_v2 = " \
 capstone \
 glibc \
 libgcc \
 php-common \
"
RDEPENDS:php-opcache:aarch64 = " \
 capstone \
 glibc \
 php-common \
"
RDEPENDS:php-pdo = " \
 glibc \
 php-common \
 sqlite-libs \
 "
RDEPENDS:php-pgsql = " \
 glibc \
 libpq \
 php-pdo \
 "
RDEPENDS:php-process = " \
 glibc \
 php-common \
 "
RDEPENDS:php-snmp = " \
 glibc \
 net-snmp \
 net-snmp-libs \
 openssl-libs \
 php-common \
 "
RDEPENDS:php-soap = " \
 glibc \
 libxml2 \
 php-common \
 "
RDEPENDS:php-xml = " \
 glibc \
 libxml2 \
 libxslt \
 php-common \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual//usr/bin/php rpm/virtual/php rpm/virtual/php-bcmath rpm/virtual/php-bz2 rpm/virtual/php-cli rpm/virtual/php-ctype rpm/virtual/php-curl rpm/virtual/php-date rpm/virtual/php-devel_x86-64_ rpm/virtual/php-devel_x86-64__ge_5.3.0 rpm/virtual/php-dom rpm/virtual/php-exif rpm/virtual/php-fileinfo rpm/virtual/php-filter rpm/virtual/php-fpm rpm/virtual/php-fpm_ge_8.0 rpm/virtual/php-ftp rpm/virtual/php-gd rpm/virtual/php-gd_x86-64_ rpm/virtual/php-gettext rpm/virtual/php-gmp rpm/virtual/php-hash rpm/virtual/php-iconv rpm/virtual/php-iconv_x86-64_ rpm/virtual/php-intl rpm/virtual/php-json rpm/virtual/php-json_x86-64_ rpm/virtual/php-ldap rpm/virtual/php-libxml rpm/virtual/php-mbstring rpm/virtual/php-mhash rpm/virtual/php-mysqli rpm/virtual/php-mysqlnd rpm/virtual/php-opcache rpm/virtual/php-openssl rpm/virtual/php-pcntl rpm/virtual/php-pcre rpm/virtual/php-pdo rpm/virtual/php-pgsql rpm/virtual/php-phar rpm/virtual/php-posix rpm/virtual/php-process rpm/virtual/php-reflection rpm/virtual/php-session rpm/virtual/php-simplexml rpm/virtual/php-sockets rpm/virtual/php-sockets_x86-64_ rpm/virtual/php-spl rpm/virtual/php-spl_x86-64_ rpm/virtual/php-sqlite3 rpm/virtual/php-tokenizer rpm/virtual/php-tokenizer_x86-64_ rpm/virtual/php-xml rpm/virtual/php-xmlreader rpm/virtual/php-xmlwriter rpm/virtual/php-xsl rpm/virtual/php-zlib rpm/virtual/php_httpd_ rpm/virtual/php_language__ge_5.3.0 rpm/virtual/php_language__ge_5.3.1 rpm/virtual/php_language__ge_5.3.3 rpm/virtual/php_language__ge_7.1 rpm/virtual/php_language__ge_7.2 rpm/virtual/php_language__ge_7.2.5 rpm/virtual/php_language__ge_7.3 rpm/virtual/php_language__ge_7.4 rpm/virtual/php_language__ge_8.1 rpm/virtual/php_language__gt_5.3 rpm/virtual/php_language__gt_5.4"

PROVIDES:append:aarch64 = " rpm/virtual//usr/bin/php rpm/virtual/php rpm/virtual/php-bcmath rpm/virtual/php-bz2 rpm/virtual/php-cli rpm/virtual/php-ctype rpm/virtual/php-curl rpm/virtual/php-date rpm/virtual/php-devel_aarch-64_ rpm/virtual/php-devel_aarch-64__ge_5.3.0 rpm/virtual/php-dom rpm/virtual/php-exif rpm/virtual/php-fileinfo rpm/virtual/php-filter rpm/virtual/php-fpm rpm/virtual/php-fpm_ge_8.0 rpm/virtual/php-ftp rpm/virtual/php-gd rpm/virtual/php-gd_aarch-64_ rpm/virtual/php-gettext rpm/virtual/php-gmp rpm/virtual/php-hash rpm/virtual/php-iconv rpm/virtual/php-iconv_aarch-64_ rpm/virtual/php-intl rpm/virtual/php-json rpm/virtual/php-json_aarch-64_ rpm/virtual/php-ldap rpm/virtual/php-libxml rpm/virtual/php-mbstring rpm/virtual/php-mhash rpm/virtual/php-mysqli rpm/virtual/php-mysqlnd rpm/virtual/php-opcache rpm/virtual/php-openssl rpm/virtual/php-pcntl rpm/virtual/php-pcre rpm/virtual/php-pdo rpm/virtual/php-pgsql rpm/virtual/php-phar rpm/virtual/php-posix rpm/virtual/php-process rpm/virtual/php-reflection rpm/virtual/php-session rpm/virtual/php-simplexml rpm/virtual/php-sockets rpm/virtual/php-sockets_aarch-64_ rpm/virtual/php-spl rpm/virtual/php-spl_aarch-64_ rpm/virtual/php-sqlite3 rpm/virtual/php-tokenizer rpm/virtual/php-tokenizer_aarch-64_ rpm/virtual/php-xml rpm/virtual/php-xmlreader rpm/virtual/php-xmlwriter rpm/virtual/php-xsl rpm/virtual/php-zlib rpm/virtual/php_httpd_ rpm/virtual/php_language__ge_5.3.0 rpm/virtual/php_language__ge_5.3.1 rpm/virtual/php_language__ge_5.3.3 rpm/virtual/php_language__ge_7.1 rpm/virtual/php_language__ge_7.2 rpm/virtual/php_language__ge_7.2.5 rpm/virtual/php_language__ge_7.3 rpm/virtual/php_language__ge_7.4 rpm/virtual/php_language__ge_8.1 rpm/virtual/php_language__gt_5.3 rpm/virtual/php_language__gt_5.4"
