# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libselinux"
PV = "3.10"
PR = "1.el10"
PACKAGES = " \
 libselinux \
 libselinux-devel \
 libselinux-ruby \
 libselinux-static \
 libselinux-utils \
 python3-libselinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libselinux-3.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3dc3c47f3040e913bd68ba865a1161bab7552f275ba823a881f05b49661f5d52"

URI_x86_64_v2_libselinux = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux}"
SRC_URI[x86_64_v2_libselinux.sha256sum] = "890c93d5c6a72f39ce3c514eb9a3e9c2de4d3f873c47cf646f294b547a29a501"

URI_x86_64_v2_libselinux-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-devel-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-devel}"
SRC_URI[x86_64_v2_libselinux-devel.sha256sum] = "5f39031b424f2edd285d31680dd449046e4ede6a3440a758a2c5d384d4db223f"

URI_x86_64_v2_libselinux-ruby = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libselinux-ruby-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-ruby;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-ruby}"
SRC_URI[x86_64_v2_libselinux-ruby.sha256sum] = "43017bda89458ee3a7748ca3d1fa0c9513e1888e676511eb68dfdcb63439504f"

URI_x86_64_v2_libselinux-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libselinux-static-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-static}"
SRC_URI[x86_64_v2_libselinux-static.sha256sum] = "8be592e1c4918f82b797872d2d4fae53be17316eaca1b3b112069062eea6d024"

URI_x86_64_v2_libselinux-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libselinux-utils-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_libselinux-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libselinux-utils}"
SRC_URI[x86_64_v2_libselinux-utils.sha256sum] = "f5c1505d1c341c44fd0125ed39959ab94885f43437247b378462940b18f05fb7"

URI_x86_64_v2_python3-libselinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libselinux-3.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libselinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libselinux}"
SRC_URI[x86_64_v2_python3-libselinux.sha256sum] = "bb3fe7058e3fa45da486e1620648c90b286e8f25f1ab3dd709efe9304d13839a"

URI_aarch64_libselinux = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-3.10-1.el10.aarch64.rpm;name=aarch64_libselinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux}"
SRC_URI[aarch64_libselinux.sha256sum] = "ba44687d4a01dc53900699d7229859c9ca61ec6d1c170e1f6f06d6b028ef0d4b"

URI_aarch64_libselinux-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-devel-3.10-1.el10.aarch64.rpm;name=aarch64_libselinux-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-devel}"
SRC_URI[aarch64_libselinux-devel.sha256sum] = "4409645cbe50940d84629933fd0313d769a2744b827cea1c666c5b90c243adba"

URI_aarch64_libselinux-ruby = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libselinux-ruby-3.10-1.el10.aarch64.rpm;name=aarch64_libselinux-ruby;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-ruby}"
SRC_URI[aarch64_libselinux-ruby.sha256sum] = "9f98a4621f1229345a1e93f8ca0a37fe98dd417edeff11dbb58121b2cdc8eee6"

URI_aarch64_libselinux-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libselinux-static-3.10-1.el10.aarch64.rpm;name=aarch64_libselinux-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-static}"
SRC_URI[aarch64_libselinux-static.sha256sum] = "332b2d55847ee291adfc8a91f3d63aefdf9a3175c3e6a0280dd36e1c832128b7"

URI_aarch64_libselinux-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libselinux-utils-3.10-1.el10.aarch64.rpm;name=aarch64_libselinux-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_libselinux-utils}"
SRC_URI[aarch64_libselinux-utils.sha256sum] = "da2ce9d605d19a0e2ad3941a50437b2daf4518f813decdf2b95547fd3427983f"

URI_aarch64_python3-libselinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libselinux-3.10-1.el10.aarch64.rpm;name=aarch64_python3-libselinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libselinux}"
SRC_URI[aarch64_python3-libselinux.sha256sum] = "c5f66dcade3200de95fb9c5bc507cf788f9e3245ac4ae45f16b2c91508aef0d9"

RDEPENDS:libselinux = " \
 glibc \
 libsepol \
 pcre2 \
 "
RDEPENDS:libselinux-devel = " \
 libselinux \
 libsepol-devel \
 pcre2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libselinux-ruby = " \
 glibc \
 libselinux \
 ruby-libs \
 "
RDEPENDS:libselinux-static = " \
 libselinux-devel \
 "
RDEPENDS:libselinux-utils = " \
 glibc \
 libselinux \
 libsepol \
 pcre2 \
 "
RDEPENDS:python3-libselinux = " \
 glibc \
 libselinux \
 python3 \
 "
