# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libzdnn"
PV = "1.1.1"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libzdnn-1.1.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d49390b1fb926ce35a48a2b9054aa49a99c5a772445a8f20936a5f7dae8fbdb7"

