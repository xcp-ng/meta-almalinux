# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "hunspell-ia"
PV = "0.20050226"
PR = "33.el10"
PACKAGES = " \
 hunspell-ia \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/hunspell-ia-0.20050226-33.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "352f8dc53479a35e7f8d9c5362d9ada1512f11d6fa8b9213a30f5e66ba7d9703"

URI_x86_64_v2_hunspell-ia = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/hunspell-ia-0.20050226-33.el10.noarch.rpm;name=x86_64_v2_hunspell-ia;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_hunspell-ia}"
SRC_URI[x86_64_v2_hunspell-ia.sha256sum] = "2bb82e0c47771e8f0b3e6259c63bcff1585610b5e51b15477d88dfe3dcc1a83b"

URI_aarch64_hunspell-ia = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/hunspell-ia-0.20050226-33.el10.noarch.rpm;name=aarch64_hunspell-ia;unpack=0"
SRC_URI:append = " ${URI_aarch64_hunspell-ia}"
SRC_URI[aarch64_hunspell-ia.sha256sum] = "2bb82e0c47771e8f0b3e6259c63bcff1585610b5e51b15477d88dfe3dcc1a83b"

RDEPENDS:hunspell-ia = " \
 hunspell-filesystem \
 "
