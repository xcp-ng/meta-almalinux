# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "liborc"
PV = "2.0.7"
PR = "1.el10_2"
PACKAGES = " \
 liborc-devel \
 liborc2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/liborc-2.0.7-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff6b221c1ba72003e4450594828c056c8395a1be23a3ae50d6d54eb793dcc099"

URI_x86_64_v2_liborc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liborc-devel-2.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liborc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liborc-devel}"
SRC_URI[x86_64_v2_liborc-devel.sha256sum] = "4ff7cbf89b33b702b55cec1f64eb23dbde2adfe6c36c5e383395037e478ca2cf"

URI_x86_64_v2_liborc2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/liborc2-2.0.7-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_liborc2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_liborc2}"
SRC_URI[x86_64_v2_liborc2.sha256sum] = "65c0fc1378792dbcffe163c6d35e5776f95e654ffa1b75e3cd1641e1269b781d"

URI_aarch64_liborc-devel = "${EPEL_MIRROR}/aarch64/Packages/l/liborc-devel-2.0.7-1.el10_2.aarch64.rpm;name=aarch64_liborc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_liborc-devel}"
SRC_URI[aarch64_liborc-devel.sha256sum] = "d34542bf46d88c39038a28a5be3cfe74f652e448c6cfcec98e70285f69bc9b73"

URI_aarch64_liborc2 = "${EPEL_MIRROR}/aarch64/Packages/l/liborc2-2.0.7-1.el10_2.aarch64.rpm;name=aarch64_liborc2;unpack=0"
SRC_URI:append = " ${URI_aarch64_liborc2}"
SRC_URI[aarch64_liborc2.sha256sum] = "4769d29efb2bc071269eee298c0b8de2e5b755e625756421bc042ee55dcc0f62"

RDEPENDS:liborc-devel = " \
 liborc2 \
 "
RDEPENDS:liborc2 = " \
 glibc \
 libgcc \
 libstdc++ \
 libzstd \
 lz4-libs \
 protobuf \
 snappy \
 zlib-ng-compat \
 "
