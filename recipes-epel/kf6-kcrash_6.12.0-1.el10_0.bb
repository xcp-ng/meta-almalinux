# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcrash"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-kcrash \
 kf6-kcrash-devel \
 kf6-kcrash-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcrash-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "197a93c889e5934efc4ac7119d31167b8d99e8e8e9824d57d99269f9f025f27d"

URI_x86_64_v2_kf6-kcrash = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash}"
SRC_URI[x86_64_v2_kf6-kcrash.sha256sum] = "a88243cf92b28593d21c91fee16421a26176e0598e0231efb5b51b2c1be023a7"

URI_x86_64_v2_kf6-kcrash-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcrash-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-devel}"
SRC_URI[x86_64_v2_kf6-kcrash-devel.sha256sum] = "d53143e2b6f6afbb6e0fd4b3357746299b4218aa22dc9314492be22212b372e1"

URI_x86_64_v2_kf6-kcrash-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcrash-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcrash-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcrash-doc}"
SRC_URI[x86_64_v2_kf6-kcrash-doc.sha256sum] = "316d5de054b19199fca804f4f6337abdfc1d39de47539a01a71030e0bef18d6a"

URI_aarch64_kf6-kcrash = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcrash;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash}"
SRC_URI[aarch64_kf6-kcrash.sha256sum] = "34815a7f6555a66f46828c03ab638003fe2a14c6c067dde5595b8ce8ad45adff"

URI_aarch64_kf6-kcrash-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-kcrash-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-devel}"
SRC_URI[aarch64_kf6-kcrash-devel.sha256sum] = "f966fc7a634e56e0073abbcdedbe50c4f0f6ad360f737cb3fffc000b4e9323cf"

URI_aarch64_kf6-kcrash-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcrash-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-kcrash-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcrash-doc}"
SRC_URI[aarch64_kf6-kcrash-doc.sha256sum] = "1b2982f0a5d071d1bc8386ffc89429a86b5b86f7b38a8706c2c9ae6ae215ff48"

RDEPENDS:kf6-kcrash = " \
 glibc \
 kf6-kcoreaddons \
 libX11 \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-kcrash-devel = " \
 cmake-filesystem \
 kf6-kcrash \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcrash-doc = " \
 "
