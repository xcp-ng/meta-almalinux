# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand_core"
PV = "0.10.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-rand_core+default-devel \
 rust-rand_core-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-rand_core-0.10.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e4246e548c1665de857e95fd08cee7d9318b82a96434fca665ee960584e5d61"

URI_x86_64_v2_rust-rand_core+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core+default-devel-0.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core+default-devel}"
SRC_URI[x86_64_v2_rust-rand_core+default-devel.sha256sum] = "3e3499df54004d578e89fbb9a6f77db390a6a69f963dcf2958879b55f02fe4d8"

URI_x86_64_v2_rust-rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand_core-devel-0.10.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-rand_core-devel}"
SRC_URI[x86_64_v2_rust-rand_core-devel.sha256sum] = "2683b8fa4a0d70594ffa92b4cadaced3e7fb75db1d2ad29d7eebf5b65dc06da2"

URI_aarch64_rust-rand_core+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core+default-devel-0.10.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_core+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core+default-devel}"
SRC_URI[aarch64_rust-rand_core+default-devel.sha256sum] = "a79b899641eda613408298bf75b77b22a67f3d5c591b38c6e8e2dfa15558ae0a"

URI_aarch64_rust-rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-rand_core-devel-0.10.1-1.el10_2.noarch.rpm;name=aarch64_rust-rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-rand_core-devel}"
SRC_URI[aarch64_rust-rand_core-devel.sha256sum] = "3ebb2be00f0ceace06e09e380fdfda6f08249e5dd643d330914425f1eb2cb0c5"

RDEPENDS:rust-rand_core+default-devel = " \
 cargo \
 rust-rand_core-devel \
 "
RDEPENDS:rust-rand_core-devel = " \
 cargo \
 rust \
 "
