# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pam"
PV = "1.6.1"
PR = "10.el10"
PACKAGES = " \
 pam \
 pam-devel \
 pam-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/pam-1.6.1-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "23464f07e58f931fef90e6ff273b416a4625f53355e5d28098befafb391ad07c"

URI_x86_64_v2_pam = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-1.6.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam}"
SRC_URI[x86_64_v2_pam.sha256sum] = "7bfbdb7eaf61c20964b84289ed4c4bc661a96007faefff6ce1b44330adab095d"

URI_x86_64_v2_pam-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam-devel-1.6.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_pam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-devel}"
SRC_URI[x86_64_v2_pam-devel.sha256sum] = "d68fcb69166da353311e17f244da15573d1bb863c2c133a7caf43e5d49191e3c"

URI_x86_64_v2_pam-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/pam-libs-1.6.1-10.el10.x86_64_v2.rpm;name=x86_64_v2_pam-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam-libs}"
SRC_URI[x86_64_v2_pam-libs.sha256sum] = "6ac560897b09dc85a0edfbc0ecfd609078b925c451057fdf222b4291a01fd28b"

URI_aarch64_pam = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-1.6.1-10.el10.aarch64.rpm;name=aarch64_pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam}"
SRC_URI[aarch64_pam.sha256sum] = "3b50497efcfbe0d33959726200ef594325023bd9a7e0ac2c76994e7a275f485b"

URI_aarch64_pam-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam-devel-1.6.1-10.el10.aarch64.rpm;name=aarch64_pam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-devel}"
SRC_URI[aarch64_pam-devel.sha256sum] = "1eca094468d16d64173ca4753d465ee2c947270f9399bde1340566cdc623038a"

URI_aarch64_pam-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/pam-libs-1.6.1-10.el10.aarch64.rpm;name=aarch64_pam-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam-libs}"
SRC_URI[aarch64_pam-libs.sha256sum] = "11abfe7abdb18835aaef87d4a58ffc2ad591d6c2b2242b5a93aa5bff931b31ef"

RDEPENDS:pam = " \
 audit-libs \
 authselect \
 bash \
 gdbm \
 gdbm-libs \
 glibc \
 libeconf \
 libpwquality \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 setup \
 "
RDEPENDS:pam-devel = " \
 pam-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:pam-libs = " \
 audit-libs \
 glibc \
 libeconf \
 "
