# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Mail-Sendmail"
PV = "0.80"
PR = "22.el10_0"
PACKAGES = " \
 perl-Mail-Sendmail \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Mail-Sendmail-0.80-22.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ebc6e3515b7a57be938dca5e9cff9d28b1deb30d6645f63f286d205dcb4d106a"

URI_x86_64_v2_perl-Mail-Sendmail = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Mail-Sendmail-0.80-22.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Mail-Sendmail;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Mail-Sendmail}"
SRC_URI[x86_64_v2_perl-Mail-Sendmail.sha256sum] = "5e86fbecbfbea5f9eb3e8eb2735f98e00d1771fbdbf90d672fbdc9012e9d5f17"

URI_aarch64_perl-Mail-Sendmail = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Mail-Sendmail-0.80-22.el10_0.noarch.rpm;name=aarch64_perl-Mail-Sendmail;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Mail-Sendmail}"
SRC_URI[aarch64_perl-Mail-Sendmail.sha256sum] = "171aa62585e6a72a959091e520ed1fb737cb9b6b43ab08f2f35ddeb81edd71fb"

RDEPENDS:perl-Mail-Sendmail = " \
 perl-Exporter \
 perl-MIME-Base64 \
 perl-Socket \
 perl-Sys-Hostname \
 perl-Time-Local \
 perl-libs \
 perl-parent \
 perl-vars \
 "
