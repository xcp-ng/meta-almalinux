# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "openvr"
PV = "2.12.14"
PR = "2.el10_2"
PACKAGES = " \
 openvr-api \
 openvr-devel \
 openvr-doc \
 openvr-samples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/openvr-2.12.14-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "768903af385dcb86d4e0e0c381938ac5e571c000e79247636e9113670a386112"

URI_x86_64_v2_openvr-api = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-api-2.12.14-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvr-api;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-api}"
SRC_URI[x86_64_v2_openvr-api.sha256sum] = "225d12745d37b13c43337dfd09480c5346a7a53e7608f2e7bac0b1a9be1fe926"

URI_x86_64_v2_openvr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-devel-2.12.14-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-devel}"
SRC_URI[x86_64_v2_openvr-devel.sha256sum] = "88afd9c60bc12c09ae6abcaeca145ea7eb36507a04889afc34af1350641af619"

URI_x86_64_v2_openvr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-doc-2.12.14-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_openvr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-doc}"
SRC_URI[x86_64_v2_openvr-doc.sha256sum] = "bb5b2665734254427cf0b18a0aa2041582faad3e273898a59be1fe70d3501877"

URI_x86_64_v2_openvr-samples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/openvr-samples-2.12.14-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_openvr-samples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_openvr-samples}"
SRC_URI[x86_64_v2_openvr-samples.sha256sum] = "1dbd7be5beeb64f29c8cf8a13ee5cff726793f1d1428e50521a8c3585b24a312"

URI_aarch64_openvr-api = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-api-2.12.14-2.el10_2.aarch64.rpm;name=aarch64_openvr-api;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-api}"
SRC_URI[aarch64_openvr-api.sha256sum] = "c7bf6b23c8de383a46fdba37edbf7206abc62f3d39ef2da0194bdb2244b2a3fa"

URI_aarch64_openvr-devel = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-devel-2.12.14-2.el10_2.aarch64.rpm;name=aarch64_openvr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-devel}"
SRC_URI[aarch64_openvr-devel.sha256sum] = "04bf9592b56d84089f7a61b556746734f7fadaba5e8e41f05f9618a8fac97b48"

URI_aarch64_openvr-doc = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-doc-2.12.14-2.el10_2.noarch.rpm;name=aarch64_openvr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-doc}"
SRC_URI[aarch64_openvr-doc.sha256sum] = "89b217a04b3a16d36b668dad61c3547f51db2ade737d6a71bbf96262d2cadbe2"

URI_aarch64_openvr-samples = "${EPEL_MIRROR}/aarch64/Packages/o/openvr-samples-2.12.14-2.el10_2.aarch64.rpm;name=aarch64_openvr-samples;unpack=0"
SRC_URI:append = " ${URI_aarch64_openvr-samples}"
SRC_URI[aarch64_openvr-samples.sha256sum] = "ab199c79187fc101d75e7379d284d6256797d33f4d9efb2193b2e2de002ba820"

RDEPENDS:openvr-api = " \
 glibc \
 jsoncpp \
 libgcc \
 libstdc++ \
 "
RDEPENDS:openvr-devel = " \
 jsoncpp-devel \
 openvr-api \
 pkgconf-pkg-config \
 "
RDEPENDS:openvr-doc = " \
 "
RDEPENDS:openvr-samples = " \
 glibc \
 libGLEW \
 libgcc \
 libglvnd-glx \
 libstdc++ \
 openvr-api \
 qt5-qtbase \
 qt5-qtbase-gui \
 sdl2-compat \
 vulkan-loader \
 "
