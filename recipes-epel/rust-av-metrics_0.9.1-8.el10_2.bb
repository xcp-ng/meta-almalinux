# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-av-metrics"
PV = "0.9.1"
PR = "8.el10_2"
PACKAGES = " \
 rust-av-metrics+default-devel \
 rust-av-metrics+serde-devel \
 rust-av-metrics-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-av-metrics-0.9.1-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5166aaf1d225d24de2185bc2dfca465aa5c15e50bb0e8399a136fa48e42011b9"

URI_x86_64_v2_rust-av-metrics+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-metrics+default-devel-0.9.1-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-metrics+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-metrics+default-devel}"
SRC_URI[x86_64_v2_rust-av-metrics+default-devel.sha256sum] = "beaa9e1f390d63185c736db3b57af07a9991c7b14d48c7228b997f7a0887959a"

URI_x86_64_v2_rust-av-metrics+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-metrics+serde-devel-0.9.1-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-metrics+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-metrics+serde-devel}"
SRC_URI[x86_64_v2_rust-av-metrics+serde-devel.sha256sum] = "0dd9da6c62bb8475294ec2a33f5cc2217114f0675a383746788d44408127c503"

URI_x86_64_v2_rust-av-metrics-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-av-metrics-devel-0.9.1-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-av-metrics-devel}"
SRC_URI[x86_64_v2_rust-av-metrics-devel.sha256sum] = "350b3e412b052e770865230bf97d5b1696bb5bea838901be9e890f91b484f5a9"

URI_aarch64_rust-av-metrics+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-metrics+default-devel-0.9.1-8.el10_2.noarch.rpm;name=aarch64_rust-av-metrics+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-metrics+default-devel}"
SRC_URI[aarch64_rust-av-metrics+default-devel.sha256sum] = "f4363d89fbd0073455a5c5635eb8e49164cc83b018bae39c87942f782d49ec98"

URI_aarch64_rust-av-metrics+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-metrics+serde-devel-0.9.1-8.el10_2.noarch.rpm;name=aarch64_rust-av-metrics+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-metrics+serde-devel}"
SRC_URI[aarch64_rust-av-metrics+serde-devel.sha256sum] = "2b950c5c249b83461aafc5a134b7046ce598db012f88f23ace328856e9da3a4e"

URI_aarch64_rust-av-metrics-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-av-metrics-devel-0.9.1-8.el10_2.noarch.rpm;name=aarch64_rust-av-metrics-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-av-metrics-devel}"
SRC_URI[aarch64_rust-av-metrics-devel.sha256sum] = "38d19c1d50193ebe6a73c8417db51c47a22458c34371134934d03d9ee959b0e5"

RDEPENDS:rust-av-metrics+default-devel = " \
 cargo \
 rust-av-metrics-devel \
 "
RDEPENDS:rust-av-metrics+serde-devel = " \
 cargo \
 rust-av-metrics-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-av-metrics-devel = " \
 cargo \
 rust-crossbeam+default-devel \
 rust-itertools+default-devel \
 rust-lab+default-devel \
 rust-num-traits+default-devel \
 rust-rayon+default-devel \
 rust-thiserror+default-devel \
 rust-v_frame0.3+default-devel \
 "
