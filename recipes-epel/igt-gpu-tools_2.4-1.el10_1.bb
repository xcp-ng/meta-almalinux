# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "igt-gpu-tools"
PV = "2.4"
PR = "1.el10_1"
PACKAGES = " \
 igt-gpu-tools \
 igt-gpu-tools-devel \
 igt-gpu-tools-docs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/i/igt-gpu-tools-2.4-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ee9e850d9fba0ce77b94a8b981de1553967c34f21667148d29ab91656d01474"

URI_x86_64_v2_igt-gpu-tools = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/igt-gpu-tools-2.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_igt-gpu-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_igt-gpu-tools}"
SRC_URI[x86_64_v2_igt-gpu-tools.sha256sum] = "b227d06916960ba60e171d298b78d781d4defe5dad1adc54f10353f583c68abe"

URI_x86_64_v2_igt-gpu-tools-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/igt-gpu-tools-devel-2.4-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_igt-gpu-tools-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_igt-gpu-tools-devel}"
SRC_URI[x86_64_v2_igt-gpu-tools-devel.sha256sum] = "31ceba329970dfd527c64215ff130d0fc930429eca6bee9d173f39bfde226759"

URI_x86_64_v2_igt-gpu-tools-docs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/igt-gpu-tools-docs-2.4-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_igt-gpu-tools-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_igt-gpu-tools-docs}"
SRC_URI[x86_64_v2_igt-gpu-tools-docs.sha256sum] = "f5b70efdae36ac7e1a4525d230d61c4b7f93d2718f76565e097505142858b870"

URI_aarch64_igt-gpu-tools = "${EPEL_MIRROR}/aarch64/Packages/i/igt-gpu-tools-2.4-1.el10_1.aarch64.rpm;name=aarch64_igt-gpu-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_igt-gpu-tools}"
SRC_URI[aarch64_igt-gpu-tools.sha256sum] = "1b46d01084205c7ed11e952e4e769b205d6d8e64e14493ef7d230f86ac9cc71f"

URI_aarch64_igt-gpu-tools-devel = "${EPEL_MIRROR}/aarch64/Packages/i/igt-gpu-tools-devel-2.4-1.el10_1.aarch64.rpm;name=aarch64_igt-gpu-tools-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_igt-gpu-tools-devel}"
SRC_URI[aarch64_igt-gpu-tools-devel.sha256sum] = "acfdb9f2779b9887b12b3ee7907b9803c1b368325df52c46fef5c108b7e21767"

URI_aarch64_igt-gpu-tools-docs = "${EPEL_MIRROR}/aarch64/Packages/i/igt-gpu-tools-docs-2.4-1.el10_1.noarch.rpm;name=aarch64_igt-gpu-tools-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_igt-gpu-tools-docs}"
SRC_URI[aarch64_igt-gpu-tools-docs.sha256sum] = "7c242675212844efdbf52fffea6935edafad5fc89c2aba4372b9f9f02a9ace39"

RDEPENDS:igt-gpu-tools = " \
 alsa-lib \
 bash \
 cairo \
 elfutils-libs \
 glib2 \
 glibc \
 gsl \
 jansson \
 kmod-libs \
 libdrm \
 liboping \
 libpciaccess \
 libunwind \
 pciutils-libs \
 perl-interpreter \
 pixman \
 procps-ng \
 python3 \
 systemd-libs \
 xmlrpc-c \
 xmlrpc-c-client \
 zlib-ng-compat \
 "
RDEPENDS:igt-gpu-tools-devel = " \
 igt-gpu-tools \
 libdrm-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:igt-gpu-tools-docs = " \
 "
