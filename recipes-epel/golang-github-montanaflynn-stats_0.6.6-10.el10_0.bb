# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-montanaflynn-stats"
PV = "0.6.6"
PR = "10.el10_0"
PACKAGES = " \
 golang-github-montanaflynn-stats-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-montanaflynn-stats-0.6.6-10.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1f78bb7d1d54bdf4e3de8c4262e5b39139d2f832f7ed1b5cbffa6cbbc4fbeb82"

URI_x86_64_v2_golang-github-montanaflynn-stats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-montanaflynn-stats-devel-0.6.6-10.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-montanaflynn-stats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-montanaflynn-stats-devel}"
SRC_URI[x86_64_v2_golang-github-montanaflynn-stats-devel.sha256sum] = "77178d9a4cdb99b3f7dba9d084b52fb5470f1a39680eedcff3ca7ffff1abe444"

URI_aarch64_golang-github-montanaflynn-stats-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-montanaflynn-stats-devel-0.6.6-10.el10_0.noarch.rpm;name=aarch64_golang-github-montanaflynn-stats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-montanaflynn-stats-devel}"
SRC_URI[aarch64_golang-github-montanaflynn-stats-devel.sha256sum] = "3d40c2393f61d0f359b21029a886b7600422c2fff8440d9df2629b4f95a8f46e"

RDEPENDS:golang-github-montanaflynn-stats-devel = " \
 go-filesystem \
 "
