# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-sphinx-theme-alabaster"
PV = "0.7.16"
PR = "5.el10"
PACKAGES = " \
 python3-sphinx-theme-alabaster \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-sphinx-theme-alabaster-0.7.16-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9064eb74cfebe2ca59cac2b2b2beacca2e44b8d240979fabe02305494e79566"

URI_x86_64_v2_python3-sphinx-theme-alabaster = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-sphinx-theme-alabaster-0.7.16-5.el10.noarch.rpm;name=x86_64_v2_python3-sphinx-theme-alabaster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-sphinx-theme-alabaster}"
SRC_URI[x86_64_v2_python3-sphinx-theme-alabaster.sha256sum] = "280419b4c99bfa2fb9de43d194205733880e1ccfa4876091cc5f00ff5f6856e1"

URI_aarch64_python3-sphinx-theme-alabaster = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-sphinx-theme-alabaster-0.7.16-5.el10.noarch.rpm;name=aarch64_python3-sphinx-theme-alabaster;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-sphinx-theme-alabaster}"
SRC_URI[aarch64_python3-sphinx-theme-alabaster.sha256sum] = "280419b4c99bfa2fb9de43d194205733880e1ccfa4876091cc5f00ff5f6856e1"

RDEPENDS:python3-sphinx-theme-alabaster = " \
 python3 \
 "
