# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "setroubleshoot"
PV = "3.3.37"
PR = "1.el10"
PACKAGES = " \
 setroubleshoot \
 setroubleshoot-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/setroubleshoot-3.3.37-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2244b4bc2020280e4464fd776067c1623f1ef089208459f4b08e283414665879"

URI_x86_64_v2_setroubleshoot = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-3.3.37-1.el10.x86_64_v2.rpm;name=x86_64_v2_setroubleshoot;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setroubleshoot}"
SRC_URI[x86_64_v2_setroubleshoot.sha256sum] = "c35c2af1a8cc59a17c6a903a559ccb39ddb8c69562715e9bdb3ae5d0d656d442"

URI_x86_64_v2_setroubleshoot-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/setroubleshoot-server-3.3.37-1.el10.x86_64_v2.rpm;name=x86_64_v2_setroubleshoot-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_setroubleshoot-server}"
SRC_URI[x86_64_v2_setroubleshoot-server.sha256sum] = "43eb8939a77197569624d86aac9777a9c25e1f9f43ce8748381134a794e4c7a3"

URI_aarch64_setroubleshoot = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-3.3.37-1.el10.aarch64.rpm;name=aarch64_setroubleshoot;unpack=0"
SRC_URI:append = " ${URI_aarch64_setroubleshoot}"
SRC_URI[aarch64_setroubleshoot.sha256sum] = "3cd185c80f71700b19a9d9cfbbae49423cc3b6c4fb3ed0e94e2b4ee2b5a5a529"

URI_aarch64_setroubleshoot-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/setroubleshoot-server-3.3.37-1.el10.aarch64.rpm;name=aarch64_setroubleshoot-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_setroubleshoot-server}"
SRC_URI[aarch64_setroubleshoot-server.sha256sum] = "4e1e00f80da7bf4df22fd45e64af9a3ad22b259dcd29299881d2608cb5aa6586"

RDEPENDS:setroubleshoot = " \
 dbus \
 desktop-file-utils \
 gtk3 \
 libnotify \
 python3 \
 python3-dasbus \
 python3-gobject \
 setroubleshoot-server \
 xdg-utils \
 "
RDEPENDS:setroubleshoot-server = " \
 audit \
 audit-libs \
 bash \
 dbus \
 dbus-libs \
 glibc \
 libcap-ng \
 libselinux \
 policycoreutils-python-utils \
 polkit \
 python3 \
 python3-audit \
 python3-dasbus \
 python3-dbus \
 python3-gobject-base \
 python3-libselinux \
 python3-libxml2 \
 python3-rpm \
 python3-systemd \
 setroubleshoot-plugins \
 "
