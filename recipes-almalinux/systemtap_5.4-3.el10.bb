# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemtap"
PV = "5.4"
PR = "3.el10"
PACKAGES = " \
 systemtap \
 systemtap-client \
 systemtap-devel \
 systemtap-exporter \
 systemtap-initscript \
 systemtap-runtime \
 systemtap-runtime-java \
 systemtap-runtime-python3 \
 systemtap-runtime-virtguest \
 systemtap-runtime-virthost \
 systemtap-sdt-devel \
 systemtap-sdt-dtrace \
 systemtap-server \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/systemtap-5.4-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f152aff246d6830a3144f134fb81c47c4e31662dd133cd094ba16869adf2fd6a"

URI_x86_64_v2_systemtap = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap}"
SRC_URI[x86_64_v2_systemtap.sha256sum] = "591b5362bca6b70c41795b01d76bd81d9cdec48e9665cb98dc393e051eb21bc8"

URI_x86_64_v2_systemtap-client = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-client-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-client}"
SRC_URI[x86_64_v2_systemtap-client.sha256sum] = "6925f926277677a50764a06c4281330575cbe9157db9c56fcbe51219ceb08c35"

URI_x86_64_v2_systemtap-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-devel-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-devel}"
SRC_URI[x86_64_v2_systemtap-devel.sha256sum] = "6245ccf4ef2c091642dcf76a48916d7b92eca2fb0ac462fce40854c9de7c6113"

URI_x86_64_v2_systemtap-exporter = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-exporter-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-exporter;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-exporter}"
SRC_URI[x86_64_v2_systemtap-exporter.sha256sum] = "122f05328d0c352f57e861d425bf370ccbc14911a9c657c4c9d2f37df1fd4913"

URI_x86_64_v2_systemtap-initscript = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-initscript-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-initscript;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-initscript}"
SRC_URI[x86_64_v2_systemtap-initscript.sha256sum] = "4ca81149da923579e15ae0b0b73c8fba938076e3de938f492d0029181581ac21"

URI_x86_64_v2_systemtap-runtime = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime}"
SRC_URI[x86_64_v2_systemtap-runtime.sha256sum] = "e62b1d15388df7fb890fa78898f56a28418e6e53b4028a84e68af60412b63c44"

URI_x86_64_v2_systemtap-runtime-java = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-java-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-java}"
SRC_URI[x86_64_v2_systemtap-runtime-java.sha256sum] = "8c2d6f7d356f3be3eed93685fb8a96853652201d4bc97643b1b17f0dc17420d7"

URI_x86_64_v2_systemtap-runtime-python3 = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-python3-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-python3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-python3}"
SRC_URI[x86_64_v2_systemtap-runtime-python3.sha256sum] = "724a2ce1813f050ee376b80eacb662eac7469840ea590fa2be6eed97acd62aa6"

URI_x86_64_v2_systemtap-runtime-virtguest = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virtguest-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virtguest;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-virtguest}"
SRC_URI[x86_64_v2_systemtap-runtime-virtguest.sha256sum] = "ef4dcd17c440bdfe02c24d4cdcc781e5c8d3765dd4f99300cdcf2e5a6ac444a3"

URI_x86_64_v2_systemtap-runtime-virthost = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-runtime-virthost-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-runtime-virthost;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-runtime-virthost}"
SRC_URI[x86_64_v2_systemtap-runtime-virthost.sha256sum] = "762600798fd58f5efaddf9907cc0e02fa9f2137242b612a9213f4e8806247086"

URI_x86_64_v2_systemtap-sdt-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-devel-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-sdt-devel}"
SRC_URI[x86_64_v2_systemtap-sdt-devel.sha256sum] = "0d8e9c4063535e8db9cc1f5663eb9c0c43569c87c2f6cee8d3f2337c9f909d94"

URI_x86_64_v2_systemtap-sdt-dtrace = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-sdt-dtrace-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-sdt-dtrace;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-sdt-dtrace}"
SRC_URI[x86_64_v2_systemtap-sdt-dtrace.sha256sum] = "4217cbfa567663b293c1500db118c1bdbf78bfff720889781265fc6c5d5a45cf"

URI_x86_64_v2_systemtap-server = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemtap-server-5.4-3.el10.x86_64_v2.rpm;name=x86_64_v2_systemtap-server;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemtap-server}"
SRC_URI[x86_64_v2_systemtap-server.sha256sum] = "42a1db3865c62d2465565b6b424a8bd1ada86adb9b6ff86f5e0af57c4235a9aa"

URI_aarch64_systemtap = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap}"
SRC_URI[aarch64_systemtap.sha256sum] = "f4f63c49c1b3e59bf0a7adf1a7169e7bb1f5d417f8ebabf9053f471eceee0626"

URI_aarch64_systemtap-client = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-client-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-client}"
SRC_URI[aarch64_systemtap-client.sha256sum] = "7f35ca04297c535dac5cad7f40dc9ebf1e720f90e04c22ca4c35377c6975caa8"

URI_aarch64_systemtap-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-devel-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-devel}"
SRC_URI[aarch64_systemtap-devel.sha256sum] = "0d8ac30e05f2ec1f05417e6647b394760ea0bd613d0cd3fb4dd6d76f956a367d"

URI_aarch64_systemtap-exporter = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-exporter-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-exporter;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-exporter}"
SRC_URI[aarch64_systemtap-exporter.sha256sum] = "a2cbfa00902c3b5d321f63cf3f95772c38c900b49ec613e0eaa272285203ef9f"

URI_aarch64_systemtap-initscript = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-initscript-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-initscript;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-initscript}"
SRC_URI[aarch64_systemtap-initscript.sha256sum] = "103203268f689e855789b18fcc41f52c6625a71171bf1d6fefa3eb96bd0fadcc"

URI_aarch64_systemtap-runtime = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-runtime;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime}"
SRC_URI[aarch64_systemtap-runtime.sha256sum] = "f0b17fdb3041b51214bfb1549d2fb8e6d02981baae173bac8eceed39b0fb412a"

URI_aarch64_systemtap-runtime-java = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-java-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-runtime-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-java}"
SRC_URI[aarch64_systemtap-runtime-java.sha256sum] = "0afb5f1a395fc32a2f20ee73cbc385b7d81c4992bdea19caf8625c0cb8a490bd"

URI_aarch64_systemtap-runtime-python3 = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-python3-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-runtime-python3;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-python3}"
SRC_URI[aarch64_systemtap-runtime-python3.sha256sum] = "f1a1918069541124c9d7f3a5bc3a678a0f6173e7ba13c0ebc8b534370d19c542"

URI_aarch64_systemtap-runtime-virtguest = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virtguest-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virtguest;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-virtguest}"
SRC_URI[aarch64_systemtap-runtime-virtguest.sha256sum] = "06de77a62a52dbe9fa80592a396cdaf0e7ec5a002c59f879b657e1d9ccce57da"

URI_aarch64_systemtap-runtime-virthost = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-runtime-virthost-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-runtime-virthost;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-runtime-virthost}"
SRC_URI[aarch64_systemtap-runtime-virthost.sha256sum] = "acc26a0a22e07ebfeb103890cf6f1e2246db5a3979430991d99492ed73923c9e"

URI_aarch64_systemtap-sdt-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-devel-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-sdt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-sdt-devel}"
SRC_URI[aarch64_systemtap-sdt-devel.sha256sum] = "d283eefcda20389b4c36c54ba529bec99633914d0b5fb89a7c4b9f895b3f7501"

URI_aarch64_systemtap-sdt-dtrace = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-sdt-dtrace-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-sdt-dtrace;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-sdt-dtrace}"
SRC_URI[aarch64_systemtap-sdt-dtrace.sha256sum] = "7d464a3f3b004105057b5b76aa265797305cbffcd2178a3d5e2702b4a3d6edb6"

URI_aarch64_systemtap-server = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemtap-server-5.4-3.el10.aarch64.rpm;name=aarch64_systemtap-server;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemtap-server}"
SRC_URI[aarch64_systemtap-server.sha256sum] = "07684092019ea20f4c3072361b56c7dcc6fc6f16c6a6e2de1c14f62ce708755f"

RDEPENDS:systemtap = " \
 bash \
 systemtap-client \
 systemtap-devel \
 "
RDEPENDS:systemtap-client:x86_64_v2 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 mokutil \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-client:aarch64 = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 elfutils-libs \
 glibc \
 grep \
 json-c \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssh-clients \
 perl-interpreter \
 readline \
 rpm-libs \
 sed \
 sqlite-libs \
 systemtap-runtime \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-devel = " \
 avahi-libs \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-devel \
 elfutils-libelf \
 elfutils-libs \
 gcc \
 glibc \
 json-c \
 libgcc \
 libstdc++ \
 make \
 nspr \
 nss \
 python3 \
 readline \
 rpm-libs \
 sqlite-libs \
 "
RDEPENDS:systemtap-exporter = " \
 bash \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-initscript = " \
 bash \
 systemd \
 systemtap \
 "
RDEPENDS:systemtap-runtime = " \
 bash \
 boost-system \
 dyninst \
 elfutils-debuginfod-client \
 elfutils-libelf \
 glibc \
 json-c \
 libgcc \
 libselinux \
 libstdc++ \
 ncurses-libs \
 nspr \
 nss \
 shadow-utils \
 "
RDEPENDS:systemtap-runtime-java = " \
 bash \
 byteman \
 glibc \
 iproute \
 java-21-openjdk-devel \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-python3 = " \
 glibc \
 python3 \
 systemtap-runtime \
 "
RDEPENDS:systemtap-runtime-virtguest = " \
 bash \
 findutils \
 grep \
 systemtap-runtime \
 virtual/coreutils \
 "
RDEPENDS:systemtap-runtime-virthost = " \
 glibc \
 libvirt-libs \
 libxml2 \
 "
RDEPENDS:systemtap-sdt-devel = " \
 systemtap-sdt-dtrace \
 "
RDEPENDS:systemtap-sdt-dtrace = " \
 python3 \
 python3-pyparsing \
 "
RDEPENDS:systemtap-server:x86_64_v2 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 openssl \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
RDEPENDS:systemtap-server:aarch64 = " \
 avahi-libs \
 bash \
 glibc \
 libgcc \
 libstdc++ \
 nspr \
 nss \
 shadow-utils \
 systemd \
 systemtap-devel \
 unzip \
 virtual/coreutils \
 zip \
"
