# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fern0.6"
PV = "0.6.2"
PR = "1.el10_0"
PACKAGES = " \
 rust-fern0.6+chrono-devel \
 rust-fern0.6+date-based-devel \
 rust-fern0.6+default-devel \
 rust-fern0.6+libc-devel \
 rust-fern0.6+meta-logging-in-format-devel \
 rust-fern0.6-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fern0.6-0.6.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "45b96a6f6ef9f10a4fe8cc7e4f4ed51d911b65397250a22fb5bea4cf500be6e2"

URI_x86_64_v2_rust-fern0.6+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern0.6+chrono-devel-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern0.6+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern0.6+chrono-devel}"
SRC_URI[x86_64_v2_rust-fern0.6+chrono-devel.sha256sum] = "54b42968d85838f9d3b4762f21ad50749dd6f2a0db3db4a2a564a45af2a02a5a"

URI_x86_64_v2_rust-fern0.6+date-based-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern0.6+date-based-devel-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern0.6+date-based-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern0.6+date-based-devel}"
SRC_URI[x86_64_v2_rust-fern0.6+date-based-devel.sha256sum] = "30eea6493d77b313e2b79d340311f7edfaf7c655fb81aaeb98251e4c36dc4073"

URI_x86_64_v2_rust-fern0.6+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern0.6+default-devel-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern0.6+default-devel}"
SRC_URI[x86_64_v2_rust-fern0.6+default-devel.sha256sum] = "99f7c012c34037baadcd70213259d2053dd4dca53bb0838b6be16e47b3fbe0f7"

URI_x86_64_v2_rust-fern0.6+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern0.6+libc-devel-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern0.6+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern0.6+libc-devel}"
SRC_URI[x86_64_v2_rust-fern0.6+libc-devel.sha256sum] = "d686928bd4e9ba4e37edf440f43dce165613cdb15ba4cf0d70f2b16a149edee3"

URI_x86_64_v2_rust-fern0.6+meta-logging-in-format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern0.6+meta-logging-in-format-devel-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern0.6+meta-logging-in-format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern0.6+meta-logging-in-format-devel}"
SRC_URI[x86_64_v2_rust-fern0.6+meta-logging-in-format-devel.sha256sum] = "e30901c4742e6690a0a273af348481f7886b24ba047f51890143785b2590f8d4"

URI_x86_64_v2_rust-fern0.6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern0.6-devel-0.6.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern0.6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern0.6-devel}"
SRC_URI[x86_64_v2_rust-fern0.6-devel.sha256sum] = "83dec08cc6c9ba5f5664f9a55926fadfd6698f4a00e0349268c6856b9b804169"

URI_aarch64_rust-fern0.6+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern0.6+chrono-devel-0.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-fern0.6+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern0.6+chrono-devel}"
SRC_URI[aarch64_rust-fern0.6+chrono-devel.sha256sum] = "7f8e8866394cca68cd4cedefd42a42ef60cb614dab78ac1120b54d5da5489872"

URI_aarch64_rust-fern0.6+date-based-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern0.6+date-based-devel-0.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-fern0.6+date-based-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern0.6+date-based-devel}"
SRC_URI[aarch64_rust-fern0.6+date-based-devel.sha256sum] = "3aedb76f76adc8af9ba3deb5fe0f6c62ac6177d044e9220474a2b69b518d5a46"

URI_aarch64_rust-fern0.6+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern0.6+default-devel-0.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-fern0.6+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern0.6+default-devel}"
SRC_URI[aarch64_rust-fern0.6+default-devel.sha256sum] = "bef933386c77ec663aa387a31a8ecbe2e1ee482bc393fefb82639d2e59e3bb9d"

URI_aarch64_rust-fern0.6+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern0.6+libc-devel-0.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-fern0.6+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern0.6+libc-devel}"
SRC_URI[aarch64_rust-fern0.6+libc-devel.sha256sum] = "ff95415e5a5390d4e3520ed67640e2f6feea6c2fbe0f8da74d79e7a32959b028"

URI_aarch64_rust-fern0.6+meta-logging-in-format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern0.6+meta-logging-in-format-devel-0.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-fern0.6+meta-logging-in-format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern0.6+meta-logging-in-format-devel}"
SRC_URI[aarch64_rust-fern0.6+meta-logging-in-format-devel.sha256sum] = "86832e911c93264d80fc1bc31e156dc1c0416e0ad7a10f9f2a1ae2e0f32b4af4"

URI_aarch64_rust-fern0.6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern0.6-devel-0.6.2-1.el10_0.noarch.rpm;name=aarch64_rust-fern0.6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern0.6-devel}"
SRC_URI[aarch64_rust-fern0.6-devel.sha256sum] = "b73844ce3268ad05d8f539a27c43f51c0509450d799ef89838cc9587083265c4"

RDEPENDS:rust-fern0.6+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-fern0.6-devel \
 "
RDEPENDS:rust-fern0.6+date-based-devel = " \
 cargo \
 rust-fern0.6+chrono-devel \
 rust-fern0.6-devel \
 "
RDEPENDS:rust-fern0.6+default-devel = " \
 cargo \
 rust-fern0.6-devel \
 "
RDEPENDS:rust-fern0.6+libc-devel = " \
 cargo \
 rust-fern0.6-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-fern0.6+meta-logging-in-format-devel = " \
 cargo \
 rust-fern0.6-devel \
 "
RDEPENDS:rust-fern0.6-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-log+std-devel \
 "
