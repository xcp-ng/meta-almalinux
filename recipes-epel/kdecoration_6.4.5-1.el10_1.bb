# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kdecoration"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 kdecoration \
 kdecoration-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kdecoration-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "daa8f07aeb3dd67d3f7b46eb62eea26516f1a61044a0e57c3c731cd5cb96332f"

URI_x86_64_v2_kdecoration = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdecoration}"
SRC_URI[x86_64_v2_kdecoration.sha256sum] = "aecbbc047cf024e449fc7ae17ec4276341af3b8caec3d49383d1bdb54877dee1"

URI_x86_64_v2_kdecoration-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kdecoration-devel-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kdecoration-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kdecoration-devel}"
SRC_URI[x86_64_v2_kdecoration-devel.sha256sum] = "69f5fa79dbf5c2d0f163938209d04194c1d845655f552ac7c105c22b194669a1"

URI_aarch64_kdecoration = "${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kdecoration;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdecoration}"
SRC_URI[aarch64_kdecoration.sha256sum] = "63b51ce596aae8804a27b57a1e1d035340f503ad61c0db5ccc6b385ee0c2a323"

URI_aarch64_kdecoration-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kdecoration-devel-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_kdecoration-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kdecoration-devel}"
SRC_URI[aarch64_kdecoration-devel.sha256sum] = "74d897ddb4ce83f3fa84482a07f8b61ae8054f544201541a87619c38a6a22184"

RDEPENDS:kdecoration = " \
 glibc \
 kf6-filesystem \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kdecoration-devel = " \
 cmake-filesystem \
 kdecoration \
 "
