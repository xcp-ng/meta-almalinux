# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glfw"
PE = "1"
PV = "3.4"
PR = "2.el10_0"
PACKAGES = " \
 glfw \
 glfw-devel \
 glfw-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/glfw-3.4-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "898430654f850c3f8429a4dc66a3c0c98959e0524c2b7aee8a23ec10b617bbc3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glfw-3.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glfw;unpack=0"
SRC_URI[x86_64_v2_glfw.sha256sum] = "2a3578cd7f0ccc97825ae1eb064c2d8a2f7312532815ea60f5a92eb4a7789f32"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glfw-devel-3.4-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glfw-devel;unpack=0"
SRC_URI[x86_64_v2_glfw-devel.sha256sum] = "dd28042ace8522eaa9491aad8ed15ef8abcfebbda5a7f7c024ac501607224bb2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glfw-doc-3.4-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_glfw-doc;unpack=0"
SRC_URI[x86_64_v2_glfw-doc.sha256sum] = "a0a4fbe42835fa6acfb3d140e8120f329d4848c2cd48b10a73d6ba1ea79bd7e0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/glfw-3.4-2.el10_0.aarch64.rpm;name=aarch64_glfw;unpack=0"
SRC_URI[aarch64_glfw.sha256sum] = "e2fa44099f2d8c11ccf4b14c5305a5a23acb17b203dea0a983df8b20a0a8afe3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/glfw-devel-3.4-2.el10_0.aarch64.rpm;name=aarch64_glfw-devel;unpack=0"
SRC_URI[aarch64_glfw-devel.sha256sum] = "96019e77b8edb084c1929b4e24fa87f9ad56eba33b84dedfbc8711afe12d10d1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/glfw-doc-3.4-2.el10_0.noarch.rpm;name=aarch64_glfw-doc;unpack=0"
SRC_URI[aarch64_glfw-doc.sha256sum] = "41a39d21878e545fece980bcea071ed47c05c667cdda0b081dfaadb131967af5"

RDEPENDS:glfw = " \
 glibc \
 "
RDEPENDS:glfw-devel = " \
 cmake-filesystem \
 glfw \
 libX11-devel \
 libXcursor-devel \
 libXi-devel \
 libXinerama-devel \
 libXrandr-devel \
 mesa-libGL-devel \
 mesa-libGLU-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:glfw-doc = " \
 "
