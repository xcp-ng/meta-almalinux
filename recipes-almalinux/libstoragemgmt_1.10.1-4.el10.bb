# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libstoragemgmt"
PV = "1.10.1"
PR = "4.el10"
PACKAGES = " \
 libstoragemgmt \
 libstoragemgmt-arcconf-plugin \
 libstoragemgmt-devel \
 libstoragemgmt-hpsa-plugin \
 libstoragemgmt-local-plugin \
 libstoragemgmt-megaraid-plugin \
 libstoragemgmt-nfs-plugin \
 libstoragemgmt-targetd-plugin \
 libstoragemgmt-udev \
 python3-libstoragemgmt \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libstoragemgmt-1.10.1-4.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a57ac0cfa31a73d62195263aa7526f9240d77aad95eceab62495bc242f6d04eb"

URI_x86_64_v2_libstoragemgmt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstoragemgmt-1.10.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libstoragemgmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstoragemgmt}"
SRC_URI[x86_64_v2_libstoragemgmt.sha256sum] = "2fe4dff8022f2806e430c19883bc6a6c6a6fffb5e6976d8439bce23c77aa8b46"

URI_x86_64_v2_libstoragemgmt-arcconf-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstoragemgmt-arcconf-plugin-1.10.1-4.el10.noarch.rpm;name=x86_64_v2_libstoragemgmt-arcconf-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstoragemgmt-arcconf-plugin}"
SRC_URI[x86_64_v2_libstoragemgmt-arcconf-plugin.sha256sum] = "30de68774ddb624c5805510a11731abff7da76ad9dec7396394d1a2ce1bd7d55"

URI_x86_64_v2_libstoragemgmt-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libstoragemgmt-devel-1.10.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libstoragemgmt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstoragemgmt-devel}"
SRC_URI[x86_64_v2_libstoragemgmt-devel.sha256sum] = "4570d60fbf8a764456823cf52a35cf2f3a487fb9e82441771c752d7b92a42706"

URI_x86_64_v2_libstoragemgmt-hpsa-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstoragemgmt-hpsa-plugin-1.10.1-4.el10.noarch.rpm;name=x86_64_v2_libstoragemgmt-hpsa-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstoragemgmt-hpsa-plugin}"
SRC_URI[x86_64_v2_libstoragemgmt-hpsa-plugin.sha256sum] = "d67f7a89af97285d8d13ea186f414ec53397dabe3ddb808261f062c887ef3151"

URI_x86_64_v2_libstoragemgmt-local-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstoragemgmt-local-plugin-1.10.1-4.el10.noarch.rpm;name=x86_64_v2_libstoragemgmt-local-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstoragemgmt-local-plugin}"
SRC_URI[x86_64_v2_libstoragemgmt-local-plugin.sha256sum] = "5322915996e6a37d05e60960d0f3faa5b0b9a926c6620d9558a5ea0dc3682fe6"

URI_x86_64_v2_libstoragemgmt-megaraid-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstoragemgmt-megaraid-plugin-1.10.1-4.el10.noarch.rpm;name=x86_64_v2_libstoragemgmt-megaraid-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstoragemgmt-megaraid-plugin}"
SRC_URI[x86_64_v2_libstoragemgmt-megaraid-plugin.sha256sum] = "a3a4ad3818fe8b26c6aef60bebd0e47119d421cdadad4cbc6aefb45ec68ef637"

URI_x86_64_v2_libstoragemgmt-nfs-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstoragemgmt-nfs-plugin-1.10.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libstoragemgmt-nfs-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstoragemgmt-nfs-plugin}"
SRC_URI[x86_64_v2_libstoragemgmt-nfs-plugin.sha256sum] = "d3cb578625a959aa30e1359efef47cdee3c0e4caf0b5d99c537b9e58365b94b6"

URI_x86_64_v2_libstoragemgmt-targetd-plugin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstoragemgmt-targetd-plugin-1.10.1-4.el10.noarch.rpm;name=x86_64_v2_libstoragemgmt-targetd-plugin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstoragemgmt-targetd-plugin}"
SRC_URI[x86_64_v2_libstoragemgmt-targetd-plugin.sha256sum] = "31860b6843b5fc2d119c0e45464ed986932035178105951a491338f479af3d3a"

URI_x86_64_v2_libstoragemgmt-udev = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libstoragemgmt-udev-1.10.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_libstoragemgmt-udev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libstoragemgmt-udev}"
SRC_URI[x86_64_v2_libstoragemgmt-udev.sha256sum] = "5e48c54c50290494083fef2327b8eb3898acb8b236151852a71bed5fc2278191"

URI_x86_64_v2_python3-libstoragemgmt = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libstoragemgmt-1.10.1-4.el10.x86_64_v2.rpm;name=x86_64_v2_python3-libstoragemgmt;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libstoragemgmt}"
SRC_URI[x86_64_v2_python3-libstoragemgmt.sha256sum] = "62acb9ec26ef78f244d3dee8355878700407affe6f81695ed472438776cebcf9"

URI_aarch64_libstoragemgmt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstoragemgmt-1.10.1-4.el10.aarch64.rpm;name=aarch64_libstoragemgmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstoragemgmt}"
SRC_URI[aarch64_libstoragemgmt.sha256sum] = "8e9bf69ba54387e26ecb6d2ea1ae8810ebc031ae3d4e7d0a7fb0f50f8fa11dbc"

URI_aarch64_libstoragemgmt-arcconf-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstoragemgmt-arcconf-plugin-1.10.1-4.el10.noarch.rpm;name=aarch64_libstoragemgmt-arcconf-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstoragemgmt-arcconf-plugin}"
SRC_URI[aarch64_libstoragemgmt-arcconf-plugin.sha256sum] = "30de68774ddb624c5805510a11731abff7da76ad9dec7396394d1a2ce1bd7d55"

URI_aarch64_libstoragemgmt-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libstoragemgmt-devel-1.10.1-4.el10.aarch64.rpm;name=aarch64_libstoragemgmt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstoragemgmt-devel}"
SRC_URI[aarch64_libstoragemgmt-devel.sha256sum] = "f860085e86876f889a98e7a373874a0acc08af36170e605d7b54e41f7be10c0e"

URI_aarch64_libstoragemgmt-hpsa-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstoragemgmt-hpsa-plugin-1.10.1-4.el10.noarch.rpm;name=aarch64_libstoragemgmt-hpsa-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstoragemgmt-hpsa-plugin}"
SRC_URI[aarch64_libstoragemgmt-hpsa-plugin.sha256sum] = "d67f7a89af97285d8d13ea186f414ec53397dabe3ddb808261f062c887ef3151"

URI_aarch64_libstoragemgmt-local-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstoragemgmt-local-plugin-1.10.1-4.el10.noarch.rpm;name=aarch64_libstoragemgmt-local-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstoragemgmt-local-plugin}"
SRC_URI[aarch64_libstoragemgmt-local-plugin.sha256sum] = "5322915996e6a37d05e60960d0f3faa5b0b9a926c6620d9558a5ea0dc3682fe6"

URI_aarch64_libstoragemgmt-megaraid-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstoragemgmt-megaraid-plugin-1.10.1-4.el10.noarch.rpm;name=aarch64_libstoragemgmt-megaraid-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstoragemgmt-megaraid-plugin}"
SRC_URI[aarch64_libstoragemgmt-megaraid-plugin.sha256sum] = "a3a4ad3818fe8b26c6aef60bebd0e47119d421cdadad4cbc6aefb45ec68ef637"

URI_aarch64_libstoragemgmt-nfs-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstoragemgmt-nfs-plugin-1.10.1-4.el10.aarch64.rpm;name=aarch64_libstoragemgmt-nfs-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstoragemgmt-nfs-plugin}"
SRC_URI[aarch64_libstoragemgmt-nfs-plugin.sha256sum] = "8bb6c9e2cccc2660b02461d7ecaa5eff3168df75cfc68cbc7bfe8b99a5d327a8"

URI_aarch64_libstoragemgmt-targetd-plugin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstoragemgmt-targetd-plugin-1.10.1-4.el10.noarch.rpm;name=aarch64_libstoragemgmt-targetd-plugin;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstoragemgmt-targetd-plugin}"
SRC_URI[aarch64_libstoragemgmt-targetd-plugin.sha256sum] = "31860b6843b5fc2d119c0e45464ed986932035178105951a491338f479af3d3a"

URI_aarch64_libstoragemgmt-udev = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libstoragemgmt-udev-1.10.1-4.el10.aarch64.rpm;name=aarch64_libstoragemgmt-udev;unpack=0"
SRC_URI:append = " ${URI_aarch64_libstoragemgmt-udev}"
SRC_URI[aarch64_libstoragemgmt-udev.sha256sum] = "b070c8513d4aef072cd400164cefd7442f834e6f742883680c4a80e5ccad5550"

URI_aarch64_python3-libstoragemgmt = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libstoragemgmt-1.10.1-4.el10.aarch64.rpm;name=aarch64_python3-libstoragemgmt;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libstoragemgmt}"
SRC_URI[aarch64_python3-libstoragemgmt.sha256sum] = "6a155a12d34d7f41b8c0f6699ab7735c5b8187d0ced6daf7157a0b9ec76689b1"

RDEPENDS:libstoragemgmt = " \
 bash \
 glib2 \
 glibc \
 ledmon-libs \
 libconfig \
 libgcc \
 libstdc++ \
 python3 \
 python3-libstoragemgmt \
 sg3_utils-libs \
 sqlite-libs \
 systemd \
 systemd-libs \
 "
RDEPENDS:libstoragemgmt-arcconf-plugin = " \
 bash \
 python3 \
 python3-libstoragemgmt \
 "
RDEPENDS:libstoragemgmt-devel = " \
 libstoragemgmt \
 pkgconf-pkg-config \
 "
RDEPENDS:libstoragemgmt-hpsa-plugin = " \
 bash \
 python3 \
 python3-libstoragemgmt \
 "
RDEPENDS:libstoragemgmt-local-plugin = " \
 bash \
 libstoragemgmt-arcconf-plugin \
 libstoragemgmt-hpsa-plugin \
 python3 \
 python3-libstoragemgmt \
 "
RDEPENDS:libstoragemgmt-megaraid-plugin = " \
 bash \
 python3 \
 python3-libstoragemgmt \
 "
RDEPENDS:libstoragemgmt-nfs-plugin = " \
 bash \
 glib2 \
 glibc \
 ledmon-libs \
 libstoragemgmt \
 nfs-utils \
 python3 \
 python3-libstoragemgmt \
 sg3_utils-libs \
 systemd-libs \
 "
RDEPENDS:libstoragemgmt-targetd-plugin = " \
 bash \
 python3 \
 python3-libstoragemgmt \
 "
RDEPENDS:libstoragemgmt-udev = " \
 glibc \
 "
RDEPENDS:python3-libstoragemgmt = " \
 glib2 \
 glibc \
 ledmon-libs \
 libstoragemgmt \
 python3 \
 python3-six \
 sg3_utils-libs \
 systemd-libs \
 "
