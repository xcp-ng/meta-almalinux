# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-num-conv"
PV = "0.1.0"
PR = "2.el10_0"
PACKAGES = " \
 rust-num-conv+default-devel \
 rust-num-conv-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-num-conv-0.1.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6fca997ae20621c458c27ddce6b0aff382cdd6c97b773854d9b1452979ffbabd"

URI_x86_64_v2_rust-num-conv+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-conv+default-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-conv+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-conv+default-devel}"
SRC_URI[x86_64_v2_rust-num-conv+default-devel.sha256sum] = "99458b60973d627668d6fe86e5cb02d8c597c3c628ec46e0a7bd22a7da792c91"

URI_x86_64_v2_rust-num-conv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-num-conv-devel-0.1.0-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-num-conv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-num-conv-devel}"
SRC_URI[x86_64_v2_rust-num-conv-devel.sha256sum] = "a5e19ed2fcc78984f1081a824904fc95e27e46f7687db31386d4af9c64fab80e"

URI_aarch64_rust-num-conv+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-conv+default-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-num-conv+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-conv+default-devel}"
SRC_URI[aarch64_rust-num-conv+default-devel.sha256sum] = "f121be4fcf3b4cf85364e875504f156a3d95113c304881e067473f2058205354"

URI_aarch64_rust-num-conv-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-num-conv-devel-0.1.0-2.el10_0.noarch.rpm;name=aarch64_rust-num-conv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-num-conv-devel}"
SRC_URI[aarch64_rust-num-conv-devel.sha256sum] = "e4e7a83ae479a1048384735d1dadd0d994509299d94747d9a6bfaf0cce9974c0"

RDEPENDS:rust-num-conv+default-devel = " \
 cargo \
 rust-num-conv-devel \
 "
RDEPENDS:rust-num-conv-devel = " \
 cargo \
 rust \
 "
