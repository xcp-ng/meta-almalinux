# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-typetag-impl"
PV = "0.2.23"
PR = "1.el10_3"
PACKAGES = " \
 rust-typetag-impl+default-devel \
 rust-typetag-impl-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-typetag-impl-0.2.23-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "38272d401775161572459d0942f7b4c19397b29900fb342d80924c90219b5eb5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-impl+default-devel-0.2.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-impl+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-typetag-impl+default-devel.sha256sum] = "252c2b17356c271e1b59affe08949827c9bef57eb145b414b1e0dfcf8286b5c7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-typetag-impl-devel-0.2.23-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-typetag-impl-devel;unpack=0"
SRC_URI[x86_64_v2_rust-typetag-impl-devel.sha256sum] = "c4e93e30e33dd03c77c157fbb51118383991d4638d1eb4eaf5c1e746f835b693"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-impl+default-devel-0.2.23-1.el10_3.noarch.rpm;name=aarch64_rust-typetag-impl+default-devel;unpack=0"
SRC_URI[aarch64_rust-typetag-impl+default-devel.sha256sum] = "c4a1c61d414a813b190dbbfcc332b4a2c1be748faab069293885ecf6b5586b88"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-typetag-impl-devel-0.2.23-1.el10_3.noarch.rpm;name=aarch64_rust-typetag-impl-devel;unpack=0"
SRC_URI[aarch64_rust-typetag-impl-devel.sha256sum] = "ab8194354084ddd99b33b510067f91e64a18fe55adb3409bc9016995f731c431"

RDEPENDS:rust-typetag-impl+default-devel = " \
 cargo \
 rust-typetag-impl-devel \
 "
RDEPENDS:rust-typetag-impl-devel = " \
 cargo \
 rust \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
