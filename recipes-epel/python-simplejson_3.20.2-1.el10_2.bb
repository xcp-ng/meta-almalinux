# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-simplejson"
PV = "3.20.2"
PR = "1.el10_2"
PACKAGES = " \
 python-simplejson-doc \
 python3-simplejson \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-simplejson-3.20.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "12194a8a3e9fafdfcacaaca0349a2e8dc327bc69fabc27cbe3e0ec266e9b192c"

URI_x86_64_v2_python-simplejson-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-simplejson-doc-3.20.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python-simplejson-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-simplejson-doc}"
SRC_URI[x86_64_v2_python-simplejson-doc.sha256sum] = "8fac6cb5354a383844ec2638168463fb6d6298eec5a590e49faf4b6405e4c969"

URI_x86_64_v2_python3-simplejson = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-simplejson-3.20.2-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-simplejson;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-simplejson}"
SRC_URI[x86_64_v2_python3-simplejson.sha256sum] = "e28be1c2d3f169c2a6e8a11186673c6da51198e7028d1e78ca950dd30cf1f606"

URI_aarch64_python-simplejson-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-simplejson-doc-3.20.2-1.el10_2.aarch64.rpm;name=aarch64_python-simplejson-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-simplejson-doc}"
SRC_URI[aarch64_python-simplejson-doc.sha256sum] = "e5d2b5b525e05dc2752e817582fb9b974c40d631247a5bef4a2256c83f04b2a2"

URI_aarch64_python3-simplejson = "${EPEL_MIRROR}/aarch64/Packages/p/python3-simplejson-3.20.2-1.el10_2.aarch64.rpm;name=aarch64_python3-simplejson;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-simplejson}"
SRC_URI[aarch64_python3-simplejson.sha256sum] = "41652fb2770920b40bc3255296267f88246ac21c97d07d95c8e604cd173615f0"

RDEPENDS:python-simplejson-doc = " \
 "
RDEPENDS:python3-simplejson = " \
 glibc \
 python3 \
 "
