# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xorg-x11-server-Xwayland"
PV = "24.1.9"
PR = "7.el10"
PACKAGES = " \
 xorg-x11-server-Xwayland \
 xorg-x11-server-Xwayland-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xorg-x11-server-Xwayland-24.1.9-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7994c9452cdb8ecebf80b09ee0dc677e2d7d4b78ffc0a7d2eee6d3936dfd2561"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-24.1.9-7.el10.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland;unpack=0"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland.sha256sum] = "6f36580f56e683d4e337b24f465cf8bc97e6b7e7d9d26fe4a9b7369e62748a09"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/xorg-x11-server-Xwayland-devel-24.1.9-7.el10.x86_64_v2.rpm;name=x86_64_v2_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI[x86_64_v2_xorg-x11-server-Xwayland-devel.sha256sum] = "4209362aa28992f67db8b0dd3f33bebce6d6eee988dc0157e3578f8d113a8895"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xorg-x11-server-Xwayland-24.1.9-7.el10.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland;unpack=0"
SRC_URI[aarch64_xorg-x11-server-Xwayland.sha256sum] = "03b47114f7a2536e1a2b80da7b64ab93073a781017cc8be2db98ad7bf028353c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/xorg-x11-server-Xwayland-devel-24.1.9-7.el10.aarch64.rpm;name=aarch64_xorg-x11-server-Xwayland-devel;unpack=0"
SRC_URI[aarch64_xorg-x11-server-Xwayland-devel.sha256sum] = "106c2efdc291bcd21bd5e420c009ce602152b14781b6dfaf263e904c7ff3ca6e"

RDEPENDS:xorg-x11-server-Xwayland = " \
 audit-libs \
 glibc \
 libXau \
 libXdmcp \
 libXfont2 \
 libdecor \
 libdrm \
 libei \
 libepoxy \
 libglvnd-egl \
 libglvnd-glx \
 liboeffis \
 libselinux \
 libtirpc \
 libwayland-client \
 libxcvt \
 libxshmfence \
 mesa-libgbm \
 openssl-libs \
 pixman \
 xkbcomp \
 xkeyboard-config \
 "
RDEPENDS:xorg-x11-server-Xwayland-devel = " \
 pkgconf-pkg-config \
 xorg-x11-server-Xwayland \
 "
