# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pyshp"
PV = "2.3.1"
PR = "15.el10_0"
PACKAGES = " \
 python3-pyshp \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pyshp-2.3.1-15.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "856229000f68d8ad1a5b9c099921565983dd91bfe2721dc6292f072781129882"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyshp-2.3.1-15.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyshp;unpack=0"
SRC_URI[x86_64_v2_python3-pyshp.sha256sum] = "18de5b11894cf907d230ec5252610f34ec89fd5ef0283efe333a6b7fe5ea26d6"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pyshp-2.3.1-15.el10_0.noarch.rpm;name=aarch64_python3-pyshp;unpack=0"
SRC_URI[aarch64_python3-pyshp.sha256sum] = "3919069cb0c0e1c039b580e4b73069de36e0baf187cd75ad2105462b6ff50414"

RDEPENDS:python3-pyshp = " \
 python3 \
 "
