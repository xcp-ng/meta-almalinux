# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hex-literal0.3"
PV = "0.3.4"
PR = "4.el10_0"
PACKAGES = " \
 rust-hex-literal0.3+default-devel \
 rust-hex-literal0.3-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-hex-literal0.3-0.3.4-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2db47161fe1176076904c80ff80a00d96b4cebda213a725a019216591f212c90"

URI_x86_64_v2_rust-hex-literal0.3+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal0.3+default-devel-0.3.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex-literal0.3+default-devel}"
SRC_URI[x86_64_v2_rust-hex-literal0.3+default-devel.sha256sum] = "ffa075733c37e5daa410a44415401abd1a112ea7b01a9377e2e41b891bad3477"

URI_x86_64_v2_rust-hex-literal0.3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hex-literal0.3-devel-0.3.4-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hex-literal0.3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-hex-literal0.3-devel}"
SRC_URI[x86_64_v2_rust-hex-literal0.3-devel.sha256sum] = "a835f931b3f1e9aa29375cba8ba23a79dde00e008c4cb9c522769fca24d4e504"

URI_aarch64_rust-hex-literal0.3+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal0.3+default-devel-0.3.4-4.el10_0.noarch.rpm;name=aarch64_rust-hex-literal0.3+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex-literal0.3+default-devel}"
SRC_URI[aarch64_rust-hex-literal0.3+default-devel.sha256sum] = "1d695afde7d22cabe933c87b5b9ed37fb0653e7d55e3f84e55dcc8808bb0a269"

URI_aarch64_rust-hex-literal0.3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-hex-literal0.3-devel-0.3.4-4.el10_0.noarch.rpm;name=aarch64_rust-hex-literal0.3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-hex-literal0.3-devel}"
SRC_URI[aarch64_rust-hex-literal0.3-devel.sha256sum] = "604e3830a8195aa668ea4d5b3e5220db3d27faec463d13ec3aac2c95c0da06dd"

RDEPENDS:rust-hex-literal0.3+default-devel = " \
 cargo \
 rust-hex-literal0.3-devel \
 "
RDEPENDS:rust-hex-literal0.3-devel = " \
 cargo \
 "
