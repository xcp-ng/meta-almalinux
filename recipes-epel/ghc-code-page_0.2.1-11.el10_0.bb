# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-code-page"
PV = "0.2.1"
PR = "11.el10_0"
PACKAGES = " \
 ghc-code-page \
 ghc-code-page-devel \
 ghc-code-page-doc \
 ghc-code-page-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-code-page-0.2.1-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4c943e9d059b88b222464b131b6b9aea6fd2243fd0876c72cc49f0fc79a09e17"

URI_x86_64_v2_ghc-code-page = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-code-page-0.2.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-code-page;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-code-page}"
SRC_URI[x86_64_v2_ghc-code-page.sha256sum] = "c6fb83e58425df0d597818ae10c8e08e210b31d157d7a470c7996d529f8cc739"

URI_x86_64_v2_ghc-code-page-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-code-page-devel-0.2.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-code-page-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-code-page-devel}"
SRC_URI[x86_64_v2_ghc-code-page-devel.sha256sum] = "d208939db7d30987556a5e6079cedb9adccf0f9c9dbc16e449c3216b789af906"

URI_x86_64_v2_ghc-code-page-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-code-page-doc-0.2.1-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-code-page-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-code-page-doc}"
SRC_URI[x86_64_v2_ghc-code-page-doc.sha256sum] = "028abf0753e4def1e7c103ab20429730988a82c8f591e0dcb78cdb16407edc89"

URI_x86_64_v2_ghc-code-page-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-code-page-prof-0.2.1-11.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-code-page-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-code-page-prof}"
SRC_URI[x86_64_v2_ghc-code-page-prof.sha256sum] = "703ced7e9bad37a4da1593747d0dc3a22bbb9645632f32cf571078e83ba35556"

URI_aarch64_ghc-code-page = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-code-page-0.2.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-code-page;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-code-page}"
SRC_URI[aarch64_ghc-code-page.sha256sum] = "94e0cc7390cacce3ab5cf082e891783bd704f417d1aa5838aa53bb1491ebd763"

URI_aarch64_ghc-code-page-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-code-page-devel-0.2.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-code-page-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-code-page-devel}"
SRC_URI[aarch64_ghc-code-page-devel.sha256sum] = "fbc64ef7237b79ccf71447f6e6763d46c558174a49ca39bfaaeafb2ff26021fa"

URI_aarch64_ghc-code-page-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-code-page-doc-0.2.1-11.el10_0.noarch.rpm;name=aarch64_ghc-code-page-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-code-page-doc}"
SRC_URI[aarch64_ghc-code-page-doc.sha256sum] = "81c35dc9632f9fc6567f522998e50dfb6f57b9070e591f13176d93b3bb9f3b66"

URI_aarch64_ghc-code-page-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-code-page-prof-0.2.1-11.el10_0.aarch64.rpm;name=aarch64_ghc-code-page-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-code-page-prof}"
SRC_URI[aarch64_ghc-code-page-prof.sha256sum] = "278dbe6ada2ab8fa98e649c5f7d2962c0e830e87a3a3d11f4fa2d0d9cb64dafb"

RDEPENDS:ghc-code-page = " \
 ghc-base \
 ghc-ghc-bignum \
 glibc \
 gmp \
 "
RDEPENDS:ghc-code-page-devel = " \
 ghc-base-devel \
 ghc-code-page \
 ghc-compiler \
 "
RDEPENDS:ghc-code-page-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-code-page-prof = " \
 ghc-base-prof \
 ghc-code-page-devel \
 "
