# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "aws-c-http"
PV = "0.9.7"
PR = "2.el10_0"
PACKAGES = " \
 aws-c-http \
 aws-c-http-devel \
 aws-c-http-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/aws-c-http-0.9.7-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cbc2745bc83034f29df068eb757a680906c198b3d5184f3070dbfd2c94c89f93"

URI_x86_64_v2_aws-c-http = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-http-0.9.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-http;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-http}"
SRC_URI[x86_64_v2_aws-c-http.sha256sum] = "9635e2b12ebd446a6562cf29cdb085e8b9c464ea68024ed7983d4ca73f1aea34"

URI_x86_64_v2_aws-c-http-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-http-devel-0.9.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-http-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-http-devel}"
SRC_URI[x86_64_v2_aws-c-http-devel.sha256sum] = "1d64435b3cf0dcf8a51de3587c84dd22634d54e1fe0881dbe48846d8bc687126"

URI_x86_64_v2_aws-c-http-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/aws-c-http-libs-0.9.7-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_aws-c-http-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_aws-c-http-libs}"
SRC_URI[x86_64_v2_aws-c-http-libs.sha256sum] = "e632426505b971ef09e3a3a216371f6f1adcedbfa70c7345203e24ee23bc4fff"

URI_aarch64_aws-c-http = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-http-0.9.7-2.el10_0.aarch64.rpm;name=aarch64_aws-c-http;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-http}"
SRC_URI[aarch64_aws-c-http.sha256sum] = "20aa84e06790ff1e6822b4173fd5fc10a978ecad376c699591a86edac144b165"

URI_aarch64_aws-c-http-devel = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-http-devel-0.9.7-2.el10_0.aarch64.rpm;name=aarch64_aws-c-http-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-http-devel}"
SRC_URI[aarch64_aws-c-http-devel.sha256sum] = "6b733aa4e82e64b74dd22d0ed1e6c8351ade98aa46bd912163bc51e131bcf978"

URI_aarch64_aws-c-http-libs = "${EPEL_MIRROR}/aarch64/Packages/a/aws-c-http-libs-0.9.7-2.el10_0.aarch64.rpm;name=aarch64_aws-c-http-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_aws-c-http-libs}"
SRC_URI[aarch64_aws-c-http-libs.sha256sum] = "f61f64261156a4f6b379849dfe2f12554803bd648800db77bee8712977d1409e"

RDEPENDS:aws-c-http = " \
 aws-c-common-libs \
 aws-c-http-libs \
 aws-c-io \
 glibc \
 "
RDEPENDS:aws-c-http-devel = " \
 aws-c-compression-devel \
 aws-c-http-libs \
 aws-c-io-devel \
 cmake-filesystem \
 openssl-devel \
 "
RDEPENDS:aws-c-http-libs = " \
 aws-c-cal-libs \
 aws-c-common-libs \
 aws-c-compression-libs \
 aws-c-io \
 glibc \
 "
