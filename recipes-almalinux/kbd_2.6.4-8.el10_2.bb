# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kbd"
PV = "2.6.4"
PR = "8.el10_2"
PACKAGES = " \
 kbd \
 kbd-legacy \
 kbd-misc \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/kbd-2.6.4-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2f750c639308ec532dec0eadfd5c8a79a550b41ecc0c8301da8b387685261016"

URI_x86_64_v2_kbd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kbd-2.6.4-8.el10_2.x86_64_v2.rpm;name=x86_64_v2_kbd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbd}"
SRC_URI[x86_64_v2_kbd.sha256sum] = "461bbc4c77f685550177b46b615f190c605d18f75d387f5f09ff316730f1e771"

URI_x86_64_v2_kbd-legacy = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kbd-legacy-2.6.4-8.el10_2.noarch.rpm;name=x86_64_v2_kbd-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbd-legacy}"
SRC_URI[x86_64_v2_kbd-legacy.sha256sum] = "5cee51a736ce671b613c202d20d8e0f6a95225637cbe4d50a835bcc5ad73f7d8"

URI_x86_64_v2_kbd-misc = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/kbd-misc-2.6.4-8.el10_2.noarch.rpm;name=x86_64_v2_kbd-misc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kbd-misc}"
SRC_URI[x86_64_v2_kbd-misc.sha256sum] = "dfda76f88d7916ddce2e03f78a2e971cb8b9657c8f23bc23a2a4003929e17ad0"

URI_aarch64_kbd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kbd-2.6.4-8.el10_2.aarch64.rpm;name=aarch64_kbd;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbd}"
SRC_URI[aarch64_kbd.sha256sum] = "05532970add98749242a3b5ea03e408d91417159b430949cc0263df1df2b3acc"

URI_aarch64_kbd-legacy = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kbd-legacy-2.6.4-8.el10_2.noarch.rpm;name=aarch64_kbd-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbd-legacy}"
SRC_URI[aarch64_kbd-legacy.sha256sum] = "5cee51a736ce671b613c202d20d8e0f6a95225637cbe4d50a835bcc5ad73f7d8"

URI_aarch64_kbd-misc = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/kbd-misc-2.6.4-8.el10_2.noarch.rpm;name=aarch64_kbd-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kbd-misc}"
SRC_URI[aarch64_kbd-misc.sha256sum] = "dfda76f88d7916ddce2e03f78a2e971cb8b9657c8f23bc23a2a4003929e17ad0"

RDEPENDS:kbd = " \
 bash \
 glibc \
 kbd-legacy \
 kbd-misc \
 pam-libs \
 "
RDEPENDS:kbd-legacy = " \
 "
RDEPENDS:kbd-misc = " \
 "
