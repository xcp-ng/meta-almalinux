# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libarrow"
PV = "17.0.0"
PR = "6.el10_0"
PACKAGES = " \
 libarrow \
 libarrow-acero-devel \
 libarrow-acero-libs \
 libarrow-dataset-devel \
 libarrow-dataset-glib-devel \
 libarrow-dataset-glib-libs \
 libarrow-dataset-libs \
 libarrow-devel \
 libarrow-doc \
 libarrow-flight-devel \
 libarrow-flight-libs \
 libarrow-glib-devel \
 libarrow-glib-libs \
 libarrow-python-devel \
 libarrow-python-flight-devel \
 libarrow-python-flight-libs \
 libarrow-python-libs \
 parquet-glib-devel \
 parquet-glib-libs \
 parquet-libs \
 parquet-libs-devel \
 python3-pyarrow \
 python3-pyarrow-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libarrow-17.0.0-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af385d04690790f5b1e292ac7c20edbf0db10e391a0abf906c7762c524453595"

URI_x86_64_v2_libarrow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow}"
SRC_URI[x86_64_v2_libarrow.sha256sum] = "badc5328290e4d44febd231f1c54bf0f6ab1424ecc8f48480a19c3093320a9e8"

URI_x86_64_v2_libarrow-acero-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-acero-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-acero-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-acero-devel}"
SRC_URI[x86_64_v2_libarrow-acero-devel.sha256sum] = "349d45522e970c2aa6492e509d62cfc2c9016a87310296c2e50b84554b3c2be0"

URI_x86_64_v2_libarrow-acero-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-acero-libs-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-acero-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-acero-libs}"
SRC_URI[x86_64_v2_libarrow-acero-libs.sha256sum] = "d292f5c255e6689b1c6d382535a28bfaefcf167ddd32dd7a156fd3670ffd7c53"

URI_x86_64_v2_libarrow-dataset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-devel}"
SRC_URI[x86_64_v2_libarrow-dataset-devel.sha256sum] = "46e97e99f49fb7ee076354d86da0185b26808cfdc7d0f2ae3b87e0b5a4939160"

URI_x86_64_v2_libarrow-dataset-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-glib-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-glib-devel}"
SRC_URI[x86_64_v2_libarrow-dataset-glib-devel.sha256sum] = "e34f3ab6306607e5109311dc845f0e7c2e8d32cdefeb34b4288c38fb2e0cda53"

URI_x86_64_v2_libarrow-dataset-glib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-glib-libs-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-glib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-glib-libs}"
SRC_URI[x86_64_v2_libarrow-dataset-glib-libs.sha256sum] = "2c1b95cf18df6050180eae510b8b7223971ace987197935bdf42fdae048e1f4c"

URI_x86_64_v2_libarrow-dataset-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-dataset-libs-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-dataset-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-dataset-libs}"
SRC_URI[x86_64_v2_libarrow-dataset-libs.sha256sum] = "cabd9e860a394f672f48333e2a72cf38fe4927252033ecd60cdcc5f32e0bad38"

URI_x86_64_v2_libarrow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-devel}"
SRC_URI[x86_64_v2_libarrow-devel.sha256sum] = "e082e59fd1a8ad714d78606420e270f032982899ac32193f4dea1da6c3ac0191"

URI_x86_64_v2_libarrow-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-doc-17.0.0-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_libarrow-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-doc}"
SRC_URI[x86_64_v2_libarrow-doc.sha256sum] = "1d316e27934645f785717bc83f915495c7b345c0f01287e2efb1f682d1b4117f"

URI_x86_64_v2_libarrow-flight-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-flight-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-flight-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-flight-devel}"
SRC_URI[x86_64_v2_libarrow-flight-devel.sha256sum] = "f6ae7da41205e9146d0c5a4c1e4065b690afaa69109e1972d02d1f4e93f7944f"

URI_x86_64_v2_libarrow-flight-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-flight-libs-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-flight-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-flight-libs}"
SRC_URI[x86_64_v2_libarrow-flight-libs.sha256sum] = "e173d2414161b0db6edd6487fe293b3b916c9e23122454a99dc9658d8a9a2ad9"

URI_x86_64_v2_libarrow-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-glib-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-glib-devel}"
SRC_URI[x86_64_v2_libarrow-glib-devel.sha256sum] = "5add91aad053bce36133e5f6226533a4a350747c67de61ff822158f827e4eda8"

URI_x86_64_v2_libarrow-glib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-glib-libs-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-glib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-glib-libs}"
SRC_URI[x86_64_v2_libarrow-glib-libs.sha256sum] = "4dea419591a1b3a1e508eaaee5097b7431f80705647779a56dda3b36049612b6"

URI_x86_64_v2_libarrow-python-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-devel}"
SRC_URI[x86_64_v2_libarrow-python-devel.sha256sum] = "d634e24571db941fe18dfe7845ef15efdc2f5227a72e64578010cdeb3f95fa03"

URI_x86_64_v2_libarrow-python-flight-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-flight-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-flight-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-flight-devel}"
SRC_URI[x86_64_v2_libarrow-python-flight-devel.sha256sum] = "73f0b86221ed0fd2d4dbdf02501fed10b1bd3f4deec415c91ea3ad4b9833e200"

URI_x86_64_v2_libarrow-python-flight-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-flight-libs-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-flight-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-flight-libs}"
SRC_URI[x86_64_v2_libarrow-python-flight-libs.sha256sum] = "502b51be3a9e7d36438e5c8473286d29c67fce2466ffd87ae1277975098bd6f3"

URI_x86_64_v2_libarrow-python-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libarrow-python-libs-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libarrow-python-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libarrow-python-libs}"
SRC_URI[x86_64_v2_libarrow-python-libs.sha256sum] = "eb90a3fae043520196ee0de484087056ceadb7abc854781eea27ebbc1ad44948"

URI_x86_64_v2_parquet-glib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-glib-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-glib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-glib-devel}"
SRC_URI[x86_64_v2_parquet-glib-devel.sha256sum] = "baf9d8cf0fa5fd75b61b91d017f66a46c91774485db7187b7afb62e541de62e9"

URI_x86_64_v2_parquet-glib-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-glib-libs-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-glib-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-glib-libs}"
SRC_URI[x86_64_v2_parquet-glib-libs.sha256sum] = "a2912175c6116621cf5251ad8f3f694fa3f6db97ec036f272495fb66a1f36b10"

URI_x86_64_v2_parquet-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-libs-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-libs}"
SRC_URI[x86_64_v2_parquet-libs.sha256sum] = "7d507b151d736ef34805dc2aa919fcecc37adbd8876104739a362a6d5361acd6"

URI_x86_64_v2_parquet-libs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/parquet-libs-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_parquet-libs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_parquet-libs-devel}"
SRC_URI[x86_64_v2_parquet-libs-devel.sha256sum] = "b3a02da9f0067a77c6b46ca153816482a1947617af1dcca6e09a40e77ebae321"

URI_x86_64_v2_python3-pyarrow = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyarrow-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyarrow;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyarrow}"
SRC_URI[x86_64_v2_python3-pyarrow.sha256sum] = "254f2f6b61a30f3b666e47b065de5aa9635aaabff2c3ca33d6c5b0cf15c79245"

URI_x86_64_v2_python3-pyarrow-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyarrow-devel-17.0.0-6.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pyarrow-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pyarrow-devel}"
SRC_URI[x86_64_v2_python3-pyarrow-devel.sha256sum] = "b1ae48661f215709cd476afb361f65230bc5f2d38d7c444d4d1d92aaaf10a190"

URI_aarch64_libarrow = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow}"
SRC_URI[aarch64_libarrow.sha256sum] = "f7d1565c4f3945f8cc30d40ff5d0f6b3baa4aca31d13e6ddd80fcfd04def41af"

URI_aarch64_libarrow-acero-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-acero-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-acero-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-acero-devel}"
SRC_URI[aarch64_libarrow-acero-devel.sha256sum] = "22686599d8768c5daa403058718eac912d2325acfa693577eeb9b5c43f9ad985"

URI_aarch64_libarrow-acero-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-acero-libs-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-acero-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-acero-libs}"
SRC_URI[aarch64_libarrow-acero-libs.sha256sum] = "ab1b5a27b3f7513715262e3b310faa46576621d375d914f9d9896c7dcec45671"

URI_aarch64_libarrow-dataset-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-dataset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-devel}"
SRC_URI[aarch64_libarrow-dataset-devel.sha256sum] = "41b5eda06cda65849c60b1fb1e283ba0b261135b2f4df4cb5da96abc427b7cc6"

URI_aarch64_libarrow-dataset-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-glib-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-dataset-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-glib-devel}"
SRC_URI[aarch64_libarrow-dataset-glib-devel.sha256sum] = "edc20ef8e23ce0683b2b38f8a42d0a3d0b19a453d33587cd1946d4a50a5d9380"

URI_aarch64_libarrow-dataset-glib-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-glib-libs-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-dataset-glib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-glib-libs}"
SRC_URI[aarch64_libarrow-dataset-glib-libs.sha256sum] = "f9f270047dd7a26d0cc2133fe621721c43d112d5bcf79e757d8e2be295f6e222"

URI_aarch64_libarrow-dataset-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-dataset-libs-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-dataset-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-dataset-libs}"
SRC_URI[aarch64_libarrow-dataset-libs.sha256sum] = "f45793a2cf597586d5457fd39a383a12acf8f117a86d37fa90ab51210ef705b9"

URI_aarch64_libarrow-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-devel}"
SRC_URI[aarch64_libarrow-devel.sha256sum] = "56ed8aae2d10fab66ee3702b1fbc4e41a0f90dd02b9f758585f911c9e4e18498"

URI_aarch64_libarrow-doc = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-doc-17.0.0-6.el10_0.noarch.rpm;name=aarch64_libarrow-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-doc}"
SRC_URI[aarch64_libarrow-doc.sha256sum] = "0eedfd413da9340f6ae9ff3bfc25dfec6cf5f9dfe948240572168e46e04b75da"

URI_aarch64_libarrow-flight-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-flight-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-flight-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-flight-devel}"
SRC_URI[aarch64_libarrow-flight-devel.sha256sum] = "012dbc389bbd7bb9b3baecebec5bd320b96425b95554a534208af18f79a5925f"

URI_aarch64_libarrow-flight-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-flight-libs-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-flight-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-flight-libs}"
SRC_URI[aarch64_libarrow-flight-libs.sha256sum] = "58813895bba68447c34a130f0e69e50a4b41fa539b2fb6bc2d55cdae74e2c679"

URI_aarch64_libarrow-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-glib-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-glib-devel}"
SRC_URI[aarch64_libarrow-glib-devel.sha256sum] = "52f0a3dfa3146559ce5ba6c7e95d9450078415882e1b5e33f9ec96f63f549da8"

URI_aarch64_libarrow-glib-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-glib-libs-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-glib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-glib-libs}"
SRC_URI[aarch64_libarrow-glib-libs.sha256sum] = "f723c61e09a16741a701d6323060a7b0b4c4ab6004f8bc18564d20eed8510768"

URI_aarch64_libarrow-python-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-python-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-devel}"
SRC_URI[aarch64_libarrow-python-devel.sha256sum] = "e32ede45ebc507745e0f039e4be2b731466f73f62d739115a48e733e290c93ed"

URI_aarch64_libarrow-python-flight-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-flight-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-python-flight-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-flight-devel}"
SRC_URI[aarch64_libarrow-python-flight-devel.sha256sum] = "e6694f922849ffa3c4ab71e7e8c75769cab7f028572e4e052689333faa1299b5"

URI_aarch64_libarrow-python-flight-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-flight-libs-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-python-flight-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-flight-libs}"
SRC_URI[aarch64_libarrow-python-flight-libs.sha256sum] = "8db18e341cce8fd53652b63ccc19bad3cc7382d3ed22c88822cb171ca7b18021"

URI_aarch64_libarrow-python-libs = "${EPEL_MIRROR}/aarch64/Packages/l/libarrow-python-libs-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_libarrow-python-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_libarrow-python-libs}"
SRC_URI[aarch64_libarrow-python-libs.sha256sum] = "f9d0159b6193a23879b19db94ca21929e2976159d22d9ef7ff54597e0cf12b3e"

URI_aarch64_parquet-glib-devel = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-glib-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_parquet-glib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-glib-devel}"
SRC_URI[aarch64_parquet-glib-devel.sha256sum] = "c07b6a273e74e16b303d62993ddaec481191b0fd6330e79106dd88ca62825efa"

URI_aarch64_parquet-glib-libs = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-glib-libs-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_parquet-glib-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-glib-libs}"
SRC_URI[aarch64_parquet-glib-libs.sha256sum] = "94644f4ddc7d70cda6e2ae941a597d128145ea642355c90d532d9e6bef291f87"

URI_aarch64_parquet-libs = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-libs-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_parquet-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-libs}"
SRC_URI[aarch64_parquet-libs.sha256sum] = "e9c3260a524916b389d35f07d4f170735e55f2b01d8ad4210ff2219fa7c69d6d"

URI_aarch64_parquet-libs-devel = "${EPEL_MIRROR}/aarch64/Packages/p/parquet-libs-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_parquet-libs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_parquet-libs-devel}"
SRC_URI[aarch64_parquet-libs-devel.sha256sum] = "73ae46a3b00ec165b57672dd98505a5376ac6873bf5d7e0b8d0af0b9335f3046"

URI_aarch64_python3-pyarrow = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyarrow-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_python3-pyarrow;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyarrow}"
SRC_URI[aarch64_python3-pyarrow.sha256sum] = "cdcfde4660aa49a9d6dceb66d4c43b1a04a1fb1ed24241b213809c87e9a2fb54"

URI_aarch64_python3-pyarrow-devel = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pyarrow-devel-17.0.0-6.el10_0.aarch64.rpm;name=aarch64_python3-pyarrow-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pyarrow-devel}"
SRC_URI[aarch64_python3-pyarrow-devel.sha256sum] = "2747c5113afb152e79cdb9143cef5a5b778144d04b95d5525610824d295e9b2f"

RDEPENDS:libarrow = " \
 bzip2-libs \
 glibc \
 libarrow-doc \
 libbrotli \
 libgcc \
 liborc2 \
 libstdc++ \
 libzstd \
 lz4-libs \
 re2 \
 snappy \
 utf8proc \
 zlib-ng-compat \
 "
RDEPENDS:libarrow-acero-devel = " \
 cmake-filesystem \
 libarrow \
 libarrow-acero-libs \
 libarrow-devel \
 libarrow-flight-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-acero-libs = " \
 glibc \
 libarrow \
 libarrow-doc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libarrow-dataset-devel = " \
 cmake-filesystem \
 libarrow \
 libarrow-acero-devel \
 libarrow-dataset-libs \
 parquet-libs-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-dataset-glib-devel = " \
 glib2-devel \
 libarrow \
 libarrow-dataset-devel \
 libarrow-dataset-glib-libs \
 libarrow-glib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-dataset-glib-libs = " \
 glib2 \
 glibc \
 libarrow \
 libarrow-dataset-libs \
 libarrow-doc \
 libarrow-glib-libs \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libarrow-dataset-libs = " \
 glibc \
 libarrow \
 libarrow-acero-libs \
 libarrow-doc \
 libgcc \
 libstdc++ \
 parquet-libs \
 "
RDEPENDS:libarrow-devel = " \
 brotli-devel \
 bzip2-devel \
 cmake-filesystem \
 libarrow \
 libarrow-devel \
 libzstd-devel \
 lz4-devel \
 openssl-devel \
 pkgconf-pkg-config \
 rapidjson-devel \
 re2-devel \
 snappy-devel \
 utf8proc-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:libarrow-doc = " \
 "
RDEPENDS:libarrow-flight-devel = " \
 cmake-filesystem \
 glib2-devel \
 libarrow \
 libarrow-devel \
 libarrow-flight-devel \
 libarrow-flight-libs \
 libarrow-glib-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-flight-libs = " \
 abseil-cpp \
 glib2 \
 glibc \
 grpc \
 grpc-cpp \
 libarrow \
 libarrow-doc \
 libarrow-glib-libs \
 libgcc \
 libstdc++ \
 protobuf \
 "
RDEPENDS:libarrow-glib-devel = " \
 glib2-devel \
 gobject-introspection-devel \
 libarrow \
 libarrow-devel \
 libarrow-glib-devel \
 libarrow-glib-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:libarrow-glib-libs = " \
 glib2 \
 glibc \
 libarrow \
 libarrow-acero-libs \
 libarrow-doc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:libarrow-python-devel = " \
 libarrow \
 libarrow-devel \
 libarrow-python-libs \
 python3-devel \
 "
RDEPENDS:libarrow-python-flight-devel = " \
 libarrow \
 libarrow-flight-devel \
 libarrow-python-devel \
 libarrow-python-flight-libs \
 "
RDEPENDS:libarrow-python-flight-libs = " \
 glibc \
 libarrow \
 libarrow-doc \
 libarrow-flight-libs \
 libarrow-python-libs \
 libgcc \
 libstdc++ \
 python3 \
 "
RDEPENDS:libarrow-python-libs = " \
 glibc \
 libarrow \
 libarrow-doc \
 libgcc \
 libstdc++ \
 python3 \
 python3-numpy \
 "
RDEPENDS:parquet-glib-devel = " \
 glib2-devel \
 libarrow \
 libarrow-glib-devel \
 parquet-glib-libs \
 parquet-libs-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:parquet-glib-libs = " \
 glib2 \
 glibc \
 libarrow \
 libarrow-doc \
 libarrow-glib-libs \
 libgcc \
 libstdc++ \
 parquet-libs \
 "
RDEPENDS:parquet-libs = " \
 boost-program-options \
 glibc \
 libarrow \
 libarrow-doc \
 libgcc \
 libstdc++ \
 openssl-libs \
 thrift \
 "
RDEPENDS:parquet-libs-devel = " \
 cmake-filesystem \
 glib2-devel \
 libarrow \
 libarrow-devel \
 libarrow-glib-devel \
 parquet-libs \
 parquet-libs-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:python3-pyarrow = " \
 glibc \
 libarrow \
 libarrow-acero-libs \
 libarrow-dataset-libs \
 libarrow-flight-libs \
 libgcc \
 libstdc++ \
 parquet-libs \
 python3 \
 python3-numpy \
 "
RDEPENDS:python3-pyarrow-devel = " \
 python3-pyarrow \
 "
