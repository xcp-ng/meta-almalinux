# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ntfs-3g-system-compression"
PV = "1.1"
PR = "1.el10_1"
PACKAGES = " \
 ntfs-3g-system-compression \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/ntfs-3g-system-compression-1.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "68684cee2667d6ce4ce4a12ffd38da66dcb264ad667f465c0f411d582f270012"

URI_x86_64_v2_ntfs-3g-system-compression = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ntfs-3g-system-compression-1.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ntfs-3g-system-compression;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ntfs-3g-system-compression}"
SRC_URI[x86_64_v2_ntfs-3g-system-compression.sha256sum] = "0a95412097c3f5ef2471cead75a29174e7fd590ebee782c0927acd808fd6df52"

URI_aarch64_ntfs-3g-system-compression = "${EPEL_MIRROR}/aarch64/Packages/n/ntfs-3g-system-compression-1.1-1.el10_1.aarch64.rpm;name=aarch64_ntfs-3g-system-compression;unpack=0"
SRC_URI:append = " ${URI_aarch64_ntfs-3g-system-compression}"
SRC_URI[aarch64_ntfs-3g-system-compression.sha256sum] = "bcc009ad1daaae903aa54609ba6c8afed19f4eac302e15f702c0f6c38290ae8e"

RDEPENDS:ntfs-3g-system-compression = " \
 glibc \
 ntfs-3g-libs \
 "
