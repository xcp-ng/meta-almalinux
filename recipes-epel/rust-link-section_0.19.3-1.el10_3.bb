# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-link-section"
PV = "0.19.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-link-section+default-devel \
 rust-link-section+proc_macro-devel \
 rust-link-section+std-devel \
 rust-link-section-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-link-section-0.19.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "24c0693a415e5a7c16f6f17613a1e91df6b3ecacf98df560b189ac18495cd620"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-section+default-devel-0.19.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-section+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-link-section+default-devel.sha256sum] = "5f60ca65131ab352e9594e03c9397f7b14b9a6629906d54f9ee4366b13f6f1e2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-section+proc_macro-devel-0.19.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-section+proc_macro-devel;unpack=0"
SRC_URI[x86_64_v2_rust-link-section+proc_macro-devel.sha256sum] = "c6315da66f002d982c81e19a59e3cf666ae9c31e5b60a7598d31c89aeef91ba4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-section+std-devel-0.19.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-section+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-link-section+std-devel.sha256sum] = "59df158fad2cb991527d70dd9001dc79b552f034ce1ef2c43d75aaf9ce7dab9d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-link-section-devel-0.19.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-link-section-devel;unpack=0"
SRC_URI[x86_64_v2_rust-link-section-devel.sha256sum] = "3c150fff82b99c14593f1383200b2dd58c694d55aa21ed498026e0f46f62f391"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-link-section+default-devel-0.19.3-1.el10_3.noarch.rpm;name=aarch64_rust-link-section+default-devel;unpack=0"
SRC_URI[aarch64_rust-link-section+default-devel.sha256sum] = "b62484b460f2d95fc4b92ff4b432b7f78deaef6dbb6991cd9e91dad1f51c8911"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-link-section+proc_macro-devel-0.19.3-1.el10_3.noarch.rpm;name=aarch64_rust-link-section+proc_macro-devel;unpack=0"
SRC_URI[aarch64_rust-link-section+proc_macro-devel.sha256sum] = "9d555cc09f4e82d50509f58116ee53d56e6e4a7a573090050bfde1ab40875456"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-link-section+std-devel-0.19.3-1.el10_3.noarch.rpm;name=aarch64_rust-link-section+std-devel;unpack=0"
SRC_URI[aarch64_rust-link-section+std-devel.sha256sum] = "5dec183f3c60bb39716daaad58cb7fd6a84caa262a40515931dcaf8bb073e514"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-link-section-devel-0.19.3-1.el10_3.noarch.rpm;name=aarch64_rust-link-section-devel;unpack=0"
SRC_URI[aarch64_rust-link-section-devel.sha256sum] = "e645a9b15be36cf7f6c4d29b87596275d7d1996c6e251fddc311bede58ee58fe"

RDEPENDS:rust-link-section+default-devel = " \
 cargo \
 rust-link-section+proc_macro-devel \
 rust-link-section+std-devel \
 rust-link-section-devel \
 "
RDEPENDS:rust-link-section+proc_macro-devel = " \
 cargo \
 rust-link-section-devel \
 rust-linktime-proc-macro+default-devel \
 rust-linktime-proc-macro+link_section-devel \
 "
RDEPENDS:rust-link-section+std-devel = " \
 cargo \
 rust-link-section-devel \
 "
RDEPENDS:rust-link-section-devel = " \
 cargo \
 rust \
 "
