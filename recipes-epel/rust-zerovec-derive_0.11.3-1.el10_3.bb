# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-zerovec-derive"
PV = "0.11.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-zerovec-derive+default-devel \
 rust-zerovec-derive-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-zerovec-derive-0.11.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "60557af1d51f97ad83fea23518e8e0ca330cc7b44c63210c32ac43f64f37ee1a"

URI_x86_64_v2_rust-zerovec-derive+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive+default-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-derive+default-devel}"
SRC_URI[x86_64_v2_rust-zerovec-derive+default-devel.sha256sum] = "a90fb83de62c0645c892a7b8d77e19d8d79d41fc93522d5529bdbd3938957807"

URI_x86_64_v2_rust-zerovec-derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-zerovec-derive-devel-0.11.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-zerovec-derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-zerovec-derive-devel}"
SRC_URI[x86_64_v2_rust-zerovec-derive-devel.sha256sum] = "d7b98196335e2204739e701f6792af0a3412d72dbccb3bdab75b77365b014826"

URI_aarch64_rust-zerovec-derive+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive+default-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec-derive+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-derive+default-devel}"
SRC_URI[aarch64_rust-zerovec-derive+default-devel.sha256sum] = "cc027ff873ad1a6e3aeb3e9e4196c0ed8b98d8dada26da8abbc5e0f8f6835490"

URI_aarch64_rust-zerovec-derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-zerovec-derive-devel-0.11.3-1.el10_3.noarch.rpm;name=aarch64_rust-zerovec-derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-zerovec-derive-devel}"
SRC_URI[aarch64_rust-zerovec-derive-devel.sha256sum] = "e5c5d56f8c6fbd337b9e92ebfb4c928c35ac521f0f88ca9f4ef50ce1aefc4e0d"

RDEPENDS:rust-zerovec-derive+default-devel = " \
 cargo \
 rust-zerovec-derive-devel \
 "
RDEPENDS:rust-zerovec-derive-devel = " \
 cargo \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn2+default-devel \
 rust-syn2+extra-traits-devel \
 "
