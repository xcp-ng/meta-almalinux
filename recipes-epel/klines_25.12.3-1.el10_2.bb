# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klines"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 klines \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/klines-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "885264aa540105692797852d78e96ba591f22140937b8dd2296992e124dc36c9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klines-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klines;unpack=0"
SRC_URI[x86_64_v2_klines.sha256sum] = "1a727b2ef287f50d49f053ccb46d21560b695ff6f03656c8d28d3a8ffa6b0707"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/klines-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_klines;unpack=0"
SRC_URI[aarch64_klines.sha256sum] = "62742479ec8f82995ffee481532fd9f3f2dc3917d8d69640b10db10b8c2c083a"

RDEPENDS:klines = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
