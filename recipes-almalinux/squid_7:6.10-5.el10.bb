# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "squid"
PE = "7"
PV = "6.10"
PR = "5.el10"
PACKAGES = " \
 squid \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/squid-6.10-5.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3a6442d372e5e448fd503ad0385a3b91529de4de45515028b6123254a63b0b9e"

URI_x86_64_v2_squid = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/squid-6.10-5.el10.x86_64_v2.rpm;name=x86_64_v2_squid;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_squid}"
SRC_URI[x86_64_v2_squid.sha256sum] = "9a90a1e56367142a7d1d4b5a663301d7b25f408c7ca072bb9a6a2d86d607ffce"

URI_aarch64_squid = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/squid-6.10-5.el10.aarch64.rpm;name=aarch64_squid;unpack=0"
SRC_URI:append = " ${URI_aarch64_squid}"
SRC_URI[aarch64_squid.sha256sum] = "d28254d3479cff5c3cafdcdad792b9173d979b6285229689638e3b6cee6d1f6d"

RDEPENDS:squid = " \
 bash \
 cyrus-sasl-lib \
 gawk \
 glibc \
 httpd-filesystem \
 krb5-libs \
 libcap \
 libcom_err \
 libecap \
 libgcc \
 libstdc++ \
 libtdb \
 libtool-ltdl \
 libxcrypt \
 openldap \
 openssl-libs \
 pam-libs \
 perl-DBI \
 perl-Data-Dumper \
 perl-Digest-MD5 \
 perl-Digest-SHA \
 perl-English \
 perl-File-Basename \
 perl-FileHandle \
 perl-Getopt-Long \
 perl-Getopt-Std \
 perl-IPC-Open3 \
 perl-Pod-Usage \
 perl-URI \
 perl-interpreter \
 perl-libnet \
 perl-libs \
 perl-vars \
 shadow-utils \
 systemd \
 systemd-libs \
 "
