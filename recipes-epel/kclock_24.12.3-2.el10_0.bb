# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kclock"
PV = "24.12.3"
PR = "2.el10_0"
PACKAGES = " \
 kclock \
 kclock-plasma-applet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kclock-24.12.3-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7c75c894c9fc9128e71286fd315cd4ea09d5a3acd6d97815f71223d2dee0f6fc"

URI_x86_64_v2_kclock = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-24.12.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kclock}"
SRC_URI[x86_64_v2_kclock.sha256sum] = "f91564791905431b44eac7c73d512743b977810e0c129b608689fbe85e303d0b"

URI_x86_64_v2_kclock-plasma-applet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kclock-plasma-applet-24.12.3-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kclock-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kclock-plasma-applet}"
SRC_URI[x86_64_v2_kclock-plasma-applet.sha256sum] = "a680df3d6f9c727007e76d900d6cc7bb118f3ec4215c4940e56bf04d67c5e765"

URI_aarch64_kclock = "${EPEL_MIRROR}/aarch64/Packages/k/kclock-24.12.3-2.el10_0.aarch64.rpm;name=aarch64_kclock;unpack=0"
SRC_URI:append = " ${URI_aarch64_kclock}"
SRC_URI[aarch64_kclock.sha256sum] = "7482fd42df8e669a17c23ec88bc3f7464e8e1add31c8c9353cbd977cec24d85f"

URI_aarch64_kclock-plasma-applet = "${EPEL_MIRROR}/aarch64/Packages/k/kclock-plasma-applet-24.12.3-2.el10_0.aarch64.rpm;name=aarch64_kclock-plasma-applet;unpack=0"
SRC_URI:append = " ${URI_aarch64_kclock-plasma-applet}"
SRC_URI[aarch64_kclock-plasma-applet.sha256sum] = "c119716689b2a09c315779b67238a289a3f7d8a9607a97979a26dcf9ddb5f001"

RDEPENDS:kclock = " \
 glibc \
 hicolor-icon-theme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-knotifications \
 kf6-kstatusnotifieritem \
 kf6-ksvg \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 "
RDEPENDS:kclock-plasma-applet = " \
 glibc \
 kclock \
 kf6-kcmutils \
 kf6-kcoreaddons \
 kf6-kirigami \
 libplasma \
 libstdc++ \
 qt6-qtbase \
 "
