# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-distroinfo"
PV = "0.6.3"
PR = "7.el10_2"
PACKAGES = " \
 python3-distroinfo \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-distroinfo-0.6.3-7.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c82f753d8931702d2cfdc2e31ac9a4ccc5179d6093ff5e3759ccfff0554af0ba"

URI_x86_64_v2_python3-distroinfo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-distroinfo-0.6.3-7.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-distroinfo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-distroinfo}"
SRC_URI[x86_64_v2_python3-distroinfo.sha256sum] = "1596744bdd48ed783484ec3dff772ba88c06a68bdf0d8c235ffb7384d2aa6ef3"

URI_aarch64_python3-distroinfo = "${EPEL_MIRROR}/aarch64/Packages/p/python3-distroinfo-0.6.3-7.el10_2.noarch.rpm;name=aarch64_python3-distroinfo;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-distroinfo}"
SRC_URI[aarch64_python3-distroinfo.sha256sum] = "9eaeac6f78dab0572268b3e61a64a37d5b2faf48ecb9951fb208683f7ec9fbca"

RDEPENDS:python3-distroinfo = " \
 git-core \
 python3 \
 python3-pbr \
 python3-pyyaml \
 python3-requests \
 python3-six \
 "
