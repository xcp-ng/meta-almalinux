# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-trove-classifiers"
PV = "2025.9.11.17"
PR = "1.el10"
PACKAGES = " \
 python3-trove-classifiers \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/python-trove-classifiers-2025.9.11.17-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "176af36acece5bd1534080b196b3bd1f10e6aaa8cc813743fa8c6bc07687e220"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/python3-trove-classifiers-2025.9.11.17-1.el10.noarch.rpm;name=x86_64_v2_python3-trove-classifiers;unpack=0"
SRC_URI[x86_64_v2_python3-trove-classifiers.sha256sum] = "3a66be3dc8625c7a45337f7d3285169708a1d699a3bdcdc2f1b032616f207d37"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/python3-trove-classifiers-2025.9.11.17-1.el10.noarch.rpm;name=aarch64_python3-trove-classifiers;unpack=0"
SRC_URI[aarch64_python3-trove-classifiers.sha256sum] = "3a66be3dc8625c7a45337f7d3285169708a1d699a3bdcdc2f1b032616f207d37"

RDEPENDS:python3-trove-classifiers = " \
 python3 \
 "
