# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "valkey"
PV = "8.1.10"
PR = "1.el10"
PACKAGES = " \
 valkey \
 valkey-devel \
 valkey-rdma \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/valkey-8.1.10-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "05142ea17435ab362c5127367c5b12123c0577134135218c990e4cd0a4ac0582"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-8.1.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_valkey;unpack=0"
SRC_URI[x86_64_v2_valkey.sha256sum] = "0bf0c6883c33677e690ae44e98f05ba7a2a6cbe49f32e9cf7bf0d7055472219f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-devel-8.1.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_valkey-devel;unpack=0"
SRC_URI[x86_64_v2_valkey-devel.sha256sum] = "e10c7a46b80c0e67c5e4fdbf421c40ed8a67399b1413f91d284d582dd27c8d56"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/valkey-rdma-8.1.10-1.el10.x86_64_v2.rpm;name=x86_64_v2_valkey-rdma;unpack=0"
SRC_URI[x86_64_v2_valkey-rdma.sha256sum] = "10bbbb1844e096ffc7922f83e9f4b84d6762fabb5e12dd9ffcf346a31fbc10b6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-8.1.10-1.el10.aarch64.rpm;name=aarch64_valkey;unpack=0"
SRC_URI[aarch64_valkey.sha256sum] = "83d6540c567ca09f3f09b4553937de4bb5291277e9555f57c9e1d91f421c0752"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-devel-8.1.10-1.el10.aarch64.rpm;name=aarch64_valkey-devel;unpack=0"
SRC_URI[aarch64_valkey-devel.sha256sum] = "44f7b9f50b2ed5f1bf193ff357dca002ff0ca0616b80c5792413a2d3b2b82e27"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/valkey-rdma-8.1.10-1.el10.aarch64.rpm;name=aarch64_valkey-rdma;unpack=0"
SRC_URI[aarch64_valkey-rdma.sha256sum] = "bc4f24a0d9686a63aeeb3f472d8d7eae462f688cebc18d5bfab234d894673611"

RDEPENDS:valkey = " \
 bash \
 glibc \
 logrotate \
 openssl-libs \
 systemd-libs \
 "
RDEPENDS:valkey-devel = " \
 valkey \
 "
RDEPENDS:valkey-rdma = " \
 glibc \
 libibverbs \
 librdmacm \
 valkey \
 "
