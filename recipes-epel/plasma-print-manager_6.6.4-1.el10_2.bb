# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-print-manager"
PV = "6.6.4"
PR = "1.el10_2"
PACKAGES = " \
 plasma-print-manager \
 plasma-print-manager-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-print-manager-6.6.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3e78d7417e1b2ff168b50eae5a279fda8536d8b383f643b67a1a748c133bfccb"

URI_x86_64_v2_plasma-print-manager = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-print-manager-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-print-manager;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-print-manager}"
SRC_URI[x86_64_v2_plasma-print-manager.sha256sum] = "a819d7f03c5d6edecf48bf5738ddc3be23d74fef9eba33094b0ace8deb5e90d4"

URI_x86_64_v2_plasma-print-manager-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-print-manager-libs-6.6.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_plasma-print-manager-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-print-manager-libs}"
SRC_URI[x86_64_v2_plasma-print-manager-libs.sha256sum] = "bf58595e71f767350836320932f8676ba32d7973f728b304570038bd7481f12f"

URI_aarch64_plasma-print-manager = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-print-manager-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-print-manager;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-print-manager}"
SRC_URI[aarch64_plasma-print-manager.sha256sum] = "17de37ea5716ce7708d3f2c04b005d85d3f76151bc3be307dff5d91d3449b07e"

URI_aarch64_plasma-print-manager-libs = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-print-manager-libs-6.6.4-1.el10_2.aarch64.rpm;name=aarch64_plasma-print-manager-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-print-manager-libs}"
SRC_URI[aarch64_plasma-print-manager-libs.sha256sum] = "0bb49bcb76c1944ee3cc181156f41ab91364e86e3cfa5b8569909efff9798a9b"

RDEPENDS:plasma-print-manager = " \
 PackageKit-Qt6 \
 cups \
 cups-libs \
 glibc \
 kf6-kcmutils \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libstdc++ \
 plasma-print-manager-libs \
 plasma-workspace \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 system-config-printer-libs \
 "
RDEPENDS:plasma-print-manager-libs = " \
 cups-libs \
 glibc \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-knotifications \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 libplasma \
 libstdc++ \
 plasma-print-manager \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
