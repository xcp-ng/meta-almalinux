# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio-rustls"
PV = "0.26.4"
PR = "1.el10_2"
PACKAGES = " \
 rust-tokio-rustls+brotli-devel \
 rust-tokio-rustls+default-devel \
 rust-tokio-rustls+early-data-devel \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls+zlib-devel \
 rust-tokio-rustls-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-rustls-0.26.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2367dad1e75ded7c0e0fa40ce64d1087bd6072fce64dd9fa682275a3f94fd107"

URI_x86_64_v2_rust-tokio-rustls+brotli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+brotli-devel-0.26.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+brotli-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+brotli-devel.sha256sum] = "e3b5ed8a4cff45f536301924ddb46f1080959c46a85db4605defb4e2fbe7d3e2"

URI_x86_64_v2_rust-tokio-rustls+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+default-devel-0.26.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+default-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+default-devel.sha256sum] = "2735384cc506f15eeb51cadf3c42993533247dcc493da29aceee4b22d32ac40c"

URI_x86_64_v2_rust-tokio-rustls+early-data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+early-data-devel-0.26.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+early-data-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+early-data-devel.sha256sum] = "a243dbd3426451db699029db7da0d2c8f37ab095f7cf43b7fb70a81a9c0e5c6e"

URI_x86_64_v2_rust-tokio-rustls+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+logging-devel-0.26.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+logging-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+logging-devel.sha256sum] = "3967ca8d9621b0d57e0363e867751ac5085cebb7a1f8a9e1879e2f051b93da9f"

URI_x86_64_v2_rust-tokio-rustls+ring-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+ring-devel-0.26.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+ring-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+ring-devel.sha256sum] = "66c261dbc032066c640f502f36e3de374ff66a49a09f757cace3e14b0547fc1b"

URI_x86_64_v2_rust-tokio-rustls+tls12-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+tls12-devel-0.26.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+tls12-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+tls12-devel.sha256sum] = "10d77fc3ed1e1232a293017eeb971b484c796929e1762ddb0e7819f48ec0edc1"

URI_x86_64_v2_rust-tokio-rustls+zlib-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls+zlib-devel-0.26.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls+zlib-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls+zlib-devel.sha256sum] = "37b2e9ad85e3f4ab7b4efbbdff74642cafa8c18dcf6eb2042f7049a6e06bd4e2"

URI_x86_64_v2_rust-tokio-rustls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-rustls-devel-0.26.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-rustls-devel}"
SRC_URI[x86_64_v2_rust-tokio-rustls-devel.sha256sum] = "4271641631e843f5fd01f85d0214de8c0ab173d05e5ea28a5787bfc8b13cfc1a"

URI_aarch64_rust-tokio-rustls+brotli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+brotli-devel-0.26.4-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+brotli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+brotli-devel}"
SRC_URI[aarch64_rust-tokio-rustls+brotli-devel.sha256sum] = "65b549dd3083bf1d4a29eb5c72da6b0315ded7cb04950e38f4e132b0e819bb6a"

URI_aarch64_rust-tokio-rustls+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+default-devel-0.26.4-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+default-devel}"
SRC_URI[aarch64_rust-tokio-rustls+default-devel.sha256sum] = "4c82620dd36271515b643d00dd0190f93a0bc345ff44fa9fe144b4426534ca20"

URI_aarch64_rust-tokio-rustls+early-data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+early-data-devel-0.26.4-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+early-data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+early-data-devel}"
SRC_URI[aarch64_rust-tokio-rustls+early-data-devel.sha256sum] = "cc28ed14c346d8ca7f9bc8d50f21327c2049e774bf0d0a78602f8ec74ef1895c"

URI_aarch64_rust-tokio-rustls+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+logging-devel-0.26.4-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+logging-devel}"
SRC_URI[aarch64_rust-tokio-rustls+logging-devel.sha256sum] = "a653b34667d13bcc1a07b5c949ac35ba56939d417307f89620eb54abb7472ce3"

URI_aarch64_rust-tokio-rustls+ring-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+ring-devel-0.26.4-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+ring-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+ring-devel}"
SRC_URI[aarch64_rust-tokio-rustls+ring-devel.sha256sum] = "4dace7d0553c4f760d46cbb578d94ab2648a05ec6ea08a2dd97afd795bb3feab"

URI_aarch64_rust-tokio-rustls+tls12-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+tls12-devel-0.26.4-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+tls12-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+tls12-devel}"
SRC_URI[aarch64_rust-tokio-rustls+tls12-devel.sha256sum] = "8507a1ee3ac23ad1f0344291987a611834da2b875bfd5343946eeb5ea69a6787"

URI_aarch64_rust-tokio-rustls+zlib-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls+zlib-devel-0.26.4-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls+zlib-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls+zlib-devel}"
SRC_URI[aarch64_rust-tokio-rustls+zlib-devel.sha256sum] = "1adf5cfad51ccd6a71880452d3e1a3080686794847064436a92a377e1fe60cf7"

URI_aarch64_rust-tokio-rustls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-rustls-devel-0.26.4-1.el10_2.noarch.rpm;name=aarch64_rust-tokio-rustls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-rustls-devel}"
SRC_URI[aarch64_rust-tokio-rustls-devel.sha256sum] = "7052c5255b5cd9b4c28fe3df637895bbe24168f677a46e7b7a100e540cf4d43e"

RDEPENDS:rust-tokio-rustls+brotli-devel = " \
 cargo \
 rust-rustls+brotli-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+default-devel = " \
 cargo \
 rust-tokio-rustls+logging-devel \
 rust-tokio-rustls+ring-devel \
 rust-tokio-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+early-data-devel = " \
 cargo \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+logging-devel = " \
 cargo \
 rust-rustls+logging-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+ring-devel = " \
 cargo \
 rust-rustls+ring-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+tls12-devel = " \
 cargo \
 rust-rustls+tls12-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls+zlib-devel = " \
 cargo \
 rust-rustls+zlib-devel \
 rust-tokio-rustls-devel \
 "
RDEPENDS:rust-tokio-rustls-devel = " \
 cargo \
 rust \
 rust-rustls+std-devel \
 rust-rustls-devel \
 rust-tokio+default-devel \
 "
