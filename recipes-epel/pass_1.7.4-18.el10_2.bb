# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pass"
PV = "1.7.4"
PR = "18.el10_2"
PACKAGES = " \
 pass \
 passmenu \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/pass-1.7.4-18.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d01c7fd5ba38838c7a1abdb5df505eb6d1913890e8922b31294a02f141998011"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pass-1.7.4-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_pass;unpack=0"
SRC_URI[x86_64_v2_pass.sha256sum] = "87f3616b36fc7a7c7e91d96c5cffd26c331daf9ba8d120054ab443d63de47460"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/passmenu-1.7.4-18.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_passmenu;unpack=0"
SRC_URI[x86_64_v2_passmenu.sha256sum] = "79a4c5dab06a41928564c2cb4837dad811de4912cb7484014938100fad1bdff7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/pass-1.7.4-18.el10_2.noarch.rpm;name=aarch64_pass;unpack=0"
SRC_URI[aarch64_pass.sha256sum] = "b16f0063602264406ff0cb98b357ed22d08d84e6aec0586428997a6d809cf41d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/passmenu-1.7.4-18.el10_2.noarch.rpm;name=aarch64_passmenu;unpack=0"
SRC_URI[aarch64_passmenu.sha256sum] = "3551c00a3af399d715b495c9898fd2d5de41cac8a800ef3fde4172850d799eae"

RDEPENDS:pass = " \
 bash \
 git-core \
 gnupg2 \
 qrencode \
 tree \
 "
RDEPENDS:passmenu = " \
 bash \
 pass \
 "
