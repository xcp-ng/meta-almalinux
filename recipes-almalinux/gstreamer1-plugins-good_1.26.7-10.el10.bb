# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gstreamer1-plugins-good"
PV = "1.26.7"
PR = "10.el10"
PACKAGES = " \
 gstreamer1-plugins-good \
 gstreamer1-plugins-good-gtk \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gstreamer1-plugins-good-1.26.7-10.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "b01465f767b8f971f4e4ba4663e55122575dfaf465a2f88af1989c1e38804677"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-1.26.7-10.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-good.sha256sum] = "97dfe864d7407d6cd30ef0fb50395ba97e71c8a03095181473b0904a31b14a03"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gstreamer1-plugins-good-gtk-1.26.7-10.el10.x86_64_v2.rpm;name=x86_64_v2_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI[x86_64_v2_gstreamer1-plugins-good-gtk.sha256sum] = "95abc153396d7662e4ac527a4b0386ea4d1550bd06c8395d87a997d440eccadf"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-1.26.7-10.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-good;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-good.sha256sum] = "6ae1d9a6a2658e7cb8f7e0d289da3f1261d5d15eed7f5e7b17e823d3f0818bf8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gstreamer1-plugins-good-gtk-1.26.7-10.el10.aarch64.rpm;name=aarch64_gstreamer1-plugins-good-gtk;unpack=0"
SRC_URI[aarch64_gstreamer1-plugins-good-gtk.sha256sum] = "e7321c9b6750d71e41aac6a70595def21d46707e108b82b99e0c0890e79ad3e8"

RDEPENDS:gstreamer1-plugins-good = " \
 bzip2-libs \
 cairo \
 cairo-gobject \
 flac-libs \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 lame-libs \
 libX11 \
 libXdamage \
 libXext \
 libXfixes \
 libXtst \
 libgcc \
 libgudev \
 libjpeg-turbo \
 libpng \
 libshout \
 libstdc++ \
 libv4l \
 libvpx \
 libxml2 \
 mpg123-libs \
 openssl-libs \
 orc \
 pulseaudio-libs \
 speex \
 taglib \
 twolame-libs \
 wavpack \
 zlib-ng-compat \
 "
RDEPENDS:gstreamer1-plugins-good-gtk = " \
 cairo \
 glib2 \
 glibc \
 gstreamer1 \
 gstreamer1-plugins-base \
 gstreamer1-plugins-good \
 gtk3 \
 "
