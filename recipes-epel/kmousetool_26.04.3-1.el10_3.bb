# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kmousetool"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kmousetool \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kmousetool-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af233a8ae2f5d5130769e1d9253cca3d103307adb76fed907afff074f3e68a0f"

URI_x86_64_v2_kmousetool = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kmousetool-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kmousetool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kmousetool}"
SRC_URI[x86_64_v2_kmousetool.sha256sum] = "a9d085ebc525a68c77ac790ef909eb1f02801d5236d09e8b3ef134853a6e4b1c"

URI_aarch64_kmousetool = "${EPEL_MIRROR}/aarch64/Packages/k/kmousetool-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kmousetool;unpack=0"
SRC_URI:append = " ${URI_aarch64_kmousetool}"
SRC_URI[aarch64_kmousetool.sha256sum] = "ce4656fc00a06b0a9431d60d30606b995a2e375298770d1738c85a5dd9f7269d"

RDEPENDS:kmousetool = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libX11 \
 libXtst \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 "
