# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Hook-LexWrap"
PV = "0.26"
PR = "19.el10_0"
PACKAGES = " \
 perl-Hook-LexWrap \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Hook-LexWrap-0.26-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "452331b21825ed3df3682693de1156255f88209a6892d90f8838c558fce9299e"

URI_x86_64_v2_perl-Hook-LexWrap = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Hook-LexWrap-0.26-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Hook-LexWrap;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Hook-LexWrap}"
SRC_URI[x86_64_v2_perl-Hook-LexWrap.sha256sum] = "d4e86919fa312c7eaea45c8d5fa067cad5cb980c568b985ade7fc452636ea79d"

URI_aarch64_perl-Hook-LexWrap = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Hook-LexWrap-0.26-19.el10_0.noarch.rpm;name=aarch64_perl-Hook-LexWrap;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Hook-LexWrap}"
SRC_URI[aarch64_perl-Hook-LexWrap.sha256sum] = "8466626c3e9ea83df3cd728e1c2fce816829334bd60ea92a61210970a6d8f0aa"

RDEPENDS:perl-Hook-LexWrap = " \
 perl-Carp \
 perl-libs \
 perl-overload \
 "
