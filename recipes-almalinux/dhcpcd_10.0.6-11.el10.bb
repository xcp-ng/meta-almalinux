# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dhcpcd"
PV = "10.0.6"
PR = "11.el10"
PACKAGES = " \
 dhcpcd \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dhcpcd-10.0.6-11.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39e39d881cb1a5b6d78b9afb29097d3e0b898ef86e7754d593f86dae24605cfb"

URI_x86_64_v2_dhcpcd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dhcpcd-10.0.6-11.el10.x86_64_v2.rpm;name=x86_64_v2_dhcpcd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dhcpcd}"
SRC_URI[x86_64_v2_dhcpcd.sha256sum] = "ef8636a95174866d982c7a42548b9670e5a8f039567ea89107a13bb12bec4ddf"

URI_aarch64_dhcpcd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dhcpcd-10.0.6-11.el10.aarch64.rpm;name=aarch64_dhcpcd;unpack=0"
SRC_URI:append = " ${URI_aarch64_dhcpcd}"
SRC_URI[aarch64_dhcpcd.sha256sum] = "4eee804632b5d26bb9e3f586aee9d7f8a8648b2537a313f4e844b79dc7993405"

RDEPENDS:dhcpcd = " \
 bash \
 glibc \
 shadow-utils \
 systemd \
 systemd-libs \
 "
