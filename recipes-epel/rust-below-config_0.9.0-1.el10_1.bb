# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-below-config"
PV = "0.9.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-below-config+default-devel \
 rust-below-config-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-below-config-0.9.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f1b4708955371e44a3d17c72665d117fc51ceb14399d028d4fd3a51f3cb0ce1"

URI_x86_64_v2_rust-below-config+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-config+default-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-config+default-devel}"
SRC_URI[x86_64_v2_rust-below-config+default-devel.sha256sum] = "b231be09e7c75e44d469669d30567d48af65ce0909ae7b6e8e41f9653201dbb4"

URI_x86_64_v2_rust-below-config-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-below-config-devel-0.9.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-below-config-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-below-config-devel}"
SRC_URI[x86_64_v2_rust-below-config-devel.sha256sum] = "9702373a00becac97fde8cf0e62bc0778ae3ea69c9a46bb7685320eb5a8d5197"

URI_aarch64_rust-below-config+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-config+default-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-config+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-config+default-devel}"
SRC_URI[aarch64_rust-below-config+default-devel.sha256sum] = "20f905bfd2f3d1dffec21547af17b39b4f294b8150852535489018e1d8d6e9c0"

URI_aarch64_rust-below-config-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-below-config-devel-0.9.0-1.el10_1.noarch.rpm;name=aarch64_rust-below-config-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-below-config-devel}"
SRC_URI[aarch64_rust-below-config-devel.sha256sum] = "ee2ad0d14fa331d5d1019e5e9cedaddaff4c024e0b3b184c733c3875e67f7f15"

RDEPENDS:rust-below-config+default-devel = " \
 cargo \
 rust-below-config-devel \
 "
RDEPENDS:rust-below-config-devel = " \
 cargo \
 rust-anyhow+default-devel \
 rust-below-btrfs+default-devel \
 rust-cgroupfs+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-toml0.8+default-devel \
 "
