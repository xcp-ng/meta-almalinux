# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-hspec"
PV = "2.11.9"
PR = "1.el10_0"
PACKAGES = " \
 ghc-hspec \
 ghc-hspec-devel \
 ghc-hspec-doc \
 ghc-hspec-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-hspec-2.11.9-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "26526c8c5c5efec2b41e7487e8db5c84cd8090a2e0ed2e87cfd89a05cb98a9df"

URI_x86_64_v2_ghc-hspec = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-2.11.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec}"
SRC_URI[x86_64_v2_ghc-hspec.sha256sum] = "916873c4471db117a5eea9472061924c4d5c677f0efd96b7afc4d4ac7a2c18e3"

URI_x86_64_v2_ghc-hspec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-devel-2.11.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-devel}"
SRC_URI[x86_64_v2_ghc-hspec-devel.sha256sum] = "5c1d56a49ded8a40b9ce168f33405e37c710782c2c424ba252b9d470a1231675"

URI_x86_64_v2_ghc-hspec-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-doc-2.11.9-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-hspec-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-doc}"
SRC_URI[x86_64_v2_ghc-hspec-doc.sha256sum] = "f59757a852e6614ae16213b1df1b4c0dd09c4b029072528af4e63fb9331d9530"

URI_x86_64_v2_ghc-hspec-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-hspec-prof-2.11.9-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-hspec-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-hspec-prof}"
SRC_URI[x86_64_v2_ghc-hspec-prof.sha256sum] = "3bc631a7d6e3b74e180fd5d5a3568e6d2e975a4378707b6b54c282dd52740fd4"

URI_aarch64_ghc-hspec = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-2.11.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec}"
SRC_URI[aarch64_ghc-hspec.sha256sum] = "2ca9c7ea81b6367a35807a7e2468a2c0138f8d327d96a29c05133574c8769673"

URI_aarch64_ghc-hspec-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-devel-2.11.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-devel}"
SRC_URI[aarch64_ghc-hspec-devel.sha256sum] = "338aff501d89ec116742428c48b113fa8345c49d2ee7b00d3488820a00932676"

URI_aarch64_ghc-hspec-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-doc-2.11.9-1.el10_0.noarch.rpm;name=aarch64_ghc-hspec-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-doc}"
SRC_URI[aarch64_ghc-hspec-doc.sha256sum] = "9647452398b8e8834347027be90d266df71067316942d6aad4883e1ea07633a3"

URI_aarch64_ghc-hspec-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-hspec-prof-2.11.9-1.el10_0.aarch64.rpm;name=aarch64_ghc-hspec-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-hspec-prof}"
SRC_URI[aarch64_ghc-hspec-prof.sha256sum] = "6299ed8349912fc82f733e636437f679ea4516bf20882d2c3c422d576e2baaa3"

RDEPENDS:ghc-hspec = " \
 ghc-HUnit \
 ghc-QuickCheck \
 ghc-ansi-terminal \
 ghc-ansi-terminal-types \
 ghc-array \
 ghc-base \
 ghc-bytestring \
 ghc-call-stack \
 ghc-colour \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-haskell-lexer \
 ghc-hspec-core \
 ghc-hspec-discover \
 ghc-hspec-expectations \
 ghc-mtl \
 ghc-pretty \
 ghc-primitive \
 ghc-process \
 ghc-quickcheck-io \
 ghc-random \
 ghc-splitmix \
 ghc-stm \
 ghc-template-haskell \
 ghc-tf-random \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-hspec-devel = " \
 ghc-QuickCheck-devel \
 ghc-base-devel \
 ghc-compiler \
 ghc-hspec \
 ghc-hspec-core-devel \
 ghc-hspec-discover-devel \
 ghc-hspec-expectations-devel \
 "
RDEPENDS:ghc-hspec-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-hspec-prof = " \
 ghc-QuickCheck-prof \
 ghc-base-prof \
 ghc-hspec-core-prof \
 ghc-hspec-devel \
 ghc-hspec-discover-prof \
 ghc-hspec-expectations-prof \
 "
