# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-icu_datetime"
PV = "2.2.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-icu_datetime+compiled_data-devel \
 rust-icu_datetime+datagen-devel \
 rust-icu_datetime+default-devel \
 rust-icu_datetime+ixdtf-devel \
 rust-icu_datetime+logging-devel \
 rust-icu_datetime+serde-devel \
 rust-icu_datetime+unstable-devel \
 rust-icu_datetime+unstable_chrono_0_4-devel \
 rust-icu_datetime+unstable_jiff_0_2-devel \
 rust-icu_datetime+unstable_time_0_3-devel \
 rust-icu_datetime-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-icu_datetime-2.2.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa57f191d3528156eea37d8c15aa1d3159ef0d1eb1035d2d29493af959653ed3"

URI_x86_64_v2_rust-icu_datetime+compiled_data-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+compiled_data-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+compiled_data-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+compiled_data-devel.sha256sum] = "9f0c8908237ed38406e9c55bb1ebf0e96a8f85e04ec6dd8b42fff9643315e8c3"

URI_x86_64_v2_rust-icu_datetime+datagen-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+datagen-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+datagen-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+datagen-devel.sha256sum] = "01eb145010067da4486c13ba27366485a734176742cc05086612eb78b531058d"

URI_x86_64_v2_rust-icu_datetime+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+default-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+default-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+default-devel.sha256sum] = "d8e7ab990d97141d4653234cec4a7a8b57ec5fbe36afce38ee0dfabb4288574c"

URI_x86_64_v2_rust-icu_datetime+ixdtf-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+ixdtf-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+ixdtf-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+ixdtf-devel.sha256sum] = "b0d8924e7958f6017534942586e79d52f4860ca1df6be0d6dda8b77b8405975f"

URI_x86_64_v2_rust-icu_datetime+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+logging-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+logging-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+logging-devel.sha256sum] = "a2600256f1f22d44cad9b7fc7aeab4f775bea103a5c1041dbab55171a004cf31"

URI_x86_64_v2_rust-icu_datetime+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+serde-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+serde-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+serde-devel.sha256sum] = "e7b67fb3bfd56c820075f04a792020b52c6d71f98bd60f223680a9f9ee9eec1e"

URI_x86_64_v2_rust-icu_datetime+unstable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+unstable-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+unstable-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+unstable-devel.sha256sum] = "03f541a78c049c7f05a17684a4412077f3b90cbee8f9e11492d0e920e68675ed"

URI_x86_64_v2_rust-icu_datetime+unstable_chrono_0_4-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+unstable_chrono_0_4-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+unstable_chrono_0_4-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+unstable_chrono_0_4-devel.sha256sum] = "b117d3d95e32862e6e091406b44ee2ad42b89df5c81f066019eecafcc8fb951b"

URI_x86_64_v2_rust-icu_datetime+unstable_jiff_0_2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+unstable_jiff_0_2-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+unstable_jiff_0_2-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+unstable_jiff_0_2-devel.sha256sum] = "8330b108fdd711ff319a03dfbd8814c71cfd397f2cd883548ad81980571f8153"

URI_x86_64_v2_rust-icu_datetime+unstable_time_0_3-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime+unstable_time_0_3-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime+unstable_time_0_3-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime+unstable_time_0_3-devel.sha256sum] = "f6fbe925ce5cc6af4a84cdb9751901614159eb577740f86f029639cd47352536"

URI_x86_64_v2_rust-icu_datetime-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-icu_datetime-devel-2.2.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-icu_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-icu_datetime-devel}"
SRC_URI[x86_64_v2_rust-icu_datetime-devel.sha256sum] = "4b5a665c1afae0e685c11daeaaebdc34ba732ad2519cfca5325ffb942975da2e"

URI_aarch64_rust-icu_datetime+compiled_data-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+compiled_data-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+compiled_data-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+compiled_data-devel}"
SRC_URI[aarch64_rust-icu_datetime+compiled_data-devel.sha256sum] = "822209933e3cad6dafc27cbdb11cff7ff38267c864f86a77eb0aaed1d778ef4c"

URI_aarch64_rust-icu_datetime+datagen-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+datagen-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+datagen-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+datagen-devel}"
SRC_URI[aarch64_rust-icu_datetime+datagen-devel.sha256sum] = "b85070d709046dff245d2604f7d13e6dfa6f2fdedc554d90fc5606f6681d2924"

URI_aarch64_rust-icu_datetime+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+default-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+default-devel}"
SRC_URI[aarch64_rust-icu_datetime+default-devel.sha256sum] = "72d86e36eb0586989f0fd32fc9562c4de780bfa013dcc5f97db57abfd2565cad"

URI_aarch64_rust-icu_datetime+ixdtf-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+ixdtf-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+ixdtf-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+ixdtf-devel}"
SRC_URI[aarch64_rust-icu_datetime+ixdtf-devel.sha256sum] = "97f3be8de529d55bd0a9de6f77d40b67493eba0d872f764637cb6825b71a9994"

URI_aarch64_rust-icu_datetime+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+logging-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+logging-devel}"
SRC_URI[aarch64_rust-icu_datetime+logging-devel.sha256sum] = "a04a6f4b26bf250bdaa883f656101f1868e598b20cc338bf301286507a810ba4"

URI_aarch64_rust-icu_datetime+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+serde-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+serde-devel}"
SRC_URI[aarch64_rust-icu_datetime+serde-devel.sha256sum] = "baef69f5c80ca7ba868e0dc906728173a836d302ebd71d33a8b3068d73e1d681"

URI_aarch64_rust-icu_datetime+unstable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+unstable-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+unstable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+unstable-devel}"
SRC_URI[aarch64_rust-icu_datetime+unstable-devel.sha256sum] = "913903dbafd0b61b94a6c16a67dcac5d00fd52d8fb953c713a794b91c3c54a5a"

URI_aarch64_rust-icu_datetime+unstable_chrono_0_4-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+unstable_chrono_0_4-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+unstable_chrono_0_4-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+unstable_chrono_0_4-devel}"
SRC_URI[aarch64_rust-icu_datetime+unstable_chrono_0_4-devel.sha256sum] = "a773a400b5aa9ece3b01be50e47460bbf3d74290a6fbff547bfb93a6cb654e20"

URI_aarch64_rust-icu_datetime+unstable_jiff_0_2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+unstable_jiff_0_2-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+unstable_jiff_0_2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+unstable_jiff_0_2-devel}"
SRC_URI[aarch64_rust-icu_datetime+unstable_jiff_0_2-devel.sha256sum] = "041296bb0d94799653ea218d7302853dd8994f3c244c35b4bea58cd27e67e2f7"

URI_aarch64_rust-icu_datetime+unstable_time_0_3-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime+unstable_time_0_3-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime+unstable_time_0_3-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime+unstable_time_0_3-devel}"
SRC_URI[aarch64_rust-icu_datetime+unstable_time_0_3-devel.sha256sum] = "221e1f0ac3252968c921d6413077cf52bd1166076d11110a539e115af27a5412"

URI_aarch64_rust-icu_datetime-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-icu_datetime-devel-2.2.0-1.el10_2.noarch.rpm;name=aarch64_rust-icu_datetime-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-icu_datetime-devel}"
SRC_URI[aarch64_rust-icu_datetime-devel.sha256sum] = "2cd79684182a75b5e4e405dba74a008fc686670065d9b4ef577f7b1735416d57"

RDEPENDS:rust-icu_datetime+compiled_data-devel = " \
 cargo \
 rust-icu_calendar+compiled_data-devel \
 rust-icu_datetime-devel \
 rust-icu_datetime_data-devel \
 rust-icu_decimal+compiled_data-devel \
 rust-icu_locale+compiled_data-devel \
 rust-icu_locale-devel \
 rust-icu_plurals+compiled_data-devel \
 rust-icu_provider+baked-devel \
 rust-icu_time+compiled_data-devel \
 "
RDEPENDS:rust-icu_datetime+datagen-devel = " \
 cargo \
 rust-databake+derive-devel \
 rust-databake-devel \
 rust-icu_calendar+datagen-devel \
 rust-icu_datetime+serde-devel \
 rust-icu_datetime-devel \
 rust-icu_pattern+databake-devel \
 rust-icu_plurals+datagen-devel \
 rust-icu_provider+export-devel \
 rust-icu_time+datagen-devel \
 rust-smallvec-devel \
 "
RDEPENDS:rust-icu_datetime+default-devel = " \
 cargo \
 rust-icu_datetime+compiled_data-devel \
 rust-icu_datetime+ixdtf-devel \
 rust-icu_datetime-devel \
 "
RDEPENDS:rust-icu_datetime+ixdtf-devel = " \
 cargo \
 rust-icu_calendar+ixdtf-devel \
 rust-icu_datetime-devel \
 rust-icu_time+ixdtf-devel \
 "
RDEPENDS:rust-icu_datetime+logging-devel = " \
 cargo \
 rust-icu_calendar+logging-devel \
 rust-icu_datetime-devel \
 "
RDEPENDS:rust-icu_datetime+serde-devel = " \
 cargo \
 rust-icu_calendar+serde-devel \
 rust-icu_datetime-devel \
 rust-icu_decimal+serde-devel \
 rust-icu_pattern+serde-devel \
 rust-icu_plurals+serde-devel \
 rust-icu_provider+alloc-devel \
 rust-icu_provider+serde-devel \
 rust-icu_time+serde-devel \
 rust-potential_utf+serde-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 rust-smallvec+serde-devel \
 rust-smallvec-devel \
 rust-tinystr+serde-devel \
 rust-zerotrie+alloc-devel \
 rust-zerotrie-devel \
 rust-zerovec+serde-devel \
 "
RDEPENDS:rust-icu_datetime+unstable-devel = " \
 cargo \
 rust-icu_datetime-devel \
 rust-icu_time+unstable-devel \
 "
RDEPENDS:rust-icu_datetime+unstable_chrono_0_4-devel = " \
 cargo \
 rust-chrono-devel \
 rust-icu_calendar+unstable_chrono_0_4-devel \
 rust-icu_datetime-devel \
 rust-icu_time+unstable_chrono_0_4-devel \
 "
RDEPENDS:rust-icu_datetime+unstable_jiff_0_2-devel = " \
 cargo \
 rust-icu_calendar+unstable_jiff_0_2-devel \
 rust-icu_datetime-devel \
 rust-icu_time+unstable_jiff_0_2-devel \
 rust-jiff-devel \
 "
RDEPENDS:rust-icu_datetime+unstable_time_0_3-devel = " \
 cargo \
 rust-icu_calendar+unstable_time_0_3-devel \
 rust-icu_datetime-devel \
 rust-icu_time+unstable_time_0_3-devel \
 rust-time-devel \
 "
RDEPENDS:rust-icu_datetime-devel = " \
 cargo \
 rust \
 rust-displaydoc-devel \
 rust-fixed_decimal-devel \
 rust-icu_calendar-devel \
 rust-icu_decimal-devel \
 rust-icu_locale_core-devel \
 rust-icu_pattern+alloc-devel \
 rust-icu_pattern+zerovec-devel \
 rust-icu_pattern-devel \
 rust-icu_plurals-devel \
 rust-icu_provider-devel \
 rust-icu_time+alloc-devel \
 rust-icu_time-devel \
 rust-potential_utf+alloc-devel \
 rust-potential_utf+zerovec-devel \
 rust-potential_utf-devel \
 rust-tinystr+alloc-devel \
 rust-tinystr+zerovec-devel \
 rust-tinystr-devel \
 rust-writeable-devel \
 rust-zerovec+alloc-devel \
 rust-zerovec+yoke-devel \
 rust-zerovec-devel \
 "
