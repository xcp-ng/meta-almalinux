# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_proxy_cluster"
PV = "1.3.22"
PR = "1.el10_0.2"
PACKAGES = " \
 mod_proxy_cluster \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_proxy_cluster-1.3.22-1.el10_0.2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "eedee5c1840e8ba13be751075b9ce6e6161b23029d4f201c3b5299870631dbb6"

URI_x86_64_v2_mod_proxy_cluster = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_proxy_cluster-1.3.22-1.el10_0.2.x86_64_v2.rpm;name=x86_64_v2_mod_proxy_cluster;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_proxy_cluster}"
SRC_URI[x86_64_v2_mod_proxy_cluster.sha256sum] = "5d51a253a8f328a97afaf0feeb45131add00d1dd7096716e4f0c68b3689dd397"

URI_aarch64_mod_proxy_cluster = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_proxy_cluster-1.3.22-1.el10_0.2.aarch64.rpm;name=aarch64_mod_proxy_cluster;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_proxy_cluster}"
SRC_URI[aarch64_mod_proxy_cluster.sha256sum] = "ae5ce20cb3f0082698fc6f1b940485bca22295afafae6a9bf5a6222faa7e89bd"

RDEPENDS:mod_proxy_cluster = " \
 apr \
 apr-util \
 bash \
 glibc \
 httpd \
 policycoreutils-python-utils \
 python3-policycoreutils \
 "
