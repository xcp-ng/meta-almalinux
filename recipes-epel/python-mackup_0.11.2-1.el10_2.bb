# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-mackup"
PV = "0.11.2"
PR = "1.el10_2"
PACKAGES = " \
 mackup \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-mackup-0.11.2-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3bdd33dc1ffdcd9383eca4ec60dfe5179c0fa585e0d8df7b6e87b0389af43afc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mackup-0.11.2-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_mackup;unpack=0"
SRC_URI[x86_64_v2_mackup.sha256sum] = "6f852a97aebac2194cf82b200ac8542ef3adec2dac84a6462743cdcecf14f565"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/m/mackup-0.11.2-1.el10_2.noarch.rpm;name=aarch64_mackup;unpack=0"
SRC_URI[aarch64_mackup.sha256sum] = "6b4919fc931fc8adeab2d843c19e0985479a924bd6b3c492864064492317c98a"

RDEPENDS:mackup = " \
 procps-ng \
 python3 \
 python3-docopt-ng \
 "
