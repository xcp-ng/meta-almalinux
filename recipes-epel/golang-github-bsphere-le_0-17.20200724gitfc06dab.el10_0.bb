# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-bsphere-le"
PV = "0"
PR = "17.20200724gitfc06dab.el10_0"
PACKAGES = " \
 golang-github-bsphere-le-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/g/golang-github-bsphere-le-0-17.20200724gitfc06dab.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "e38d216b9b156d0bd3edbc035bda916043b3681f2baca4684441a026a385e39d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/g/golang-github-bsphere-le-devel-0-17.20200724gitfc06dab.el10_0.noarch.rpm;name=aarch64_golang-github-bsphere-le-devel;unpack=0"
SRC_URI[aarch64_golang-github-bsphere-le-devel.sha256sum] = "272eff18e576d9c5d53f0a2000df19ab33a7ca175770de6c2a8a0d904b4d6c2f"

RDEPENDS:golang-github-bsphere-le-devel = " \
 go-filesystem \
 "
