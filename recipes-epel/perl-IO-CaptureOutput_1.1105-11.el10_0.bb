# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-IO-CaptureOutput"
PV = "1.1105"
PR = "11.el10_0"
PACKAGES = " \
 perl-IO-CaptureOutput \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-IO-CaptureOutput-1.1105-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3036f247b86a964f69b06a5cdbc0dd72a47ddbf8519040a894d52b45779eb59d"

URI_x86_64_v2_perl-IO-CaptureOutput = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-IO-CaptureOutput-1.1105-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-IO-CaptureOutput;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-IO-CaptureOutput}"
SRC_URI[x86_64_v2_perl-IO-CaptureOutput.sha256sum] = "538181774c7b7ebf32600b0777d2d8b50bd4896de48486d11073b4acac9c3f15"

URI_aarch64_perl-IO-CaptureOutput = "${EPEL_MIRROR}/aarch64/Packages/p/perl-IO-CaptureOutput-1.1105-11.el10_0.noarch.rpm;name=aarch64_perl-IO-CaptureOutput;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-IO-CaptureOutput}"
SRC_URI[aarch64_perl-IO-CaptureOutput.sha256sum] = "7f42073b4e5a432fa59d0b614a9488edc8612cc739d04a18a285feb5ee8677b0"

RDEPENDS:perl-IO-CaptureOutput = " \
 perl-Carp \
 perl-Exporter \
 perl-File-Basename \
 perl-File-Temp \
 perl-Symbol \
 perl-libs \
 perl-vars \
 "
