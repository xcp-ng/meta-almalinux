# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cipher"
PV = "0.4.4"
PR = "5.el10_0"
PACKAGES = " \
 rust-cipher+alloc-devel \
 rust-cipher+blobby-devel \
 rust-cipher+block-padding-devel \
 rust-cipher+default-devel \
 rust-cipher+dev-devel \
 rust-cipher+rand_core-devel \
 rust-cipher+std-devel \
 rust-cipher+zeroize-devel \
 rust-cipher-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cipher-0.4.4-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7a492868c1686e645215ddf2d9fbe765eef8b2586e500f8028d1f7fe84f53ccd"

URI_x86_64_v2_rust-cipher+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+alloc-devel-0.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+alloc-devel}"
SRC_URI[x86_64_v2_rust-cipher+alloc-devel.sha256sum] = "b6253a285dbf0d70e8ebddf651ca3fb092b6f01a48b2abb9c2f8ee7d8fdea50c"

URI_x86_64_v2_rust-cipher+blobby-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+blobby-devel-0.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+blobby-devel}"
SRC_URI[x86_64_v2_rust-cipher+blobby-devel.sha256sum] = "062608f58eabd6d286b90a267ff0160a5ba10e27528b0f6252615e07b71acc0e"

URI_x86_64_v2_rust-cipher+block-padding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+block-padding-devel-0.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+block-padding-devel}"
SRC_URI[x86_64_v2_rust-cipher+block-padding-devel.sha256sum] = "e24058757a97c848cdce8b6e1bc181f6388305cb85c6cd9ea90f5705931e0c4c"

URI_x86_64_v2_rust-cipher+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+default-devel-0.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+default-devel}"
SRC_URI[x86_64_v2_rust-cipher+default-devel.sha256sum] = "5520b52b844538ced6cc0091927b5f1ee667b85feb88986678fa28720ca4d0ab"

URI_x86_64_v2_rust-cipher+dev-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+dev-devel-0.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+dev-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+dev-devel}"
SRC_URI[x86_64_v2_rust-cipher+dev-devel.sha256sum] = "b480157b55deeaab4dab6bceeb396409fa349af5c75ea4f1e16b3f293c3cf46e"

URI_x86_64_v2_rust-cipher+rand_core-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+rand_core-devel-0.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+rand_core-devel}"
SRC_URI[x86_64_v2_rust-cipher+rand_core-devel.sha256sum] = "ca64083f3b0b8ae729641ba62cefbde4a70a4c77fe08cba8826f5e3650298795"

URI_x86_64_v2_rust-cipher+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+std-devel-0.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+std-devel}"
SRC_URI[x86_64_v2_rust-cipher+std-devel.sha256sum] = "aa50f1d4b12107778dace6f761843e5a4a7ceffdc7d59e89d8549e39c004b33c"

URI_x86_64_v2_rust-cipher+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher+zeroize-devel-0.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cipher+zeroize-devel.sha256sum] = "12c8140f66d91b46d266beee85c4f53850850d375b641984c700b53d7e203496"

URI_x86_64_v2_rust-cipher-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cipher-devel-0.4.4-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cipher-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cipher-devel}"
SRC_URI[x86_64_v2_rust-cipher-devel.sha256sum] = "b9cbf20c3479306acdbb76154ae8d65227e88e339d7bbd3b577815eceb311058"

URI_aarch64_rust-cipher+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+alloc-devel-0.4.4-5.el10_0.noarch.rpm;name=aarch64_rust-cipher+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+alloc-devel}"
SRC_URI[aarch64_rust-cipher+alloc-devel.sha256sum] = "e90763fb54862d1223fdff68fd5fb6af817f26fd88dfc4806b8d1fa6a7945bc4"

URI_aarch64_rust-cipher+blobby-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+blobby-devel-0.4.4-5.el10_0.noarch.rpm;name=aarch64_rust-cipher+blobby-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+blobby-devel}"
SRC_URI[aarch64_rust-cipher+blobby-devel.sha256sum] = "e174ac010bc54d06ec7770f1924b62f09496513055dd1efb6858fd50411018c6"

URI_aarch64_rust-cipher+block-padding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+block-padding-devel-0.4.4-5.el10_0.noarch.rpm;name=aarch64_rust-cipher+block-padding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+block-padding-devel}"
SRC_URI[aarch64_rust-cipher+block-padding-devel.sha256sum] = "281d5a525241bb77a2b04634d089e9ddb8cf68365827e0b134f92e1201f5c9ff"

URI_aarch64_rust-cipher+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+default-devel-0.4.4-5.el10_0.noarch.rpm;name=aarch64_rust-cipher+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+default-devel}"
SRC_URI[aarch64_rust-cipher+default-devel.sha256sum] = "1556f6a38e0bab107a8d07f4cb14aff1e5ad59de6c017b9ef02f6f4181e6b408"

URI_aarch64_rust-cipher+dev-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+dev-devel-0.4.4-5.el10_0.noarch.rpm;name=aarch64_rust-cipher+dev-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+dev-devel}"
SRC_URI[aarch64_rust-cipher+dev-devel.sha256sum] = "d818dac3abdcc27ad753aac1753ebd4f99898cbf9c799a83ffa5f11eb89598d0"

URI_aarch64_rust-cipher+rand_core-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+rand_core-devel-0.4.4-5.el10_0.noarch.rpm;name=aarch64_rust-cipher+rand_core-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+rand_core-devel}"
SRC_URI[aarch64_rust-cipher+rand_core-devel.sha256sum] = "d8ae041d9b33cd9942d1731b3d0f5e0f7f42946c2dce88c27a9c3e85a6ac63f7"

URI_aarch64_rust-cipher+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+std-devel-0.4.4-5.el10_0.noarch.rpm;name=aarch64_rust-cipher+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+std-devel}"
SRC_URI[aarch64_rust-cipher+std-devel.sha256sum] = "ba5b999cdd9edb3566705c35dc030d622d7fa16541ca130c0119840ca946d5f3"

URI_aarch64_rust-cipher+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher+zeroize-devel-0.4.4-5.el10_0.noarch.rpm;name=aarch64_rust-cipher+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher+zeroize-devel}"
SRC_URI[aarch64_rust-cipher+zeroize-devel.sha256sum] = "2cf11842f37b4991ac0e9964543bdcba7eea84ce0ec0cd858646eee430f5a578"

URI_aarch64_rust-cipher-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cipher-devel-0.4.4-5.el10_0.noarch.rpm;name=aarch64_rust-cipher-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cipher-devel}"
SRC_URI[aarch64_rust-cipher-devel.sha256sum] = "5be39416c8841737b18297555148e1d13abf39234ec60605d3fabdecc574f5d8"

RDEPENDS:rust-cipher+alloc-devel = " \
 cargo \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+blobby-devel = " \
 cargo \
 rust-blobby+default-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+block-padding-devel = " \
 cargo \
 rust-cipher-devel \
 rust-inout+block-padding-devel \
 "
RDEPENDS:rust-cipher+default-devel = " \
 cargo \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+dev-devel = " \
 cargo \
 rust-cipher+blobby-devel \
 rust-cipher-devel \
 "
RDEPENDS:rust-cipher+rand_core-devel = " \
 cargo \
 rust-cipher-devel \
 rust-crypto-common+rand_core-devel \
 "
RDEPENDS:rust-cipher+std-devel = " \
 cargo \
 rust-cipher+alloc-devel \
 rust-cipher-devel \
 rust-crypto-common+std-devel \
 rust-inout+std-devel \
 "
RDEPENDS:rust-cipher+zeroize-devel = " \
 cargo \
 rust-cipher-devel \
 rust-zeroize-devel \
 "
RDEPENDS:rust-cipher-devel = " \
 cargo \
 rust \
 rust-crypto-common+default-devel \
 rust-inout+default-devel \
 "
