# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "pdftk-java"
PV = "3.3.3"
PR = "8.el10_0"
PACKAGES = " \
 pdftk-java \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/pdftk-java-3.3.3-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ae2e528708669dbf6047381e7ffce96d1a5aac2dddf0480e1722d554f7c98677"

URI_x86_64_v2_pdftk-java = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/pdftk-java-3.3.3-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_pdftk-java;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pdftk-java}"
SRC_URI[x86_64_v2_pdftk-java.sha256sum] = "281ee9ea69a1b57da3c727d21df3f32f0f250e3a9c4b12dd273dc04e1fab60be"

URI_aarch64_pdftk-java = "${EPEL_MIRROR}/aarch64/Packages/p/pdftk-java-3.3.3-8.el10_0.noarch.rpm;name=aarch64_pdftk-java;unpack=0"
SRC_URI:append = " ${URI_aarch64_pdftk-java}"
SRC_URI[aarch64_pdftk-java.sha256sum] = "2873e1b1c05a40d17695845912a7db0ea3eb507880fc925205bce1d2176e9d38"

RDEPENDS:pdftk-java = " \
 apache-commons-lang3 \
 bash \
 bouncycastle \
 java-21-openjdk-headless \
 javapackages-tools \
 "
