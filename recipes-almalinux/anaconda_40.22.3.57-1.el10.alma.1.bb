# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "anaconda"
PV = "40.22.3.57"
PR = "1.el10.alma.1"
PACKAGES = " \
 anaconda \
 anaconda-core \
 anaconda-dracut \
 anaconda-gui \
 anaconda-install-env-deps \
 anaconda-install-img-deps \
 anaconda-tui \
 anaconda-widgets \
 anaconda-widgets-devel \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/anaconda-40.22.3.57-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "2468fd37b075e712b31843f2d9e19bfb7bdd6ea3cba6defefeea1be0754271db"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - anaconda-install-env-deps: tmux

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - anaconda-install-env-deps: tmux

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-40.22.3.57-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda;unpack=0"
SRC_URI[x86_64_v2_anaconda.sha256sum] = "87dcd0a396d760c79fe6fcac382b299290a0521b98c7b27f8958d7ff2fe9446c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-core-40.22.3.57-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-core;unpack=0"
SRC_URI[x86_64_v2_anaconda-core.sha256sum] = "8c7d919746971ed97250d4cc0b2b0bd6e32491db9e8b12d6321e7a567b0ac592"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-dracut-40.22.3.57-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-dracut;unpack=0"
SRC_URI[x86_64_v2_anaconda-dracut.sha256sum] = "778ea3c61622d6172f0185eb3f3d78371e38a10e9826957567cf92b4abc1b9c2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-gui-40.22.3.57-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-gui;unpack=0"
SRC_URI[x86_64_v2_anaconda-gui.sha256sum] = "94c04bd5f4fc2487319b6dbba43721ca23b3aac1b5d4ec4cb5d9e12a9eb650c0"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-env-deps-40.22.3.57-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-env-deps;unpack=0"
SRC_URI[x86_64_v2_anaconda-install-env-deps.sha256sum] = "25eab532f67a0f1ad4023c4c4e3da8dddd234cf3173de0ae61f29d6182273d3d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-install-img-deps-40.22.3.57-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-install-img-deps;unpack=0"
SRC_URI[x86_64_v2_anaconda-install-img-deps.sha256sum] = "9321e94c96904e49270afb1ee539f7b0027c5c60084479ab1b2bae8295f395c7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-tui-40.22.3.57-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-tui;unpack=0"
SRC_URI[x86_64_v2_anaconda-tui.sha256sum] = "4886d75b1d89e29fd24dc677dbf24d1b13b8f8e69146301bdb50fb10024dade9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/anaconda-widgets-40.22.3.57-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets;unpack=0"
SRC_URI[x86_64_v2_anaconda-widgets.sha256sum] = "2a70085ec6553760a40740bd0da0e6a9c77e40752eee55e5dbd2dae91cda247d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/anaconda-widgets-devel-40.22.3.57-1.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_anaconda-widgets-devel;unpack=0"
SRC_URI[x86_64_v2_anaconda-widgets-devel.sha256sum] = "9476d9f094ab5f229ed2ca011cf5a1a00073500a6d031372c5ac843c4c7972b7"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-40.22.3.57-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda;unpack=0"
SRC_URI[aarch64_anaconda.sha256sum] = "e722f895abeb794d5420df89d7e54e88298c0abc7dc96ecac2c744bddf8b00b8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-core-40.22.3.57-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-core;unpack=0"
SRC_URI[aarch64_anaconda-core.sha256sum] = "1aa519c2ec7fee4f8afd6358c6022c4a0c1a401ce22f9c709f25956cdbcf2706"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-dracut-40.22.3.57-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-dracut;unpack=0"
SRC_URI[aarch64_anaconda-dracut.sha256sum] = "faf938da8056715c126a1b84c2a3178085d385f06ceff5b5cad454fccc282286"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-gui-40.22.3.57-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-gui;unpack=0"
SRC_URI[aarch64_anaconda-gui.sha256sum] = "d766ba2f7424325788aae1d87d800bdb602984b243a165b2b2681cc5c9410746"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-env-deps-40.22.3.57-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-install-env-deps;unpack=0"
SRC_URI[aarch64_anaconda-install-env-deps.sha256sum] = "ac1ecf796858ccf60e09ef0f41701ee73548e9a47f4d39515e40c97cd80628ed"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-install-img-deps-40.22.3.57-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-install-img-deps;unpack=0"
SRC_URI[aarch64_anaconda-install-img-deps.sha256sum] = "4e05ed407a3f2acd9ce1f9b3fcb21fadb1e89142277f6a1de4061eada957a4be"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-tui-40.22.3.57-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-tui;unpack=0"
SRC_URI[aarch64_anaconda-tui.sha256sum] = "e79c8b029c2edc269630451ca6bc621eb8ff41ce3eefd8a4b1dd5d76426d051c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/anaconda-widgets-40.22.3.57-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets;unpack=0"
SRC_URI[aarch64_anaconda-widgets.sha256sum] = "6c9e56bd23d40a00f3fe0741daac3c4d73a2530b58a4dff9e994792c612c0e21"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/anaconda-widgets-devel-40.22.3.57-1.el10.alma.1.aarch64.rpm;name=aarch64_anaconda-widgets-devel;unpack=0"
SRC_URI[aarch64_anaconda-widgets-devel.sha256sum] = "9fd67c20fce6487aadf2d0db24918ca5308baab0a5949c0ffb2158c82f9e8396"

RDEPENDS:anaconda = " \
 anaconda-gui \
 anaconda-tui \
 "
RDEPENDS:anaconda-core = " \
 NetworkManager \
 NetworkManager-libnm \
 anaconda-tui \
 bash \
 chrony \
 cracklib-dicts \
 crypto-policies \
 crypto-policies-scripts \
 dbus-daemon \
 flatpak \
 flatpak-libs \
 grub2-common \
 kbd \
 python3 \
 python3-blivet \
 python3-blockdev \
 python3-dasbus \
 python3-dnf \
 python3-gobject-base \
 python3-kickstart \
 python3-langtable \
 python3-libs \
 python3-libselinux \
 python3-meh \
 python3-pid \
 python3-productmd \
 python3-pwquality \
 python3-pyparted \
 python3-requests \
 python3-requests-file \
 python3-requests-ftp \
 python3-rpm \
 python3-systemd \
 systemd \
 util-linux \
 virtual//usr/bin/date \
 virtual/glibc-langpack-en_or_glibc-all-langpacks \
 "
RDEPENDS:anaconda-dracut = " \
 bash \
 dnsconfd \
 dnsconfd-dracut \
 dracut \
 dracut-live \
 dracut-network \
 glibc \
 iputils \
 libarchive \
 python3 \
 python3-kickstart \
 rpm-libs \
 xz \
 "
RDEPENDS:anaconda-gui = " \
 NetworkManager-wifi \
 adwaita-icon-theme \
 almalinux-logos \
 anaconda-core \
 anaconda-widgets \
 nm-connection-editor \
 python3 \
 python3-iso639 \
 python3-meh-gui \
 python3-xkbregistry \
 tecla \
 "
RDEPENDS:anaconda-install-env-deps = " \
 dosfstools \
 e2fsprogs \
 gdb \
 isomd5sum \
 kexec-tools \
 libblockdev-plugins-all \
 realmd \
 rsync \
 udisks2-iscsi \
 xfsprogs \
 "
RDEPENDS:anaconda-install-img-deps:x86_64_v2 = " \
 anaconda-install-env-deps \
 bootc \
 bootupd \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 fcoe-utils \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 libselinux-utils \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 policycoreutils \
 policycoreutils-python-utils \
 python3-pam \
 rpm-ostree \
 selinux-policy \
 selinux-policy-targeted \
 skopeo \
 zram-generator-defaults \
"
RDEPENDS:anaconda-install-img-deps:aarch64 = " \
 anaconda-install-env-deps \
 bootc \
 bootupd \
 brltty \
 createrepo_c \
 device-mapper-multipath \
 dnsconfd \
 dnsconfd-dracut \
 gnome-kiosk \
 gnome-remote-desktop \
 gsettings-desktop-schemas \
 kdump-anaconda-addon \
 librsvg2 \
 libselinux-utils \
 mesa-dri-drivers \
 nm-connection-editor \
 nvme-cli \
 openssl \
 ostree \
 policycoreutils \
 policycoreutils-python-utils \
 python3-pam \
 rpm-ostree \
 selinux-policy \
 selinux-policy-targeted \
 skopeo \
 zram-generator-defaults \
"
RDEPENDS:anaconda-tui = " \
 anaconda-core \
 python3 \
 python3-simpleline \
 "
RDEPENDS:anaconda-widgets = " \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 gtk3 \
 harfbuzz \
 libgcc \
 pango \
 python3 \
 "
RDEPENDS:anaconda-widgets-devel = " \
 anaconda-widgets \
 "
