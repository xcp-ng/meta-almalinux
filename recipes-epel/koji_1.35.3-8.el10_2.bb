# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "koji"
PV = "1.35.3"
PR = "8.el10_2"
PACKAGES = " \
 koji \
 koji-builder \
 koji-builder-plugins \
 koji-hub \
 koji-hub-plugins \
 koji-utils \
 koji-vm \
 koji-web \
 python3-koji \
 python3-koji-cli-plugins \
 python3-koji-hub \
 python3-koji-hub-plugins \
 python3-koji-web \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/koji-1.35.3-8.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d29cfb45a712669d969e820fc6e285c27faab4b54038e06dccccbd049394446e"

URI_x86_64_v2_koji = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_koji;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji}"
SRC_URI[x86_64_v2_koji.sha256sum] = "13af9a5a8d114a15794b4c2459a49b687daf128ed33dd8f6d4fe8590cad1b64b"

URI_x86_64_v2_koji-builder = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-builder-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_koji-builder;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-builder}"
SRC_URI[x86_64_v2_koji-builder.sha256sum] = "7cb70f6bc4f1c85064a4242e62eda692dc85c3fd67f0d7f46a2800a706d750a0"

URI_x86_64_v2_koji-builder-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-builder-plugins-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_koji-builder-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-builder-plugins}"
SRC_URI[x86_64_v2_koji-builder-plugins.sha256sum] = "d032774ffcd226737c15ced50ce9a71bf26d36899999bdd01143eec5b12822e9"

URI_x86_64_v2_koji-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-hub-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_koji-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-hub}"
SRC_URI[x86_64_v2_koji-hub.sha256sum] = "8aba440a23b65f56e0fa88cff48a1ef17f6aba9fd3f26250eddd28606a20c429"

URI_x86_64_v2_koji-hub-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-hub-plugins-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-hub-plugins}"
SRC_URI[x86_64_v2_koji-hub-plugins.sha256sum] = "78364238eb53f4ab330f3b622ff0dda69ae00583bbf769cd4482a4da086aa462"

URI_x86_64_v2_koji-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-utils-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_koji-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-utils}"
SRC_URI[x86_64_v2_koji-utils.sha256sum] = "bff1cb9dcfa58fde30fbe37140b4a502fabfc1d18428315cd3e96353b8c40eb2"

URI_x86_64_v2_koji-vm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-vm-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_koji-vm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-vm}"
SRC_URI[x86_64_v2_koji-vm.sha256sum] = "7f599dbb53fc22b49a50617b27c38ed08c4d3702f907c688ee617947e089d22c"

URI_x86_64_v2_koji-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/koji-web-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_koji-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_koji-web}"
SRC_URI[x86_64_v2_koji-web.sha256sum] = "a8ed4d96344448fa29140a348e968304dda7f2458bc9eb130c832be5b44c37a4"

URI_x86_64_v2_python3-koji = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji}"
SRC_URI[x86_64_v2_python3-koji.sha256sum] = "550d022d51b2f5303800d0b3f355d2fac68f1a34ec166e0343e984ec25d31d28"

URI_x86_64_v2_python3-koji-cli-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-cli-plugins-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-cli-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-cli-plugins}"
SRC_URI[x86_64_v2_python3-koji-cli-plugins.sha256sum] = "d4709f2ac5a353aa20df1a055b5176e19f905cf6f06b3b05ad2c0222a367da6a"

URI_x86_64_v2_python3-koji-hub = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-hub-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-hub;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-hub}"
SRC_URI[x86_64_v2_python3-koji-hub.sha256sum] = "76fe3f1f195c6a9a61f023c07c6a33106b7458f58ef34acf54b46ab7238f8efc"

URI_x86_64_v2_python3-koji-hub-plugins = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-hub-plugins-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-hub-plugins}"
SRC_URI[x86_64_v2_python3-koji-hub-plugins.sha256sum] = "4b6d12521cc82d47d5f326c5750f10d66986b304691bb836b7badfca9fc5c51e"

URI_x86_64_v2_python3-koji-web = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-koji-web-1.35.3-8.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-koji-web;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-koji-web}"
SRC_URI[x86_64_v2_python3-koji-web.sha256sum] = "fda2f53201d85158386a002cd98209ca0ac1ce1ebb0c6136a36e7b001c1cd111"

URI_aarch64_koji = "${EPEL_MIRROR}/aarch64/Packages/k/koji-1.35.3-8.el10_2.noarch.rpm;name=aarch64_koji;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji}"
SRC_URI[aarch64_koji.sha256sum] = "1e231c59ae8bcb0d79bdf19e51b9c922810eb4cbc53ee83b5a2974b676c0c986"

URI_aarch64_koji-builder = "${EPEL_MIRROR}/aarch64/Packages/k/koji-builder-1.35.3-8.el10_2.noarch.rpm;name=aarch64_koji-builder;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-builder}"
SRC_URI[aarch64_koji-builder.sha256sum] = "0920eb3f6c6f551ef7f574217cf3d46f5c604253b2dc446df2c346c0e54ec42b"

URI_aarch64_koji-builder-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/koji-builder-plugins-1.35.3-8.el10_2.noarch.rpm;name=aarch64_koji-builder-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-builder-plugins}"
SRC_URI[aarch64_koji-builder-plugins.sha256sum] = "69738a9941d22a7faa4fac1eaf36e2b6f48ac6a43b8c816dd080769e701f8ce0"

URI_aarch64_koji-hub = "${EPEL_MIRROR}/aarch64/Packages/k/koji-hub-1.35.3-8.el10_2.noarch.rpm;name=aarch64_koji-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-hub}"
SRC_URI[aarch64_koji-hub.sha256sum] = "61a7079117c108fcda42836d843a95509651f5b557aa778c0f855d73c782025e"

URI_aarch64_koji-hub-plugins = "${EPEL_MIRROR}/aarch64/Packages/k/koji-hub-plugins-1.35.3-8.el10_2.noarch.rpm;name=aarch64_koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-hub-plugins}"
SRC_URI[aarch64_koji-hub-plugins.sha256sum] = "1aea5bdc4af4ca149710a711d2a03def33749c5b7bcb1663a0e3ce36152e8272"

URI_aarch64_koji-utils = "${EPEL_MIRROR}/aarch64/Packages/k/koji-utils-1.35.3-8.el10_2.noarch.rpm;name=aarch64_koji-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-utils}"
SRC_URI[aarch64_koji-utils.sha256sum] = "a7d06ff9f7adcaa98c714569c024e4fc5bf31d332d93b09899060ee1c58973ac"

URI_aarch64_koji-vm = "${EPEL_MIRROR}/aarch64/Packages/k/koji-vm-1.35.3-8.el10_2.noarch.rpm;name=aarch64_koji-vm;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-vm}"
SRC_URI[aarch64_koji-vm.sha256sum] = "ede41a27df0d0e74da87a6fb5541ee04fad1e4b4f8cf9262a0934300c1c1ffcd"

URI_aarch64_koji-web = "${EPEL_MIRROR}/aarch64/Packages/k/koji-web-1.35.3-8.el10_2.noarch.rpm;name=aarch64_koji-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_koji-web}"
SRC_URI[aarch64_koji-web.sha256sum] = "54d0c6e43d11b080dff82f5af33b2b169c803535039a6e9dbf63a81fe6cbf8ad"

URI_aarch64_python3-koji = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-1.35.3-8.el10_2.noarch.rpm;name=aarch64_python3-koji;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji}"
SRC_URI[aarch64_python3-koji.sha256sum] = "d030f7f2ad5bf53b3032a06b63866b362148bed20696a71c882305048662d819"

URI_aarch64_python3-koji-cli-plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-cli-plugins-1.35.3-8.el10_2.noarch.rpm;name=aarch64_python3-koji-cli-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-cli-plugins}"
SRC_URI[aarch64_python3-koji-cli-plugins.sha256sum] = "bc5f607e683bafc912a7659f46cd50c38a43c13be3b051194f0c6eff0edf97d4"

URI_aarch64_python3-koji-hub = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-hub-1.35.3-8.el10_2.noarch.rpm;name=aarch64_python3-koji-hub;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-hub}"
SRC_URI[aarch64_python3-koji-hub.sha256sum] = "bbfdcf323ac1e187f277a3e8fb806fe642d1c9ca153640ad3e144f9c78bc3f3e"

URI_aarch64_python3-koji-hub-plugins = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-hub-plugins-1.35.3-8.el10_2.noarch.rpm;name=aarch64_python3-koji-hub-plugins;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-hub-plugins}"
SRC_URI[aarch64_python3-koji-hub-plugins.sha256sum] = "fb78345223978851f1fba33d4eb38e767fedf29a6e10595b5c146eeb2ac7658c"

URI_aarch64_python3-koji-web = "${EPEL_MIRROR}/aarch64/Packages/p/python3-koji-web-1.35.3-8.el10_2.noarch.rpm;name=aarch64_python3-koji-web;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-koji-web}"
SRC_URI[aarch64_python3-koji-web.sha256sum] = "b7801e5c65b72e85c8c848d9f9cf737d7826e7a5a6dbc3ac41b3e1134b0cf8e0"

RDEPENDS:koji = " \
 python3 \
 python3-koji \
 python3-libcomps \
 "
RDEPENDS:koji-builder = " \
 bash \
 createrepo_c \
 git-core \
 mock \
 python3 \
 python3-cheetah \
 python3-koji \
 python3-librepo \
 python3-multilib \
 python3-pycdio \
 squashfs-tools \
 subversion \
 systemd \
 "
RDEPENDS:koji-builder-plugins = " \
 koji \
 koji-builder \
 "
RDEPENDS:koji-hub = " \
 koji \
 python3 \
 python3-koji-hub \
 "
RDEPENDS:koji-hub-plugins = " \
 python3-koji-hub-plugins \
 "
RDEPENDS:koji-utils = " \
 bash \
 koji \
 python3 \
 python3-psycopg2 \
 systemd \
 "
RDEPENDS:koji-vm = " \
 bash \
 koji \
 python3 \
 python3-libvirt \
 python3-libxml2 \
 qemu-img \
 systemd \
 virt-install \
 "
RDEPENDS:koji-web = " \
 koji \
 python3-koji-web \
 "
RDEPENDS:python3-koji = " \
 python3 \
 python3-dateutil \
 python3-defusedxml \
 python3-requests \
 python3-requests-gssapi \
 python3-rpm \
 python3-six \
 "
RDEPENDS:python3-koji-cli-plugins = " \
 python3 \
 python3-koji \
 "
RDEPENDS:python3-koji-hub = " \
 httpd \
 mod_auth_gssapi \
 python3 \
 python3-koji \
 python3-mod_wsgi \
 python3-psycopg2 \
 "
RDEPENDS:python3-koji-hub-plugins = " \
 cpio \
 python3-koji-hub \
 python3-qpid-proton \
 "
RDEPENDS:python3-koji-web = " \
 httpd \
 mod_auth_gssapi \
 python3-cheetah \
 python3-koji \
 python3-mod_wsgi \
 python3-psycopg2 \
 "
