# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kjumpingcube"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kjumpingcube \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kjumpingcube-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3cf59dbe0d5fe28a0078f855ed50fd4cf2e167cda109c076272745590b0761cc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kjumpingcube-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kjumpingcube;unpack=0"
SRC_URI[x86_64_v2_kjumpingcube.sha256sum] = "7688375bb7c1a9e99aa0d241b49a5253a559dc23030eee580cfd6d09bd3fb05e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kjumpingcube-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kjumpingcube;unpack=0"
SRC_URI[aarch64_kjumpingcube.sha256sum] = "745146bdf3ed76b3378223434ac8e388078f75187734a687a8ca59466e542e44"

RDEPENDS:kjumpingcube = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libkdegames \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtsvg \
 "
