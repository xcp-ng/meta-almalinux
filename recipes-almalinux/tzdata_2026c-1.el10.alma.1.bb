# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tzdata"
PV = "2026c"
PR = "1.el10.alma.1"
PACKAGES = " \
 tzdata \
 tzdata-java \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tzdata-2026c-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6cea5a6fa7088dd3bc34a9e5ceb7575dbc25003c336a71e4627f1b00f67fa4a5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tzdata-2026c-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tzdata;unpack=0"
SRC_URI[x86_64_v2_tzdata.sha256sum] = "1d5a94dafc6d828285165f7ac4e4ba23c368033521a7b42ae555e4c9dbc35952"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tzdata-java-2026c-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tzdata-java;unpack=0"
SRC_URI[x86_64_v2_tzdata-java.sha256sum] = "16d52742057b0e70c9d3f754afba0f799a5edd044e3ad4e5d52a6535e0bb3a4d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tzdata-2026c-1.el10.alma.1.noarch.rpm;name=aarch64_tzdata;unpack=0"
SRC_URI[aarch64_tzdata.sha256sum] = "1d5a94dafc6d828285165f7ac4e4ba23c368033521a7b42ae555e4c9dbc35952"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tzdata-java-2026c-1.el10.alma.1.noarch.rpm;name=aarch64_tzdata-java;unpack=0"
SRC_URI[aarch64_tzdata-java.sha256sum] = "16d52742057b0e70c9d3f754afba0f799a5edd044e3ad4e5d52a6535e0bb3a4d"

RDEPENDS:tzdata = " \
 "
RDEPENDS:tzdata-java = " \
 "
