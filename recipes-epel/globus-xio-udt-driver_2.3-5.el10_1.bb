# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-xio-udt-driver"
PV = "2.3"
PR = "5.el10_1"
PACKAGES = " \
 globus-xio-udt-driver \
 globus-xio-udt-driver-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-xio-udt-driver-2.3-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "17b5f93764eb2f6c2b9e7b8bc0a5a5d7598f8a83667ab65231e5df84071370f6"

URI_x86_64_v2_globus-xio-udt-driver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-udt-driver-2.3-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-udt-driver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-udt-driver}"
SRC_URI[x86_64_v2_globus-xio-udt-driver.sha256sum] = "299cc9486c4f7a5b6ebaa26604a6247d670c94673e0c4966a1c95ff25ce9e505"

URI_x86_64_v2_globus-xio-udt-driver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-xio-udt-driver-devel-2.3-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-xio-udt-driver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-xio-udt-driver-devel}"
SRC_URI[x86_64_v2_globus-xio-udt-driver-devel.sha256sum] = "c5dff0779e8d9790e1214966f17ceb917a1e96b904f721f10945b7b3b6d65dbf"

URI_aarch64_globus-xio-udt-driver = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-udt-driver-2.3-5.el10_1.aarch64.rpm;name=aarch64_globus-xio-udt-driver;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-udt-driver}"
SRC_URI[aarch64_globus-xio-udt-driver.sha256sum] = "2a05e6f857faf3022fe746a541545a24dbfe7d5f2b366187baaa42c3a6f96c50"

URI_aarch64_globus-xio-udt-driver-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-xio-udt-driver-devel-2.3-5.el10_1.aarch64.rpm;name=aarch64_globus-xio-udt-driver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-xio-udt-driver-devel}"
SRC_URI[aarch64_globus-xio-udt-driver-devel.sha256sum] = "87d67f9d902342ac901606e070ddc673905ee54679ba3471e06f82ea75bdb4c7"

RDEPENDS:globus-xio-udt-driver = " \
 glib2 \
 glibc \
 globus-common \
 globus-xio \
 libgcc \
 libnice \
 libstdc++ \
 udt \
 "
RDEPENDS:globus-xio-udt-driver-devel = " \
 globus-common-devel \
 globus-xio-devel \
 globus-xio-udt-driver \
 pkgconf-pkg-config \
 "
