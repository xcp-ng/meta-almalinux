# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libdeflate-sys"
PV = "1.25.2"
PR = "1.el10_1"
PACKAGES = " \
 rust-libdeflate-sys+default-devel \
 rust-libdeflate-sys+dynamic-devel \
 rust-libdeflate-sys+freestanding-devel \
 rust-libdeflate-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libdeflate-sys-1.25.2-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ea4c86a2f80cb829aa2a7c713e9345467094e3c39ee9da1ac6f9ea53f2e6f7f8"

URI_x86_64_v2_rust-libdeflate-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+default-devel-1.25.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys+default-devel.sha256sum] = "bfdf31ace54109c683088e4f1472ff4a41f9448e7b4212de60a95f356d7def33"

URI_x86_64_v2_rust-libdeflate-sys+dynamic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+dynamic-devel-1.25.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys+dynamic-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys+dynamic-devel.sha256sum] = "251aea144c9f2032390c5e05816e2d9e2c5f5a36f814aa911e775354581879e3"

URI_x86_64_v2_rust-libdeflate-sys+freestanding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys+freestanding-devel-1.25.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys+freestanding-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys+freestanding-devel.sha256sum] = "599ceb90b111fd655112a9927f2b2f6dedee61300223deaf0b5e0d865806d90e"

URI_x86_64_v2_rust-libdeflate-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libdeflate-sys-devel-1.25.2-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libdeflate-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libdeflate-sys-devel}"
SRC_URI[x86_64_v2_rust-libdeflate-sys-devel.sha256sum] = "1b5e4530bbed5081b2eba490e8fb7418e78792f03398cad4dca0f4fc1ff87ec4"

URI_aarch64_rust-libdeflate-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+default-devel-1.25.2-1.el10_1.noarch.rpm;name=aarch64_rust-libdeflate-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys+default-devel}"
SRC_URI[aarch64_rust-libdeflate-sys+default-devel.sha256sum] = "b3e29c24840c33a3b1bd2bed7da942c4f94efb7f61203ae16d31dff5cd87eddc"

URI_aarch64_rust-libdeflate-sys+dynamic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+dynamic-devel-1.25.2-1.el10_1.noarch.rpm;name=aarch64_rust-libdeflate-sys+dynamic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys+dynamic-devel}"
SRC_URI[aarch64_rust-libdeflate-sys+dynamic-devel.sha256sum] = "0e380537b898d9e9c4e920e219dcc66afe273f5f8ce0cdc020af1a928268b85e"

URI_aarch64_rust-libdeflate-sys+freestanding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys+freestanding-devel-1.25.2-1.el10_1.noarch.rpm;name=aarch64_rust-libdeflate-sys+freestanding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys+freestanding-devel}"
SRC_URI[aarch64_rust-libdeflate-sys+freestanding-devel.sha256sum] = "613632c8f9fe2d7ba9185d341373cc24d5d81a70ac4a4e7d52179a0df7896612"

URI_aarch64_rust-libdeflate-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libdeflate-sys-devel-1.25.2-1.el10_1.noarch.rpm;name=aarch64_rust-libdeflate-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libdeflate-sys-devel}"
SRC_URI[aarch64_rust-libdeflate-sys-devel.sha256sum] = "cd8fff5a39e0e4f625de27eb7beb4d195b8229e2612f0bb38bab147e8c0c1e86"

RDEPENDS:rust-libdeflate-sys+default-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys+dynamic-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys+freestanding-devel = " \
 cargo \
 rust-libdeflate-sys-devel \
 "
RDEPENDS:rust-libdeflate-sys-devel = " \
 cargo \
 libdeflate-devel \
 rust-cc+default-devel \
 rust-pkg-config+default-devel \
 "
