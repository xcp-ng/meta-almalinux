# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Tie-Hash-Method"
PV = "0.02"
PR = "32.el10_1"
PACKAGES = " \
 perl-Tie-Hash-Method \
 perl-Tie-Hash-Method-tests \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Tie-Hash-Method-0.02-32.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0cf8f775504f5869be1c21471574cb5cb70ae58c5afe3f5d93fdb7bed986dd3b"

URI_x86_64_v2_perl-Tie-Hash-Method = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Hash-Method-0.02-32.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Hash-Method;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Hash-Method}"
SRC_URI[x86_64_v2_perl-Tie-Hash-Method.sha256sum] = "9681090ff4ed128f9da316d66544a3eb88210fe9b37c9771b996dc364a61b794"

URI_x86_64_v2_perl-Tie-Hash-Method-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Tie-Hash-Method-tests-0.02-32.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Tie-Hash-Method-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Tie-Hash-Method-tests}"
SRC_URI[x86_64_v2_perl-Tie-Hash-Method-tests.sha256sum] = "daf4e13a094b4e66da8b295af9dd8737c45220203a6becb3a09a622fdee488c2"

URI_aarch64_perl-Tie-Hash-Method = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Hash-Method-0.02-32.el10_1.noarch.rpm;name=aarch64_perl-Tie-Hash-Method;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Hash-Method}"
SRC_URI[aarch64_perl-Tie-Hash-Method.sha256sum] = "8b787e92523a95d4a414d6586187a00dca931eecd509f99210789f9f38c5e83b"

URI_aarch64_perl-Tie-Hash-Method-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Tie-Hash-Method-tests-0.02-32.el10_1.noarch.rpm;name=aarch64_perl-Tie-Hash-Method-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Tie-Hash-Method-tests}"
SRC_URI[aarch64_perl-Tie-Hash-Method-tests.sha256sum] = "11cd6450aec9599fa7a1742f63865afb15d7cdc6edfc44b1f27dea2f398eedf6"

RDEPENDS:perl-Tie-Hash-Method = " \
 perl-Data-Dumper \
 perl-Exporter \
 perl-base \
 perl-constant \
 perl-libs \
 "
RDEPENDS:perl-Tie-Hash-Method-tests = " \
 bash \
 perl-Test-Harness \
 perl-Test-Simple \
 perl-Tie-Hash-Method \
 "
