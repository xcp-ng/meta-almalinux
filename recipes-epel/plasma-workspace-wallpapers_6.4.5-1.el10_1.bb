# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "plasma-workspace-wallpapers"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 plasma-workspace-wallpapers \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/plasma-workspace-wallpapers-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1b83f062ebe6fee7e328f76c9ef955059afee9987d1edc0ca1a38386b1270fbc"

URI_x86_64_v2_plasma-workspace-wallpapers = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/plasma-workspace-wallpapers-6.4.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_plasma-workspace-wallpapers;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_plasma-workspace-wallpapers}"
SRC_URI[x86_64_v2_plasma-workspace-wallpapers.sha256sum] = "bfbfb42f176aa9980216cd9b71e7eea4982667a610075919d6734415df4dca4f"

URI_aarch64_plasma-workspace-wallpapers = "${EPEL_MIRROR}/aarch64/Packages/p/plasma-workspace-wallpapers-6.4.5-1.el10_1.noarch.rpm;name=aarch64_plasma-workspace-wallpapers;unpack=0"
SRC_URI:append = " ${URI_aarch64_plasma-workspace-wallpapers}"
SRC_URI[aarch64_plasma-workspace-wallpapers.sha256sum] = "e9c9cd68c0c6ae44d1e8ef38976f22cc41ecd56ac746864eb0e1979105e678d3"

RDEPENDS:plasma-workspace-wallpapers = " \
 kde-filesystem \
 "
