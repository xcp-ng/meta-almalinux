# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "antlr"
PV = "2.7.7"
PR = "79.el10"
PACKAGES = " \
 antlr-C++ \
 antlr-javadoc \
 antlr-manual \
 antlr-tool \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/antlr-2.7.7-79.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8596ac60908b0eeaea06b695de07d84b3a5b264591d7e06dcd8770db4f0b2140"

URI_x86_64_v2_antlr-C++ = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/antlr-C++-2.7.7-79.el10.x86_64_v2.rpm;name=x86_64_v2_antlr-C++;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_antlr-C++}"
SRC_URI[x86_64_v2_antlr-C++.sha256sum] = "a179d84302b2c7898b3206fab7540800e74fcd5b55526944affef6d8e6eb6396"

URI_x86_64_v2_antlr-javadoc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/antlr-javadoc-2.7.7-79.el10.noarch.rpm;name=x86_64_v2_antlr-javadoc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_antlr-javadoc}"
SRC_URI[x86_64_v2_antlr-javadoc.sha256sum] = "5171a64ce6a9b560d841ae82343973e9d9fabed52c8c27d245322ca929a95389"

URI_x86_64_v2_antlr-manual = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/antlr-manual-2.7.7-79.el10.noarch.rpm;name=x86_64_v2_antlr-manual;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_antlr-manual}"
SRC_URI[x86_64_v2_antlr-manual.sha256sum] = "3460d4bb8ac3da3369dbd619b14bfeda7c9073228a9eb5e8eae574ce85c38372"

URI_x86_64_v2_antlr-tool = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/antlr-tool-2.7.7-79.el10.noarch.rpm;name=x86_64_v2_antlr-tool;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_antlr-tool}"
SRC_URI[x86_64_v2_antlr-tool.sha256sum] = "cfce639ae1f1484afabcb82d705e09ad048e414e1e91ce95d48fbf8a16b434a0"

URI_aarch64_antlr-C++ = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/antlr-C++-2.7.7-79.el10.aarch64.rpm;name=aarch64_antlr-C++;unpack=0"
SRC_URI:append = " ${URI_aarch64_antlr-C++}"
SRC_URI[aarch64_antlr-C++.sha256sum] = "f8c72227082c9488498aa1758759a971775ee34b3c25f13462e0ad23bc0ad5cf"

URI_aarch64_antlr-javadoc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/antlr-javadoc-2.7.7-79.el10.noarch.rpm;name=aarch64_antlr-javadoc;unpack=0"
SRC_URI:append = " ${URI_aarch64_antlr-javadoc}"
SRC_URI[aarch64_antlr-javadoc.sha256sum] = "5171a64ce6a9b560d841ae82343973e9d9fabed52c8c27d245322ca929a95389"

URI_aarch64_antlr-manual = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/antlr-manual-2.7.7-79.el10.noarch.rpm;name=aarch64_antlr-manual;unpack=0"
SRC_URI:append = " ${URI_aarch64_antlr-manual}"
SRC_URI[aarch64_antlr-manual.sha256sum] = "3460d4bb8ac3da3369dbd619b14bfeda7c9073228a9eb5e8eae574ce85c38372"

URI_aarch64_antlr-tool = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/antlr-tool-2.7.7-79.el10.noarch.rpm;name=aarch64_antlr-tool;unpack=0"
SRC_URI:append = " ${URI_aarch64_antlr-tool}"
SRC_URI[aarch64_antlr-tool.sha256sum] = "cfce639ae1f1484afabcb82d705e09ad048e414e1e91ce95d48fbf8a16b434a0"

RDEPENDS:antlr-C++ = " \
 bash \
 "
RDEPENDS:antlr-javadoc = " \
 javapackages-filesystem \
 "
RDEPENDS:antlr-manual = " \
 "
RDEPENDS:antlr-tool = " \
 bash \
 javapackages-filesystem \
 javapackages-tools \
 "
