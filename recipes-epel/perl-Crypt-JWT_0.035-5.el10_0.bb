# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Crypt-JWT"
PV = "0.035"
PR = "5.el10_0"
PACKAGES = " \
 perl-Crypt-JWT \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Crypt-JWT-0.035-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3793c4713f591de9e85e7ab4ebd6fb561e4fc332406e96fa2820d985259245a3"

URI_x86_64_v2_perl-Crypt-JWT = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Crypt-JWT-0.035-5.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Crypt-JWT;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Crypt-JWT}"
SRC_URI[x86_64_v2_perl-Crypt-JWT.sha256sum] = "d02a2286c7f1a57f0dc66ea97c31c549f5fdcd5409322be4f1836bbc8d30f254"

URI_aarch64_perl-Crypt-JWT = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Crypt-JWT-0.035-5.el10_0.noarch.rpm;name=aarch64_perl-Crypt-JWT;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Crypt-JWT}"
SRC_URI[aarch64_perl-Crypt-JWT.sha256sum] = "87aa31640210f73aa006d54094cd12defe81f4e117b9070662d7832c4b135b79"

RDEPENDS:perl-Crypt-JWT = " \
 perl-Carp \
 perl-Compress-Raw-Zlib \
 perl-Crypt-JWT \
 perl-CryptX \
 perl-Exporter \
 perl-JSON \
 perl-Scalar-List-Utils \
 perl-libs \
 "
