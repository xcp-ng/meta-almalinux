# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcalendarcore"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kcalendarcore \
 kf6-kcalendarcore-devel \
 kf6-kcalendarcore-doc \
 kf6-kcalendarcore-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcalendarcore-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4e0741abb8cdfb755fa4d8c5f11844a1c8cf813d6bbe903e45726031e051d91f"

URI_x86_64_v2_kf6-kcalendarcore = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore}"
SRC_URI[x86_64_v2_kf6-kcalendarcore.sha256sum] = "7bfaa82e0eb1c6ecac7bdf8e8b65daeb3622d6b2ff980d34b2a975dab297630f"

URI_x86_64_v2_kf6-kcalendarcore-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcalendarcore-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-devel}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-devel.sha256sum] = "827d9b3a2ba8ddde28d1bd9c62fb2d1b03ecfc16afc90fafcb34164478c2880f"

URI_x86_64_v2_kf6-kcalendarcore-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcalendarcore-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-doc}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-doc.sha256sum] = "eb04ea9a145211808a2235d7462b0d0f8ae636d0d50005493fd93854df5057a7"

URI_x86_64_v2_kf6-kcalendarcore-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcalendarcore-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcalendarcore-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcalendarcore-html}"
SRC_URI[x86_64_v2_kf6-kcalendarcore-html.sha256sum] = "ab660ddb6361ab934bbb42b94883b84dacc5287fe0fcd68d289b96d04d29146c"

URI_aarch64_kf6-kcalendarcore = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcalendarcore;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore}"
SRC_URI[aarch64_kf6-kcalendarcore.sha256sum] = "c1daa699d794c31187979fa5aef5a040d9e22695e3beee81516976d9097a5e6c"

URI_aarch64_kf6-kcalendarcore-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcalendarcore-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-devel}"
SRC_URI[aarch64_kf6-kcalendarcore-devel.sha256sum] = "06126e779e21419ec469834e2793547bcd351aa0c5bae55adf9707e1af92d432"

URI_aarch64_kf6-kcalendarcore-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcalendarcore-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-doc}"
SRC_URI[aarch64_kf6-kcalendarcore-doc.sha256sum] = "355df5ca786f6242428d8348674514a9fe8875348d16668801f07c077b6a5a04"

URI_aarch64_kf6-kcalendarcore-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcalendarcore-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcalendarcore-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcalendarcore-html}"
SRC_URI[aarch64_kf6-kcalendarcore-html.sha256sum] = "5e864cafe46a3edb4345e5192c5f1d48d2600c27e189b609f536ff8e3ae4298d"

RDEPENDS:kf6-kcalendarcore = " \
 glibc \
 libical \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-kcalendarcore-devel = " \
 cmake-filesystem \
 kf6-kcalendarcore \
 libical-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcalendarcore-doc = " \
 "
RDEPENDS:kf6-kcalendarcore-html = " \
 "
