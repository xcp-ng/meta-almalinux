# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Email-MessageID"
PV = "1.408"
PR = "1.el10_0"
PACKAGES = " \
 perl-Email-MessageID \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-Email-MessageID-1.408-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "5ef8993a9dd35b9d7175712a992bcedefbb7d149c644bb4ac36e5218f8a1b451"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Email-MessageID-1.408-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Email-MessageID;unpack=0"
SRC_URI[x86_64_v2_perl-Email-MessageID.sha256sum] = "cf7bc0280f62e101c7e7caaa5b6524aac8ba249835709d88a5432a5ccc580974"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-Email-MessageID-1.408-1.el10_0.noarch.rpm;name=aarch64_perl-Email-MessageID;unpack=0"
SRC_URI[aarch64_perl-Email-MessageID.sha256sum] = "9c6fb40492a140186f949a182839208398605b0718d3cd2c36de8907028ac6fe"

RDEPENDS:perl-Email-MessageID = " \
 perl-Sys-Hostname \
 perl-libs \
 perl-overload \
 "
