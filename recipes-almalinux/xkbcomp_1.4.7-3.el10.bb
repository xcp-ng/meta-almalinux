# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xkbcomp"
PV = "1.4.7"
PR = "3.el10"
PACKAGES = " \
 xkbcomp \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xkbcomp-1.4.7-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "92f3acc8993a70b007f5771c9b2104190ea20a2a90ef43d87d8f1e2195924488"

URI_x86_64_v2_xkbcomp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xkbcomp-1.4.7-3.el10.x86_64_v2.rpm;name=x86_64_v2_xkbcomp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xkbcomp}"
SRC_URI[x86_64_v2_xkbcomp.sha256sum] = "51f45c401c1990a76ca6c3889d7ea02e11188d659d2312134e1ab4b14e159433"

URI_aarch64_xkbcomp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xkbcomp-1.4.7-3.el10.aarch64.rpm;name=aarch64_xkbcomp;unpack=0"
SRC_URI:append = " ${URI_aarch64_xkbcomp}"
SRC_URI[aarch64_xkbcomp.sha256sum] = "d39a17bc7d768a961a57b11a198458a5f69ba83b347bb5bb203a387bbac932ba"

RDEPENDS:xkbcomp = " \
 glibc \
 libX11 \
 libxkbfile \
 "
