# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-tables"
PV = "3.10.1"
PR = "5.el10_1"
PACKAGES = " \
 python-tables-doc \
 python3-tables \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-tables-3.10.1-5.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e0ff37bedf142e93c0c1159183ab0f73ba943427065b22b96bdd154e9d565f5e"

URI_x86_64_v2_python-tables-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-tables-doc-3.10.1-5.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python-tables-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-tables-doc}"
SRC_URI[x86_64_v2_python-tables-doc.sha256sum] = "0c8b0d4bd5bb6c207154b129994a09494885f1477a51e5b08567daba18f25070"

URI_x86_64_v2_python3-tables = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-tables-3.10.1-5.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-tables;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-tables}"
SRC_URI[x86_64_v2_python3-tables.sha256sum] = "9f319954c383a70680542e161daa2bf02a2da239cd38bc331e6a18a6596a0920"

URI_aarch64_python-tables-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-tables-doc-3.10.1-5.el10_1.noarch.rpm;name=aarch64_python-tables-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-tables-doc}"
SRC_URI[aarch64_python-tables-doc.sha256sum] = "869e78946923d1ff6b0dd85cea056053c915a6d7ee3b8a96fadccc9ff2dce691"

URI_aarch64_python3-tables = "${EPEL_MIRROR}/aarch64/Packages/p/python3-tables-3.10.1-5.el10_1.aarch64.rpm;name=aarch64_python3-tables;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-tables}"
SRC_URI[aarch64_python3-tables.sha256sum] = "41b6f275e18385a85695d21e7de922448da5f5d1926532aa02d7c2f8c19c9b1c"

RDEPENDS:python-tables-doc = " \
 "
RDEPENDS:python3-tables = " \
 blosc \
 blosc2 \
 bzip2-libs \
 glibc \
 hdf5 \
 lzo \
 python3 \
 python3-blosc2 \
 python3-cpuinfo \
 python3-numexpr \
 python3-numpy \
 python3-packaging \
 python3-six \
 python3-typing-extensions \
 "
