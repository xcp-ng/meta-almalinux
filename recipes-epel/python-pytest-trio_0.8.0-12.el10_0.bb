# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-trio"
PV = "0.8.0"
PR = "12.el10_0"
PACKAGES = " \
 python3-pytest-trio \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-trio-0.8.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "204e7a9d3249a2ca08ef43ab8dca356f416fec5606642696b07e6ad5ca033c41"

URI_x86_64_v2_python3-pytest-trio = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-trio-0.8.0-12.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-trio;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-trio}"
SRC_URI[x86_64_v2_python3-pytest-trio.sha256sum] = "a0dcae20be9aa25f4aec9d27d750e3417ead15c339fa897391fe5b39dd113d6c"

URI_aarch64_python3-pytest-trio = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-trio-0.8.0-12.el10_0.noarch.rpm;name=aarch64_python3-pytest-trio;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-trio}"
SRC_URI[aarch64_python3-pytest-trio.sha256sum] = "3ebcf8798150e24f0def9b7086cba0855317863a64cb6027519580e134976944"

RDEPENDS:python3-pytest-trio = " \
 python3 \
 python3-outcome \
 python3-pytest \
 python3-trio \
 "
