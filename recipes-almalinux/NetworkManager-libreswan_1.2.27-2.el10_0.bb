# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-libreswan"
PV = "1.2.27"
PR = "2.el10_0"
PACKAGES = " \
 NetworkManager-libreswan \
 NetworkManager-libreswan-gnome \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/NetworkManager-libreswan-1.2.27-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "91be2e898f420084bbac23320475ef3b4fc782e4b4c60513abf83ea1f6e3a2f4"

URI_x86_64_v2_NetworkManager-libreswan = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-1.2.27-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libreswan}"
SRC_URI[x86_64_v2_NetworkManager-libreswan.sha256sum] = "b39a92f5ac17db75743439102fdd863019e1c04667b3043fb7ce35e345a23ace"

URI_x86_64_v2_NetworkManager-libreswan-gnome = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-libreswan-gnome-1.2.27-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-libreswan-gnome}"
SRC_URI[x86_64_v2_NetworkManager-libreswan-gnome.sha256sum] = "22d29677922e161575738c4d21f0ae4d34ab25a774184d0d87ab78badaa0283e"

URI_aarch64_NetworkManager-libreswan = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-1.2.27-2.el10_0.aarch64.rpm;name=aarch64_NetworkManager-libreswan;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libreswan}"
SRC_URI[aarch64_NetworkManager-libreswan.sha256sum] = "9bb8163ac3afe71cc303e85c350c6ee269caf0253efdb49ec0734e1c385c6acd"

URI_aarch64_NetworkManager-libreswan-gnome = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-libreswan-gnome-1.2.27-2.el10_0.aarch64.rpm;name=aarch64_NetworkManager-libreswan-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-libreswan-gnome}"
SRC_URI[aarch64_NetworkManager-libreswan-gnome.sha256sum] = "bb778a7b731025166258c27b90eee3cca38403b185ea021a13bfcb2e45a3da98"

RDEPENDS:NetworkManager-libreswan = " \
 NetworkManager \
 NetworkManager-libnm \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 libnl3 \
 libreswan \
 "
RDEPENDS:NetworkManager-libreswan-gnome = " \
 NetworkManager-libnm \
 NetworkManager-libreswan \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 pango \
 shared-mime-info \
 vulkan-loader \
 "
