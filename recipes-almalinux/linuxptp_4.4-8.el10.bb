# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "linuxptp"
PV = "4.4"
PR = "8.el10"
PACKAGES = " \
 linuxptp \
 linuxptp-selinux \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/linuxptp-4.4-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d21d7c1c01bdb8eb3cbb77b93c8e309cb470bcd1046509e3b2cae419f3528350"

URI_x86_64_v2_linuxptp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/linuxptp-4.4-8.el10.x86_64_v2.rpm;name=x86_64_v2_linuxptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linuxptp}"
SRC_URI[x86_64_v2_linuxptp.sha256sum] = "ba602502a55bd6f8d0112d95e07ce25a09a1562b0a8bd10a00eab1c26a7ce750"

URI_x86_64_v2_linuxptp-selinux = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/linuxptp-selinux-4.4-8.el10.noarch.rpm;name=x86_64_v2_linuxptp-selinux;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_linuxptp-selinux}"
SRC_URI[x86_64_v2_linuxptp-selinux.sha256sum] = "0bee177e5da8b94456d7b1f6137b94eea1e4fd7cfc0be56e4775124a097a8a47"

URI_aarch64_linuxptp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/linuxptp-4.4-8.el10.aarch64.rpm;name=aarch64_linuxptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_linuxptp}"
SRC_URI[aarch64_linuxptp.sha256sum] = "9e9afea471a90cb5c6b1a73280d02d785ff4f3bd61137997baf30a1e0017ff80"

URI_aarch64_linuxptp-selinux = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/linuxptp-selinux-4.4-8.el10.noarch.rpm;name=aarch64_linuxptp-selinux;unpack=0"
SRC_URI:append = " ${URI_aarch64_linuxptp-selinux}"
SRC_URI[aarch64_linuxptp-selinux.sha256sum] = "0bee177e5da8b94456d7b1f6137b94eea1e4fd7cfc0be56e4775124a097a8a47"

RDEPENDS:linuxptp = " \
 bash \
 glibc \
 gnutls \
 libcap \
 linuxptp-selinux \
 setup \
 shadow-utils \
 systemd \
 "
RDEPENDS:linuxptp-selinux = " \
 bash \
 libselinux-utils \
 policycoreutils \
 policycoreutils-python-utils \
 selinux-policy \
 selinux-policy-targeted \
 "
