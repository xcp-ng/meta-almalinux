# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-tencent-cos"
PV = "3.0.2"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-tencent-cos+default-devel \
 rust-reqsign-tencent-cos-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-tencent-cos-3.0.2-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "edf750d759e803315fd835d9368507b2c5a3412e69f40aab584522a860acbd2e"

URI_x86_64_v2_rust-reqsign-tencent-cos+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-tencent-cos+default-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-tencent-cos+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-tencent-cos+default-devel}"
SRC_URI[x86_64_v2_rust-reqsign-tencent-cos+default-devel.sha256sum] = "7b1bdb204763382ea537096efc13b117cd6577d51d0c3ee879eeb5ef70cea2dd"

URI_x86_64_v2_rust-reqsign-tencent-cos-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-tencent-cos-devel-3.0.2-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-tencent-cos-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-reqsign-tencent-cos-devel}"
SRC_URI[x86_64_v2_rust-reqsign-tencent-cos-devel.sha256sum] = "a3a4734ec024f517b1a295d590194420d8455489975f29d7c89aec11676fe409"

URI_aarch64_rust-reqsign-tencent-cos+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-tencent-cos+default-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-tencent-cos+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-tencent-cos+default-devel}"
SRC_URI[aarch64_rust-reqsign-tencent-cos+default-devel.sha256sum] = "b87715f4ed8af75c308c37103630a406adad0a8a5d2cf11b50d018fc8628bf6f"

URI_aarch64_rust-reqsign-tencent-cos-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-tencent-cos-devel-3.0.2-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-tencent-cos-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-reqsign-tencent-cos-devel}"
SRC_URI[aarch64_rust-reqsign-tencent-cos-devel.sha256sum] = "6b1112f242a7e798cfdb1ec1e810597be3a145bec42fb0a37e6fd87616c01789"

RDEPENDS:rust-reqsign-tencent-cos+default-devel = " \
 cargo \
 rust-reqsign-tencent-cos-devel \
 "
RDEPENDS:rust-reqsign-tencent-cos-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 "
