# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "systemd"
PV = "257"
PR = "30.el10.alma.1"
PACKAGES = " \
 systemd \
 systemd-boot-unsigned \
 systemd-container \
 systemd-devel \
 systemd-journal-remote \
 systemd-libs \
 systemd-oomd \
 systemd-pam \
 systemd-resolved \
 systemd-rpm-macros \
 systemd-udev \
 systemd-ukify \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/systemd-257-30.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "293c3e881745fd5449fd6c6661b5df8910a5f066915768356fc9f2fc6a8761c4"

## Requires (aarch64) that were seen as not satisfiable in original repo:
# - systemd-container: libcap.so.2()(64bit)
# - systemd-libs: libcap.so.2()(64bit)
# - systemd-pam: libcap.so.2()(64bit)
# - systemd: libcap.so.2()(64bit)

URI_x86_64_v2_systemd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd}"
SRC_URI[x86_64_v2_systemd.sha256sum] = "118f86982d211221a01e82f9df2c9124b406054969a63c2700424994f1a758b6"
RPROVIDES:systemd:x86_64_v2 = "virtual/group_dialout_ virtual/group_tty_ virtual/syslog"

URI_x86_64_v2_systemd-boot-unsigned = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-boot-unsigned-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-boot-unsigned;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-boot-unsigned}"
SRC_URI[x86_64_v2_systemd-boot-unsigned.sha256sum] = "089534cf9c8fd156ec16961e7fa14c90e3837852befe4b44bcb7262402fecec3"

URI_x86_64_v2_systemd-container = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-container-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-container;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-container}"
SRC_URI[x86_64_v2_systemd-container.sha256sum] = "1900cc6fbd10a81d131db972a6f0645f548f9737cf7619935ab7fd0ce027e908"

URI_x86_64_v2_systemd-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-devel-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-devel}"
SRC_URI[x86_64_v2_systemd-devel.sha256sum] = "91dc012ab978a697d0c941236887eeb49b0b78b7b99914844c9527c9d999431d"

URI_x86_64_v2_systemd-journal-remote = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-journal-remote-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-journal-remote;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-journal-remote}"
SRC_URI[x86_64_v2_systemd-journal-remote.sha256sum] = "f7668ce722984bfd16232cc5294730aa11be3af91477c719e3a84751996216b7"

URI_x86_64_v2_systemd-libs = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-libs-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-libs}"
SRC_URI[x86_64_v2_systemd-libs.sha256sum] = "2fce89f3edd6fe245a06ccf98712204624fd76563baadd8ed4962aa41b648742"

URI_x86_64_v2_systemd-oomd = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-oomd-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-oomd;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-oomd}"
SRC_URI[x86_64_v2_systemd-oomd.sha256sum] = "7e140ca9cc97ca21f2387839939477842852d9d2da4d35cf6dfb41c20f94aa2a"

URI_x86_64_v2_systemd-pam = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-pam-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-pam}"
SRC_URI[x86_64_v2_systemd-pam.sha256sum] = "c1671e8bb11cbbb501f034b455efe93477dbe65ae24ca79764ad9ccb2d1b6d93"

URI_x86_64_v2_systemd-resolved = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-resolved-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-resolved;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-resolved}"
SRC_URI[x86_64_v2_systemd-resolved.sha256sum] = "fdb54ae8ac770697881458b6b5b6422d799de2949e99cbfa81c1f560b594356c"

URI_x86_64_v2_systemd-rpm-macros = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-rpm-macros-257-30.el10.alma.1.noarch.rpm;name=x86_64_v2_systemd-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-rpm-macros}"
SRC_URI[x86_64_v2_systemd-rpm-macros.sha256sum] = "3921c34f5bd3423a58a358d2bf65505d7fd1fe957d8e859c94ef252199378f13"

URI_x86_64_v2_systemd-udev = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/systemd-udev-257-30.el10.alma.1.x86_64_v2.rpm;name=x86_64_v2_systemd-udev;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-udev}"
SRC_URI[x86_64_v2_systemd-udev.sha256sum] = "483985cd24304bac2bd556a766c8a73396cbb9be7ef17838e91848eb80444fea"

URI_x86_64_v2_systemd-ukify = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/systemd-ukify-257-30.el10.alma.1.noarch.rpm;name=x86_64_v2_systemd-ukify;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_systemd-ukify}"
SRC_URI[x86_64_v2_systemd-ukify.sha256sum] = "0a4ddbc94a2158562adacfb3ef40a8460f8eb95b4578957be9b046a55e8e13ed"

URI_aarch64_systemd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd}"
SRC_URI[aarch64_systemd.sha256sum] = "5f9a701beda430d5a0305f30b85dae4206b93dc7dc4e96c8cc8f906840298408"
RPROVIDES:systemd:aarch64 = "virtual/group_dialout_ virtual/group_tty_ virtual/syslog"

URI_aarch64_systemd-boot-unsigned = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-boot-unsigned-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd-boot-unsigned;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-boot-unsigned}"
SRC_URI[aarch64_systemd-boot-unsigned.sha256sum] = "05a6bdc69e639aad10c5e23969715b8fd969953b412ee673f1afb4c56c2fef04"

URI_aarch64_systemd-container = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-container-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd-container;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-container}"
SRC_URI[aarch64_systemd-container.sha256sum] = "95e3b807cbebc16da4e1b5ece9f630dc5be09681799c4a5fbf0e8365d95ca84e"

URI_aarch64_systemd-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-devel-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-devel}"
SRC_URI[aarch64_systemd-devel.sha256sum] = "b3e8805d01793597fc80938ef841b052cacf158d3895b97cd46a0fc759f9b496"

URI_aarch64_systemd-journal-remote = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-journal-remote-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd-journal-remote;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-journal-remote}"
SRC_URI[aarch64_systemd-journal-remote.sha256sum] = "1cbffa7cc98dc6c7728890ad125e41afc16a6785d85c8702db81217853521899"

URI_aarch64_systemd-libs = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-libs-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-libs}"
SRC_URI[aarch64_systemd-libs.sha256sum] = "6344f739cc8fb0cf6344ad90a56b4bd70cb2b245e7078a3d8276311c015d6586"

URI_aarch64_systemd-oomd = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-oomd-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd-oomd;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-oomd}"
SRC_URI[aarch64_systemd-oomd.sha256sum] = "b90f0023572cff2c96587d1b68a7255689ee60431bb249bd651c1e91e39018cd"

URI_aarch64_systemd-pam = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-pam-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-pam}"
SRC_URI[aarch64_systemd-pam.sha256sum] = "0279e49fb06c9afd511ade54be6639e5a77bbf21996a63d73618e30cacd80946"

URI_aarch64_systemd-resolved = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-resolved-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd-resolved;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-resolved}"
SRC_URI[aarch64_systemd-resolved.sha256sum] = "b61c5a87c771bd2a4c9b56228bb18086527530064addc6f78200a3a5fadb1d7f"

URI_aarch64_systemd-rpm-macros = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-rpm-macros-257-30.el10.alma.1.noarch.rpm;name=aarch64_systemd-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-rpm-macros}"
SRC_URI[aarch64_systemd-rpm-macros.sha256sum] = "3921c34f5bd3423a58a358d2bf65505d7fd1fe957d8e859c94ef252199378f13"

URI_aarch64_systemd-udev = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/systemd-udev-257-30.el10.alma.1.aarch64.rpm;name=aarch64_systemd-udev;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-udev}"
SRC_URI[aarch64_systemd-udev.sha256sum] = "810e564afb3a34a664c786dfd78e37066ff3eb388fdfaea5ea181eb8a7448221"

URI_aarch64_systemd-ukify = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/systemd-ukify-257-30.el10.alma.1.noarch.rpm;name=aarch64_systemd-ukify;unpack=0"
SRC_URI:append = " ${URI_aarch64_systemd-ukify}"
SRC_URI[aarch64_systemd-ukify.sha256sum] = "0a4ddbc94a2158562adacfb3ef40a8460f8eb95b4578957be9b046a55e8e13ed"

RDEPENDS:systemd:x86_64_v2 = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libcap \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd:aarch64 = " \
 audit-libs \
 bash \
 bzip2-libs \
 dbus \
 glibc \
 grep \
 libacl \
 libblkid \
 libfdisk \
 libgcc \
 libmount \
 libseccomp \
 libselinux \
 libxcrypt \
 openssl-libs \
 pam-libs \
 systemd-libs \
 systemd-pam \
 systemd-rpm-macros \
 virtual/coreutils \
 virtual/util-linux-core_or_util-linux \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-boot-unsigned = " \
 "
RDEPENDS:systemd-container:x86_64_v2 = " \
 bzip2-libs \
 glibc \
 libcap \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-container:aarch64 = " \
 bzip2-libs \
 glibc \
 libgcc \
 libseccomp \
 libselinux \
 openssl-libs \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 xz-libs \
 zlib-ng-compat \
"
RDEPENDS:systemd-devel = " \
 systemd-libs \
 systemd-rpm-macros \
 "
RDEPENDS:systemd-journal-remote = " \
 bash \
 firewalld-filesystem \
 glibc \
 libgcc \
 libmicrohttpd \
 systemd \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:systemd-libs:x86_64_v2 = " \
 glibc \
 libcap \
 libgcc \
"
RDEPENDS:systemd-libs:aarch64 = " \
 glibc \
 libgcc \
"
RDEPENDS:systemd-oomd = " \
 bash \
 glibc \
 libgcc \
 systemd \
 systemd-udev \
 "
RDEPENDS:systemd-pam:x86_64_v2 = " \
 glibc \
 libcap \
 libgcc \
 pam-libs \
 systemd \
"
RDEPENDS:systemd-pam:aarch64 = " \
 glibc \
 libgcc \
 pam-libs \
 systemd \
"
RDEPENDS:systemd-resolved = " \
 bash \
 glibc \
 grep \
 libgcc \
 libidn2 \
 openssl-libs \
 shadow-utils \
 systemd \
 "
RDEPENDS:systemd-rpm-macros = " \
 bash \
 "
RDEPENDS:systemd-udev = " \
 bash \
 cryptsetup-libs \
 glibc \
 grep \
 grubby \
 kbd \
 kmod \
 kmod-libs \
 libblkid \
 libfdisk \
 libgcc \
 openssl-libs \
 sdubby \
 systemd \
 "
RDEPENDS:systemd-ukify = " \
 python3 \
 python3-cryptography \
 python3-pefile \
 python3-zstandard \
 systemd \
 systemd-boot-unsigned \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/group_dialout_ rpm/virtual/group_tty_ rpm/virtual/syslog"

PROVIDES:append:aarch64 = " rpm/virtual/group_dialout_ rpm/virtual/group_tty_ rpm/virtual/syslog"
