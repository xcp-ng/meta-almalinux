# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libmimalloc-sys"
PV = "0.1.42"
PR = "1.el10_1"
PACKAGES = " \
 rust-libmimalloc-sys+arena-devel \
 rust-libmimalloc-sys+cty-devel \
 rust-libmimalloc-sys+debug-devel \
 rust-libmimalloc-sys+debug_in_debug-devel \
 rust-libmimalloc-sys+default-devel \
 rust-libmimalloc-sys+extended-devel \
 rust-libmimalloc-sys+local_dynamic_tls-devel \
 rust-libmimalloc-sys+no_thp-devel \
 rust-libmimalloc-sys+override-devel \
 rust-libmimalloc-sys+secure-devel \
 rust-libmimalloc-sys-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libmimalloc-sys-0.1.42-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "67122541ee564569790990fea77063916055933514f2f991ae8342809f8a02d7"

URI_x86_64_v2_rust-libmimalloc-sys+arena-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+arena-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+arena-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+arena-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+arena-devel.sha256sum] = "6e9936d906113bca14b4a4052c07b28f08806f805cd219e5bb2ce8d25ebde177"

URI_x86_64_v2_rust-libmimalloc-sys+cty-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+cty-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+cty-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+cty-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+cty-devel.sha256sum] = "c53c182c56442c4bd240bf77f69bf2f4e814e9a606f096285cdb087ff0afb49e"

URI_x86_64_v2_rust-libmimalloc-sys+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+debug-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+debug-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+debug-devel.sha256sum] = "c4e3a0a4fb254c8097ab0650e5f551f7c5baea2366ee2aeb2324be096911c1c1"

URI_x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+debug_in_debug-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+debug_in_debug-devel.sha256sum] = "e374be9e027a3639e3fe0288d32519cd67b6a19d583871d1f1c0da48accb157c"

URI_x86_64_v2_rust-libmimalloc-sys+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+default-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+default-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+default-devel.sha256sum] = "588cd79994610c5fa75ca789db9b6e8d7e8b7252d90307092dbfa435735f33a5"

URI_x86_64_v2_rust-libmimalloc-sys+extended-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+extended-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+extended-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+extended-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+extended-devel.sha256sum] = "b222ddc49cd5c7cd975db0d177904c5c9792b8eb82d9baea35bfbc4e744f3c68"

URI_x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+local_dynamic_tls-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+local_dynamic_tls-devel.sha256sum] = "0e9cbb40c78c108c127a3ae176afff39937f674e30338af269d1cf5d5b89e699"

URI_x86_64_v2_rust-libmimalloc-sys+no_thp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+no_thp-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+no_thp-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+no_thp-devel.sha256sum] = "1da8aa71372d31010609749b6c8157d9aaa76c9dea1cbe0d16a294f101d227da"

URI_x86_64_v2_rust-libmimalloc-sys+override-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+override-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+override-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+override-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+override-devel.sha256sum] = "9ec5b0acbf4b2ace68edc45888df6538a1736dcf599505d08012170fd54d8676"

URI_x86_64_v2_rust-libmimalloc-sys+secure-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys+secure-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys+secure-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys+secure-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys+secure-devel.sha256sum] = "36f0181bbc73bee8160cc28d5e6150e5d7376d31dd9413f22233213e155d09e8"

URI_x86_64_v2_rust-libmimalloc-sys-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libmimalloc-sys-devel-0.1.42-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libmimalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libmimalloc-sys-devel}"
SRC_URI[x86_64_v2_rust-libmimalloc-sys-devel.sha256sum] = "43f9d7b3e0d5b6b206bb429db0939f515456dc15fd275b5f762da271e63517fc"

URI_aarch64_rust-libmimalloc-sys+arena-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+arena-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+arena-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+arena-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+arena-devel.sha256sum] = "0abac2e556565141c9b98d7cb0b66c95ed7b4883be6b7894eb391f15262935a0"

URI_aarch64_rust-libmimalloc-sys+cty-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+cty-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+cty-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+cty-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+cty-devel.sha256sum] = "19c0a34295c96bc418d40e775310a4ff124095409f27e76c15303a1ae0744ea5"

URI_aarch64_rust-libmimalloc-sys+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+debug-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+debug-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+debug-devel.sha256sum] = "ed264a2ab7a7d1d5470a2e69ec9e1ed00f6790778901bfae4ee79a0fee58f16f"

URI_aarch64_rust-libmimalloc-sys+debug_in_debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+debug_in_debug-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+debug_in_debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+debug_in_debug-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+debug_in_debug-devel.sha256sum] = "0cd896833c4aca2d18ce03a412bbf8702e16427988a2aa7b3cbe89e5ba940f06"

URI_aarch64_rust-libmimalloc-sys+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+default-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+default-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+default-devel.sha256sum] = "bd7fec20d1bd404de27b11454e70b88d9c4af42ffdfdb5e3df92fd93d5e5e27f"

URI_aarch64_rust-libmimalloc-sys+extended-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+extended-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+extended-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+extended-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+extended-devel.sha256sum] = "aa9394c20db18e44fed07f8b712df18ce848cccc93faaeb7fc270013ab985234"

URI_aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+local_dynamic_tls-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+local_dynamic_tls-devel.sha256sum] = "891ade535364a601af42a500ca61f0b615a94e9a5522a7539d0790a03a4d0fef"

URI_aarch64_rust-libmimalloc-sys+no_thp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+no_thp-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+no_thp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+no_thp-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+no_thp-devel.sha256sum] = "445f307150ae517793c7fd88da7a4c0bfee9994bf723dd81ea5d85b4058c79fe"

URI_aarch64_rust-libmimalloc-sys+override-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+override-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+override-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+override-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+override-devel.sha256sum] = "fdeec93453bdd89ecf46df90e7e43d39ce5b3f30f56516edccaa2ecee63b7de9"

URI_aarch64_rust-libmimalloc-sys+secure-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys+secure-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys+secure-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys+secure-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys+secure-devel.sha256sum] = "40a3d715acb8eef64700f0f50f56078df7431e934e10d52d616abd077e1fba76"

URI_aarch64_rust-libmimalloc-sys-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libmimalloc-sys-devel-0.1.42-1.el10_1.noarch.rpm;name=aarch64_rust-libmimalloc-sys-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libmimalloc-sys-devel}"
SRC_URI[aarch64_rust-libmimalloc-sys-devel.sha256sum] = "5d37913d30f5627f0f7a383b2c21d573821564ab6f23271b4df791a874d4b824"

RDEPENDS:rust-libmimalloc-sys+arena-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+cty-devel = " \
 cargo \
 rust-cty+default-devel \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+debug-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+debug_in_debug-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+default-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+extended-devel = " \
 cargo \
 rust-libmimalloc-sys+cty-devel \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+local_dynamic_tls-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+no_thp-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+override-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys+secure-devel = " \
 cargo \
 rust-libmimalloc-sys-devel \
 "
RDEPENDS:rust-libmimalloc-sys-devel = " \
 cargo \
 rust-cc+default-devel \
 rust-libc+default-devel \
 "
