# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "zerofree"
PV = "1.1.1"
PR = "17.el10_2"
PACKAGES = " \
 zerofree \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/z/zerofree-1.1.1-17.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1328b29f7ba877aea0b2adfa49a76d24b9b809c235426fa9827df126557a626f"

URI_x86_64_v2_zerofree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/zerofree-1.1.1-17.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_zerofree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_zerofree}"
SRC_URI[x86_64_v2_zerofree.sha256sum] = "2a44d6cb33a7b2323cbabcbde56a9f8f0f376c4f29168aae056dda825fd75ee0"

URI_aarch64_zerofree = "${EPEL_MIRROR}/aarch64/Packages/z/zerofree-1.1.1-17.el10_2.aarch64.rpm;name=aarch64_zerofree;unpack=0"
SRC_URI:append = " ${URI_aarch64_zerofree}"
SRC_URI[aarch64_zerofree.sha256sum] = "79fd547983e85121ab091091517b7c59b35e7b5f0931b56c0ddb2775d84b2ef4"

RDEPENDS:zerofree = " \
 e2fsprogs-libs \
 glibc \
 "
