# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "klettres"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 klettres \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/klettres-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "7875f08e4aa2e726388b02c9843013d90f442314d23b9f23656f108dd639cbe8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/klettres-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_klettres;unpack=0"
SRC_URI[x86_64_v2_klettres.sha256sum] = "5349c1362a2c89898cb490852a22b8470e19a770a2724f378ebf312e969a2206"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/klettres-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_klettres;unpack=0"
SRC_URI[aarch64_klettres.sha256sum] = "0b45a965893770cd9ee16adc10f9519ef294cf92cdeb44442282a83dc6c831ba"

RDEPENDS:klettres = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-knewstuff \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtsvg \
 "
