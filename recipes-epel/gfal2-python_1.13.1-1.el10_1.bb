# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gfal2-python"
PV = "1.13.1"
PR = "1.el10_1"
PACKAGES = " \
 python3-gfal2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gfal2-python-1.13.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53021297ecabbb6a4ee2e60436c12b400ec0c41bdb1aa68ea024c1fdc39c8724"

URI_x86_64_v2_python3-gfal2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-gfal2-1.13.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-gfal2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-gfal2}"
SRC_URI[x86_64_v2_python3-gfal2.sha256sum] = "c0d424296b64bf8795fa33ac1053fbfc6835b296e9026415539fff856579d9b8"

URI_aarch64_python3-gfal2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-gfal2-1.13.1-1.el10_1.aarch64.rpm;name=aarch64_python3-gfal2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-gfal2}"
SRC_URI[aarch64_python3-gfal2.sha256sum] = "919f661ae7ec117fbc2ac6b5c578624a07961d013b8313fb4a010e7475d042be"

RDEPENDS:python3-gfal2 = " \
 boost-python3 \
 gfal2 \
 glib2 \
 glibc \
 libgcc \
 libstdc++ \
 python3 \
 "
