# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-ExtUtils-PkgConfig"
PV = "1.16"
PR = "25.el10_0"
PACKAGES = " \
 perl-ExtUtils-PkgConfig \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/perl-ExtUtils-PkgConfig-1.16-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "f8273ba3169d8bb1fdfacf9ddd2c9052c3fa49db7594ecf4c45fd483219a6daf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-ExtUtils-PkgConfig-1.16-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-ExtUtils-PkgConfig;unpack=0"
SRC_URI[x86_64_v2_perl-ExtUtils-PkgConfig.sha256sum] = "5e7ff13e848c4f40ffa60ee54f2a1421ad93689e1e024ee9bbb960ae52b53a1e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/perl-ExtUtils-PkgConfig-1.16-25.el10_0.noarch.rpm;name=aarch64_perl-ExtUtils-PkgConfig;unpack=0"
SRC_URI[aarch64_perl-ExtUtils-PkgConfig.sha256sum] = "df1fe895d0d256d09832321f5a3e367b238357e427d4002db6d41e0453b89416"

RDEPENDS:perl-ExtUtils-PkgConfig = " \
 perl-Carp \
 perl-English \
 perl-libs \
 perl-vars \
 pkgconf-pkg-config \
 "
