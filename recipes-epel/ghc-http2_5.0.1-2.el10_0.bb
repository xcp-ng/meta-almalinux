# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-http2"
PV = "5.0.1"
PR = "2.el10_0"
PACKAGES = " \
 ghc-http2 \
 ghc-http2-devel \
 ghc-http2-doc \
 ghc-http2-prof \
 ghc-network-control \
 ghc-network-control-devel \
 ghc-network-control-doc \
 ghc-network-control-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-http2-5.0.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5897e5f8f37480ccb5ceaca7ac2c404882a6daf5309fe0958a9de8cb51b39f17"

URI_x86_64_v2_ghc-http2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http2-5.0.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http2}"
SRC_URI[x86_64_v2_ghc-http2.sha256sum] = "de511266d00adc06780f978d5420c535c3ddec0671953c14d1a7ca6edcca6df0"

URI_x86_64_v2_ghc-http2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http2-devel-5.0.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http2-devel}"
SRC_URI[x86_64_v2_ghc-http2-devel.sha256sum] = "d38c5fc27eb4d1f6ddccf19e17cce72fdda29479b0199cefe7a60128d24e63df"

URI_x86_64_v2_ghc-http2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http2-doc-5.0.1-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-http2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http2-doc}"
SRC_URI[x86_64_v2_ghc-http2-doc.sha256sum] = "6aa53b91bbfc836912b991f490b0ed1afe05714ceaa52e2a87c0f93b0c90a9a0"

URI_x86_64_v2_ghc-http2-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-http2-prof-5.0.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-http2-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-http2-prof}"
SRC_URI[x86_64_v2_ghc-http2-prof.sha256sum] = "18ae1bb53b47db318c4a8a48bd6d2be94b7c9f91c4e4aa5f375f7fe251b23abf"

URI_x86_64_v2_ghc-network-control = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-control-0.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-control;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-control}"
SRC_URI[x86_64_v2_ghc-network-control.sha256sum] = "1054122f5fb25e7ae370a5a5b32300fa88e0894d6403f468bd13e085c9a39467"

URI_x86_64_v2_ghc-network-control-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-control-devel-0.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-control-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-control-devel}"
SRC_URI[x86_64_v2_ghc-network-control-devel.sha256sum] = "fc6a113783c0b172a289cd6f6ca12f911222e7e8ab21f9d31312461fa6a82e08"

URI_x86_64_v2_ghc-network-control-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-control-doc-0.0.2-2.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-network-control-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-control-doc}"
SRC_URI[x86_64_v2_ghc-network-control-doc.sha256sum] = "376c234951515cbc9299aa8600199f362a8abaa802568968b40d27449c698161"

URI_x86_64_v2_ghc-network-control-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-network-control-prof-0.0.2-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-network-control-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-network-control-prof}"
SRC_URI[x86_64_v2_ghc-network-control-prof.sha256sum] = "acd4f5f77409a6be5a8544c51d2b294cb0f2a72bceeb40a95ae381dd0a6b30bc"

URI_aarch64_ghc-http2 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http2-5.0.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-http2;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http2}"
SRC_URI[aarch64_ghc-http2.sha256sum] = "f88ce2e27b8dac91be9693b61b1d4b3bdfcf0bb769b51cdae9956b9af91e3b35"

URI_aarch64_ghc-http2-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http2-devel-5.0.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-http2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http2-devel}"
SRC_URI[aarch64_ghc-http2-devel.sha256sum] = "d39d031ab93cd9e2cf06e402d7b2fed7dbcf05c396a7826eb8f1ee5b62712a0f"

URI_aarch64_ghc-http2-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http2-doc-5.0.1-2.el10_0.noarch.rpm;name=aarch64_ghc-http2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http2-doc}"
SRC_URI[aarch64_ghc-http2-doc.sha256sum] = "60d13f93a7cb92bf69a37022e9a311e8f1b020dcbf9e2a26c45d3676762547d3"

URI_aarch64_ghc-http2-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-http2-prof-5.0.1-2.el10_0.aarch64.rpm;name=aarch64_ghc-http2-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-http2-prof}"
SRC_URI[aarch64_ghc-http2-prof.sha256sum] = "ebf0667b8de154a29fe37824e6d2d5cd49e96875ab788ac0d04ffa731b720e5f"

URI_aarch64_ghc-network-control = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-control-0.0.2-2.el10_0.aarch64.rpm;name=aarch64_ghc-network-control;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-control}"
SRC_URI[aarch64_ghc-network-control.sha256sum] = "2875d037b9d68dfd2fc27b00ae9bd09afd4beea3c63a26688cbe6b68e849b362"

URI_aarch64_ghc-network-control-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-control-devel-0.0.2-2.el10_0.aarch64.rpm;name=aarch64_ghc-network-control-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-control-devel}"
SRC_URI[aarch64_ghc-network-control-devel.sha256sum] = "478edeb25ad8d0120b3cda8d9f39f932df30a6a888cd9358bc10ab63f3107f8d"

URI_aarch64_ghc-network-control-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-control-doc-0.0.2-2.el10_0.noarch.rpm;name=aarch64_ghc-network-control-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-control-doc}"
SRC_URI[aarch64_ghc-network-control-doc.sha256sum] = "ea94b37d230cbdd8f322b3ba829c1331526d884745dbcbcf5b432a1fff3af352"

URI_aarch64_ghc-network-control-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-network-control-prof-0.0.2-2.el10_0.aarch64.rpm;name=aarch64_ghc-network-control-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-network-control-prof}"
SRC_URI[aarch64_ghc-network-control-prof.sha256sum] = "53ef603ea318c59b89a78b9b547a866a183aa5da83a327870a9804eefc5c3490"

RDEPENDS:ghc-http2 = " \
 ghc-array \
 ghc-async \
 ghc-auto-update \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-containers \
 ghc-deepseq \
 ghc-directory \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-types \
 ghc-mtl \
 ghc-network \
 ghc-network-byte-order \
 ghc-network-control \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pretty \
 ghc-process \
 ghc-psqueues \
 ghc-safe-exceptions \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-time \
 ghc-time-manager \
 ghc-transformers \
 ghc-unix \
 ghc-unix-time \
 ghc-unliftio \
 ghc-unliftio-core \
 glibc \
 gmp \
 "
RDEPENDS:ghc-http2-devel = " \
 ghc-array-devel \
 ghc-async-devel \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-containers-devel \
 ghc-http-types-devel \
 ghc-http2 \
 ghc-network-byte-order-devel \
 ghc-network-control-devel \
 ghc-network-devel \
 ghc-stm-devel \
 ghc-time-manager-devel \
 ghc-unix-time-devel \
 ghc-unliftio-devel \
 "
RDEPENDS:ghc-http2-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-http2-prof = " \
 ghc-array-prof \
 ghc-async-prof \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-containers-prof \
 ghc-http-types-prof \
 ghc-http2-devel \
 ghc-network-byte-order-prof \
 ghc-network-control-prof \
 ghc-network-prof \
 ghc-stm-prof \
 ghc-time-manager-prof \
 ghc-unix-time-prof \
 ghc-unliftio-prof \
 "
RDEPENDS:ghc-network-control = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-mtl \
 ghc-old-locale \
 ghc-old-time \
 ghc-os-string \
 ghc-pretty \
 ghc-psqueues \
 ghc-stm \
 ghc-template-haskell \
 ghc-text \
 ghc-transformers \
 ghc-unix-time \
 glibc \
 gmp \
 "
RDEPENDS:ghc-network-control-devel = " \
 ghc-base-devel \
 ghc-compiler \
 ghc-network-control \
 ghc-psqueues-devel \
 ghc-unix-time-devel \
 "
RDEPENDS:ghc-network-control-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-network-control-prof = " \
 ghc-base-prof \
 ghc-network-control-devel \
 ghc-psqueues-prof \
 ghc-unix-time-prof \
 "
