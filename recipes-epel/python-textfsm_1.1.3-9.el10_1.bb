# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-textfsm"
PV = "1.1.3"
PR = "9.el10_1"
PACKAGES = " \
 python3-textfsm \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-textfsm-1.1.3-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a551ad9e42bc9e24be1f3a6e96cae0d2bf2049d15856e1a6f6f2851c85bb522f"

URI_x86_64_v2_python3-textfsm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-textfsm-1.1.3-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-textfsm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-textfsm}"
SRC_URI[x86_64_v2_python3-textfsm.sha256sum] = "f4eb6a0ad3db9f0c38e4af9f4bf7350d6dfd89ac416e6f178c83789d195ae8d9"

URI_aarch64_python3-textfsm = "${EPEL_MIRROR}/aarch64/Packages/p/python3-textfsm-1.1.3-9.el10_1.noarch.rpm;name=aarch64_python3-textfsm;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-textfsm}"
SRC_URI[aarch64_python3-textfsm.sha256sum] = "abf9ce74d339124c264343b2218d62b4b80f69a3c020fe4276717a35bb1b45d3"

RDEPENDS:python3-textfsm = " \
 python3 \
 python3-six \
 "
