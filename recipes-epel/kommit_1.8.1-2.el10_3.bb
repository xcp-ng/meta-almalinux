# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kommit"
PV = "1.8.1"
PR = "2.el10_3"
PACKAGES = " \
 kommit \
 kommit-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kommit-1.8.1-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "10accfba7ae9c4621f215bdfefed123a3ab9c788c64aeddfc652f712370489c7"

## Requires (x86_64_v2) that were seen as not satisfiable in original repo:
# - kommit: libgit2.so.1.9()(64bit)

URI_x86_64_v2_kommit = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kommit-1.8.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kommit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kommit}"
SRC_URI[x86_64_v2_kommit.sha256sum] = "599c9f972ee8b02ff7b10d9dd7f40151c07d52c616fcd251f9133db1f931172a"

URI_x86_64_v2_kommit-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kommit-devel-1.8.1-2.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kommit-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kommit-devel}"
SRC_URI[x86_64_v2_kommit-devel.sha256sum] = "f7d418e26e83c153ec7d646597411b0afde963d4dcc153ee66b7cf2b0dd30d0d"

URI_aarch64_kommit = "${EPEL_MIRROR}/aarch64/Packages/k/kommit-1.8.1-2.el10_3.aarch64.rpm;name=aarch64_kommit;unpack=0"
SRC_URI:append = " ${URI_aarch64_kommit}"
SRC_URI[aarch64_kommit.sha256sum] = "8227f31a5f60ab5dcc83809ada88a0d13a0b175084fbb25660c1923ff9d65587"

URI_aarch64_kommit-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kommit-devel-1.8.1-2.el10_3.aarch64.rpm;name=aarch64_kommit-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kommit-devel}"
SRC_URI[aarch64_kommit-devel.sha256sum] = "7787b461853b92e9c407946f9a976de06399d4ae49bda04cf85e335f77e9c46e"

RDEPENDS:kommit:x86_64_v2 = " \
 bash \
 dolphin-libs \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
"
RDEPENDS:kommit:aarch64 = " \
 bash \
 dolphin-libs \
 glibc \
 hicolor-icon-theme \
 kf6-filesystem \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-syntax-highlighting \
 libgit2_1.9 \
 libstdc++ \
 openssl-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtcharts \
"
RDEPENDS:kommit-devel = " \
 kommit \
 "
