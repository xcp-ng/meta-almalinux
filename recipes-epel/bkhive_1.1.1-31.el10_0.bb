# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bkhive"
PV = "1.1.1"
PR = "31.el10_0"
PACKAGES = " \
 bkhive \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bkhive-1.1.1-31.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "6f06ba66729fb2c648889d2ff6fbfbad7cab0343d82fc891a3e8ef783bf43087"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bkhive-1.1.1-31.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bkhive;unpack=0"
SRC_URI[x86_64_v2_bkhive.sha256sum] = "c70ece8a39b6e067a16819c1ec5e6a6fc1e5995c8bff38c64e84121e9303adf2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bkhive-1.1.1-31.el10_0.aarch64.rpm;name=aarch64_bkhive;unpack=0"
SRC_URI[aarch64_bkhive.sha256sum] = "28941ce9c99dea9004747b6e6203ae73b3466870772ad39227aa70cd68213780"

RDEPENDS:bkhive = " \
 glibc \
 "
