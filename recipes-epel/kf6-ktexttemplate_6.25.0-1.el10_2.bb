# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexttemplate"
PV = "6.25.0"
PR = "1.el10_2"
PACKAGES = " \
 kf6-ktexttemplate \
 kf6-ktexttemplate-devel \
 kf6-ktexttemplate-doc \
 kf6-ktexttemplate-html \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexttemplate-6.25.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c4560becb43c34c541e17bfa99ba656e93fcc07e24ed84cf2e572804273fc6fa"

URI_x86_64_v2_kf6-ktexttemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate}"
SRC_URI[x86_64_v2_kf6-ktexttemplate.sha256sum] = "0f59fc92264456dade7e54a22e0faeaffc776e6e82270d3b73aa4f50aa4fb32a"

URI_x86_64_v2_kf6-ktexttemplate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-devel-6.25.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-devel}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-devel.sha256sum] = "dfec3e2dc1dc3bcf7e5185d2641a991eefb6451b38f09ceeaad55604979bce0e"

URI_x86_64_v2_kf6-ktexttemplate-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-doc-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexttemplate-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-doc}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-doc.sha256sum] = "e215db72f716201c730c7e381b0ff10c5db9dae870204a355eaa61e4284cb46d"

URI_x86_64_v2_kf6-ktexttemplate-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexttemplate-html-6.25.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexttemplate-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-ktexttemplate-html}"
SRC_URI[x86_64_v2_kf6-ktexttemplate-html.sha256sum] = "9353fa0a9805a268bf65b8c0b11aad738d4125856cbdc75bdc454a7694348484"

URI_aarch64_kf6-ktexttemplate = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ktexttemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate}"
SRC_URI[aarch64_kf6-ktexttemplate.sha256sum] = "3dc6674d5f0f47d6f65705f54eed75c528ef257221eddf2f3546f0831a22096e"

URI_aarch64_kf6-ktexttemplate-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-devel-6.25.0-1.el10_2.aarch64.rpm;name=aarch64_kf6-ktexttemplate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-devel}"
SRC_URI[aarch64_kf6-ktexttemplate-devel.sha256sum] = "b68db287855e5ce6262b8254b6a555187774eb7bafc5fcea55c5bca925a1decc"

URI_aarch64_kf6-ktexttemplate-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-doc-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ktexttemplate-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-doc}"
SRC_URI[aarch64_kf6-ktexttemplate-doc.sha256sum] = "3d06c5495b7d4eeddaf4ed27e37730346bfd5177e7342c341a5e3686fc0b50dd"

URI_aarch64_kf6-ktexttemplate-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexttemplate-html-6.25.0-1.el10_2.noarch.rpm;name=aarch64_kf6-ktexttemplate-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-ktexttemplate-html}"
SRC_URI[aarch64_kf6-ktexttemplate-html.sha256sum] = "47dd3d1221777f811f167ced750564d3dd12050319a36400f8f14a01455145c9"

RDEPENDS:kf6-ktexttemplate = " \
 glibc \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
RDEPENDS:kf6-ktexttemplate-devel = " \
 cmake-filesystem \
 kf6-ktexttemplate \
 "
RDEPENDS:kf6-ktexttemplate-doc = " \
 "
RDEPENDS:kf6-ktexttemplate-html = " \
 "
