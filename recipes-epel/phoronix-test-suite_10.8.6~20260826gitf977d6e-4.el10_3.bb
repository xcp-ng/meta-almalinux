# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "phoronix-test-suite"
PV = "10.8.6~20260826gitf977d6e"
PR = "4.el10_3"
PACKAGES = " \
 phoronix-test-suite \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/phoronix-test-suite-10.8.6~20260826gitf977d6e-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "3e3631d6ac0c98c6df7b73b4ab6af9cdaffe4c91904f275b4ac49b7f121c42a8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/phoronix-test-suite-10.8.6~20260826gitf977d6e-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_phoronix-test-suite;unpack=0"
SRC_URI[x86_64_v2_phoronix-test-suite.sha256sum] = "07ec22544dcaa9d6ae18d6a87a365a21eab817230673f5571032b1fffc0b09e1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/phoronix-test-suite-10.8.6~20260826gitf977d6e-4.el10_3.noarch.rpm;name=aarch64_phoronix-test-suite;unpack=0"
SRC_URI[aarch64_phoronix-test-suite.sha256sum] = "510d11ce1ce46cfa06efbbc6d64e885a18ad6ed893199573f8f0f35a542309f5"

RDEPENDS:phoronix-test-suite = " \
 bash \
 hicolor-icon-theme \
 systemd \
 virtual/php-cli \
 virtual/php-curl \
 virtual/php-gd \
 virtual/php-json \
 virtual/php-openssl \
 virtual/php-posix \
 virtual/php-sqlite3 \
 virtual/php-xml \
 "
