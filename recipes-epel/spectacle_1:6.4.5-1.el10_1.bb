# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "spectacle"
PE = "1"
PV = "6.4.5"
PR = "1.el10_1"
PACKAGES = " \
 spectacle \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/spectacle-6.4.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d99b3ebe535a2f55826fd75e22248a6310b07453275e59907dc6bfbb18cc093a"

URI_x86_64_v2_spectacle = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/spectacle-6.4.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_spectacle;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_spectacle}"
SRC_URI[x86_64_v2_spectacle.sha256sum] = "e8f1039406771728b4e50a4f2365c2c40ede6e6a2049f3c91910e92e519a5a72"

URI_aarch64_spectacle = "${EPEL_MIRROR}/aarch64/Packages/s/spectacle-6.4.5-1.el10_1.aarch64.rpm;name=aarch64_spectacle;unpack=0"
SRC_URI:append = " ${URI_aarch64_spectacle}"
SRC_URI[aarch64_spectacle.sha256sum] = "ecd1e9b89d633e32badcc8100cc89136a4011472915c111dd25daf15cd492f3f"

RDEPENDS:spectacle = " \
 glibc \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kirigami \
 kf6-kjobwidgets \
 kf6-knotifications \
 kf6-kservice \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 kf6-prison \
 kf6-purpose \
 kpipewire \
 layer-shell-qt \
 libgcc \
 libstdc++ \
 libwayland-client \
 libxcb \
 opencv-core \
 opencv-imgproc \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 xcb-util \
 xcb-util-cursor \
 xcb-util-image \
 "
