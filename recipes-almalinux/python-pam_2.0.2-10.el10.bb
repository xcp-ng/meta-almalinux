# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pam"
PV = "2.0.2"
PR = "10.el10"
PACKAGES = " \
 python3-pam \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-pam-2.0.2-10.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "19579fa550176497d81f065c1b4865953aa16bfa5710736ad8a8794243759856"

URI_x86_64_v2_python3-pam = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-pam-2.0.2-10.el10.noarch.rpm;name=x86_64_v2_python3-pam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pam}"
SRC_URI[x86_64_v2_python3-pam.sha256sum] = "cdbdfcfdb8ac5dbacc9b1c69c4fa785cfe9501542635dc56e837c57454f1a94b"

URI_aarch64_python3-pam = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-pam-2.0.2-10.el10.noarch.rpm;name=aarch64_python3-pam;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pam}"
SRC_URI[aarch64_python3-pam.sha256sum] = "cdbdfcfdb8ac5dbacc9b1c69c4fa785cfe9501542635dc56e837c57454f1a94b"

RDEPENDS:python3-pam = " \
 python3 \
 "
