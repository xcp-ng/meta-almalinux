# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "yakuake"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 yakuake \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/yakuake-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4612c245b0600176f83461c4623e7a10a82638523600d344f3268438a42642ff"

URI_x86_64_v2_yakuake = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/yakuake-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_yakuake;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_yakuake}"
SRC_URI[x86_64_v2_yakuake.sha256sum] = "d3c0a43f69630e24c066d7d4b2dee88f72f5ea0bcc10f993ba63d498eac06f6c"

URI_aarch64_yakuake = "${EPEL_MIRROR}/aarch64/Packages/y/yakuake-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_yakuake;unpack=0"
SRC_URI:append = " ${URI_aarch64_yakuake}"
SRC_URI[aarch64_yakuake.sha256sum] = "51a4630c1410bc0058127808883723bcd5918548aaa06f0f8805443778b1c5f6"

RDEPENDS:yakuake = " \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-kglobalaccel \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-knewstuff \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kparts \
 kf6-kstatusnotifieritem \
 kf6-kwidgetsaddons \
 kf6-kwindowsystem \
 kf6-kxmlgui \
 konsole-part \
 kwayland \
 libX11 \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
