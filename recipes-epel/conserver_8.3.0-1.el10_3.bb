# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "conserver"
PV = "8.3.0"
PR = "1.el10_3"
PACKAGES = " \
 conserver \
 conserver-client \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/c/conserver-8.3.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7141c0b419894ed9fb860ae0164a0387d3533e105ea71de3411ebf4fde9f0453"

URI_x86_64_v2_conserver = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/conserver-8.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_conserver;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conserver}"
SRC_URI[x86_64_v2_conserver.sha256sum] = "df883e4a9a2347fdc91851934478e45ec0670a5b54c97323be49e44e799190d3"

URI_x86_64_v2_conserver-client = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/conserver-client-8.3.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_conserver-client;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_conserver-client}"
SRC_URI[x86_64_v2_conserver-client.sha256sum] = "0593aa894aa0c05b9e8b14f8ccdc6147158f12d205871442fdaf1ba87e1b6812"

URI_aarch64_conserver = "${EPEL_MIRROR}/aarch64/Packages/c/conserver-8.3.0-1.el10_3.aarch64.rpm;name=aarch64_conserver;unpack=0"
SRC_URI:append = " ${URI_aarch64_conserver}"
SRC_URI[aarch64_conserver.sha256sum] = "0ea1ab99bf212c524ce747d2bba077cba074d8baaa97be8291e43fda37d4b123"

URI_aarch64_conserver-client = "${EPEL_MIRROR}/aarch64/Packages/c/conserver-client-8.3.0-1.el10_3.aarch64.rpm;name=aarch64_conserver-client;unpack=0"
SRC_URI:append = " ${URI_aarch64_conserver-client}"
SRC_URI[aarch64_conserver-client.sha256sum] = "06d3400f7c5df0e0cdaa90197171aa98bc64efb0a766c035c473c9d769de31fd"

RDEPENDS:conserver = " \
 bash \
 freeipmi \
 glibc \
 krb5-libs \
 libxcrypt \
 openssl-libs \
 pam-libs \
 "
RDEPENDS:conserver-client = " \
 glibc \
 krb5-libs \
 openssl-libs \
 "
