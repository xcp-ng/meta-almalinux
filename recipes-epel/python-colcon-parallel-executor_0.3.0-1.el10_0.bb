# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-parallel-executor"
PV = "0.3.0"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-parallel-executor \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-parallel-executor-0.3.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "707123f0908944d7adedd89f54318b49b4455dfe63ee549331d048dc9f2afd22"

URI_x86_64_v2_python3-colcon-parallel-executor = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-parallel-executor-0.3.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-parallel-executor;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-parallel-executor}"
SRC_URI[x86_64_v2_python3-colcon-parallel-executor.sha256sum] = "2c2dfe7f362a37403995ced87092b2b85c385e3f4bf5fc926b6074c8a4f88600"

URI_aarch64_python3-colcon-parallel-executor = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-parallel-executor-0.3.0-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-parallel-executor;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-parallel-executor}"
SRC_URI[aarch64_python3-colcon-parallel-executor.sha256sum] = "9262093ccebe7c56d4e67212c74927d56fd4d9e906832b48dec543ffc41f4c65"

RDEPENDS:python3-colcon-parallel-executor = " \
 python3 \
 python3-colcon-core \
 "
