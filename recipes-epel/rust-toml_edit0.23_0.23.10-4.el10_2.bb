# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-toml_edit0.23"
PV = "0.23.10"
PR = "4.el10_2"
PACKAGES = " \
 rust-toml_edit0.23+debug-devel \
 rust-toml_edit0.23+default-devel \
 rust-toml_edit0.23+display-devel \
 rust-toml_edit0.23+parse-devel \
 rust-toml_edit0.23+serde-devel \
 rust-toml_edit0.23+unbounded-devel \
 rust-toml_edit0.23-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-toml_edit0.23-0.23.10-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f486b496612ef9d9119d062e5750f90acc9a4287d6b187809d866246a7682af9"

URI_x86_64_v2_rust-toml_edit0.23+debug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+debug-devel-0.23.10-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+debug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+debug-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+debug-devel.sha256sum] = "d21b6b3731db079319a779425a04fc58a5233725cd86ddd9d940d61d6b46d0fb"

URI_x86_64_v2_rust-toml_edit0.23+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+default-devel-0.23.10-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+default-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+default-devel.sha256sum] = "8fff33adea739e4bb54cd0db6310237778918fd37061afc2eee60dde6c753b8c"
RPROVIDES:rust-toml_edit0.23+default-devel:x86_64_v2 = "virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~"

URI_x86_64_v2_rust-toml_edit0.23+display-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+display-devel-0.23.10-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+display-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+display-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+display-devel.sha256sum] = "8f3c86eb5078d1d59c0025fd7da9665a8c7128c7e942bd15cb6bff0c30738209"
RPROVIDES:rust-toml_edit0.23+display-devel:x86_64_v2 = "virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~"

URI_x86_64_v2_rust-toml_edit0.23+parse-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+parse-devel-0.23.10-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+parse-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+parse-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+parse-devel.sha256sum] = "ea8724f491fb4f1cfc048be25031c20931d7fc5f006061f516b8ec3ea79ae819"
RPROVIDES:rust-toml_edit0.23+parse-devel:x86_64_v2 = "virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ virtual/crate_toml_edit/parse__ge_0.23.2_with_crate_toml_edit/parse__lt_0.25.0~"

URI_x86_64_v2_rust-toml_edit0.23+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+serde-devel-0.23.10-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+serde-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+serde-devel.sha256sum] = "85ff53758bf95105633716c3e1ccd06dbc2e0a2b2bde94381787112db987e55e"
RPROVIDES:rust-toml_edit0.23+serde-devel:x86_64_v2 = "virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~"

URI_x86_64_v2_rust-toml_edit0.23+unbounded-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23+unbounded-devel-0.23.10-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23+unbounded-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23+unbounded-devel.sha256sum] = "33f25b49569be178763770d876b5cf7fcf1da2b757aa67b04ef55455ad66e8ca"

URI_x86_64_v2_rust-toml_edit0.23-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-toml_edit0.23-devel-0.23.10-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-toml_edit0.23-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-toml_edit0.23-devel}"
SRC_URI[x86_64_v2_rust-toml_edit0.23-devel.sha256sum] = "f9ebf47b2eb3a97b6a4178245077f32bb65483f501227a6ad998767a75823c19"
RPROVIDES:rust-toml_edit0.23-devel:x86_64_v2 = "virtual/crate_toml_edit__ge_0.23.2_with_crate_toml_edit__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+debug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+debug-devel-0.23.10-4.el10_2.noarch.rpm;name=aarch64_rust-toml_edit0.23+debug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+debug-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+debug-devel.sha256sum] = "642da7c601e0d9210e25b4e8f6c69b2fbc852f3b20dd51d2afd5c9d4a4fbf251"

URI_aarch64_rust-toml_edit0.23+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+default-devel-0.23.10-4.el10_2.noarch.rpm;name=aarch64_rust-toml_edit0.23+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+default-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+default-devel.sha256sum] = "5da4bb03da751cfdafe0e6410960d50a033bf8ce2eac4b7c2a17f39d5364d7e4"
RPROVIDES:rust-toml_edit0.23+default-devel:aarch64 = "virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+display-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+display-devel-0.23.10-4.el10_2.noarch.rpm;name=aarch64_rust-toml_edit0.23+display-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+display-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+display-devel.sha256sum] = "bb82bac5d7622333437d2bee6efadc975f50d0bf2297a679eb6f203b4e0944a5"
RPROVIDES:rust-toml_edit0.23+display-devel:aarch64 = "virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+parse-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+parse-devel-0.23.10-4.el10_2.noarch.rpm;name=aarch64_rust-toml_edit0.23+parse-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+parse-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+parse-devel.sha256sum] = "ca5e6061dc744a34b531151e35f4f2b5250eb567f03261143a0de56ba82959b9"
RPROVIDES:rust-toml_edit0.23+parse-devel:aarch64 = "virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ virtual/crate_toml_edit/parse__ge_0.23.2_with_crate_toml_edit/parse__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+serde-devel-0.23.10-4.el10_2.noarch.rpm;name=aarch64_rust-toml_edit0.23+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+serde-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+serde-devel.sha256sum] = "4bb8e30e64428f3c24cd8c36f7bd0ade64b2ffb2b632bcd247f93ef0965ac76b"
RPROVIDES:rust-toml_edit0.23+serde-devel:aarch64 = "virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~"

URI_aarch64_rust-toml_edit0.23+unbounded-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23+unbounded-devel-0.23.10-4.el10_2.noarch.rpm;name=aarch64_rust-toml_edit0.23+unbounded-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23+unbounded-devel}"
SRC_URI[aarch64_rust-toml_edit0.23+unbounded-devel.sha256sum] = "3d0b082fb197dc8f623ddde572032e815aecc9078ab2a2ff4731f42aeaeedda1"

URI_aarch64_rust-toml_edit0.23-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-toml_edit0.23-devel-0.23.10-4.el10_2.noarch.rpm;name=aarch64_rust-toml_edit0.23-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-toml_edit0.23-devel}"
SRC_URI[aarch64_rust-toml_edit0.23-devel.sha256sum] = "06fcb5e4ca57dd0ce0d119e5ba0579e145fd1efd7693475371d532a87101e735"
RPROVIDES:rust-toml_edit0.23-devel:aarch64 = "virtual/crate_toml_edit__ge_0.23.2_with_crate_toml_edit__lt_0.25.0~"

RDEPENDS:rust-toml_edit0.23+debug-devel = " \
 cargo \
 rust-anstream0.6+default-devel \
 rust-anstyle+default-devel \
 rust-toml_edit0.23+display-devel \
 rust-toml_edit0.23-devel \
 rust-toml_parser+debug-devel \
 rust-toml_parser+default-devel \
 "
RDEPENDS:rust-toml_edit0.23+default-devel = " \
 cargo \
 rust-toml_edit0.23+display-devel \
 rust-toml_edit0.23+parse-devel \
 rust-toml_edit0.23-devel \
 "
RDEPENDS:rust-toml_edit0.23+display-devel = " \
 cargo \
 rust-toml_edit0.23-devel \
 rust-toml_writer+default-devel \
 "
RDEPENDS:rust-toml_edit0.23+parse-devel = " \
 cargo \
 rust-toml_edit0.23-devel \
 rust-toml_parser+default-devel \
 rust-winnow+default-devel \
 "
RDEPENDS:rust-toml_edit0.23+serde-devel = " \
 cargo \
 rust-serde_core+default-devel \
 rust-serde_spanned+default-devel \
 rust-serde_spanned+serde-devel \
 rust-toml_datetime0.7+serde-devel \
 rust-toml_edit0.23-devel \
 "
RDEPENDS:rust-toml_edit0.23+unbounded-devel = " \
 cargo \
 rust-toml_edit0.23-devel \
 "
RDEPENDS:rust-toml_edit0.23-devel = " \
 cargo \
 rust \
 rust-indexmap+default-devel \
 rust-indexmap+std-devel \
 rust-toml_datetime0.7+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ rpm/virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~ rpm/virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~ rpm/virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ rpm/virtual/crate_toml_edit/parse__ge_0.23.2_with_crate_toml_edit/parse__lt_0.25.0~ rpm/virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ rpm/virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~ rpm/virtual/crate_toml_edit__ge_0.23.2_with_crate_toml_edit__lt_0.25.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_toml_edit/default__ge_0.23.0_with_crate_toml_edit/default__lt_0.25.0~ rpm/virtual/crate_toml_edit/default__ge_0.23.5_with_crate_toml_edit/default__lt_0.25.0~ rpm/virtual/crate_toml_edit/display__ge_0.23.0_with_crate_toml_edit/display__lt_0.25.0~ rpm/virtual/crate_toml_edit/parse__ge_0.23.0_with_crate_toml_edit/parse__lt_0.25.0~ rpm/virtual/crate_toml_edit/parse__ge_0.23.2_with_crate_toml_edit/parse__lt_0.25.0~ rpm/virtual/crate_toml_edit/serde__ge_0.23.0_with_crate_toml_edit/serde__lt_0.25.0~ rpm/virtual/crate_toml_edit/serde__ge_0.23.5_with_crate_toml_edit/serde__lt_0.25.0~ rpm/virtual/crate_toml_edit__ge_0.23.2_with_crate_toml_edit__lt_0.25.0~"
