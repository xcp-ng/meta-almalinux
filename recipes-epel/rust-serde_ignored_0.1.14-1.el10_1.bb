# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-serde_ignored"
PV = "0.1.14"
PR = "1.el10_1"
PACKAGES = " \
 rust-serde_ignored+default-devel \
 rust-serde_ignored-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-serde_ignored-0.1.14-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "63330e555d1089b589efb22056a80f01f04c3d484e85a6974cc95f0eb712825e"

URI_x86_64_v2_rust-serde_ignored+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_ignored+default-devel-0.1.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_ignored+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_ignored+default-devel}"
SRC_URI[x86_64_v2_rust-serde_ignored+default-devel.sha256sum] = "938820916f3fe7cefa4123c310a6b71a80e881e9bdd1c09e6597b84eef016957"

URI_x86_64_v2_rust-serde_ignored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-serde_ignored-devel-0.1.14-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-serde_ignored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-serde_ignored-devel}"
SRC_URI[x86_64_v2_rust-serde_ignored-devel.sha256sum] = "0794600d9c10904c3e0265c62aef7b94ad325321dabb3cb51bc5fb84306b1ff2"

URI_aarch64_rust-serde_ignored+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_ignored+default-devel-0.1.14-1.el10_1.noarch.rpm;name=aarch64_rust-serde_ignored+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_ignored+default-devel}"
SRC_URI[aarch64_rust-serde_ignored+default-devel.sha256sum] = "19d58741e145e1e2c599dd19d7513af157084df2584d4997e19e21305609ad14"

URI_aarch64_rust-serde_ignored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-serde_ignored-devel-0.1.14-1.el10_1.noarch.rpm;name=aarch64_rust-serde_ignored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-serde_ignored-devel}"
SRC_URI[aarch64_rust-serde_ignored-devel.sha256sum] = "5a780f9abf5a688c50cdb35892462dd15555e96e2ec2a46dc8529e84b43b2b44"

RDEPENDS:rust-serde_ignored+default-devel = " \
 cargo \
 rust-serde_ignored-devel \
 "
RDEPENDS:rust-serde_ignored-devel = " \
 cargo \
 rust \
 rust-serde-devel \
 rust-serde_core+alloc-devel \
 rust-serde_core-devel \
 "
