# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Devel-PPPort"
PV = "3.72"
PR = "512.el10"
PACKAGES = " \
 perl-Devel-PPPort \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Devel-PPPort-3.72-512.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e3d6cc0531f33f8e7038d3e26171dbacdce56528ff6fd66801624801bc4944c5"

URI_x86_64_v2_perl-Devel-PPPort = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Devel-PPPort-3.72-512.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Devel-PPPort;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Devel-PPPort}"
SRC_URI[x86_64_v2_perl-Devel-PPPort.sha256sum] = "986b1c50f96621be2d1fccce436b7f55c332c45cfbfc1534e54fa3b6d5ab2f0d"

URI_aarch64_perl-Devel-PPPort = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Devel-PPPort-3.72-512.el10.aarch64.rpm;name=aarch64_perl-Devel-PPPort;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Devel-PPPort}"
SRC_URI[aarch64_perl-Devel-PPPort.sha256sum] = "3791517dc6f9b7f4cf30dbf7eae3d23e7411ab7687e81d4086d3b7ae593ed9be"

RDEPENDS:perl-Devel-PPPort = " \
 glibc \
 perl-libs \
 perl-vars \
 "
