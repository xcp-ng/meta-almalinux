# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-yoke"
PV = "0.8.1"
PR = "1.el10_1"
PACKAGES = " \
 rust-yoke+alloc-devel \
 rust-yoke+default-devel \
 rust-yoke+derive-devel \
 rust-yoke+serde-devel \
 rust-yoke+zerofrom-devel \
 rust-yoke-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-yoke-0.8.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d8638f0d18567fd9c6acb4ed7a45397845d2185550ecd4ce0991e44930296ff"

URI_x86_64_v2_rust-yoke+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+alloc-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+alloc-devel}"
SRC_URI[x86_64_v2_rust-yoke+alloc-devel.sha256sum] = "d2b260cb542c3399d8c5e9b89ceb4b26a57f70f137f435f2e3cdc2da806f49df"

URI_x86_64_v2_rust-yoke+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+default-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+default-devel}"
SRC_URI[x86_64_v2_rust-yoke+default-devel.sha256sum] = "8de9340f4aaa4113905edb4f14bb7597e219071dc7d3818ad004dc30b87ecfc2"

URI_x86_64_v2_rust-yoke+derive-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+derive-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+derive-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+derive-devel}"
SRC_URI[x86_64_v2_rust-yoke+derive-devel.sha256sum] = "c8d4c511a0a5ead586060f85ec2779b998d26f0795d6b30b1b3ef30f1d8585e2"

URI_x86_64_v2_rust-yoke+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+serde-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+serde-devel}"
SRC_URI[x86_64_v2_rust-yoke+serde-devel.sha256sum] = "fd7a9d26cbf64502f14977235f2d0627674d1204d7b71edfa6f5301d78647bbb"

URI_x86_64_v2_rust-yoke+zerofrom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke+zerofrom-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke+zerofrom-devel}"
SRC_URI[x86_64_v2_rust-yoke+zerofrom-devel.sha256sum] = "3fab83dfada23cec40af38330610c50de7fbdde08dece68b02b70e65fd7ff666"

URI_x86_64_v2_rust-yoke-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-yoke-devel-0.8.1-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-yoke-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-yoke-devel}"
SRC_URI[x86_64_v2_rust-yoke-devel.sha256sum] = "e5e73789f05f97a148fc25709ec78d9eb52eb847183781e8ab70cfde480f8e0a"

URI_aarch64_rust-yoke+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+alloc-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-yoke+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+alloc-devel}"
SRC_URI[aarch64_rust-yoke+alloc-devel.sha256sum] = "9821b3828a1b8093f47752ae65632552f7b9c07a6314cfb8296912297cc17369"

URI_aarch64_rust-yoke+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+default-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-yoke+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+default-devel}"
SRC_URI[aarch64_rust-yoke+default-devel.sha256sum] = "e8cb2c42db759cfb14aba1b2c19fc796b369b4f5ff909f2a15b7c17039d4ae36"

URI_aarch64_rust-yoke+derive-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+derive-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-yoke+derive-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+derive-devel}"
SRC_URI[aarch64_rust-yoke+derive-devel.sha256sum] = "2e797b4245d19a77d456e0d4fdf34f9151872ae6da40df513d88beb082662030"

URI_aarch64_rust-yoke+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+serde-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-yoke+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+serde-devel}"
SRC_URI[aarch64_rust-yoke+serde-devel.sha256sum] = "b74cd03ec86066be4f51744d13753e9697358480ab135b7c760d565f58be65d9"

URI_aarch64_rust-yoke+zerofrom-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke+zerofrom-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-yoke+zerofrom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke+zerofrom-devel}"
SRC_URI[aarch64_rust-yoke+zerofrom-devel.sha256sum] = "de1ceff8cf307ceb110c7bcfea02b9f8cc7fd00d283a3ed29b27a0d83b7857b7"

URI_aarch64_rust-yoke-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-yoke-devel-0.8.1-1.el10_1.noarch.rpm;name=aarch64_rust-yoke-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-yoke-devel}"
SRC_URI[aarch64_rust-yoke-devel.sha256sum] = "c6305553994b0a1953487d154ef9c6632d51fb28bd399b8e4226d76aa723da50"

RDEPENDS:rust-yoke+alloc-devel = " \
 cargo \
 rust-stable_deref_trait+alloc-devel \
 rust-yoke-devel \
 rust-zerofrom+alloc-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke+default-devel = " \
 cargo \
 rust-yoke+alloc-devel \
 rust-yoke+zerofrom-devel \
 rust-yoke-devel \
 "
RDEPENDS:rust-yoke+derive-devel = " \
 cargo \
 rust-yoke-derive-devel \
 rust-yoke-devel \
 rust-zerofrom+derive-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke+serde-devel = " \
 cargo \
 rust-yoke-devel \
 "
RDEPENDS:rust-yoke+zerofrom-devel = " \
 cargo \
 rust-yoke-devel \
 rust-zerofrom-devel \
 "
RDEPENDS:rust-yoke-devel = " \
 cargo \
 rust \
 rust-stable_deref_trait-devel \
 "
