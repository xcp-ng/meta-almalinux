# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-google-renameio"
PV = "1.0.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-google-renameio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-google-renameio-1.0.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de070d24bb255b32785475ce85d02c61abc2c5c4ce22bbb0f229acf38fdae15e"

URI_x86_64_v2_golang-github-google-renameio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-google-renameio-devel-1.0.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-google-renameio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-google-renameio-devel}"
SRC_URI[x86_64_v2_golang-github-google-renameio-devel.sha256sum] = "c22fb65954b90891322e79d5c3944bd5005cdfd1061805fab62b186aec877505"

URI_aarch64_golang-github-google-renameio-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-google-renameio-devel-1.0.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-google-renameio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-google-renameio-devel}"
SRC_URI[aarch64_golang-github-google-renameio-devel.sha256sum] = "0b38153c40fc527c1e282d9044249deefe0811ca1f739d10fa8f1f12a5a0d49d"

RDEPENDS:golang-github-google-renameio-devel = " \
 go-filesystem \
 "
