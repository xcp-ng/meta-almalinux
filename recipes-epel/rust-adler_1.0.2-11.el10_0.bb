# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-adler"
PV = "1.0.2"
PR = "11.el10_0"
PACKAGES = " \
 rust-adler+default-devel \
 rust-adler+std-devel \
 rust-adler-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-adler-1.0.2-11.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4cad2e47ce0b4a31e4081cf5962c5c4c066bd493ac2a2057a73274272f36f195"

URI_x86_64_v2_rust-adler+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adler+default-devel-1.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adler+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adler+default-devel}"
SRC_URI[x86_64_v2_rust-adler+default-devel.sha256sum] = "6a1db87f328424fe1d7603ac3ac13ab674ee85c811b09a8c244c22234037cc74"

URI_x86_64_v2_rust-adler+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adler+std-devel-1.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adler+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adler+std-devel}"
SRC_URI[x86_64_v2_rust-adler+std-devel.sha256sum] = "3640cdaae8fea8c114da4f937c94a16f520ba5039c5284db0de28d4829044c5d"

URI_x86_64_v2_rust-adler-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adler-devel-1.0.2-11.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adler-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adler-devel}"
SRC_URI[x86_64_v2_rust-adler-devel.sha256sum] = "cde02ddd8854387edfe34a5620cbab79fb3ebf9e31174c3cf8c62c917ed7e9df"

URI_aarch64_rust-adler+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adler+default-devel-1.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-adler+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adler+default-devel}"
SRC_URI[aarch64_rust-adler+default-devel.sha256sum] = "bd161fa62201903ed0b9c8530e3f6171d4bf4a7b31e5f0f85242ef00ac778e03"

URI_aarch64_rust-adler+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adler+std-devel-1.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-adler+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adler+std-devel}"
SRC_URI[aarch64_rust-adler+std-devel.sha256sum] = "dd5401fc01c11aa669073676551f4f155ccae4542a691876b0d8416f512a2d6d"

URI_aarch64_rust-adler-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adler-devel-1.0.2-11.el10_0.noarch.rpm;name=aarch64_rust-adler-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adler-devel}"
SRC_URI[aarch64_rust-adler-devel.sha256sum] = "299b175e379c9ea572d7bbe72b2b2c1842c7a04572aa6ef639ec016f8e821c79"

RDEPENDS:rust-adler+default-devel = " \
 cargo \
 rust-adler+std-devel \
 rust-adler-devel \
 "
RDEPENDS:rust-adler+std-devel = " \
 cargo \
 rust-adler-devel \
 "
RDEPENDS:rust-adler-devel = " \
 cargo \
 "
