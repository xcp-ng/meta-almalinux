# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "indent"
PV = "2.2.13"
PR = "9.el10_0"
PACKAGES = " \
 indent \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/i/indent-2.2.13-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "0aa8de7bac98fed07d949cd75bf61621ebf28b65962dfc068be032369ba602d7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/indent-2.2.13-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_indent;unpack=0"
SRC_URI[x86_64_v2_indent.sha256sum] = "88ab786739dddf6b57ae410682f41d7c0e4d3e033008543c6eb76e4035a01bab"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/i/indent-2.2.13-9.el10_0.aarch64.rpm;name=aarch64_indent;unpack=0"
SRC_URI[aarch64_indent.sha256sum] = "1cffa80abbf8c3352c55b5d3ad8609f8e5e39e028b41369c8dcf507bbbdd491d"

RDEPENDS:indent = " \
 glibc \
 "
