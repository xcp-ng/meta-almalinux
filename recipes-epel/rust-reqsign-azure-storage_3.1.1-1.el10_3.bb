# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-azure-storage"
PV = "3.1.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-azure-storage+default-devel \
 rust-reqsign-azure-storage-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-azure-storage-3.1.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "08c83d402dea519cc1e5a6eaf317a09287006b72cdae17baee3d953d47609f4b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-azure-storage+default-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-azure-storage+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-azure-storage+default-devel.sha256sum] = "3ea30045ed9adc3bccdda75e841dcd0182f7d1d351762e756dd7c16b2680b459"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-azure-storage-devel-3.1.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-azure-storage-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-azure-storage-devel.sha256sum] = "72299ff7d183acc87e75234879d81c80455580bb6fdbfb41943725514c38c558"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-azure-storage+default-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-azure-storage+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-azure-storage+default-devel.sha256sum] = "3b3e252f940bd2835e6f4262aac8c80595444c35d500848c5ae9721879f6df89"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-azure-storage-devel-3.1.1-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-azure-storage-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-azure-storage-devel.sha256sum] = "8aa988d656532a3bb77767136877dabb61e2e88265b0d477fc44fba7d3e6acc4"

RDEPENDS:rust-reqsign-azure-storage+default-devel = " \
 cargo \
 rust-reqsign-azure-storage-devel \
 "
RDEPENDS:rust-reqsign-azure-storage-devel = " \
 cargo \
 rust \
 rust-anyhow+default-devel \
 rust-base64_0.22+default-devel \
 rust-bytes+default-devel \
 rust-form_urlencoded+default-devel \
 rust-http+default-devel \
 rust-log+default-devel \
 rust-pem3+default-devel \
 rust-percent-encoding+default-devel \
 rust-reqsign-core+default-devel \
 rust-reqsign-core+jwt-devel \
 rust-rsa+default-devel \
 rust-rsa+pkcs5-devel \
 rust-rsa+sha2-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-sha1+default-devel \
 "
