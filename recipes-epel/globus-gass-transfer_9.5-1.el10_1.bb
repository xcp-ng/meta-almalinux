# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "globus-gass-transfer"
PV = "9.5"
PR = "1.el10_1"
PACKAGES = " \
 globus-gass-transfer \
 globus-gass-transfer-devel \
 globus-gass-transfer-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/globus-gass-transfer-9.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "33c36d8a25fcba3acafd7dbc1e8f9c47106bfa45261c4322c2b014d2935dab1a"

URI_x86_64_v2_globus-gass-transfer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-transfer-9.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-transfer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-transfer}"
SRC_URI[x86_64_v2_globus-gass-transfer.sha256sum] = "3dbea302f2a2f84d162e2375292fddd074de054c4685ead3c49b3eee1bf69035"

URI_x86_64_v2_globus-gass-transfer-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-transfer-devel-9.5-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_globus-gass-transfer-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-transfer-devel}"
SRC_URI[x86_64_v2_globus-gass-transfer-devel.sha256sum] = "991f6e92ccaa17e7ba54046b637c28736d437b3293910889e233f688d5a1623b"

URI_x86_64_v2_globus-gass-transfer-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/globus-gass-transfer-doc-9.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_globus-gass-transfer-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_globus-gass-transfer-doc}"
SRC_URI[x86_64_v2_globus-gass-transfer-doc.sha256sum] = "2d67c06609195d6aa1e4d34be1804681d72ad57c69e65358b328b77bf58d70de"

URI_aarch64_globus-gass-transfer = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-transfer-9.5-1.el10_1.aarch64.rpm;name=aarch64_globus-gass-transfer;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-transfer}"
SRC_URI[aarch64_globus-gass-transfer.sha256sum] = "194aef229b10b0adda2f7b67ff0ead73e550e415ba913d55ccb06f9dd65766ca"

URI_aarch64_globus-gass-transfer-devel = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-transfer-devel-9.5-1.el10_1.aarch64.rpm;name=aarch64_globus-gass-transfer-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-transfer-devel}"
SRC_URI[aarch64_globus-gass-transfer-devel.sha256sum] = "b5f0dee661806b34cd625d7e040b8f6c5aff7f714c25bcee62de241a05422dd7"

URI_aarch64_globus-gass-transfer-doc = "${EPEL_MIRROR}/aarch64/Packages/g/globus-gass-transfer-doc-9.5-1.el10_1.noarch.rpm;name=aarch64_globus-gass-transfer-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_globus-gass-transfer-doc}"
SRC_URI[aarch64_globus-gass-transfer-doc.sha256sum] = "9f0b76f4d84a13beb30d2b4e7a05cbd8dee084791e6dd82aa248085e83e3b189"

RDEPENDS:globus-gass-transfer = " \
 glibc \
 globus-common \
 globus-gss-assist \
 globus-gssapi-gsi \
 globus-io \
 "
RDEPENDS:globus-gass-transfer-devel = " \
 globus-common-devel \
 globus-gass-transfer \
 globus-gss-assist-devel \
 globus-gssapi-gsi-devel \
 globus-io-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:globus-gass-transfer-doc = " \
 "
