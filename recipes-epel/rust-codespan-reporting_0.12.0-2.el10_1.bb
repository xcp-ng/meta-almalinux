# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-codespan-reporting"
PV = "0.12.0"
PR = "2.el10_1"
PACKAGES = " \
 rust-codespan-reporting+ascii-only-devel \
 rust-codespan-reporting+default-devel \
 rust-codespan-reporting+serde-devel \
 rust-codespan-reporting+serialization-devel \
 rust-codespan-reporting+std-devel \
 rust-codespan-reporting+termcolor-devel \
 rust-codespan-reporting-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-codespan-reporting-0.12.0-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ec6a59333bd3d4835bfb9de3763104a92836371f683e355797eb4feec384f66f"

URI_x86_64_v2_rust-codespan-reporting+ascii-only-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+ascii-only-devel-0.12.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+ascii-only-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+ascii-only-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+ascii-only-devel.sha256sum] = "74e04666b19647eb28fd719de1cd0e6ff63d6a7270962820434f6532dbba8a57"

URI_x86_64_v2_rust-codespan-reporting+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+default-devel-0.12.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+default-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+default-devel.sha256sum] = "edd58d83e2074791d373d22e91ebe31560bfe0bbe06f582193d2ed5bd3fe1aa5"

URI_x86_64_v2_rust-codespan-reporting+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+serde-devel-0.12.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+serde-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+serde-devel.sha256sum] = "e631077a40bd43ee4197b14ccf1d818c669a3c5c3c2b7a081c9653663f5a6213"

URI_x86_64_v2_rust-codespan-reporting+serialization-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+serialization-devel-0.12.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+serialization-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+serialization-devel.sha256sum] = "af8dbc3c3ae60cb7dde8fadf08e2988dd1813a1a0ad0df6760c37ab3b69fc3bb"

URI_x86_64_v2_rust-codespan-reporting+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+std-devel-0.12.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+std-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+std-devel.sha256sum] = "8034cc51bf502ba089658001c1b2d3b53c813f0a56a55d74c65fe163e7ae2f61"

URI_x86_64_v2_rust-codespan-reporting+termcolor-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting+termcolor-devel-0.12.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting+termcolor-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting+termcolor-devel.sha256sum] = "2c125e0c0434ad113fef11e62cec1f713dc7a10e7e070ecfa4e4af7755603df4"

URI_x86_64_v2_rust-codespan-reporting-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-codespan-reporting-devel-0.12.0-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-codespan-reporting-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-codespan-reporting-devel}"
SRC_URI[x86_64_v2_rust-codespan-reporting-devel.sha256sum] = "e523627b0f0af489d30eb071510b8818866fc6f50afad283485b6aa31f7dc1a0"

URI_aarch64_rust-codespan-reporting+ascii-only-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+ascii-only-devel-0.12.0-2.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting+ascii-only-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+ascii-only-devel}"
SRC_URI[aarch64_rust-codespan-reporting+ascii-only-devel.sha256sum] = "194bf4e81f56b04cf781a67949720070babe101303853f17fd3471d390394552"

URI_aarch64_rust-codespan-reporting+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+default-devel-0.12.0-2.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+default-devel}"
SRC_URI[aarch64_rust-codespan-reporting+default-devel.sha256sum] = "1da5c8e6fda39e9e09ca5df28df9394dd473dece173b7786fd1a5f696790e2e9"

URI_aarch64_rust-codespan-reporting+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+serde-devel-0.12.0-2.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+serde-devel}"
SRC_URI[aarch64_rust-codespan-reporting+serde-devel.sha256sum] = "d94372037631f46d679e3326d2bededbeeda0c92bc3c58cf764705dd90f0f4e3"

URI_aarch64_rust-codespan-reporting+serialization-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+serialization-devel-0.12.0-2.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting+serialization-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+serialization-devel}"
SRC_URI[aarch64_rust-codespan-reporting+serialization-devel.sha256sum] = "a539f9eb596d06f1fee2427a6312525963f7ec9490f4a16efd5fc6e9b6c9d179"

URI_aarch64_rust-codespan-reporting+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+std-devel-0.12.0-2.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+std-devel}"
SRC_URI[aarch64_rust-codespan-reporting+std-devel.sha256sum] = "ec2e5972306072d907d2fb10a71d4f231fe28ca9fb68794cfd5d55c2d68b57c2"

URI_aarch64_rust-codespan-reporting+termcolor-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting+termcolor-devel-0.12.0-2.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting+termcolor-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting+termcolor-devel}"
SRC_URI[aarch64_rust-codespan-reporting+termcolor-devel.sha256sum] = "39c52b2a863a957fdcddb9c900941ea84be63fde4fb985980f4a8d82d01d268b"

URI_aarch64_rust-codespan-reporting-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-codespan-reporting-devel-0.12.0-2.el10_1.noarch.rpm;name=aarch64_rust-codespan-reporting-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-codespan-reporting-devel}"
SRC_URI[aarch64_rust-codespan-reporting-devel.sha256sum] = "3c0027ed5a48860fc76e9a78c8f7544a98d8763d74b7b3c6adf9d61203272449"

RDEPENDS:rust-codespan-reporting+ascii-only-devel = " \
 cargo \
 rust-codespan-reporting-devel \
 "
RDEPENDS:rust-codespan-reporting+default-devel = " \
 cargo \
 rust-codespan-reporting+std-devel \
 rust-codespan-reporting+termcolor-devel \
 rust-codespan-reporting-devel \
 "
RDEPENDS:rust-codespan-reporting+serde-devel = " \
 cargo \
 rust-codespan-reporting-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-codespan-reporting+serialization-devel = " \
 cargo \
 rust-codespan-reporting+serde-devel \
 rust-codespan-reporting-devel \
 "
RDEPENDS:rust-codespan-reporting+std-devel = " \
 cargo \
 rust-codespan-reporting-devel \
 rust-serde+alloc-devel \
 rust-serde+derive-devel \
 rust-serde+std-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-codespan-reporting+termcolor-devel = " \
 cargo \
 rust-codespan-reporting+std-devel \
 rust-codespan-reporting-devel \
 rust-termcolor+default-devel \
 "
RDEPENDS:rust-codespan-reporting-devel = " \
 cargo \
 rust \
 virtual/crate_unicode-width/default__ge_0.1.0_with_crate_unicode-width/default__lt_0.3.0~ \
 "
