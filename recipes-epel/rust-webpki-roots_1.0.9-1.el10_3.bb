# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-webpki-roots"
PV = "1.0.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-webpki-roots+default-devel \
 rust-webpki-roots-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-webpki-roots-1.0.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e4bff7b9a6fa228d67793b2fe783a448a425ff47920143fde44b367deb385a42"

URI_x86_64_v2_rust-webpki-roots+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots+default-devel-1.0.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots+default-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots+default-devel.sha256sum] = "77505e70250aae04b27efdbd2c9b315702d6d4389196fe98d11c8cce95440283"

URI_x86_64_v2_rust-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots-devel-1.0.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots-devel.sha256sum] = "7d5be89a74c261e6a3533699226bfb1e6b0ce71b4eb0bfba6bf1478715f8893d"

URI_aarch64_rust-webpki-roots+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots+default-devel-1.0.9-1.el10_3.noarch.rpm;name=aarch64_rust-webpki-roots+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots+default-devel}"
SRC_URI[aarch64_rust-webpki-roots+default-devel.sha256sum] = "3fcdb130eef81afd1298d95d2fba6ef716aac818daaac2a41cf333aae509b3dc"

URI_aarch64_rust-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots-devel-1.0.9-1.el10_3.noarch.rpm;name=aarch64_rust-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots-devel}"
SRC_URI[aarch64_rust-webpki-roots-devel.sha256sum] = "93e5adbaf2a9b12d719c2aca7783f4ba7e40ff39e00d188edbfe0210dc15e491"

RDEPENDS:rust-webpki-roots+default-devel = " \
 cargo \
 rust-webpki-roots-devel \
 "
RDEPENDS:rust-webpki-roots-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 "
