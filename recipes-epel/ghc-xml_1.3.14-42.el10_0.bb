# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-xml"
PV = "1.3.14"
PR = "42.el10_0"
PACKAGES = " \
 ghc-xml \
 ghc-xml-devel \
 ghc-xml-doc \
 ghc-xml-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-xml-1.3.14-42.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ddd1f569059ce7bf1891eb8016e6e14b34112577aa01132f15c88c43e2544fea"

URI_x86_64_v2_ghc-xml = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-1.3.14-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml}"
SRC_URI[x86_64_v2_ghc-xml.sha256sum] = "5d2884376b7d4c09882a9592b5f7cdab67c42483e4c8906d813ff41f2637a1b9"

URI_x86_64_v2_ghc-xml-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-devel-1.3.14-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-devel}"
SRC_URI[x86_64_v2_ghc-xml-devel.sha256sum] = "b408772472a8c3d3b94a6e609e52db511bb0fce36ff919245616f1cfca0d5c1f"

URI_x86_64_v2_ghc-xml-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-doc-1.3.14-42.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-xml-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-doc}"
SRC_URI[x86_64_v2_ghc-xml-doc.sha256sum] = "613cda58480a44c8ced059e20c37ef2ae83018f3992dbfd76de659c86f7717b7"

URI_x86_64_v2_ghc-xml-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-xml-prof-1.3.14-42.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-xml-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-xml-prof}"
SRC_URI[x86_64_v2_ghc-xml-prof.sha256sum] = "24a492a395002a495b2de63cf7c87a1843b73df98ee1805a6d07cd6be8eff24d"

URI_aarch64_ghc-xml = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-1.3.14-42.el10_0.aarch64.rpm;name=aarch64_ghc-xml;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml}"
SRC_URI[aarch64_ghc-xml.sha256sum] = "bd6b9b9a1705d65b8d7658968a67c6615bee0d92903765a6f52c7039f53a8254"

URI_aarch64_ghc-xml-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-devel-1.3.14-42.el10_0.aarch64.rpm;name=aarch64_ghc-xml-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-devel}"
SRC_URI[aarch64_ghc-xml-devel.sha256sum] = "5a56f6e506d54d078364ba9184be5bbb863b87e87d2885cd02d8fd87285e0076"

URI_aarch64_ghc-xml-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-doc-1.3.14-42.el10_0.noarch.rpm;name=aarch64_ghc-xml-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-doc}"
SRC_URI[aarch64_ghc-xml-doc.sha256sum] = "9deeec31837485902916bad74ca12c867305a19e7a54156bd2861a8f7270ac9c"

URI_aarch64_ghc-xml-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-xml-prof-1.3.14-42.el10_0.aarch64.rpm;name=aarch64_ghc-xml-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-xml-prof}"
SRC_URI[aarch64_ghc-xml-prof.sha256sum] = "63eb878f4c99b2234e623bdff3fd9292699e5cf7e3137b0a0713d5647fd55cbc"

RDEPENDS:ghc-xml = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-xml-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-text-devel \
 ghc-xml \
 "
RDEPENDS:ghc-xml-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-xml-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-text-prof \
 ghc-xml-devel \
 "
