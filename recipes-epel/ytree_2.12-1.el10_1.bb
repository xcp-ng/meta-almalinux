# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ytree"
PV = "2.12"
PR = "1.el10_1"
PACKAGES = " \
 ytree \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/y/ytree-2.12-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bc5c73f86e8af95c841e710bd38b0ad90c8bb76cd09c41c9c70a0d473d4baa0f"

URI_x86_64_v2_ytree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ytree-2.12-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ytree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ytree}"
SRC_URI[x86_64_v2_ytree.sha256sum] = "d68de2e7a5c21f2f32905853122c012898e83b8df62dbfd5cba05f1ac8380c8e"

URI_aarch64_ytree = "${EPEL_MIRROR}/aarch64/Packages/y/ytree-2.12-1.el10_1.aarch64.rpm;name=aarch64_ytree;unpack=0"
SRC_URI:append = " ${URI_aarch64_ytree}"
SRC_URI[aarch64_ytree.sha256sum] = "dc63278987258f695995a2bd497c44a0fa50e3e75f18aecc59613d5585d96e41"

RDEPENDS:ytree = " \
 glibc \
 ncurses-libs \
 readline \
 "
