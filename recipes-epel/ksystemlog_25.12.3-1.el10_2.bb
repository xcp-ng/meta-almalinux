# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ksystemlog"
PV = "25.12.3"
PR = "1.el10_2"
PACKAGES = " \
 ksystemlog \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/ksystemlog-25.12.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a6c67fe1b75f31b80c0b26f3787ad391c2ca46bf84f1a44c43675b0018c31932"

URI_x86_64_v2_ksystemlog = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ksystemlog-25.12.3-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ksystemlog;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ksystemlog}"
SRC_URI[x86_64_v2_ksystemlog.sha256sum] = "e61e1acc07de2b54325f94422ecae6b2c3da5f8777dd8d0e29fa91b7381b535a"

URI_aarch64_ksystemlog = "${EPEL_MIRROR}/aarch64/Packages/k/ksystemlog-25.12.3-1.el10_2.aarch64.rpm;name=aarch64_ksystemlog;unpack=0"
SRC_URI:append = " ${URI_aarch64_ksystemlog}"
SRC_URI[aarch64_ksystemlog.sha256sum] = "19492f6a6cdd9d4dc7821b67e650e21ed57b81eabfed284e2cfc0c45479e8178"

RDEPENDS:ksystemlog = " \
 audit-libs \
 glibc \
 kf6-karchive \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-ki18n \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-ktextwidgets \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 systemd-libs \
 "
