# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "fapolicy-analyzer"
PV = "1.5.1"
PR = "1.el10_2"
PACKAGES = " \
 fapolicy-analyzer \
 fapolicy-analyzer-cli \
 fapolicy-analyzer-gui \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/fapolicy-analyzer-1.5.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4f77d644d4e5c96206eece035bd896be7a3e34c3381ff8aedcc4e986f24c3d63"

URI_aarch64_fapolicy-analyzer = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-1.5.1-1.el10_2.aarch64.rpm;name=aarch64_fapolicy-analyzer;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer}"
SRC_URI[aarch64_fapolicy-analyzer.sha256sum] = "0e2cfda10b9d726af9084b01d6a7b39da38cdc33398b36090870465dd80f1302"

URI_aarch64_fapolicy-analyzer-cli = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-cli-1.5.1-1.el10_2.aarch64.rpm;name=aarch64_fapolicy-analyzer-cli;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer-cli}"
SRC_URI[aarch64_fapolicy-analyzer-cli.sha256sum] = "318dd46ed40cbd00ad45e2c698b1718b2111aa564af9297ed4945004a7a26f14"

URI_aarch64_fapolicy-analyzer-gui = "${EPEL_MIRROR}/aarch64/Packages/f/fapolicy-analyzer-gui-1.5.1-1.el10_2.aarch64.rpm;name=aarch64_fapolicy-analyzer-gui;unpack=0"
SRC_URI:append = " ${URI_aarch64_fapolicy-analyzer-gui}"
SRC_URI[aarch64_fapolicy-analyzer-gui.sha256sum] = "6a29f63a66420051ff191c74a9e904e3e3656298b2b49c36790f25563a4c5972"

RDEPENDS:fapolicy-analyzer = " \
 fapolicy-analyzer-cli \
 fapolicy-analyzer-gui \
 "
RDEPENDS:fapolicy-analyzer-cli = " \
 audit-libs \
 dbus-libs \
 glibc \
 libgcc \
 lmdb-libs \
 "
RDEPENDS:fapolicy-analyzer-gui = " \
 audit-libs \
 bash \
 dbus-libs \
 glibc \
 gnome-icon-theme \
 gtk3 \
 gtksourceview3 \
 libgcc \
 lmdb-libs \
 mesa-dri-drivers \
 python3 \
 python3-configargparse \
 python3-gobject \
 python3-matplotlib \
 python3-more-itertools \
 python3-rx \
 python3-tomli \
 webkit2gtk4.1 \
 "
