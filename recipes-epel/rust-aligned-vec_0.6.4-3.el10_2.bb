# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-aligned-vec"
PV = "0.6.4"
PR = "3.el10_2"
PACKAGES = " \
 rust-aligned-vec+default-devel \
 rust-aligned-vec+serde-devel \
 rust-aligned-vec+std-devel \
 rust-aligned-vec-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-aligned-vec-0.6.4-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4198a90854360108674859736a59027fad1d1f13b12b8228f2127570796cd84e"

URI_x86_64_v2_rust-aligned-vec+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec+default-devel-0.6.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec+default-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec+default-devel.sha256sum] = "0580cca8ba34efddaf3435fbd83ac1c3ccd292ac9e14541a0f5805ddbdf8e17e"

URI_x86_64_v2_rust-aligned-vec+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec+serde-devel-0.6.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec+serde-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec+serde-devel.sha256sum] = "2f72d5c6ee9a5ca23767f7bc1aed1d5f3ccdcd4f02a6582258565f4b106451bc"

URI_x86_64_v2_rust-aligned-vec+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec+std-devel-0.6.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec+std-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec+std-devel.sha256sum] = "faaabbc92fd32e1e245bb2d0657aaf5075530aba328e037b836797092a38b688"

URI_x86_64_v2_rust-aligned-vec-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-aligned-vec-devel-0.6.4-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-aligned-vec-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-aligned-vec-devel}"
SRC_URI[x86_64_v2_rust-aligned-vec-devel.sha256sum] = "524c4b2a8d035c5b08e4f6c0651af20ef8a853d7e27b2b32d46dc79f717d70f3"

URI_aarch64_rust-aligned-vec+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec+default-devel-0.6.4-3.el10_2.noarch.rpm;name=aarch64_rust-aligned-vec+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec+default-devel}"
SRC_URI[aarch64_rust-aligned-vec+default-devel.sha256sum] = "b590e53f7b03da44dde46dd97008553e04728c705d0d6181e89e17e8d8c95cee"

URI_aarch64_rust-aligned-vec+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec+serde-devel-0.6.4-3.el10_2.noarch.rpm;name=aarch64_rust-aligned-vec+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec+serde-devel}"
SRC_URI[aarch64_rust-aligned-vec+serde-devel.sha256sum] = "35ac32277ddc03cbf3525905a69578d96c4ed683a49c3e4c1687fa3f7fc1b060"

URI_aarch64_rust-aligned-vec+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec+std-devel-0.6.4-3.el10_2.noarch.rpm;name=aarch64_rust-aligned-vec+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec+std-devel}"
SRC_URI[aarch64_rust-aligned-vec+std-devel.sha256sum] = "9aa877aa5c702544890297452f18c357679ccd38c876e33bd155f4d903c75c2d"

URI_aarch64_rust-aligned-vec-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-aligned-vec-devel-0.6.4-3.el10_2.noarch.rpm;name=aarch64_rust-aligned-vec-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-aligned-vec-devel}"
SRC_URI[aarch64_rust-aligned-vec-devel.sha256sum] = "0b3d200318d9c9ac75fe3f1f1281a12e9585bdd2f3994b33e5d2b473a4ef2386"

RDEPENDS:rust-aligned-vec+default-devel = " \
 cargo \
 rust-aligned-vec+std-devel \
 rust-aligned-vec-devel \
 "
RDEPENDS:rust-aligned-vec+serde-devel = " \
 cargo \
 rust-aligned-vec-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-aligned-vec+std-devel = " \
 cargo \
 rust-aligned-vec-devel \
 "
RDEPENDS:rust-aligned-vec-devel = " \
 cargo \
 rust-equator+default-devel \
 "
