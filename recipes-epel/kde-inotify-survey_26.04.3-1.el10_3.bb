# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-inotify-survey"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kde-inotify-survey \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-inotify-survey-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a380372265864c5b4cfff86a9919c3e61a1d9741de3ac2d05d0b4c5406bebbc3"

URI_x86_64_v2_kde-inotify-survey = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-inotify-survey-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-inotify-survey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-inotify-survey}"
SRC_URI[x86_64_v2_kde-inotify-survey.sha256sum] = "2e1fcb644426dd0d0dbe92bf06354901dffc0da58b89e3fc9d8f4a3cb5e7f556"

URI_aarch64_kde-inotify-survey = "${EPEL_MIRROR}/aarch64/Packages/k/kde-inotify-survey-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kde-inotify-survey;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-inotify-survey}"
SRC_URI[aarch64_kde-inotify-survey.sha256sum] = "47fc961b41d68ac2618995ae0ccc2339bebab8c776873c05aadbd93e02a3568b"

RDEPENDS:kde-inotify-survey = " \
 dbus-common \
 glibc \
 kf6-kauth \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kded \
 kf6-ki18n \
 kf6-knotifications \
 libstdc++ \
 polkit \
 qt6-qtbase \
 "
