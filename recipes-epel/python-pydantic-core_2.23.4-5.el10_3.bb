# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pydantic-core"
PV = "2.23.4"
PR = "5.el10_3"
PACKAGES = " \
 python3-pydantic-core \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pydantic-core-2.23.4-5.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3c6678924379dc8411836f50a9749014b8a2ac4b13d99bcdd5f040741d2ddd7d"

URI_x86_64_v2_python3-pydantic-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pydantic-core-2.23.4-5.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-pydantic-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pydantic-core}"
SRC_URI[x86_64_v2_python3-pydantic-core.sha256sum] = "13229e0fbe27c66fa93cb616f0fa708f4e8f8512c43a9f13078531bc021d4c25"

URI_aarch64_python3-pydantic-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pydantic-core-2.23.4-5.el10_3.aarch64.rpm;name=aarch64_python3-pydantic-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pydantic-core}"
SRC_URI[aarch64_python3-pydantic-core.sha256sum] = "f1d655d713031d605848400b7b23b0d615dfff39854224a49435719f308ec442"

RDEPENDS:python3-pydantic-core = " \
 glibc \
 libgcc \
 python3 \
 python3-typing-extensions \
 "
