# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Params-ValidationCompiler"
PV = "0.31"
PR = "1.el10_0"
PACKAGES = " \
 perl-Params-ValidationCompiler \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Params-ValidationCompiler-0.31-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "904dd0a4048894e8140291562a8d5cd2c797e1b5770ed8e89b3f5f99d5b17dbb"

URI_x86_64_v2_perl-Params-ValidationCompiler = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Params-ValidationCompiler-0.31-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Params-ValidationCompiler;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Params-ValidationCompiler}"
SRC_URI[x86_64_v2_perl-Params-ValidationCompiler.sha256sum] = "efbe425c2dfdd8c7e0f22eb6ba3af80af32b455095580fd12368489c85dc0564"

URI_aarch64_perl-Params-ValidationCompiler = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Params-ValidationCompiler-0.31-1.el10_0.noarch.rpm;name=aarch64_perl-Params-ValidationCompiler;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Params-ValidationCompiler}"
SRC_URI[aarch64_perl-Params-ValidationCompiler.sha256sum] = "ff6cc8adc0d59d92b76ae4734db07ad74b229fc898493c4075d8b73e7576a355"

RDEPENDS:perl-Params-ValidationCompiler = " \
 perl-B \
 perl-Carp \
 perl-Eval-Closure \
 perl-Exception-Class \
 perl-Exporter \
 perl-Params-ValidationCompiler \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-overload \
 "
