# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-frozendict"
PV = "2.4.6"
PR = "6.el10_1"
PACKAGES = " \
 python3-frozendict \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-frozendict-2.4.6-6.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3f2f6384c4750c2fafc41b2838b82a57ecaff8cd3be1473a3438bde17519fee"

URI_x86_64_v2_python3-frozendict = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-frozendict-2.4.6-6.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-frozendict;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-frozendict}"
SRC_URI[x86_64_v2_python3-frozendict.sha256sum] = "3ba3f26941639413413e34cc14ab680e1dbc0d196786ee54b3e582141e161bbb"

URI_aarch64_python3-frozendict = "${EPEL_MIRROR}/aarch64/Packages/p/python3-frozendict-2.4.6-6.el10_1.noarch.rpm;name=aarch64_python3-frozendict;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-frozendict}"
SRC_URI[aarch64_python3-frozendict.sha256sum] = "25e8c87fb9621df4a37505a91243734f851f89a2cb392b1bb9123577b63ac6ca"

RDEPENDS:python3-frozendict = " \
 python3 \
 "
