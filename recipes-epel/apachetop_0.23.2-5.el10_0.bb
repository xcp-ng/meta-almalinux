# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "apachetop"
PV = "0.23.2"
PR = "5.el10_0"
PACKAGES = " \
 apachetop \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/apachetop-0.23.2-5.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "0d7fa6d63d3e2392960697fc73bda34b511bd1961699e29fcaffdf5d67cab636"

URI_x86_64_v2_apachetop = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/apachetop-0.23.2-5.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_apachetop;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_apachetop}"
SRC_URI[x86_64_v2_apachetop.sha256sum] = "727b989bc2269d63ac96c344d878805304f5ec588529a5206b77b689b5a22b68"

URI_aarch64_apachetop = "${EPEL_MIRROR}/aarch64/Packages/a/apachetop-0.23.2-5.el10_0.aarch64.rpm;name=aarch64_apachetop;unpack=0"
SRC_URI:append = " ${URI_aarch64_apachetop}"
SRC_URI[aarch64_apachetop.sha256sum] = "9cef557df0b10336e6cd2b6b07b094ec3ca78fb13e9f5567b16d0f5672ed57c3"

RDEPENDS:apachetop = " \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 pcre2 \
 readline \
 "
