# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libnvme"
PV = "1.16.1"
PR = "3.el10_2"
PACKAGES = " \
 libnvme \
 libnvme-devel \
 python3-libnvme \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libnvme-1.16.1-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b7c5efe7e2dbe658ce85825ebc6a78a9f6d509c1e117abdc05fdc519e3a75271"

URI_x86_64_v2_libnvme = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libnvme-1.16.1-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_libnvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnvme}"
SRC_URI[x86_64_v2_libnvme.sha256sum] = "81794ee471522b733ab665f40b42b17172fe1dd00966ddeff444f033ae0b0bcf"

URI_x86_64_v2_libnvme-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libnvme-devel-1.16.1-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_libnvme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libnvme-devel}"
SRC_URI[x86_64_v2_libnvme-devel.sha256sum] = "a3ff687c1702eeccd8efef8e60c7f00f4ddb8373d10f7bd6d330a8208add5436"

URI_x86_64_v2_python3-libnvme = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-libnvme-1.16.1-3.el10_2.x86_64_v2.rpm;name=x86_64_v2_python3-libnvme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-libnvme}"
SRC_URI[x86_64_v2_python3-libnvme.sha256sum] = "a29695fd44aa7a895c3a38b64335ebc31b7ef9b699a6a2428793a02ecf77406f"

URI_aarch64_libnvme = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libnvme-1.16.1-3.el10_2.aarch64.rpm;name=aarch64_libnvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnvme}"
SRC_URI[aarch64_libnvme.sha256sum] = "d076e22a361ca4735a4426f6d7f5245350d2de2ed4132f48057a8f85b1a6bf7d"

URI_aarch64_libnvme-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libnvme-devel-1.16.1-3.el10_2.aarch64.rpm;name=aarch64_libnvme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libnvme-devel}"
SRC_URI[aarch64_libnvme-devel.sha256sum] = "413022588b60ae14d9d8d7ac6fd157dc0613ea193316e75a7fc37a910d3b2a23"

URI_aarch64_python3-libnvme = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-libnvme-1.16.1-3.el10_2.aarch64.rpm;name=aarch64_python3-libnvme;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-libnvme}"
SRC_URI[aarch64_python3-libnvme.sha256sum] = "825c2c627e4dbffb10af33da8e4c2c50b40ddd183c00666cde5d04c81bbba4a5"

RDEPENDS:libnvme = " \
 dbus-libs \
 glibc \
 json-c \
 keyutils-libs \
 libgcc \
 openssl-libs \
 "
RDEPENDS:libnvme-devel = " \
 dbus-devel \
 json-c-devel \
 keyutils-libs-devel \
 libnvme \
 openssl-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:python3-libnvme = " \
 glibc \
 libnvme \
 python3 \
 "
