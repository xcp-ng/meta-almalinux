# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-ipuz"
PV = "1.0"
PR = "1.el10_3"
PACKAGES = " \
 python-ipuz-doc \
 python3-ipuz \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-ipuz-1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "450cec86eadbd589c2762113e6db900bef4f1c7a04977337c0500af034f03359"

URI_x86_64_v2_python-ipuz-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-ipuz-doc-1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-ipuz-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-ipuz-doc}"
SRC_URI[x86_64_v2_python-ipuz-doc.sha256sum] = "fd2b4a23f102158a77621a37be4650dea0dcebbcc58d204e3de8ab6063bcae04"

URI_x86_64_v2_python3-ipuz = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-ipuz-1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-ipuz;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-ipuz}"
SRC_URI[x86_64_v2_python3-ipuz.sha256sum] = "5f1f3a3c821c9ec16235b8e52a1437953e13eeb580b163f1a18fd01c7c4ea97c"

URI_aarch64_python-ipuz-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-ipuz-doc-1.0-1.el10_3.noarch.rpm;name=aarch64_python-ipuz-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-ipuz-doc}"
SRC_URI[aarch64_python-ipuz-doc.sha256sum] = "e1dee61994401479b1f987350d28cab45c8541c27d760851eb68232a709c561d"

URI_aarch64_python3-ipuz = "${EPEL_MIRROR}/aarch64/Packages/p/python3-ipuz-1.0-1.el10_3.noarch.rpm;name=aarch64_python3-ipuz;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-ipuz}"
SRC_URI[aarch64_python3-ipuz.sha256sum] = "edbfc9b248deb27ac2c9ded77ae29702add2b4336b42eaea6204c849dda1194b"

RDEPENDS:python-ipuz-doc = " \
 "
RDEPENDS:python3-ipuz = " \
 python3 \
 "
