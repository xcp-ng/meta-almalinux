# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rcssmin"
PV = "1.2.2"
PR = "1.el10_0"
PACKAGES = " \
 python3-rcssmin \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rcssmin-1.2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "6bd7cc0e321328f085afa92eeb7b6b839427d052f3fb9556a377f3d360c857c7"

URI_x86_64_v2_python3-rcssmin = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rcssmin-1.2.2-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-rcssmin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rcssmin}"
SRC_URI[x86_64_v2_python3-rcssmin.sha256sum] = "b64f3452418847ae593163b15ba2b10c6957a6630e0378884919161a37720007"

URI_aarch64_python3-rcssmin = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rcssmin-1.2.2-1.el10_0.aarch64.rpm;name=aarch64_python3-rcssmin;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rcssmin}"
SRC_URI[aarch64_python3-rcssmin.sha256sum] = "e7d080ac28bfa0c55581d71be4add3111a7de7891d805ba3ca201c9ce147e0d4"

RDEPENDS:python3-rcssmin = " \
 glibc \
 python3 \
 "
