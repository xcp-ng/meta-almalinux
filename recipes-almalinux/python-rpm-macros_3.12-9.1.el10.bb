# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rpm-macros"
PV = "3.12"
PR = "9.1.el10"
PACKAGES = " \
 python-rpm-macros \
 python-srpm-macros \
 python3-rpm-macros \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-rpm-macros-3.12-9.1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c1d4405ee652b8fe4e79848895d58af8733753c4370222a22984adc1267d9fc3"

URI_x86_64_v2_python-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-rpm-macros-3.12-9.1.el10.noarch.rpm;name=x86_64_v2_python-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-rpm-macros}"
SRC_URI[x86_64_v2_python-rpm-macros.sha256sum] = "59267287dfd846d1b24763250f0a0ededcf17020a20837b5c2f41943c1bb5c53"

URI_x86_64_v2_python-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python-srpm-macros-3.12-9.1.el10.noarch.rpm;name=x86_64_v2_python-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-srpm-macros}"
SRC_URI[x86_64_v2_python-srpm-macros.sha256sum] = "d75a2cbf30f4f7c5b29c63db56c4e6189b19cadf878f606dc6e6d864c358356f"

URI_x86_64_v2_python3-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-rpm-macros-3.12-9.1.el10.noarch.rpm;name=x86_64_v2_python3-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rpm-macros}"
SRC_URI[x86_64_v2_python3-rpm-macros.sha256sum] = "ac250f9118daa3a735e704037d7dae5cc85c3db566480616a7547d5389dd0296"

URI_aarch64_python-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-rpm-macros-3.12-9.1.el10.noarch.rpm;name=aarch64_python-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-rpm-macros}"
SRC_URI[aarch64_python-rpm-macros.sha256sum] = "59267287dfd846d1b24763250f0a0ededcf17020a20837b5c2f41943c1bb5c53"

URI_aarch64_python-srpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python-srpm-macros-3.12-9.1.el10.noarch.rpm;name=aarch64_python-srpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-srpm-macros}"
SRC_URI[aarch64_python-srpm-macros.sha256sum] = "d75a2cbf30f4f7c5b29c63db56c4e6189b19cadf878f606dc6e6d864c358356f"

URI_aarch64_python3-rpm-macros = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-rpm-macros-3.12-9.1.el10.noarch.rpm;name=aarch64_python3-rpm-macros;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rpm-macros}"
SRC_URI[aarch64_python3-rpm-macros.sha256sum] = "ac250f9118daa3a735e704037d7dae5cc85c3db566480616a7547d5389dd0296"

RDEPENDS:python-rpm-macros = " \
 python-srpm-macros \
 "
RDEPENDS:python-srpm-macros = " \
 bash \
 redhat-rpm-config \
 "
RDEPENDS:python3-rpm-macros = " \
 python-rpm-macros \
 python-srpm-macros \
 "
