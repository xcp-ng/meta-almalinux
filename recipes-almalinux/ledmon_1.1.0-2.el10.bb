# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ledmon"
PV = "1.1.0"
PR = "2.el10"
PACKAGES = " \
 ledmon \
 ledmon-devel \
 ledmon-libs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/ledmon-1.1.0-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cfd5b517eb9dac0492664cdd3dc667b7c26fe4cc94346fd1808c7d40ffa4e1c"

URI_x86_64_v2_ledmon = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/ledmon-1.1.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ledmon;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ledmon}"
SRC_URI[x86_64_v2_ledmon.sha256sum] = "23dff2c7e932ec34f52983bb1c0206948311a4ffc17c99f2f486e3154991d3eb"

URI_x86_64_v2_ledmon-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/ledmon-devel-1.1.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ledmon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ledmon-devel}"
SRC_URI[x86_64_v2_ledmon-devel.sha256sum] = "c6bfb1804d8c0504f302a9593925bbade2d78a4bcd57db93957c3e77aa200d1d"

URI_x86_64_v2_ledmon-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/ledmon-libs-1.1.0-2.el10.x86_64_v2.rpm;name=x86_64_v2_ledmon-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ledmon-libs}"
SRC_URI[x86_64_v2_ledmon-libs.sha256sum] = "04d4b0cd2bd2aeb1eee0798a3af1829b2e5a45e12cc78a33d17881c2f5554211"

URI_aarch64_ledmon = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/ledmon-1.1.0-2.el10.aarch64.rpm;name=aarch64_ledmon;unpack=0"
SRC_URI:append = " ${URI_aarch64_ledmon}"
SRC_URI[aarch64_ledmon.sha256sum] = "cba628957e9c3dcd54023b49f1ac4f87420c211658c475bd3ae689ecc5a483f8"

URI_aarch64_ledmon-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/ledmon-devel-1.1.0-2.el10.aarch64.rpm;name=aarch64_ledmon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ledmon-devel}"
SRC_URI[aarch64_ledmon-devel.sha256sum] = "09364d29499c038c18731857d3553c71e358c567eda9581090672577953dd264"

URI_aarch64_ledmon-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/ledmon-libs-1.1.0-2.el10.aarch64.rpm;name=aarch64_ledmon-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_ledmon-libs}"
SRC_URI[aarch64_ledmon-libs.sha256sum] = "6d1435822993eeab125a7b238eb54db7229ba02efc9b938bc81326a81761b130"

RDEPENDS:ledmon = " \
 bash \
 glibc \
 pciutils-libs \
 sg3_utils-libs \
 systemd-libs \
 "
RDEPENDS:ledmon-devel = " \
 ledmon-libs \
 pciutils-devel \
 pkgconf-pkg-config \
 sg3_utils-devel \
 "
RDEPENDS:ledmon-libs = " \
 glibc \
 pciutils-libs \
 sg3_utils-libs \
 "
