# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Parse-PMFile"
PV = "0.45"
PR = "3.el10"
PACKAGES = " \
 perl-Parse-PMFile \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Parse-PMFile-0.45-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b423fb8b6c810434df2c71eae037a972a1f8f15fbf82270dcaea52c34d4014c"

URI_x86_64_v2_perl-Parse-PMFile = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Parse-PMFile-0.45-3.el10.noarch.rpm;name=x86_64_v2_perl-Parse-PMFile;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Parse-PMFile}"
SRC_URI[x86_64_v2_perl-Parse-PMFile.sha256sum] = "6c3b2c6ea39e16137e23940fa8ae25181d3fbeb32f27a2f75b0a26a23a9c89af"

URI_aarch64_perl-Parse-PMFile = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Parse-PMFile-0.45-3.el10.noarch.rpm;name=aarch64_perl-Parse-PMFile;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Parse-PMFile}"
SRC_URI[aarch64_perl-Parse-PMFile.sha256sum] = "6c3b2c6ea39e16137e23940fa8ae25181d3fbeb32f27a2f75b0a26a23a9c89af"

RDEPENDS:perl-Parse-PMFile = " \
 perl-Dumpvalue \
 perl-JSON-PP \
 perl-PathTools \
 perl-Safe \
 perl-libs \
 perl-version \
 "
