# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtquickcontrols2"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtquickcontrols2 \
 qt5-qtquickcontrols2-devel \
 qt5-qtquickcontrols2-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtquickcontrols2-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "03e3dcd6aeb6aaddb491cdc81a624d9fb36f0cb3f7575cc4d536c1307ea5b398"

URI_x86_64_v2_qt5-qtquickcontrols2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2.sha256sum] = "4793170fb5fe016d08b0966232940ea6f6ea5afb28ee9440ef6967ad70567d05"

URI_x86_64_v2_qt5-qtquickcontrols2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-devel-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2-devel}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2-devel.sha256sum] = "e9c601f7d54899590f12a7949d73eb7743c110c265af1996e660f696a96a9bbd"

URI_x86_64_v2_qt5-qtquickcontrols2-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtquickcontrols2-examples-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtquickcontrols2-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtquickcontrols2-examples}"
SRC_URI[x86_64_v2_qt5-qtquickcontrols2-examples.sha256sum] = "875b97fa70943e921d49039f539d8689ea3964979ec067137b5e50b96a63c46f"

URI_aarch64_qt5-qtquickcontrols2 = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtquickcontrols2;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2}"
SRC_URI[aarch64_qt5-qtquickcontrols2.sha256sum] = "4612558181ba20fbcc4d3b486e04e368b8ff8ad44ae54f124310e58d62126f28"

URI_aarch64_qt5-qtquickcontrols2-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-devel-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtquickcontrols2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2-devel}"
SRC_URI[aarch64_qt5-qtquickcontrols2-devel.sha256sum] = "b197665857e4df66325a051fdd90dc601fba3d41e4129eda89b9ab32fa479eac"

URI_aarch64_qt5-qtquickcontrols2-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtquickcontrols2-examples-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtquickcontrols2-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtquickcontrols2-examples}"
SRC_URI[aarch64_qt5-qtquickcontrols2-examples.sha256sum] = "b0cc154595ab6d19713b2bf200d76d743708318234fd51b0b766de0fa7d2e7b6"

RDEPENDS:qt5-qtquickcontrols2 = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtgraphicaleffects \
 "
RDEPENDS:qt5-qtquickcontrols2-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtquickcontrols2 \
 "
RDEPENDS:qt5-qtquickcontrols2-examples = " \
 glibc \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtquickcontrols2 \
 "
