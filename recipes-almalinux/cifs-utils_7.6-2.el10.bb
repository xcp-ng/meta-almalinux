# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cifs-utils"
PV = "7.6"
PR = "2.el10"
PACKAGES = " \
 cifs-utils \
 cifs-utils-devel \
 pam_cifscreds \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/cifs-utils-7.6-2.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8b2522c9c24d3787a3833b0a72c69328cdca2cd424a09afa7885988280170ce4"

URI_x86_64_v2_cifs-utils = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/cifs-utils-7.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_cifs-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cifs-utils}"
SRC_URI[x86_64_v2_cifs-utils.sha256sum] = "72a91bc717c73b14fa4e25810ab83be9a5afc347d9f25f1b850a3854d0d844f1"

URI_x86_64_v2_cifs-utils-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/cifs-utils-devel-7.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_cifs-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_cifs-utils-devel}"
SRC_URI[x86_64_v2_cifs-utils-devel.sha256sum] = "56e3ef974d58cb385290d9610a5216d805c9c4060a752863bed0675e15e9cbdf"

URI_x86_64_v2_pam_cifscreds = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/pam_cifscreds-7.6-2.el10.x86_64_v2.rpm;name=x86_64_v2_pam_cifscreds;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_pam_cifscreds}"
SRC_URI[x86_64_v2_pam_cifscreds.sha256sum] = "7565b4f0b59679556e3f1f39235ca97b647e56687842994e5fb4251d00406fbb"

URI_aarch64_cifs-utils = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/cifs-utils-7.6-2.el10.aarch64.rpm;name=aarch64_cifs-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_cifs-utils}"
SRC_URI[aarch64_cifs-utils.sha256sum] = "730bc8b5d5c1c03750d588474ef2b9e63b342464ddf107b305a6f622fdd45b86"

URI_aarch64_cifs-utils-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/cifs-utils-devel-7.6-2.el10.aarch64.rpm;name=aarch64_cifs-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_cifs-utils-devel}"
SRC_URI[aarch64_cifs-utils-devel.sha256sum] = "e6637473a0d6f94779b188ab7a9d4328045eaccd09c67df9efa491d24dd94b03"

URI_aarch64_pam_cifscreds = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/pam_cifscreds-7.6-2.el10.aarch64.rpm;name=aarch64_pam_cifscreds;unpack=0"
SRC_URI:append = " ${URI_aarch64_pam_cifscreds}"
SRC_URI[aarch64_pam_cifscreds.sha256sum] = "5ef019d9ad1ee0bb62e8fa010696d1bd6646360e23f3796a23b954c06b3443b7"

RDEPENDS:cifs-utils = " \
 alternatives \
 bash \
 glibc \
 keyutils \
 keyutils-libs \
 krb5-libs \
 libcap-ng \
 libtalloc \
 libwbclient \
 "
RDEPENDS:cifs-utils-devel = " \
 "
RDEPENDS:pam_cifscreds = " \
 glibc \
 keyutils-libs \
 libtalloc \
 pam-libs \
 "
