# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tomcat9"
PE = "1"
PV = "9.0.120"
PR = "1.el10.alma.1"
PACKAGES = " \
 tomcat9 \
 tomcat9-admin-webapps \
 tomcat9-docs-webapp \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-lib \
 tomcat9-servlet-4.0-api \
 tomcat9-webapps \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tomcat9-9.0.120-1.el10.alma.1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "664597e27a1add4ca5d842a5ea5271f77c1e069dcf67d55b8a42820bd022a4eb"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-9.0.120-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9;unpack=0"
SRC_URI[x86_64_v2_tomcat9.sha256sum] = "ea02e37dbe7191aec749503e2392de8ac4f9b47b5a03faac1e051c4140cd0538"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-admin-webapps-9.0.120-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-admin-webapps;unpack=0"
SRC_URI[x86_64_v2_tomcat9-admin-webapps.sha256sum] = "8c30c92d53d51e1e85f580ffdafe2d2da612201d4b1f67cc2c2124f99df14009"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-docs-webapp-9.0.120-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-docs-webapp;unpack=0"
SRC_URI[x86_64_v2_tomcat9-docs-webapp.sha256sum] = "e50fb65f1c75fdb741c6cd261edeafc1cf1d02233c1424528e9809725f804492"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-el-3.0-api-9.0.120-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-el-3.0-api;unpack=0"
SRC_URI[x86_64_v2_tomcat9-el-3.0-api.sha256sum] = "fa415be58ed0eb055020af1a588a73c60505aa58e32f9dd8942be9bf8964bf3f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-jsp-2.3-api-9.0.120-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI[x86_64_v2_tomcat9-jsp-2.3-api.sha256sum] = "9dc75afec430acdcfcca54d525d85ccf25474cd21b7f7fd96cfe5ff6acecd113"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-lib-9.0.120-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-lib;unpack=0"
SRC_URI[x86_64_v2_tomcat9-lib.sha256sum] = "b432b2d1dbac37a0f7a89d8ba33aa41ce45f7c9ec0ce3b8b47cae98d45d2739c"
RPROVIDES:tomcat9-lib:append:x86_64_v2 = " virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-juli_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-servlet-4.0-api-9.0.120-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI[x86_64_v2_tomcat9-servlet-4.0-api.sha256sum] = "bb2e7a3b218c4e076fd2c6b02e4908e777a27b67dc0334cd591abe72dcbb9d31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/tomcat9-webapps-9.0.120-1.el10.alma.1.noarch.rpm;name=x86_64_v2_tomcat9-webapps;unpack=0"
SRC_URI[x86_64_v2_tomcat9-webapps.sha256sum] = "b50067bdc8cdbded8684d57845b6da78d506afe9ffb48f56f4f085c9eb28b5f2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-9.0.120-1.el10.alma.1.noarch.rpm;name=aarch64_tomcat9;unpack=0"
SRC_URI[aarch64_tomcat9.sha256sum] = "ea02e37dbe7191aec749503e2392de8ac4f9b47b5a03faac1e051c4140cd0538"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-admin-webapps-9.0.120-1.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-admin-webapps;unpack=0"
SRC_URI[aarch64_tomcat9-admin-webapps.sha256sum] = "8c30c92d53d51e1e85f580ffdafe2d2da612201d4b1f67cc2c2124f99df14009"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-docs-webapp-9.0.120-1.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-docs-webapp;unpack=0"
SRC_URI[aarch64_tomcat9-docs-webapp.sha256sum] = "e50fb65f1c75fdb741c6cd261edeafc1cf1d02233c1424528e9809725f804492"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-el-3.0-api-9.0.120-1.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-el-3.0-api;unpack=0"
SRC_URI[aarch64_tomcat9-el-3.0-api.sha256sum] = "fa415be58ed0eb055020af1a588a73c60505aa58e32f9dd8942be9bf8964bf3f"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-jsp-2.3-api-9.0.120-1.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-jsp-2.3-api;unpack=0"
SRC_URI[aarch64_tomcat9-jsp-2.3-api.sha256sum] = "9dc75afec430acdcfcca54d525d85ccf25474cd21b7f7fd96cfe5ff6acecd113"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-lib-9.0.120-1.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-lib;unpack=0"
SRC_URI[aarch64_tomcat9-lib.sha256sum] = "b432b2d1dbac37a0f7a89d8ba33aa41ce45f7c9ec0ce3b8b47cae98d45d2739c"
RPROVIDES:tomcat9-lib:append:aarch64 = " virtual/mvn_org.apache.tomcat_tomcat-catalina_ virtual/mvn_org.apache.tomcat_tomcat-coyote_ virtual/mvn_org.apache.tomcat_tomcat-juli_"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-servlet-4.0-api-9.0.120-1.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-servlet-4.0-api;unpack=0"
SRC_URI[aarch64_tomcat9-servlet-4.0-api.sha256sum] = "bb2e7a3b218c4e076fd2c6b02e4908e777a27b67dc0334cd591abe72dcbb9d31"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tomcat9-webapps-9.0.120-1.el10.alma.1.noarch.rpm;name=aarch64_tomcat9-webapps;unpack=0"
SRC_URI[aarch64_tomcat9-webapps.sha256sum] = "b50067bdc8cdbded8684d57845b6da78d506afe9ffb48f56f4f085c9eb28b5f2"

RDEPENDS:tomcat9 = " \
 bash \
 javapackages-tools \
 shadow-utils \
 systemd \
 tomcat9-lib \
 virtual/java-headless_or_java-25-headless \
 "
RDEPENDS:tomcat9-admin-webapps = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-docs-webapp = " \
 tomcat9 \
 "
RDEPENDS:tomcat9-el-3.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-jsp-2.3-api = " \
 bash \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-servlet-4.0-api \
 "
RDEPENDS:tomcat9-lib = " \
 ecj \
 javapackages-filesystem \
 tomcat9-el-3.0-api \
 tomcat9-jsp-2.3-api \
 tomcat9-servlet-4.0-api \
 virtual/coreutils \
 "
RDEPENDS:tomcat9-servlet-4.0-api = " \
 bash \
 javapackages-filesystem \
 "
RDEPENDS:tomcat9-webapps = " \
 tomcat9 \
 "
