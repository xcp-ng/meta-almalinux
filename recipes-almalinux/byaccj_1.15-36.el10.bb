# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "byaccj"
PV = "1.15"
PR = "36.el10"
PACKAGES = " \
 byaccj \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/CRB/Source/Packages/byaccj-1.15-36.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ab2fbb64d0edaa9466fa201d8a399826f510d8a2a04c89a24fd9180abf180b73"

URI_x86_64_v2_byaccj = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/byaccj-1.15-36.el10.x86_64_v2.rpm;name=x86_64_v2_byaccj;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_byaccj}"
SRC_URI[x86_64_v2_byaccj.sha256sum] = "7870f520e38b09b2ad779883a267e3eddda1c7c925c3359249c61eded76109c7"

URI_aarch64_byaccj = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/byaccj-1.15-36.el10.aarch64.rpm;name=aarch64_byaccj;unpack=0"
SRC_URI:append = " ${URI_aarch64_byaccj}"
SRC_URI[aarch64_byaccj.sha256sum] = "d2fc6701e7efa251017ba944b6f811837618df2301da18d60c0084688be2b781"

RDEPENDS:byaccj = " \
 glibc \
 "
