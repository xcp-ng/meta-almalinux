# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tar"
PE = "2"
PV = "1.35"
PR = "7.el10"
PACKAGES = " \
 tar \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/tar-1.35-7.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a679a366749308018ac1d97c254dd63cb97876bd09b37f9c11e4d53f1fbfbba6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tar-1.35-7.el10.x86_64_v2.rpm;name=x86_64_v2_tar;unpack=0"
SRC_URI[x86_64_v2_tar.sha256sum] = "9347545384c81359347d7d5ab5557d5a6f80b7a17d0dd5e55283fb5e26394599"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/tar-1.35-7.el10.aarch64.rpm;name=aarch64_tar;unpack=0"
SRC_URI[aarch64_tar.sha256sum] = "df6fdb46bf5deef8cd41e0cedde50a8274f8c5c5862faa401194f7eb380d75ab"

RDEPENDS:tar = " \
 glibc \
 libacl \
 libselinux \
 "
