# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nload"
PV = "0.7.4"
PR = "30.el10_1"
PACKAGES = " \
 nload \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/nload-0.7.4-30.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "58a387028a51824cec3c26daa219fe996ed329b0782e22e331e3987188b23785"

URI_x86_64_v2_nload = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/nload-0.7.4-30.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_nload;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nload}"
SRC_URI[x86_64_v2_nload.sha256sum] = "785f93e6ef821e6d3829e723f2a307fe4aaf671e2028e4d875b5aaef3b3b2041"

URI_aarch64_nload = "${EPEL_MIRROR}/aarch64/Packages/n/nload-0.7.4-30.el10_1.aarch64.rpm;name=aarch64_nload;unpack=0"
SRC_URI:append = " ${URI_aarch64_nload}"
SRC_URI[aarch64_nload.sha256sum] = "dfe487a2f5d5335e6b8ae260e0281f6f7bcfe339456ae4853c39f795d324b92f"

RDEPENDS:nload = " \
 glibc \
 libgcc \
 libstdc++ \
 ncurses-libs \
 "
