# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ddgr"
PV = "2.2"
PR = "1.el10_0"
PACKAGES = " \
 ddgr \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/d/ddgr-2.2-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a2c362cd1eaaa5cc28b708139662df916f07ef5d66e8e9486a4b9f9017a9b492"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ddgr-2.2-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ddgr;unpack=0"
SRC_URI[x86_64_v2_ddgr.sha256sum] = "37fa474ca444a9a4e9af2471101ba2cd854fc1d975b85f2f05635ade0a68d915"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/d/ddgr-2.2-1.el10_0.noarch.rpm;name=aarch64_ddgr;unpack=0"
SRC_URI[aarch64_ddgr.sha256sum] = "5ff83dd27c794223e9a45481a83c01301e7561a3fc3567485b0305f1cf75f6bf"

RDEPENDS:ddgr = " \
 python3 \
 "
