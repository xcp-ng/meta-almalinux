# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-dbus-client-gen"
PV = "0.5.1"
PR = "8.el10"
PACKAGES = " \
 python3-dbus-client-gen \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/python-dbus-client-gen-0.5.1-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "863fd5c4bdb251a1175ab5dc0b806031c1f7210523ab47c00ca084f700c690cd"

URI_x86_64_v2_python3-dbus-client-gen = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/python3-dbus-client-gen-0.5.1-8.el10.noarch.rpm;name=x86_64_v2_python3-dbus-client-gen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-dbus-client-gen}"
SRC_URI[x86_64_v2_python3-dbus-client-gen.sha256sum] = "b552453131e8f3cd5d8aed7299bffff7c08719a40a4178df5bce55411998e2ea"

URI_aarch64_python3-dbus-client-gen = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/python3-dbus-client-gen-0.5.1-8.el10.noarch.rpm;name=aarch64_python3-dbus-client-gen;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-dbus-client-gen}"
SRC_URI[aarch64_python3-dbus-client-gen.sha256sum] = "b552453131e8f3cd5d8aed7299bffff7c08719a40a4178df5bce55411998e2ea"

RDEPENDS:python3-dbus-client-gen = " \
 python3 \
 "
