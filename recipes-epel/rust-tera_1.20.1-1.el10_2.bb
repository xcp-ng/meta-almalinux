# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tera"
PV = "1.20.1"
PR = "1.el10_2"
PACKAGES = " \
 rust-tera+builtins-devel \
 rust-tera+chrono-devel \
 rust-tera+chrono-tz-devel \
 rust-tera+date-locale-devel \
 rust-tera+default-devel \
 rust-tera+humansize-devel \
 rust-tera+percent-encoding-devel \
 rust-tera+preserve_order-devel \
 rust-tera+rand-devel \
 rust-tera+slug-devel \
 rust-tera+urlencode-devel \
 rust-tera-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tera-1.20.1-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e703080a8890967d5cce73f57268ba362b16836ff5e1df5162caf947f7cddc65"

URI_x86_64_v2_rust-tera+builtins-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+builtins-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+builtins-devel}"
SRC_URI[x86_64_v2_rust-tera+builtins-devel.sha256sum] = "953a4703da76273746ba42b0b2f0865513af952575545ff394c8207ba6c6352f"

URI_x86_64_v2_rust-tera+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+chrono-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+chrono-devel}"
SRC_URI[x86_64_v2_rust-tera+chrono-devel.sha256sum] = "01105b3254518e895d2ca63b39b8f577c2c13927b28aa895a48f850d6fd10653"

URI_x86_64_v2_rust-tera+chrono-tz-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+chrono-tz-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+chrono-tz-devel}"
SRC_URI[x86_64_v2_rust-tera+chrono-tz-devel.sha256sum] = "15744e5d2eb69b189c947023bcf902481b592c4ede1d562a4a7a38919876d705"

URI_x86_64_v2_rust-tera+date-locale-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+date-locale-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+date-locale-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+date-locale-devel}"
SRC_URI[x86_64_v2_rust-tera+date-locale-devel.sha256sum] = "f2703916d618d0c4498aa9b16e23d7bed3b195ecab4190d1e0e307a274339c23"

URI_x86_64_v2_rust-tera+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+default-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+default-devel}"
SRC_URI[x86_64_v2_rust-tera+default-devel.sha256sum] = "18da7c75cf3b06605edf395e0b841608dd0450de5002ae269e0737f60e005a31"

URI_x86_64_v2_rust-tera+humansize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+humansize-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+humansize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+humansize-devel}"
SRC_URI[x86_64_v2_rust-tera+humansize-devel.sha256sum] = "ce146c7bad042d5f85dbdb3329453a457647320378a5cf0188d766e39b5e4296"

URI_x86_64_v2_rust-tera+percent-encoding-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+percent-encoding-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+percent-encoding-devel}"
SRC_URI[x86_64_v2_rust-tera+percent-encoding-devel.sha256sum] = "d919c5a824d2e9e915bdf9302680883aebb8d3deff5fa87b4877ea643f972dfe"

URI_x86_64_v2_rust-tera+preserve_order-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+preserve_order-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+preserve_order-devel}"
SRC_URI[x86_64_v2_rust-tera+preserve_order-devel.sha256sum] = "b1b28d491360f61f0681f24d7acd321932d74aa22239f8e3c31307a7824b09c7"

URI_x86_64_v2_rust-tera+rand-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+rand-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+rand-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+rand-devel}"
SRC_URI[x86_64_v2_rust-tera+rand-devel.sha256sum] = "b60cc8400c204fd10d788918e5a98a4a3522a6b063a62e78726369411f42c3eb"

URI_x86_64_v2_rust-tera+slug-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+slug-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+slug-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+slug-devel}"
SRC_URI[x86_64_v2_rust-tera+slug-devel.sha256sum] = "1e4df14d18b52676d7c7051c6d29ec32d6b0cc49b4b5aee444a9658ad02f75c4"

URI_x86_64_v2_rust-tera+urlencode-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera+urlencode-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera+urlencode-devel}"
SRC_URI[x86_64_v2_rust-tera+urlencode-devel.sha256sum] = "60d4eb1b39a03ec1aac103b680839d4a55d6176e2b0736e6764a445f14832d75"

URI_x86_64_v2_rust-tera-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tera-devel-1.20.1-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tera-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tera-devel}"
SRC_URI[x86_64_v2_rust-tera-devel.sha256sum] = "8f23ce9fdd1fe64e3bb83d2646ec618beab8aa5ca5d3b4353b8b650b41f6b45f"

URI_aarch64_rust-tera+builtins-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+builtins-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+builtins-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+builtins-devel}"
SRC_URI[aarch64_rust-tera+builtins-devel.sha256sum] = "76666b206bdc6e155732874265b4f68ea3b27c563bb4a0d378ed5e7988cb5098"

URI_aarch64_rust-tera+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+chrono-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+chrono-devel}"
SRC_URI[aarch64_rust-tera+chrono-devel.sha256sum] = "5c4c4157048fa57ded780e4d5ae5329d03b878289eb4d375056b0fcb5c44a4c9"

URI_aarch64_rust-tera+chrono-tz-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+chrono-tz-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+chrono-tz-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+chrono-tz-devel}"
SRC_URI[aarch64_rust-tera+chrono-tz-devel.sha256sum] = "d0ad35c3b8e9899941528b4f37cbdff9bc7f96f86721aaf28eb81b5cda3be2ac"

URI_aarch64_rust-tera+date-locale-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+date-locale-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+date-locale-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+date-locale-devel}"
SRC_URI[aarch64_rust-tera+date-locale-devel.sha256sum] = "14a19bd82aa8434db64fa36c50a8748ba4f06634c683f0e641b4582ad085499d"

URI_aarch64_rust-tera+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+default-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+default-devel}"
SRC_URI[aarch64_rust-tera+default-devel.sha256sum] = "44fe7ca1df8d2dd81a925cb13a7482d6f54208f6d8e23b79c4f02617a6d242af"

URI_aarch64_rust-tera+humansize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+humansize-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+humansize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+humansize-devel}"
SRC_URI[aarch64_rust-tera+humansize-devel.sha256sum] = "85ecb1b95d00bcfed5594c504736680905ed3005f6d73aa84ea4d690bf6b9fe3"

URI_aarch64_rust-tera+percent-encoding-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+percent-encoding-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+percent-encoding-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+percent-encoding-devel}"
SRC_URI[aarch64_rust-tera+percent-encoding-devel.sha256sum] = "f95a63f6a0d3070e0f5118646e4ece6d94cae93f3b646adc715a07b80e0e514e"

URI_aarch64_rust-tera+preserve_order-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+preserve_order-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+preserve_order-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+preserve_order-devel}"
SRC_URI[aarch64_rust-tera+preserve_order-devel.sha256sum] = "95923037e6c8e376b3d39c76e054994d9975b7e90aef4b9fa195b6f2404a4775"

URI_aarch64_rust-tera+rand-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+rand-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+rand-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+rand-devel}"
SRC_URI[aarch64_rust-tera+rand-devel.sha256sum] = "2fbcaacb8aac29b49974389a47caf8f017e5b7b35963ce7a7fdd28415e366d94"

URI_aarch64_rust-tera+slug-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+slug-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+slug-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+slug-devel}"
SRC_URI[aarch64_rust-tera+slug-devel.sha256sum] = "2f75099e9ab165cd4b81082c66a49835ea5b8ad9586ea380aac9b883a07d1d97"

URI_aarch64_rust-tera+urlencode-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera+urlencode-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera+urlencode-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera+urlencode-devel}"
SRC_URI[aarch64_rust-tera+urlencode-devel.sha256sum] = "801274875cce9df3c59e7882902f3cbc88b2cbe7151827baaadb952f2661a787"

URI_aarch64_rust-tera-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tera-devel-1.20.1-1.el10_2.noarch.rpm;name=aarch64_rust-tera-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tera-devel}"
SRC_URI[aarch64_rust-tera-devel.sha256sum] = "2632e637bf97fc8f8ebb37820f5002a8f7e2a0755d98897e85fed623d64e9bfd"

RDEPENDS:rust-tera+builtins-devel = " \
 cargo \
 rust-tera+chrono-devel \
 rust-tera+chrono-tz-devel \
 rust-tera+humansize-devel \
 rust-tera+rand-devel \
 rust-tera+slug-devel \
 rust-tera+urlencode-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+chrono-tz-devel = " \
 cargo \
 rust-chrono-tz+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+date-locale-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono+unstable-locales-devel \
 rust-chrono-devel \
 rust-tera+builtins-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+default-devel = " \
 cargo \
 rust-tera+builtins-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+humansize-devel = " \
 cargo \
 rust-humansize+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+percent-encoding-devel = " \
 cargo \
 rust-percent-encoding+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+preserve_order-devel = " \
 cargo \
 rust-serde_json+preserve_order-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+rand-devel = " \
 cargo \
 rust-rand0.8+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+slug-devel = " \
 cargo \
 rust-slug+default-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera+urlencode-devel = " \
 cargo \
 rust-tera+percent-encoding-devel \
 rust-tera-devel \
 "
RDEPENDS:rust-tera-devel = " \
 cargo \
 rust \
 rust-globwalk+default-devel \
 rust-lazy_static+default-devel \
 rust-pest+default-devel \
 rust-pest_derive+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde_json+default-devel \
 rust-unicode-segmentation+default-devel \
 "
