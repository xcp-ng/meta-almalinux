# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-strict-rfc3339"
PV = "0.7"
PR = "16.el10_1"
PACKAGES = " \
 python3-strict-rfc3339 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-strict-rfc3339-0.7-16.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5c6fd98c5ca7f46e12e6dd8b3129bb33b90d207d5619a63d7a8779e76e3562c0"

URI_x86_64_v2_python3-strict-rfc3339 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-strict-rfc3339-0.7-16.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-strict-rfc3339;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-strict-rfc3339}"
SRC_URI[x86_64_v2_python3-strict-rfc3339.sha256sum] = "23c0c2f207e7b3f6e408fae5423381b264a54ed6c2ab1a8f064caac65a7fefe3"

URI_aarch64_python3-strict-rfc3339 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-strict-rfc3339-0.7-16.el10_1.noarch.rpm;name=aarch64_python3-strict-rfc3339;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-strict-rfc3339}"
SRC_URI[aarch64_python3-strict-rfc3339.sha256sum] = "f52ed0cbe2e29de9f9e7da557ff59861b6b1a8216147686e6a9dd758ef26f462"

RDEPENDS:python3-strict-rfc3339 = " \
 python3 \
 "
