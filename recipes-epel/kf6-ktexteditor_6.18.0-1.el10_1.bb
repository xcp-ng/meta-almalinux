# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-ktexteditor"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-ktexteditor \
 kf6-ktexteditor-devel \
 kf6-ktexteditor-doc \
 kf6-ktexteditor-html \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kf6-ktexteditor-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c12c79ffb8b3eab2a15046c27352726dee5033c63dd06d3c7b70ce3ccf082c58"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexteditor.sha256sum] = "5f967e7d53af46319d61265ade2f7e95e758d37e28b4e1f296f8e7810166795e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-ktexteditor-devel;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexteditor-devel.sha256sum] = "6536b9b11c5179776a9a40250f9e5c305e5e588d6a5a57202fb97a8cd02f9375"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexteditor-doc;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexteditor-doc.sha256sum] = "714473f2e99008aac54d47b2fb96d49c15783acd0be2fff5b2f73186061cadde"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-ktexteditor-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-ktexteditor-html;unpack=0"
SRC_URI[x86_64_v2_kf6-ktexteditor-html.sha256sum] = "039d819c279ee7ae6915c82933c0d2cb0d04f53f07e2c6f24fdad5ecfea726af"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-ktexteditor;unpack=0"
SRC_URI[aarch64_kf6-ktexteditor.sha256sum] = "f3e440d9c3bb7881a1cb0d46643e557dc53619c70dc7b2bc036f1cddba88aaaa"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-ktexteditor-devel;unpack=0"
SRC_URI[aarch64_kf6-ktexteditor-devel.sha256sum] = "af96a93a4c16cb861b41e40b8e872b955ff6c607a87703015160c8a7b9886055"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-ktexteditor-doc;unpack=0"
SRC_URI[aarch64_kf6-ktexteditor-doc.sha256sum] = "859c998a27a6ba5cbd7ca1b76a0e8c382f2a1ab11f157ec2c3692e9bad26a5bc"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kf6-ktexteditor-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-ktexteditor-html;unpack=0"
SRC_URI[aarch64_kf6-ktexteditor-html.sha256sum] = "dd7c9ba0751a90549e68374a0ed796bf352b6fb5470bee6b4fd7ba849390a3c4"

RDEPENDS:kf6-ktexteditor = " \
 editorconfig-libs \
 glibc \
 kf6-filesystem \
 kf6-karchive \
 kf6-kauth \
 kf6-kcodecs \
 kf6-kcolorscheme \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kguiaddons \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kitemviews \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-sonnet \
 kf6-syntax-highlighting \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtspeech \
 "
RDEPENDS:kf6-ktexteditor-devel = " \
 cmake-filesystem \
 kf6-kparts-devel \
 kf6-ktexteditor \
 kf6-syntax-highlighting-devel \
 "
RDEPENDS:kf6-ktexteditor-doc = " \
 "
RDEPENDS:kf6-ktexteditor-html = " \
 "
