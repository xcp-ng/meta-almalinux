# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "tpm2-tools"
PV = "5.7"
PR = "6.el10"
PACKAGES = " \
 tpm2-tools \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/tpm2-tools-5.7-6.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c65829420c29e8384a7bdb585825e5f5438323f22ab7cd0ccac3eb88feb18722"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/tpm2-tools-5.7-6.el10.x86_64_v2.rpm;name=x86_64_v2_tpm2-tools;unpack=0"
SRC_URI[x86_64_v2_tpm2-tools.sha256sum] = "711ac6146b6b47ed21614a9c97adfcb1c76be1587bcaa63d707b8f439a0fa934"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/tpm2-tools-5.7-6.el10.aarch64.rpm;name=aarch64_tpm2-tools;unpack=0"
SRC_URI[aarch64_tpm2-tools.sha256sum] = "2263da06c876f35c5f553e30c5d1a700c09ce7af7e09dd8f501b5edd01a8a213"

RDEPENDS:tpm2-tools = " \
 glibc \
 openssl-libs \
 tpm2-tss \
 tpm2-tss-fapi \
 virtual/libcurl.so.4___64bit_ \
 "
