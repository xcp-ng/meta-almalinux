# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-calculator"
PV = "46.3"
PR = "1.el10"
PACKAGES = " \
 gnome-calculator \
 gnome-calculator-devel \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/gnome-calculator-46.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "560f61d1c599eb33059f76f138f0c4405089bbd1e7489b9e4f2dc9562e74064b"

URI_x86_64_v2_gnome-calculator = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/gnome-calculator-46.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-calculator;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-calculator}"
SRC_URI[x86_64_v2_gnome-calculator.sha256sum] = "d7308432734b9a3c361b6b07059de8bcc3c93387da1047b29c24fc5c4291154e"

URI_x86_64_v2_gnome-calculator-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/gnome-calculator-devel-46.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_gnome-calculator-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-calculator-devel}"
SRC_URI[x86_64_v2_gnome-calculator-devel.sha256sum] = "487e7e71d963e7108bc0e2c211375399ca5a2da980d1aea293bf3c887cdf5076"

URI_aarch64_gnome-calculator = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/gnome-calculator-46.3-1.el10.aarch64.rpm;name=aarch64_gnome-calculator;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-calculator}"
SRC_URI[aarch64_gnome-calculator.sha256sum] = "c76f42db4ce0cf688c876879d04d2205c63f2753e9425d3c107c635952a47b25"

URI_aarch64_gnome-calculator-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/gnome-calculator-devel-46.3-1.el10.aarch64.rpm;name=aarch64_gnome-calculator-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-calculator-devel}"
SRC_URI[aarch64_gnome-calculator-devel.sha256sum] = "ecd7a8a7b3192fd76826c200c0b14181f79c5a4b37025ef313de31beab1e013f"

RDEPENDS:gnome-calculator = " \
 glib2 \
 glibc \
 gtk4 \
 gtksourceview5 \
 libadwaita \
 libgee \
 libmpc \
 libsoup3 \
 libxml2 \
 mpfr \
 "
RDEPENDS:gnome-calculator-devel = " \
 glib2-devel \
 gnome-calculator \
 gnome-calculator-devel \
 gtk4-devel \
 libgee-devel \
 pkgconf-pkg-config \
 "
