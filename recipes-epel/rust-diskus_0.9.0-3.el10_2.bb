# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-diskus"
PV = "0.9.0"
PR = "3.el10_2"
PACKAGES = " \
 diskus \
 rust-diskus+cli-devel \
 rust-diskus+default-devel \
 rust-diskus-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-diskus-0.9.0-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14e45462d47b7f4fd2a09653371ec5cf5693adf479a954ddcfa903a7d861200b"

URI_x86_64_v2_diskus = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/diskus-0.9.0-3.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_diskus;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_diskus}"
SRC_URI[x86_64_v2_diskus.sha256sum] = "83ef39c4f831041cbb656e22c52a72771e622ad25bd475dd0d1703b42d55f24c"

URI_x86_64_v2_rust-diskus+cli-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-diskus+cli-devel-0.9.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-diskus+cli-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-diskus+cli-devel}"
SRC_URI[x86_64_v2_rust-diskus+cli-devel.sha256sum] = "402f547201a3545532983c7c4a6bbd08c4a49d07d61cc4d3a2aa512687eac2d5"

URI_x86_64_v2_rust-diskus+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-diskus+default-devel-0.9.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-diskus+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-diskus+default-devel}"
SRC_URI[x86_64_v2_rust-diskus+default-devel.sha256sum] = "631b0baef8846142027d7e28cc19d21a8b9cb9a78351ff6ea2ad43073c7746d4"

URI_x86_64_v2_rust-diskus-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-diskus-devel-0.9.0-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-diskus-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-diskus-devel}"
SRC_URI[x86_64_v2_rust-diskus-devel.sha256sum] = "0933d81c428a1219d1ab404c10272a9e449a5558000696631bf8c4c8628af8f0"

URI_aarch64_diskus = "${EPEL_MIRROR}/aarch64/Packages/d/diskus-0.9.0-3.el10_2.aarch64.rpm;name=aarch64_diskus;unpack=0"
SRC_URI:append = " ${URI_aarch64_diskus}"
SRC_URI[aarch64_diskus.sha256sum] = "eafa6d26e58efa0302fdbd42a61c8ef4bfe541d3d5552ad8d735955f2d34fd23"

URI_aarch64_rust-diskus+cli-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-diskus+cli-devel-0.9.0-3.el10_2.noarch.rpm;name=aarch64_rust-diskus+cli-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-diskus+cli-devel}"
SRC_URI[aarch64_rust-diskus+cli-devel.sha256sum] = "f9343261f03e5076b4d232aa7148e7b8c07c5463596839530edb7e322ca6fb3b"

URI_aarch64_rust-diskus+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-diskus+default-devel-0.9.0-3.el10_2.noarch.rpm;name=aarch64_rust-diskus+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-diskus+default-devel}"
SRC_URI[aarch64_rust-diskus+default-devel.sha256sum] = "abd4db129e33d849dcc1be8fb1b7b8c6e811d153b6add2309d931389337d6876"

URI_aarch64_rust-diskus-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-diskus-devel-0.9.0-3.el10_2.noarch.rpm;name=aarch64_rust-diskus-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-diskus-devel}"
SRC_URI[aarch64_rust-diskus-devel.sha256sum] = "806e8dcd149154e2af7c2036e99adab86c58bb93955e16b33c2d879deca9a1c4"

RDEPENDS:diskus = " \
 glibc \
 libgcc \
 "
RDEPENDS:rust-diskus+cli-devel = " \
 cargo \
 rust-clap+color-devel \
 rust-clap+default-devel \
 rust-clap+suggestions-devel \
 rust-clap+wrap_help-devel \
 rust-diskus-devel \
 rust-humansize+default-devel \
 rust-num-format+default-devel \
 "
RDEPENDS:rust-diskus+default-devel = " \
 cargo \
 rust-diskus+cli-devel \
 rust-diskus-devel \
 "
RDEPENDS:rust-diskus-devel = " \
 cargo \
 rust \
 rust-crossbeam-channel+default-devel \
 rust-rayon+default-devel \
 "
