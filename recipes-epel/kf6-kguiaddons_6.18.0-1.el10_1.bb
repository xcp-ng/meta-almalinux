# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kguiaddons"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kguiaddons \
 kf6-kguiaddons-devel \
 kf6-kguiaddons-doc \
 kf6-kguiaddons-html \
 python3-kf6-kguiaddons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kguiaddons-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "64523c402f0059c244058c005c4a2d49eaaa8602d215cf4b44d8851f7e7707d2"

URI_x86_64_v2_kf6-kguiaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons}"
SRC_URI[x86_64_v2_kf6-kguiaddons.sha256sum] = "3909773b726abfc0a150f2b9b2846b3c8d7addd52bc4e8a5bb2c2733e58f3702"

URI_x86_64_v2_kf6-kguiaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kguiaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons-devel}"
SRC_URI[x86_64_v2_kf6-kguiaddons-devel.sha256sum] = "630839d112d790e1c83746e52ef82ce65e025cd64661eeb63a78ec7cf438267e"

URI_x86_64_v2_kf6-kguiaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kguiaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons-doc}"
SRC_URI[x86_64_v2_kf6-kguiaddons-doc.sha256sum] = "e56cdee0a0be3b47f9f2da823ecf564e492fe6e77fb087697759d435beb46c2a"

URI_x86_64_v2_kf6-kguiaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kguiaddons-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kguiaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kguiaddons-html}"
SRC_URI[x86_64_v2_kf6-kguiaddons-html.sha256sum] = "b2d9c327a8f65762bb0b1037f45d9cfaec23126535497f318d23430463592c17"

URI_x86_64_v2_python3-kf6-kguiaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kguiaddons-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kguiaddons}"
SRC_URI[x86_64_v2_python3-kf6-kguiaddons.sha256sum] = "be8bc459651d00b60f55cf0811b640ddbbf883f5b2e833c82e813e6604bdebb9"

URI_aarch64_kf6-kguiaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons}"
SRC_URI[aarch64_kf6-kguiaddons.sha256sum] = "e1a43d746c3ea64f4e83b48bcc35021ea53fdc32f6a253ee7886740e0701c818"

URI_aarch64_kf6-kguiaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kguiaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons-devel}"
SRC_URI[aarch64_kf6-kguiaddons-devel.sha256sum] = "2919a8633879d63fef84b7202174ae790e7d503e83073c72a8fb2c374718cd2d"

URI_aarch64_kf6-kguiaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kguiaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons-doc}"
SRC_URI[aarch64_kf6-kguiaddons-doc.sha256sum] = "f84f1256873dd45d77f8051826a0e98bb5d22c3a3fa055b49f01b22cf1f6ffbc"

URI_aarch64_kf6-kguiaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kguiaddons-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kguiaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kguiaddons-html}"
SRC_URI[aarch64_kf6-kguiaddons-html.sha256sum] = "88f1e2912d1043b0b59b490c28bbebd8fde4df09d0a1269a413401244fd1ba3a"

URI_aarch64_python3-kf6-kguiaddons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kguiaddons-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_python3-kf6-kguiaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kguiaddons}"
SRC_URI[aarch64_python3-kf6-kguiaddons.sha256sum] = "46905604fd92b0233bdc475845422c4f7417c1cf94473bcdc3515cab46626f7e"

RDEPENDS:kf6-kguiaddons = " \
 glibc \
 kf6-filesystem \
 libX11 \
 libstdc++ \
 libwayland-client \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtwayland \
 "
RDEPENDS:kf6-kguiaddons-devel = " \
 cmake-filesystem \
 kf6-kguiaddons \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kguiaddons-doc = " \
 "
RDEPENDS:kf6-kguiaddons-html = " \
 "
RDEPENDS:python3-kf6-kguiaddons = " \
 glibc \
 kf6-kguiaddons \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
