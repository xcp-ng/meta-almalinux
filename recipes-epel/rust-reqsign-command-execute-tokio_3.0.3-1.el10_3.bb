# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-reqsign-command-execute-tokio"
PV = "3.0.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-reqsign-command-execute-tokio+default-devel \
 rust-reqsign-command-execute-tokio-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-reqsign-command-execute-tokio-3.0.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "aa08a0f5ca0dacebf0741b3f72c2b5ff68436fb6c4241e9db98045cd852f65ab"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-command-execute-tokio+default-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-command-execute-tokio+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-command-execute-tokio+default-devel.sha256sum] = "a68d84a7ccdd68c5d3239a6ec2369c3f2788559792896706c6910510e61dc889"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-reqsign-command-execute-tokio-devel-3.0.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-reqsign-command-execute-tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-reqsign-command-execute-tokio-devel.sha256sum] = "4007d0cbc225fe45c9bbc54a7c152715fbed682172748c7644ea3b273c24a28d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-command-execute-tokio+default-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-command-execute-tokio+default-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-command-execute-tokio+default-devel.sha256sum] = "6434502c30174864333f235e4fe01dc638dd1a0242a8a7d0af78e27ddcff0306"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-reqsign-command-execute-tokio-devel-3.0.3-1.el10_3.noarch.rpm;name=aarch64_rust-reqsign-command-execute-tokio-devel;unpack=0"
SRC_URI[aarch64_rust-reqsign-command-execute-tokio-devel.sha256sum] = "2709d4feafa6533869858826e17e1ddaae9bbde50af5de80a639706895aff3c6"

RDEPENDS:rust-reqsign-command-execute-tokio+default-devel = " \
 cargo \
 rust-reqsign-command-execute-tokio-devel \
 "
RDEPENDS:rust-reqsign-command-execute-tokio-devel = " \
 cargo \
 rust \
 rust-reqsign-core+default-devel \
 rust-tokio+io-util-devel \
 rust-tokio+process-devel \
 rust-tokio-devel \
 "
