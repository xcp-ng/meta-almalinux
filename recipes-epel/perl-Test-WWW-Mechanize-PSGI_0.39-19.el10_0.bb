# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Test-WWW-Mechanize-PSGI"
PV = "0.39"
PR = "19.el10_0"
PACKAGES = " \
 perl-Test-WWW-Mechanize-PSGI \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Test-WWW-Mechanize-PSGI-0.39-19.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a9a2b09882671102dbe5d1f5c5a2092d28ceab347c04648ee200bc7f990c0090"

URI_x86_64_v2_perl-Test-WWW-Mechanize-PSGI = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Test-WWW-Mechanize-PSGI-0.39-19.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Test-WWW-Mechanize-PSGI;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Test-WWW-Mechanize-PSGI}"
SRC_URI[x86_64_v2_perl-Test-WWW-Mechanize-PSGI.sha256sum] = "254cad8e6663f9272618f5fae2e0a63afe7d06834449daf1bad801f6a4cbe967"

URI_aarch64_perl-Test-WWW-Mechanize-PSGI = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Test-WWW-Mechanize-PSGI-0.39-19.el10_0.noarch.rpm;name=aarch64_perl-Test-WWW-Mechanize-PSGI;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Test-WWW-Mechanize-PSGI}"
SRC_URI[aarch64_perl-Test-WWW-Mechanize-PSGI.sha256sum] = "fa12d652cbe30daf3f67a3f1cf651f0db6d63d4e1524a7da02c83d190deaea2b"

RDEPENDS:perl-Test-WWW-Mechanize-PSGI = " \
 perl-Carp \
 perl-Plack \
 perl-Test-WWW-Mechanize \
 perl-Try-Tiny \
 perl-base \
 perl-libs \
 "
