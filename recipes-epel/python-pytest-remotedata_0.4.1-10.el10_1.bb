# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pytest-remotedata"
PV = "0.4.1"
PR = "10.el10_1"
PACKAGES = " \
 python3-pytest-remotedata \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-pytest-remotedata-0.4.1-10.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7e0e34fa5874673dec0f358e49966d44ce897b8fef902bad86647ca192a41e65"

URI_x86_64_v2_python3-pytest-remotedata = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pytest-remotedata-0.4.1-10.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pytest-remotedata;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-pytest-remotedata}"
SRC_URI[x86_64_v2_python3-pytest-remotedata.sha256sum] = "5da435c0ad6db95214e2743c70040830248d1d009571a7567c7c3270e715614b"

URI_aarch64_python3-pytest-remotedata = "${EPEL_MIRROR}/aarch64/Packages/p/python3-pytest-remotedata-0.4.1-10.el10_1.noarch.rpm;name=aarch64_python3-pytest-remotedata;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-pytest-remotedata}"
SRC_URI[aarch64_python3-pytest-remotedata.sha256sum] = "a8347b43f394967b912a18b5820b53e68fff8d8a24fdb822ce1a0d252a011a99"

RDEPENDS:python3-pytest-remotedata = " \
 python3 \
 python3-packaging \
 python3-pytest \
 "
