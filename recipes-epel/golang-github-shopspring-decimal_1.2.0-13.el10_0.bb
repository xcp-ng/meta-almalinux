# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-shopspring-decimal"
PV = "1.2.0"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-shopspring-decimal-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-shopspring-decimal-1.2.0-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1fde6ef0a36a8dc1f691f709953e0e39ed9c4d8599717a108fe0cb13b429c3df"

URI_x86_64_v2_golang-github-shopspring-decimal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-shopspring-decimal-devel-1.2.0-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-shopspring-decimal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-shopspring-decimal-devel}"
SRC_URI[x86_64_v2_golang-github-shopspring-decimal-devel.sha256sum] = "085655e591a122ba5ae908db21a8ce1594724b8658c3affe80a6dada8dadbcde"

URI_aarch64_golang-github-shopspring-decimal-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-shopspring-decimal-devel-1.2.0-13.el10_0.noarch.rpm;name=aarch64_golang-github-shopspring-decimal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-shopspring-decimal-devel}"
SRC_URI[aarch64_golang-github-shopspring-decimal-devel.sha256sum] = "ca268da68e295c1956a954953dfb510086f2a39b5ab8e0a234e57ae5cd8c6098"

RDEPENDS:golang-github-shopspring-decimal-devel = " \
 go-filesystem \
 "
