# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libzpc"
PV = "1.4.1"
PR = "1.el10"
PACKAGES = " \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/libzpc-1.4.1-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c0c15534b3423921fc9ae535431ff5a65709993c8b8f0c9094f0be634cd8ff41"

