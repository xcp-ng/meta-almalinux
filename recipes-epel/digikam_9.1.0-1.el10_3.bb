# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "digikam"
PV = "9.1.0"
PR = "1.el10_3"
PACKAGES = " \
 digikam \
 digikam-devel \
 digikam-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/digikam-9.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "041114cf80538325a8ee889164816269d9ae028462208a559f780f57658141a8"

URI_x86_64_v2_digikam = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/digikam-9.1.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_digikam;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_digikam}"
SRC_URI[x86_64_v2_digikam.sha256sum] = "ebebea325b9cb8cb8593d42aaf91eb81c33400680bb9aeb8b544d10650fcee04"

URI_x86_64_v2_digikam-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/digikam-devel-9.1.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_digikam-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_digikam-devel}"
SRC_URI[x86_64_v2_digikam-devel.sha256sum] = "e233ef3cadc1bf7823592f701320b5356593b849051f2184f8d5cea77ba5b123"

URI_x86_64_v2_digikam-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/digikam-libs-9.1.0-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_digikam-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_digikam-libs}"
SRC_URI[x86_64_v2_digikam-libs.sha256sum] = "e9805cae3ac9f338a6d315ea94f7008e2e4e226c96248d181931872f6c936d64"

URI_aarch64_digikam = "${EPEL_MIRROR}/aarch64/Packages/d/digikam-9.1.0-1.el10_3.aarch64.rpm;name=aarch64_digikam;unpack=0"
SRC_URI:append = " ${URI_aarch64_digikam}"
SRC_URI[aarch64_digikam.sha256sum] = "51254616d1ef33639634f892ee074257f98ce3f12f85ad8f3ae1f0fe553fcac6"

URI_aarch64_digikam-devel = "${EPEL_MIRROR}/aarch64/Packages/d/digikam-devel-9.1.0-1.el10_3.aarch64.rpm;name=aarch64_digikam-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_digikam-devel}"
SRC_URI[aarch64_digikam-devel.sha256sum] = "0b98a5543b4276e51bb2e235255a7c8c78157b3e00aac8dd9214d939deba9bd6"

URI_aarch64_digikam-libs = "${EPEL_MIRROR}/aarch64/Packages/d/digikam-libs-9.1.0-1.el10_3.aarch64.rpm;name=aarch64_digikam-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_digikam-libs}"
SRC_URI[aarch64_digikam-libs.sha256sum] = "aa6fcf3e0bb4951f59485c884bbae4c1240667ec483b782bf77016bd4be8c798"

RDEPENDS:digikam = " \
 ImageMagick-c++ \
 bash \
 digikam-libs \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kxmlgui \
 libgcc \
 libstdc++ \
 perl-File-Path \
 perl-Getopt-Std \
 perl-PathTools \
 perl-interpreter \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:digikam-devel = " \
 cmake-filesystem \
 digikam-libs \
 "
RDEPENDS:digikam-libs = " \
 ImageMagick-c++ \
 ImageMagick-libs \
 exiv2-libs \
 expat \
 glib2 \
 glibc \
 jasper-libs \
 kf6-kcalendarcore \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kio-core-libs \
 kf6-kio-widgets-libs \
 kf6-knotifications \
 kf6-knotifyconfig \
 kf6-kservice \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 kf6-solid \
 kf6-sonnet \
 kf6-threadweaver \
 lcms2 \
 lensfun \
 libX11 \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libgcc \
 libglvnd-opengl \
 libgomp \
 libgphoto2 \
 libheif \
 libjpeg-turbo \
 libjxl \
 libksane \
 libpng \
 libstdc++ \
 libswscale-free \
 libtiff \
 libxml2 \
 libxslt \
 opencv-core \
 opencv-dnn \
 opencv-imgcodecs \
 opencv-imgproc \
 opencv-ml \
 opencv-objdetect \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtmultimedia \
 qt6-qtnetworkauth \
 qt6-qtscxml \
 qt6-qtsvg \
 qt6-qtwebengine \
 zlib-ng-compat \
 "
