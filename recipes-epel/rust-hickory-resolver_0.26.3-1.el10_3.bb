# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-hickory-resolver"
PV = "0.26.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-hickory-resolver+default-devel \
 rust-hickory-resolver+metrics-devel \
 rust-hickory-resolver+recursor-devel \
 rust-hickory-resolver+serde-devel \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+tokio-devel \
 rust-hickory-resolver+toml-devel \
 rust-hickory-resolver+webpki-roots-devel \
 rust-hickory-resolver-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-hickory-resolver-0.26.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "05a62cc6fac90ae2dabc30c8f20f02055fe264912540598dfc521c65a0d07164"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+default-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-resolver+default-devel.sha256sum] = "356cbcdfeed6749107065dfebf5faffad992c53607b79d20ac13510bd1552f4b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+metrics-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+metrics-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-resolver+metrics-devel.sha256sum] = "1f0d4c823e10b04e0458486d00747d596774c1b8259b87fdc36c543803da3bd0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+recursor-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+recursor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-resolver+recursor-devel.sha256sum] = "47daf8bf39a3ef08876477f647aa438c67a83d81f1436171fe989d2a5f69c328"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+serde-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-resolver+serde-devel.sha256sum] = "d0d7fba646f05ed425c4a1b0d32bdae21ab2a56bd2901fd46da6009f7fc92697"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+system-config-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-resolver+system-config-devel.sha256sum] = "d70d6fdb04d0cab50570cea9a5e4c17a7fa47c7789890325cd81e994e5970ee5"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+tokio-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-resolver+tokio-devel.sha256sum] = "4661ad2caca5e8857589219ae003d39d74373483c833479f019853a1c14a2fc0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+toml-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+toml-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-resolver+toml-devel.sha256sum] = "a7b3fb14cd360164e44fdd24c40198f01ea26034c33758c3aa6cbaa548296ff7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver+webpki-roots-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver+webpki-roots-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-resolver+webpki-roots-devel.sha256sum] = "70b4bc89fbc35dff41bde22ccfc39222b78ff0027f58f4022ddb68c2d3cdda94"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-hickory-resolver-devel-0.26.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-hickory-resolver-devel;unpack=0"
SRC_URI[x86_64_v2_rust-hickory-resolver-devel.sha256sum] = "b5e292d49546c8233cf3d4790a5b306aed0bc0824791da4a1e1f2639af9d4bc7"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+default-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+default-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-resolver+default-devel.sha256sum] = "750a040539ef6f08a80abee39e126af5fa1ca1c4dfe58755a624299fb7c8a651"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+metrics-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+metrics-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-resolver+metrics-devel.sha256sum] = "a6b9efdb5929d97e652770843368ffa08ae4aebcfdf09ff21ff3926da0d5da3a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+recursor-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+recursor-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-resolver+recursor-devel.sha256sum] = "350996a5125caabb1f018d57acdef4cd689c79027e2477d849b7ce07972254f4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+serde-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+serde-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-resolver+serde-devel.sha256sum] = "d2a370c2b9bdec4ac46c68aaa4295709b96943b243b79c8d9a4485d6c1b42072"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+system-config-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+system-config-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-resolver+system-config-devel.sha256sum] = "e4ff02883ea6c4f5ef36cbcde04a674c62f80a3fd98f337186cea1d7755e706d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+tokio-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+tokio-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-resolver+tokio-devel.sha256sum] = "dfc0a661d9a9ac75693e6a1543a115e636f4d84940db1bdfc45dc1961a545372"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+toml-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+toml-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-resolver+toml-devel.sha256sum] = "e20bcefc5eff5d35718991e7486c399bc4b09b46c9ea833acb89fe5858ef7248"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver+webpki-roots-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver+webpki-roots-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-resolver+webpki-roots-devel.sha256sum] = "6a78f3c3bb9720de2e35e42e0ba9238468ed9a98b5d9eab8eca545cb010efe76"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-hickory-resolver-devel-0.26.3-1.el10_3.noarch.rpm;name=aarch64_rust-hickory-resolver-devel;unpack=0"
SRC_URI[aarch64_rust-hickory-resolver-devel.sha256sum] = "d58506c22bad78facb6e56af606e049e34e30333f55b2048ef49e0568b1e19ae"

RDEPENDS:rust-hickory-resolver+default-devel = " \
 cargo \
 rust-hickory-resolver+system-config-devel \
 rust-hickory-resolver+tokio-devel \
 rust-hickory-resolver-devel \
 "
RDEPENDS:rust-hickory-resolver+metrics-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-metrics+default-devel \
 "
RDEPENDS:rust-hickory-resolver+recursor-devel = " \
 cargo \
 rust-async-recursion+default-devel \
 rust-hickory-resolver-devel \
 rust-lru-cache+default-devel \
 "
RDEPENDS:rust-hickory-resolver+serde-devel = " \
 cargo \
 rust-hickory-proto+serde-devel \
 rust-hickory-resolver-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 "
RDEPENDS:rust-hickory-resolver+system-config-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-resolv-conf+default-devel \
 rust-resolv-conf+system-devel \
 "
RDEPENDS:rust-hickory-resolver+tokio-devel = " \
 cargo \
 rust-hickory-net+tokio-devel \
 rust-hickory-resolver-devel \
 rust-tokio+default-devel \
 rust-tokio+rt-devel \
 "
RDEPENDS:rust-hickory-resolver+toml-devel = " \
 cargo \
 rust-hickory-resolver-devel \
 rust-toml+default-devel \
 "
RDEPENDS:rust-hickory-resolver+webpki-roots-devel = " \
 cargo \
 rust-hickory-net+webpki-roots-devel \
 rust-hickory-resolver-devel \
 rust-webpki-roots+default-devel \
 "
RDEPENDS:rust-hickory-resolver-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 rust-futures-util+std-devel \
 rust-futures-util-devel \
 rust-hickory-net-devel \
 rust-hickory-proto+access-control-devel \
 rust-hickory-proto+std-devel \
 rust-hickory-proto-devel \
 rust-ipnet+serde-devel \
 rust-ipnet-devel \
 rust-moka+default-devel \
 rust-moka+sync-devel \
 rust-once_cell+critical-section-devel \
 rust-once_cell-devel \
 rust-parking_lot+default-devel \
 rust-rand+alloc-devel \
 rust-rand-devel \
 rust-smallvec+default-devel \
 rust-thiserror-devel \
 rust-tracing-devel \
 "
