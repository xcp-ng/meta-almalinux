# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-TermReadKey"
PV = "2.38"
PR = "24.el10"
PACKAGES = " \
 perl-TermReadKey \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-TermReadKey-2.38-24.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "949d4f9ee3c24f92a7e6f1b73971f677db3f171f0fe700b58f5fe5aa58d5ed5a"

URI_x86_64_v2_perl-TermReadKey = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-TermReadKey-2.38-24.el10.x86_64_v2.rpm;name=x86_64_v2_perl-TermReadKey;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-TermReadKey}"
SRC_URI[x86_64_v2_perl-TermReadKey.sha256sum] = "19e473c79b303a8182316ca0f05e1bb65a847f867a9eacb207b9b87c96cd97d9"

URI_aarch64_perl-TermReadKey = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-TermReadKey-2.38-24.el10.aarch64.rpm;name=aarch64_perl-TermReadKey;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-TermReadKey}"
SRC_URI[aarch64_perl-TermReadKey.sha256sum] = "c83b244fc17525944d74d07627656e91790d938bf8030b7b47bd0b6b017760a2"

RDEPENDS:perl-TermReadKey = " \
 glibc \
 perl-DynaLoader \
 perl-Exporter \
 perl-libs \
 perl-vars \
 "
