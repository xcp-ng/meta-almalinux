# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "vim-nerdtree"
PV = "7.1.3"
PR = "2.el10_1"
PACKAGES = " \
 vim-nerdtree \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/v/vim-nerdtree-7.1.3-2.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bfbe2a03b31efb8074fad44d76346c944e7f1b16812313543527bf6773f41e47"

URI_x86_64_v2_vim-nerdtree = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/vim-nerdtree-7.1.3-2.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_vim-nerdtree;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_vim-nerdtree}"
SRC_URI[x86_64_v2_vim-nerdtree.sha256sum] = "2173e3f24d6a561a51d1fb65f715476278203664b7ef2681f9c5ccff49b3fa3c"

URI_aarch64_vim-nerdtree = "${EPEL_MIRROR}/aarch64/Packages/v/vim-nerdtree-7.1.3-2.el10_1.noarch.rpm;name=aarch64_vim-nerdtree;unpack=0"
SRC_URI:append = " ${URI_aarch64_vim-nerdtree}"
SRC_URI[aarch64_vim-nerdtree.sha256sum] = "7384e7a1bf80f3cf0cdcb16777212336f6fa52e4a83099f8606b1d2c8a690443"

RDEPENDS:vim-nerdtree = " \
 vim-common \
 vim-enhanced \
 "
