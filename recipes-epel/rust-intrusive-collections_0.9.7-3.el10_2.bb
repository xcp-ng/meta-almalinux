# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-intrusive-collections"
PV = "0.9.7"
PR = "3.el10_2"
PACKAGES = " \
 rust-intrusive-collections+alloc-devel \
 rust-intrusive-collections+default-devel \
 rust-intrusive-collections+nightly-devel \
 rust-intrusive-collections-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-intrusive-collections-0.9.7-3.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "53034367b3e872cc1c6ae5fc72f4b944287df13957375de89be8653bcc7e0e1e"

URI_x86_64_v2_rust-intrusive-collections+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intrusive-collections+alloc-devel-0.9.7-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intrusive-collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intrusive-collections+alloc-devel}"
SRC_URI[x86_64_v2_rust-intrusive-collections+alloc-devel.sha256sum] = "918abd69f69adadf7d7a5adad3273187cfe67eb06d595559f874e41aaad11774"

URI_x86_64_v2_rust-intrusive-collections+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intrusive-collections+default-devel-0.9.7-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intrusive-collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intrusive-collections+default-devel}"
SRC_URI[x86_64_v2_rust-intrusive-collections+default-devel.sha256sum] = "893bb71bb25b64654568faeeaa2d6a20f1232f4e625c88688c9280220478d94c"

URI_x86_64_v2_rust-intrusive-collections+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intrusive-collections+nightly-devel-0.9.7-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intrusive-collections+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intrusive-collections+nightly-devel}"
SRC_URI[x86_64_v2_rust-intrusive-collections+nightly-devel.sha256sum] = "38e9f29ecb4fb07a871e4ad0b437c2d0ea94fb53cd013955c506f3afe8d2f1ce"

URI_x86_64_v2_rust-intrusive-collections-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-intrusive-collections-devel-0.9.7-3.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-intrusive-collections-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-intrusive-collections-devel}"
SRC_URI[x86_64_v2_rust-intrusive-collections-devel.sha256sum] = "92ee2c54b92fd8e08975d5311ba707e3fa25b9707e9df03fcb90c8c27bc43646"

URI_aarch64_rust-intrusive-collections+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intrusive-collections+alloc-devel-0.9.7-3.el10_2.noarch.rpm;name=aarch64_rust-intrusive-collections+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intrusive-collections+alloc-devel}"
SRC_URI[aarch64_rust-intrusive-collections+alloc-devel.sha256sum] = "46be5dbb3dea2e4138e995dca87fb298e8da704527b4cb6d79992e0f0e64e942"

URI_aarch64_rust-intrusive-collections+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intrusive-collections+default-devel-0.9.7-3.el10_2.noarch.rpm;name=aarch64_rust-intrusive-collections+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intrusive-collections+default-devel}"
SRC_URI[aarch64_rust-intrusive-collections+default-devel.sha256sum] = "ad4f363c665d0d4924bc649d409c0fee8e0c16c7d4a460badecaac42f71db5c2"

URI_aarch64_rust-intrusive-collections+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intrusive-collections+nightly-devel-0.9.7-3.el10_2.noarch.rpm;name=aarch64_rust-intrusive-collections+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intrusive-collections+nightly-devel}"
SRC_URI[aarch64_rust-intrusive-collections+nightly-devel.sha256sum] = "4ac793d866a77143d2abe0240052383ec7936dacb5c91e54016f57ea8b4f4cab"

URI_aarch64_rust-intrusive-collections-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-intrusive-collections-devel-0.9.7-3.el10_2.noarch.rpm;name=aarch64_rust-intrusive-collections-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-intrusive-collections-devel}"
SRC_URI[aarch64_rust-intrusive-collections-devel.sha256sum] = "ececdcae9566e9e49be9a6e6fcea345189b79773491a6384a43b5b4f6c3bb20a"

RDEPENDS:rust-intrusive-collections+alloc-devel = " \
 cargo \
 rust-intrusive-collections-devel \
 "
RDEPENDS:rust-intrusive-collections+default-devel = " \
 cargo \
 rust-intrusive-collections+alloc-devel \
 rust-intrusive-collections-devel \
 "
RDEPENDS:rust-intrusive-collections+nightly-devel = " \
 cargo \
 rust-intrusive-collections-devel \
 "
RDEPENDS:rust-intrusive-collections-devel = " \
 cargo \
 rust-memoffset+default-devel \
 "
