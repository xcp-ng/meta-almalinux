# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-pkcs1"
PV = "0.7.5"
PR = "5.el10_2"
PACKAGES = " \
 rust-pkcs1+alloc-devel \
 rust-pkcs1+default-devel \
 rust-pkcs1+pem-devel \
 rust-pkcs1+pkcs8-devel \
 rust-pkcs1+std-devel \
 rust-pkcs1+zeroize-devel \
 rust-pkcs1-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-pkcs1-0.7.5-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ac437c6b75518c059400cbae36ac46abc30ed53a02b5287df1d4a76fb27e6a9"

URI_x86_64_v2_rust-pkcs1+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+alloc-devel-0.7.5-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+alloc-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+alloc-devel.sha256sum] = "9b832ea967a4188cd86eb656832f3c19aa001be60926aa3c10ce190bd124dae9"

URI_x86_64_v2_rust-pkcs1+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+default-devel-0.7.5-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+default-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+default-devel.sha256sum] = "38321cbc131ec422cbf48a9fcaf78400c55a1a1cb6b6c4901b6e3796a74f88f2"

URI_x86_64_v2_rust-pkcs1+pem-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+pem-devel-0.7.5-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+pem-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+pem-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+pem-devel.sha256sum] = "de757fb91cc0aa5ef7dee2a40765c113e535544371af8ab4c2060b6d144767f1"

URI_x86_64_v2_rust-pkcs1+pkcs8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+pkcs8-devel-0.7.5-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+pkcs8-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+pkcs8-devel.sha256sum] = "ee28c021bff2a83af67b36439473e0d6ce284d8c1d37486d0334e07c1c5e4730"

URI_x86_64_v2_rust-pkcs1+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+std-devel-0.7.5-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+std-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+std-devel.sha256sum] = "08d36d5f4383d7ee7c3da2e10604de1419a09e76c1d36e6c2c0c1c4eb9ed0f7d"

URI_x86_64_v2_rust-pkcs1+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1+zeroize-devel-0.7.5-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1+zeroize-devel}"
SRC_URI[x86_64_v2_rust-pkcs1+zeroize-devel.sha256sum] = "e4ae08c59df9cbc688256fe27adb169f38f75653c4f6e991bfe16736729281e8"

URI_x86_64_v2_rust-pkcs1-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-pkcs1-devel-0.7.5-5.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-pkcs1-devel}"
SRC_URI[x86_64_v2_rust-pkcs1-devel.sha256sum] = "72e595edee4b08975459732c869c65dc84cd5f155ec2e22cc24d6f22760ca371"

URI_aarch64_rust-pkcs1+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+alloc-devel-0.7.5-5.el10_2.noarch.rpm;name=aarch64_rust-pkcs1+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+alloc-devel}"
SRC_URI[aarch64_rust-pkcs1+alloc-devel.sha256sum] = "a214afeb5c0b6713ec2117246674ed7b1622ea9d197154b0f4aeec832338aeb5"

URI_aarch64_rust-pkcs1+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+default-devel-0.7.5-5.el10_2.noarch.rpm;name=aarch64_rust-pkcs1+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+default-devel}"
SRC_URI[aarch64_rust-pkcs1+default-devel.sha256sum] = "da05aae091e5aae4ade0742f833acb026c655ae2087edeec9e320b0311c44cb6"

URI_aarch64_rust-pkcs1+pem-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+pem-devel-0.7.5-5.el10_2.noarch.rpm;name=aarch64_rust-pkcs1+pem-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+pem-devel}"
SRC_URI[aarch64_rust-pkcs1+pem-devel.sha256sum] = "a7b27dff2c0d071e47949c12618ec4125cd2538b4e884a5326127767bd2de773"

URI_aarch64_rust-pkcs1+pkcs8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+pkcs8-devel-0.7.5-5.el10_2.noarch.rpm;name=aarch64_rust-pkcs1+pkcs8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+pkcs8-devel}"
SRC_URI[aarch64_rust-pkcs1+pkcs8-devel.sha256sum] = "8373c551daa72acf91035eddea5c62b384f49dfa1a043428cca30ac88312ac06"

URI_aarch64_rust-pkcs1+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+std-devel-0.7.5-5.el10_2.noarch.rpm;name=aarch64_rust-pkcs1+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+std-devel}"
SRC_URI[aarch64_rust-pkcs1+std-devel.sha256sum] = "bdf16a72b9ddd04113ccc82a852fa3f48127ed7508b883d10b4344ebbb3241ab"

URI_aarch64_rust-pkcs1+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1+zeroize-devel-0.7.5-5.el10_2.noarch.rpm;name=aarch64_rust-pkcs1+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1+zeroize-devel}"
SRC_URI[aarch64_rust-pkcs1+zeroize-devel.sha256sum] = "05066750ffbd92116898b2ccd7201d62d950184fee45866e336ed72d67acd39d"

URI_aarch64_rust-pkcs1-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-pkcs1-devel-0.7.5-5.el10_2.noarch.rpm;name=aarch64_rust-pkcs1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-pkcs1-devel}"
SRC_URI[aarch64_rust-pkcs1-devel.sha256sum] = "f975cef5d8c1d49baac5f254f2f2826013a6d7247c40352d5528915f53a3f7c1"

RDEPENDS:rust-pkcs1+alloc-devel = " \
 cargo \
 rust-der+alloc-devel \
 rust-pkcs1+zeroize-devel \
 rust-pkcs1-devel \
 rust-pkcs8+alloc-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs1+default-devel = " \
 cargo \
 rust-pkcs1-devel \
 "
RDEPENDS:rust-pkcs1+pem-devel = " \
 cargo \
 rust-der+pem-devel \
 rust-pkcs1+alloc-devel \
 rust-pkcs1-devel \
 rust-pkcs8+pem-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs1+pkcs8-devel = " \
 cargo \
 rust-pkcs1-devel \
 rust-pkcs8-devel \
 "
RDEPENDS:rust-pkcs1+std-devel = " \
 cargo \
 rust-der+std-devel \
 rust-pkcs1+alloc-devel \
 rust-pkcs1-devel \
 "
RDEPENDS:rust-pkcs1+zeroize-devel = " \
 cargo \
 rust-der+zeroize-devel \
 rust-pkcs1-devel \
 "
RDEPENDS:rust-pkcs1-devel = " \
 cargo \
 rust \
 rust-der+default-devel \
 rust-der+oid-devel \
 rust-spki+default-devel \
 "
