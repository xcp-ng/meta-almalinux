# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyghmi"
PV = "1.6.16"
PR = "2.el10_2"
PACKAGES = " \
 python-pyghmi-doc \
 python3-pyghmi \
 python3-pyghmi-tests \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pyghmi-1.6.16-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d14e04679f50759f485a6d1a5aa6f7f094b0dd088fc1cb2bb24177e5acf62ef0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pyghmi-doc-1.6.16-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-pyghmi-doc;unpack=0"
SRC_URI[x86_64_v2_python-pyghmi-doc.sha256sum] = "d1456a196b661ff01e8fa4e512a871c27d1f0bc123a96fa37b8c4e97ab5261a7"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyghmi-1.6.16-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyghmi;unpack=0"
SRC_URI[x86_64_v2_python3-pyghmi.sha256sum] = "836a8c1a1d98d9c6aebfcd10fe1d259f2e4d6155b9a4d534f9c1fd59dcba4b8a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyghmi-tests-1.6.16-2.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyghmi-tests;unpack=0"
SRC_URI[x86_64_v2_python3-pyghmi-tests.sha256sum] = "abffc1cd56d5eba83a10e0b9f0882ee252e47c5cf08d4d6280fce4dfe63047ca"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-pyghmi-doc-1.6.16-2.el10_2.noarch.rpm;name=aarch64_python-pyghmi-doc;unpack=0"
SRC_URI[aarch64_python-pyghmi-doc.sha256sum] = "6f40787fbad404df42a2ed8248814c7063143514456130323c372bf89b495717"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pyghmi-1.6.16-2.el10_2.noarch.rpm;name=aarch64_python3-pyghmi;unpack=0"
SRC_URI[aarch64_python3-pyghmi.sha256sum] = "87b90f76f489c4f010aa4524df4ba9ce4e14f1a7e20af70fb31ea2e7425a7500"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pyghmi-tests-1.6.16-2.el10_2.noarch.rpm;name=aarch64_python3-pyghmi-tests;unpack=0"
SRC_URI[aarch64_python3-pyghmi-tests.sha256sum] = "ff01a708c5fb85909aa629dc80a78f5a883525ef52be7a4b3d59435a48ef2144"

RDEPENDS:python-pyghmi-doc = " \
 "
RDEPENDS:python3-pyghmi = " \
 python3 \
 python3-cryptography \
 python3-dateutil \
 "
RDEPENDS:python3-pyghmi-tests = " \
 python3 \
 python3-pyghmi \
 "
