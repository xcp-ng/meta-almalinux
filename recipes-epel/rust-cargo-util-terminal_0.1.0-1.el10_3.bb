# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cargo-util-terminal"
PV = "0.1.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-cargo-util-terminal+default-devel \
 rust-cargo-util-terminal-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-cargo-util-terminal-0.1.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "82c2848d565b66715419bfcd65c27c565a96fdefd516152dc874cafe3b564e25"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-terminal+default-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-terminal+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-util-terminal+default-devel.sha256sum] = "bf04dabfa99c7d1584f261bcf689ea52c6b122e545f6b98c9be9027290524cdd"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cargo-util-terminal-devel-0.1.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cargo-util-terminal-devel;unpack=0"
SRC_URI[x86_64_v2_rust-cargo-util-terminal-devel.sha256sum] = "b35154a814071c44f8df1f0dce3c7c094a92f7e95b6a2aa2da7f9494ffc1b55a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-terminal+default-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util-terminal+default-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-util-terminal+default-devel.sha256sum] = "254ee09a7e18f1784510e8be3adb2f4e42674952b543fee54a153fc52e9d5590"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-cargo-util-terminal-devel-0.1.0-1.el10_3.noarch.rpm;name=aarch64_rust-cargo-util-terminal-devel;unpack=0"
SRC_URI[aarch64_rust-cargo-util-terminal-devel.sha256sum] = "bd5c239331e35cda3b5a9cd777174dce7d296e77efee318f218360f8e7d127ba"

RDEPENDS:rust-cargo-util-terminal+default-devel = " \
 cargo \
 rust-cargo-util-terminal-devel \
 "
RDEPENDS:rust-cargo-util-terminal-devel = " \
 cargo \
 rust \
 rust-annotate-snippets+default-devel \
 rust-annotate-snippets+simd-devel \
 rust-anstream+default-devel \
 rust-anstyle+default-devel \
 rust-anstyle-hyperlink+default-devel \
 rust-anstyle-hyperlink+file-devel \
 rust-anstyle-progress+default-devel \
 rust-anyhow+default-devel \
 rust-libc+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-serde_json+raw_value-devel \
 rust-supports-hyperlinks+default-devel \
 rust-supports-unicode+default-devel \
 "
