# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "airinv"
PV = "1.00.12"
PR = "1.el10_2"
PACKAGES = " \
 airinv \
 airinv-devel \
 airinv-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/a/airinv-1.00.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a353cc664ac4a24740f7036531b1ec634854c70c291a17898d52f043e2f90414"

URI_x86_64_v2_airinv = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/airinv-1.00.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_airinv;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_airinv}"
SRC_URI[x86_64_v2_airinv.sha256sum] = "ea298d508cf1a8aaf4c6af558a62049892340fc8ffddbfb6261b02ec1db17f8c"

URI_x86_64_v2_airinv-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/airinv-devel-1.00.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_airinv-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_airinv-devel}"
SRC_URI[x86_64_v2_airinv-devel.sha256sum] = "3f229ffd411ca00e4687069edf328455fc53552232da239cbdae17d0762936c9"

URI_x86_64_v2_airinv-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/airinv-doc-1.00.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_airinv-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_airinv-doc}"
SRC_URI[x86_64_v2_airinv-doc.sha256sum] = "57b78252a2c48e3a586e658b51da93ddcb82179ee3bdb18b28f79f6ef3e6cd77"

URI_aarch64_airinv = "${EPEL_MIRROR}/aarch64/Packages/a/airinv-1.00.12-1.el10_2.aarch64.rpm;name=aarch64_airinv;unpack=0"
SRC_URI:append = " ${URI_aarch64_airinv}"
SRC_URI[aarch64_airinv.sha256sum] = "005ad8fc7f0d3058f600b03525aa1dce5debd09529c9d7d9ffa6c1028ffd35d2"

URI_aarch64_airinv-devel = "${EPEL_MIRROR}/aarch64/Packages/a/airinv-devel-1.00.12-1.el10_2.aarch64.rpm;name=aarch64_airinv-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_airinv-devel}"
SRC_URI[aarch64_airinv-devel.sha256sum] = "574e7ded3b334e4100666f754fc6c4d360cdf3679bdd34e8918a891abc03e659"

URI_aarch64_airinv-doc = "${EPEL_MIRROR}/aarch64/Packages/a/airinv-doc-1.00.12-1.el10_2.noarch.rpm;name=aarch64_airinv-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_airinv-doc}"
SRC_URI[aarch64_airinv-doc.sha256sum] = "b2b05f59662a6dcc47865edf4cfbe213d839929ef61c5cc6a85f461f7a22bb1d"

RDEPENDS:airinv = " \
 airrac \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 rmol \
 sevmgr \
 stdair \
 zeromq \
 "
RDEPENDS:airinv-devel = " \
 airinv \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 "
RDEPENDS:airinv-doc = " \
 "
