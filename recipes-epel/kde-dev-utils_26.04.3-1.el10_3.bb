# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kde-dev-utils"
PV = "26.04.3"
PR = "1.el10_3"
PACKAGES = " \
 kde-dev-utils \
 kde-dev-utils-common \
 kpartloader \
 kuiviewer \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kde-dev-utils-26.04.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd4ed30624e260e64616b28ab102664339f832e2c737ad706990cb44e30a6f72"

URI_x86_64_v2_kde-dev-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kde-dev-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-utils}"
SRC_URI[x86_64_v2_kde-dev-utils.sha256sum] = "cc83dedeaab628395e67a9304e58a4fd71b1f5be16842340dfb5b6561d837111"

URI_x86_64_v2_kde-dev-utils-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kde-dev-utils-common-26.04.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kde-dev-utils-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kde-dev-utils-common}"
SRC_URI[x86_64_v2_kde-dev-utils-common.sha256sum] = "60fa802381257fcb5c2a2b56b7a686adf2f0c443a21a49932467b52acab55d68"

URI_x86_64_v2_kpartloader = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpartloader-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpartloader;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kpartloader}"
SRC_URI[x86_64_v2_kpartloader.sha256sum] = "ae56ddb99ad739763186db7145648d4c47d1edfc3226a0d28a4f29347fe8a820"

URI_x86_64_v2_kuiviewer = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kuiviewer-26.04.3-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kuiviewer;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kuiviewer}"
SRC_URI[x86_64_v2_kuiviewer.sha256sum] = "153342dd35c9ae7da7a9c0a0c577c24d758013c85d9bb109f9e5c4ede4eea093"

URI_aarch64_kde-dev-utils = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kde-dev-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-utils}"
SRC_URI[aarch64_kde-dev-utils.sha256sum] = "8d80279197eede4dc8dd922328164d5e3d6135de7120628f6a3be6feb7caebda"

URI_aarch64_kde-dev-utils-common = "${EPEL_MIRROR}/aarch64/Packages/k/kde-dev-utils-common-26.04.3-1.el10_3.noarch.rpm;name=aarch64_kde-dev-utils-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_kde-dev-utils-common}"
SRC_URI[aarch64_kde-dev-utils-common.sha256sum] = "054a77851dbc545d32ca80cba8d6b828b963ab492b2441780cac7e7bd3f628ee"

URI_aarch64_kpartloader = "${EPEL_MIRROR}/aarch64/Packages/k/kpartloader-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kpartloader;unpack=0"
SRC_URI:append = " ${URI_aarch64_kpartloader}"
SRC_URI[aarch64_kpartloader.sha256sum] = "9e88a2c800ea950dfa55288732dd9641d94a0e8fda991f0409f9096aca743b5d"

URI_aarch64_kuiviewer = "${EPEL_MIRROR}/aarch64/Packages/k/kuiviewer-26.04.3-1.el10_3.aarch64.rpm;name=aarch64_kuiviewer;unpack=0"
SRC_URI:append = " ${URI_aarch64_kuiviewer}"
SRC_URI[aarch64_kuiviewer.sha256sum] = "658718bb0f96e197721a55583ea44f83d9ebc62c0dfa3c9295035135f55aebf7"

RDEPENDS:kde-dev-utils = " \
 kpartloader \
 kuiviewer \
 "
RDEPENDS:kde-dev-utils-common = " \
 "
RDEPENDS:kpartloader = " \
 glibc \
 kde-dev-utils-common \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kuiviewer = " \
 glibc \
 kde-dev-utils-common \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-ki18n \
 kf6-kio-gui \
 kf6-kparts \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qttools-libs-designer \
 "
