# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cast5"
PV = "0.11.1"
PR = "4.el10_2"
PACKAGES = " \
 rust-cast5+default-devel \
 rust-cast5+zeroize-devel \
 rust-cast5-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cast5-0.11.1-4.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd8ef95d61067098d16c0541441634243402b5233186c04fb8cc63e08b5ecc82"

URI_x86_64_v2_rust-cast5+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cast5+default-devel-0.11.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cast5+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cast5+default-devel}"
SRC_URI[x86_64_v2_rust-cast5+default-devel.sha256sum] = "083f3eba2fe3c2a880daf8a2f13c75d1c15ad3c386eedbbc8c150fb50eecb632"

URI_x86_64_v2_rust-cast5+zeroize-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cast5+zeroize-devel-0.11.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cast5+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cast5+zeroize-devel}"
SRC_URI[x86_64_v2_rust-cast5+zeroize-devel.sha256sum] = "791005580e5843b6e61d2b562e036f3a86a2a137cf2a49ddd1ab85f7e60b79e7"

URI_x86_64_v2_rust-cast5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cast5-devel-0.11.1-4.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cast5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cast5-devel}"
SRC_URI[x86_64_v2_rust-cast5-devel.sha256sum] = "0a2f407ff5e37b97ed8438d6612450cd6ffeb4a0f595b24d3f70dbdd27518fc5"

URI_aarch64_rust-cast5+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cast5+default-devel-0.11.1-4.el10_2.noarch.rpm;name=aarch64_rust-cast5+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cast5+default-devel}"
SRC_URI[aarch64_rust-cast5+default-devel.sha256sum] = "59d1b20bf327b6fa59ce8e9bdba0a7fb9b3de6ab293d00fe3baab7ace29d7657"

URI_aarch64_rust-cast5+zeroize-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cast5+zeroize-devel-0.11.1-4.el10_2.noarch.rpm;name=aarch64_rust-cast5+zeroize-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cast5+zeroize-devel}"
SRC_URI[aarch64_rust-cast5+zeroize-devel.sha256sum] = "a3063bbb79a3349b0c9caa3d94e4aca1823c2178f6054e19a8cc1c003a521644"

URI_aarch64_rust-cast5-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cast5-devel-0.11.1-4.el10_2.noarch.rpm;name=aarch64_rust-cast5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cast5-devel}"
SRC_URI[aarch64_rust-cast5-devel.sha256sum] = "087e7d42a35da6e796c9ed1ca16cd681d23d8afb62ea155c052a4bf794df47ce"

RDEPENDS:rust-cast5+default-devel = " \
 cargo \
 rust-cast5-devel \
 "
RDEPENDS:rust-cast5+zeroize-devel = " \
 cargo \
 rust-cast5-devel \
 rust-cipher0.4+zeroize-devel \
 "
RDEPENDS:rust-cast5-devel = " \
 cargo \
 rust \
 rust-cipher0.4+default-devel \
 "
