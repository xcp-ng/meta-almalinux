# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Class-Accessor-Grouped"
PV = "0.10014"
PR = "24.el10_2"
PACKAGES = " \
 perl-Class-Accessor-Grouped \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Class-Accessor-Grouped-0.10014-24.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1714dcc812e4abcbdf9250eef67a2233f1e9bee2d30438dce56b94d24e247d1c"

URI_x86_64_v2_perl-Class-Accessor-Grouped = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Class-Accessor-Grouped-0.10014-24.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_perl-Class-Accessor-Grouped;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Class-Accessor-Grouped}"
SRC_URI[x86_64_v2_perl-Class-Accessor-Grouped.sha256sum] = "baa42ae398ebf122de89db84d43b20b30575ca3ddd6f35138d73a46c50d9bd20"

URI_aarch64_perl-Class-Accessor-Grouped = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Class-Accessor-Grouped-0.10014-24.el10_2.noarch.rpm;name=aarch64_perl-Class-Accessor-Grouped;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Class-Accessor-Grouped}"
SRC_URI[aarch64_perl-Class-Accessor-Grouped.sha256sum] = "cb939358f6e311f691e628ad342e487d4e3e5a4451c23d5b0fe43cd5d10af5cd"

RDEPENDS:perl-Class-Accessor-Grouped = " \
 perl-Carp \
 perl-Module-Runtime \
 perl-Scalar-List-Utils \
 perl-libs \
 perl-mro \
 "
