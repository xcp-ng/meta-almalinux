# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "otf2"
PV = "3.1.1"
PR = "1.el10_0"
PACKAGES = " \
 otf2 \
 otf2-devel \
 otf2-doc \
 python3-otf2 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/o/otf2-3.1.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c2ebf32f47e9455fc4f983bb7c45976d9252de640820371b5605ab1542ecc7c0"

URI_x86_64_v2_otf2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/otf2-3.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_otf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_otf2}"
SRC_URI[x86_64_v2_otf2.sha256sum] = "c67bd13665ed7e7a6e612dd565f9578486c5a86941edd91a6418affce0d47a8b"

URI_x86_64_v2_otf2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/otf2-devel-3.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_otf2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_otf2-devel}"
SRC_URI[x86_64_v2_otf2-devel.sha256sum] = "2c834e86113e02333bde4cf7243ca1cc0376ceee727817fd38fe6e1069a97c65"

URI_x86_64_v2_otf2-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/otf2-doc-3.1.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_otf2-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_otf2-doc}"
SRC_URI[x86_64_v2_otf2-doc.sha256sum] = "04843260d5aeacd7b2af8464bda15facdafabae4f90663a090b43c1cf7b8e568"

URI_x86_64_v2_python3-otf2 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-otf2-3.1.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-otf2;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-otf2}"
SRC_URI[x86_64_v2_python3-otf2.sha256sum] = "d5f3a78a9e04dde3eebb9a4e38186c87e5563c16f0f2e9e6b8efe2bf2c6d82cc"

URI_aarch64_otf2 = "${EPEL_MIRROR}/aarch64/Packages/o/otf2-3.1.1-1.el10_0.aarch64.rpm;name=aarch64_otf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_otf2}"
SRC_URI[aarch64_otf2.sha256sum] = "f6eba4063a7a805edc6d01ba74d9d99854b421cd7eab7ade10ee84b12cc2629e"

URI_aarch64_otf2-devel = "${EPEL_MIRROR}/aarch64/Packages/o/otf2-devel-3.1.1-1.el10_0.aarch64.rpm;name=aarch64_otf2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_otf2-devel}"
SRC_URI[aarch64_otf2-devel.sha256sum] = "f5a573d474da0194ea4bd76c270339b51dd6305daa95b43d433a9a18bdadbc47"

URI_aarch64_otf2-doc = "${EPEL_MIRROR}/aarch64/Packages/o/otf2-doc-3.1.1-1.el10_0.noarch.rpm;name=aarch64_otf2-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_otf2-doc}"
SRC_URI[aarch64_otf2-doc.sha256sum] = "301c91ea9869979a537a2dd7de433f0fcf4f430abcf03f676c1bf9597c56fe32"

URI_aarch64_python3-otf2 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-otf2-3.1.1-1.el10_0.aarch64.rpm;name=aarch64_python3-otf2;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-otf2}"
SRC_URI[aarch64_python3-otf2.sha256sum] = "39b9fc5ad069206489cf08c05213d2ed8f7de0b455aed6d84a4d62ae7a1cf1ef"

RDEPENDS:otf2 = " \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:otf2-devel = " \
 glibc \
 libgcc \
 libstdc++ \
 otf2 \
 pkgconf-pkg-config \
 "
RDEPENDS:otf2-doc = " \
 "
RDEPENDS:python3-otf2 = " \
 glibc \
 otf2 \
 python3 \
 python3-jinja2 \
 python3-six \
 "
