# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rand"
PV = "0.10.3"
PR = "1.el10_3"
PACKAGES = " \
 rust-rand+alloc-devel \
 rust-rand+chacha-devel \
 rust-rand+default-devel \
 rust-rand+log-devel \
 rust-rand+serde-devel \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand+unbiased-devel \
 rust-rand-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rand-0.10.3-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "c7f19256d70b3a218faa9f2f519514a419b7a652d7f2b2b6463f1849269caf24"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+alloc-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+alloc-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+alloc-devel.sha256sum] = "19eff853c8e0a27c40b5499942a1b931e1341e508bbc2d732a7b3ebc2544f7fc"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+chacha-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+chacha-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+chacha-devel.sha256sum] = "29fb45bbf995b713af3faa0a7bab6f8a9fba749da70af5753e5aa6825708b0a4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+default-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+default-devel.sha256sum] = "cb7016a3575078eabb860ad12a4d3402f7817fd8bd671ef8047570c5bdb1e13b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+log-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+log-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+log-devel.sha256sum] = "acde085210d0f5a3e5d2d98e7fc0e613d153276b0dc428c54984091237ce19f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+serde-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+serde-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+serde-devel.sha256sum] = "684c6220204b9ddbd0c1db912f9fef43d91fcc6007640235c29a66207ccbb97f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+std-devel.sha256sum] = "91c3f3baffd9e6b73dd969ffee15b7e19816685a4df207c2e3d376f61d0b799f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+std_rng-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+std_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+std_rng-devel.sha256sum] = "1abc7d6810d089b1b7411c5ff703988e2595a0caab7dd92ead224cff17717a40"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+sys_rng-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+sys_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+sys_rng-devel.sha256sum] = "571420ef10dcec2ae09729205a9855126ab9581d31106f7e8d598f00f830d495"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+thread_rng-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+thread_rng-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+thread_rng-devel.sha256sum] = "24cf3c51f2df612874cf1763da458484c4b253bd0f8d3fdded827d6db5d4e880"
RPROVIDES:rust-rand+thread_rng-devel:append:x86_64_v2 = " virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand+unbiased-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand+unbiased-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand+unbiased-devel.sha256sum] = "c03572782c099238c86547de8945c44e5ebf6a933fd3d3ca6ab371877e8a8c10"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rand-devel-0.10.3-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rand-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rand-devel.sha256sum] = "e8cb43390dd77bd74728ad84aec02e66ffeb023142bed7ad7e7849b47e3e4940"
RPROVIDES:rust-rand-devel:append:x86_64_v2 = " virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+alloc-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+alloc-devel;unpack=0"
SRC_URI[aarch64_rust-rand+alloc-devel.sha256sum] = "9b9d40e5661c4ba9b212742eb6c8f272f3f78e64545b0dfdd5af9d8e5833da20"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+chacha-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+chacha-devel;unpack=0"
SRC_URI[aarch64_rust-rand+chacha-devel.sha256sum] = "0b6ddc808d86a6e9e3115b2ddd9d8e1a0053635316dc9067cc62640ff3b7a48e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+default-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+default-devel;unpack=0"
SRC_URI[aarch64_rust-rand+default-devel.sha256sum] = "0dacb2dc46b6b77d2f969cff9f36178b562304da97cd59b4e3d2f8a537550304"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+log-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+log-devel;unpack=0"
SRC_URI[aarch64_rust-rand+log-devel.sha256sum] = "667a30ed7c398c3c80f73d52e9899a658122b01c5fde2fdc17188ab9f587392d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+serde-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+serde-devel;unpack=0"
SRC_URI[aarch64_rust-rand+serde-devel.sha256sum] = "1cc1ae1acc6f0cdb6aa4847ed35af299ad31443845311c8ded3fdacdb525dace"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+std-devel;unpack=0"
SRC_URI[aarch64_rust-rand+std-devel.sha256sum] = "ea395ba28b3c81273df8ddceadddb670d76c70314c3e65a0cde2aad6c455578a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+std_rng-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+std_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand+std_rng-devel.sha256sum] = "bc3f616efc238fe0681c0535eb878fef4b710dbec0c5ff26de162d628b628704"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+sys_rng-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+sys_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand+sys_rng-devel.sha256sum] = "bbca2b0f6361ad6bcfc3f07a87bb1f8cde43619e94f53d6b720ec492d57f78f5"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+thread_rng-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+thread_rng-devel;unpack=0"
SRC_URI[aarch64_rust-rand+thread_rng-devel.sha256sum] = "4f02a6eb1e343b0abd35b00373a21c7d237919a85d16c06584fda30b18b4c858"
RPROVIDES:rust-rand+thread_rng-devel:append:aarch64 = " virtual/crate_rand/thread_rng__ge_0.9.0_with_crate_rand/thread_rng__le_0.11.0"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand+unbiased-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand+unbiased-devel;unpack=0"
SRC_URI[aarch64_rust-rand+unbiased-devel.sha256sum] = "10ee1f424bab80c46635a8fdcb2ab6e26faa0a3e90192310a0c99fdf3e55554a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rand-devel-0.10.3-1.el10_3.noarch.rpm;name=aarch64_rust-rand-devel;unpack=0"
SRC_URI[aarch64_rust-rand-devel.sha256sum] = "8dfeb48b9788626d39c6cf7d36aad146c1060f47f1ca357c13d0d4bad466191d"
RPROVIDES:rust-rand-devel:append:aarch64 = " virtual/crate_rand__ge_0.9.0_with_crate_rand__le_0.11.0"

RDEPENDS:rust-rand+alloc-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+chacha-devel = " \
 cargo \
 rust-chacha20+rng-devel \
 rust-chacha20-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+default-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand+thread_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+log-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+serde-devel = " \
 cargo \
 rust-rand-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-rand+std-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+std-devel \
 rust-rand+alloc-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+std_rng-devel = " \
 cargo \
 rust-chacha20+rng-devel \
 rust-chacha20-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+sys_rng-devel = " \
 cargo \
 rust-getrandom+default-devel \
 rust-getrandom+sys_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+thread_rng-devel = " \
 cargo \
 rust-rand+std-devel \
 rust-rand+std_rng-devel \
 rust-rand+sys_rng-devel \
 rust-rand-devel \
 "
RDEPENDS:rust-rand+unbiased-devel = " \
 cargo \
 rust-rand-devel \
 "
RDEPENDS:rust-rand-devel = " \
 cargo \
 rust \
 rust-rand_core-devel \
 "
