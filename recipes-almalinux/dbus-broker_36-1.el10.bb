# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dbus-broker"
PV = "36"
PR = "1.el10"
PACKAGES = " \
 dbus-broker \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/dbus-broker-36-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a1f0cbbdb792a8e975a14ecafe2c234bdadc6504f791ec8d9afddacc3a8436b2"

URI_x86_64_v2_dbus-broker = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/dbus-broker-36-1.el10.x86_64_v2.rpm;name=x86_64_v2_dbus-broker;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dbus-broker}"
SRC_URI[x86_64_v2_dbus-broker.sha256sum] = "b8b22221fa91a55f58fd2ff6840082b8c117435eaad38497f18c69926d0c8eeb"

URI_aarch64_dbus-broker = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/dbus-broker-36-1.el10.aarch64.rpm;name=aarch64_dbus-broker;unpack=0"
SRC_URI:append = " ${URI_aarch64_dbus-broker}"
SRC_URI[aarch64_dbus-broker.sha256sum] = "4ba8dc8bff7285ba1e538fc9946aa7ef963ef53eb753ab3d9aa3234bf64eb230"

RDEPENDS:dbus-broker = " \
 audit-libs \
 bash \
 dbus-common \
 expat \
 glibc \
 libcap-ng \
 libgcc \
 libselinux \
 shadow-utils \
 systemd-libs \
 "
