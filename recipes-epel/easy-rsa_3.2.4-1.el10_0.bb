# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "easy-rsa"
PV = "3.2.4"
PR = "1.el10_0"
PACKAGES = " \
 easy-rsa \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/e/easy-rsa-3.2.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1ed0c6bdfb459be910b3697d4a0ce36ff49ab0709ceded5e5c85d1f56eb1bae4"

URI_x86_64_v2_easy-rsa = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/easy-rsa-3.2.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_easy-rsa;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_easy-rsa}"
SRC_URI[x86_64_v2_easy-rsa.sha256sum] = "c17e59ff57f04954b0ae995f6f6a4f09bdc822e621ad97fb668e458de851cd86"

URI_aarch64_easy-rsa = "${EPEL_MIRROR}/aarch64/Packages/e/easy-rsa-3.2.4-1.el10_0.noarch.rpm;name=aarch64_easy-rsa;unpack=0"
SRC_URI:append = " ${URI_aarch64_easy-rsa}"
SRC_URI[aarch64_easy-rsa.sha256sum] = "25d70eda820ae73b7a6b1e200399af7e5df3c8d073a43a47bb651d5a9d391662"

RDEPENDS:easy-rsa = " \
 bash \
 openssl \
 "
