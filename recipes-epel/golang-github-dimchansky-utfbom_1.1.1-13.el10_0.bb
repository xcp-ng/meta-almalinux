# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-dimchansky-utfbom"
PV = "1.1.1"
PR = "13.el10_0"
PACKAGES = " \
 golang-github-dimchansky-utfbom-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-dimchansky-utfbom-1.1.1-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8cbdd4d3b0a3c6eb75143159ec68a333fca538eec29691047450ed34dfd4821a"

URI_x86_64_v2_golang-github-dimchansky-utfbom-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-dimchansky-utfbom-devel-1.1.1-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-dimchansky-utfbom-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-dimchansky-utfbom-devel}"
SRC_URI[x86_64_v2_golang-github-dimchansky-utfbom-devel.sha256sum] = "692a50c8e898fc47f772c9942b67ef15c0b48a9b3344e7ea815f1e188832529b"

URI_aarch64_golang-github-dimchansky-utfbom-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-dimchansky-utfbom-devel-1.1.1-13.el10_0.noarch.rpm;name=aarch64_golang-github-dimchansky-utfbom-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-dimchansky-utfbom-devel}"
SRC_URI[aarch64_golang-github-dimchansky-utfbom-devel.sha256sum] = "1d1df9a1b603e1532449a47c46d95bae2a360e715c339d31c24001b946069bb0"

RDEPENDS:golang-github-dimchansky-utfbom-devel = " \
 go-filesystem \
 "
