# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-execnet"
PV = "2.1.1"
PR = "4.el10_0"
PACKAGES = " \
 python3-execnet \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-execnet-2.1.1-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "434b9d7ee7ddf8a6c0efda8c1ad4f8077e368c6b17a20212f301821333ee2242"

URI_x86_64_v2_python3-execnet = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-execnet-2.1.1-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-execnet;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-execnet}"
SRC_URI[x86_64_v2_python3-execnet.sha256sum] = "c990b6134966ba3d62e55bb6288e10dfc634b7300d516bcc4e6794428d3eb706"

URI_aarch64_python3-execnet = "${EPEL_MIRROR}/aarch64/Packages/p/python3-execnet-2.1.1-4.el10_0.noarch.rpm;name=aarch64_python3-execnet;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-execnet}"
SRC_URI[aarch64_python3-execnet.sha256sum] = "046b29767fe6c238802ac5bc3fc13183acc5b7ae26783deda20a689061b2b318"

RDEPENDS:python3-execnet = " \
 python3 \
 "
