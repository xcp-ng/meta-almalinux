# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-diff"
PV = "0.53.0"
PR = "1.el10_1"
PACKAGES = " \
 rust-gix-diff+blob-devel \
 rust-gix-diff+default-devel \
 rust-gix-diff+document-features-devel \
 rust-gix-diff+index-devel \
 rust-gix-diff+serde-devel \
 rust-gix-diff-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-diff-0.53.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c890ff58296ff3d3fc5a3143abea18851b1337e9c679f06c49e06f045bbac29c"

URI_x86_64_v2_rust-gix-diff+blob-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+blob-devel-0.53.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+blob-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+blob-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+blob-devel.sha256sum] = "fe7cc7c79b8e93cb1356de94910fe9328f0b158e93e7f0fd2a544c60eaefcd31"

URI_x86_64_v2_rust-gix-diff+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+default-devel-0.53.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+default-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+default-devel.sha256sum] = "1695946a78a248f0ede4d0f4c1ed4513444e852ce816437c786553dca9449781"

URI_x86_64_v2_rust-gix-diff+document-features-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+document-features-devel-0.53.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+document-features-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+document-features-devel.sha256sum] = "90f66ddd774e98796528b9f497522119ee2f38af0434853f8116248e9c150ebd"

URI_x86_64_v2_rust-gix-diff+index-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+index-devel-0.53.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+index-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+index-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+index-devel.sha256sum] = "03ca7b07780c53e3387d0962eaf3607383acf5b33a4144bdc41daa9f8f10ee00"

URI_x86_64_v2_rust-gix-diff+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff+serde-devel-0.53.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff+serde-devel}"
SRC_URI[x86_64_v2_rust-gix-diff+serde-devel.sha256sum] = "cac4f97fdd9e4277dbca37ea9d1d2e0350795740b93d54fd42ad2db9bf510788"

URI_x86_64_v2_rust-gix-diff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-diff-devel-0.53.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-diff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-diff-devel}"
SRC_URI[x86_64_v2_rust-gix-diff-devel.sha256sum] = "ede20acced160c99e765db0ef4493d169b8ef1b5ea3382e23042801676d77bb8"

URI_aarch64_rust-gix-diff+blob-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+blob-devel-0.53.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-diff+blob-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+blob-devel}"
SRC_URI[aarch64_rust-gix-diff+blob-devel.sha256sum] = "f7c454d5c7221f0ea9798b38095e2d281a889d825ae3618b63bfa8349f5d6be8"

URI_aarch64_rust-gix-diff+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+default-devel-0.53.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-diff+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+default-devel}"
SRC_URI[aarch64_rust-gix-diff+default-devel.sha256sum] = "6785ab94ad04b9d80a9f825ec270ac267587398d0757ef0bc387abe48e5ee93f"

URI_aarch64_rust-gix-diff+document-features-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+document-features-devel-0.53.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-diff+document-features-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+document-features-devel}"
SRC_URI[aarch64_rust-gix-diff+document-features-devel.sha256sum] = "481d90c4027f9c56c553bd49b22cb404bf480ea83d65d0c0ad80832ad6143d53"

URI_aarch64_rust-gix-diff+index-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+index-devel-0.53.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-diff+index-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+index-devel}"
SRC_URI[aarch64_rust-gix-diff+index-devel.sha256sum] = "d997e5c872884142ee488daaafec908ad93b7f93619784fd1f2adc533816776c"

URI_aarch64_rust-gix-diff+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff+serde-devel-0.53.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-diff+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff+serde-devel}"
SRC_URI[aarch64_rust-gix-diff+serde-devel.sha256sum] = "f5e2110d61935d97e9d523a55549150873f4fbe16624e938355a6fc53bf8b033"

URI_aarch64_rust-gix-diff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-diff-devel-0.53.0-1.el10_1.noarch.rpm;name=aarch64_rust-gix-diff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-diff-devel}"
SRC_URI[aarch64_rust-gix-diff-devel.sha256sum] = "16e0d15f5b513804485059dc4a7a2d4d0a18183eebcd6457eda2ef7dbad1c7fe"

RDEPENDS:rust-gix-diff+blob-devel = " \
 cargo \
 rust-gix-command+default-devel \
 rust-gix-diff-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-path+default-devel \
 rust-gix-tempfile+default-devel \
 rust-gix-trace+default-devel \
 rust-gix-traverse+default-devel \
 rust-gix-worktree+attributes-devel \
 rust-gix-worktree-devel \
 rust-imara-diff0.1+default-devel \
 "
RDEPENDS:rust-gix-diff+default-devel = " \
 cargo \
 rust-gix-diff+blob-devel \
 rust-gix-diff+index-devel \
 rust-gix-diff-devel \
 "
RDEPENDS:rust-gix-diff+document-features-devel = " \
 cargo \
 rust-document-features+default-devel \
 rust-gix-diff-devel \
 "
RDEPENDS:rust-gix-diff+index-devel = " \
 cargo \
 rust-gix-attributes+default-devel \
 rust-gix-diff-devel \
 rust-gix-index+default-devel \
 rust-gix-pathspec+default-devel \
 "
RDEPENDS:rust-gix-diff+serde-devel = " \
 cargo \
 rust-gix-diff-devel \
 rust-gix-hash+serde-devel \
 rust-gix-index+default-devel \
 rust-gix-index+serde-devel \
 rust-gix-object+serde-devel \
 rust-serde+derive-devel \
 rust-serde-devel \
 "
RDEPENDS:rust-gix-diff-devel = " \
 cargo \
 rust \
 rust-bstr-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-thiserror+default-devel \
 "
