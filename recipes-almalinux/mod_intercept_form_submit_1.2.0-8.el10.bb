# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mod_intercept_form_submit"
PV = "1.2.0"
PR = "8.el10"
PACKAGES = " \
 mod_intercept_form_submit \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/mod_intercept_form_submit-1.2.0-8.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "148e91b56387ced5bdb8e9a8ab930875b4c5c4d96792b08acac04d956b8620aa"

URI_x86_64_v2_mod_intercept_form_submit = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/mod_intercept_form_submit-1.2.0-8.el10.x86_64_v2.rpm;name=x86_64_v2_mod_intercept_form_submit;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mod_intercept_form_submit}"
SRC_URI[x86_64_v2_mod_intercept_form_submit.sha256sum] = "e79cbe61700c3b2ba047dc1c4cddc688fb5a26a7baa84a5b27c8b1d3fc572de2"

URI_aarch64_mod_intercept_form_submit = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/mod_intercept_form_submit-1.2.0-8.el10.aarch64.rpm;name=aarch64_mod_intercept_form_submit;unpack=0"
SRC_URI:append = " ${URI_aarch64_mod_intercept_form_submit}"
SRC_URI[aarch64_mod_intercept_form_submit.sha256sum] = "d1b350f41c20a29c6a5059af8d77ba5c1ed07b422843d6742d816cf8a91273ff"

RDEPENDS:mod_intercept_form_submit = " \
 glibc \
 httpd-core \
 mod_authnz_pam \
 "
