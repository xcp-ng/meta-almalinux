# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sddm"
PV = "0.21.0"
PR = "9.el10_1"
PACKAGES = " \
 sddm \
 sddm-themes \
 sddm-wayland-generic \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sddm-0.21.0-9.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ba743aa884cb238610e524966b05b984af1cd8c6b7d9d23b6b3a24f8efc672dc"

URI_x86_64_v2_sddm = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-0.21.0-9.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sddm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm}"
SRC_URI[x86_64_v2_sddm.sha256sum] = "1016cf34bf09608bdafe886c98f0447a88225116d105213491e70d70ae398884"

URI_x86_64_v2_sddm-themes = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-themes-0.21.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-themes;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-themes}"
SRC_URI[x86_64_v2_sddm-themes.sha256sum] = "76cc59da4a2b5fe9913bf7381a947130da2f48ef23cc8705e71cb5df169fd62a"

URI_x86_64_v2_sddm-wayland-generic = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sddm-wayland-generic-0.21.0-9.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_sddm-wayland-generic;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sddm-wayland-generic}"
SRC_URI[x86_64_v2_sddm-wayland-generic.sha256sum] = "a2e1e1549837f68bd2769c4f6d2b3253c9247fec9dc724f0a42340ad2fc7e239"
RPROVIDES:sddm-wayland-generic:x86_64_v2 = "virtual/sddm-greeter-displayserver"

URI_aarch64_sddm = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-0.21.0-9.el10_1.aarch64.rpm;name=aarch64_sddm;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm}"
SRC_URI[aarch64_sddm.sha256sum] = "0ebe49d84ecb1c71927b62bf42ec7db51287f08ca524d67b0598f6cb94e881b4"

URI_aarch64_sddm-themes = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-themes-0.21.0-9.el10_1.noarch.rpm;name=aarch64_sddm-themes;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-themes}"
SRC_URI[aarch64_sddm-themes.sha256sum] = "9d4b6ca746c9c16046dbb36fbe618493250bc82abda725773b4fabfdad16038f"

URI_aarch64_sddm-wayland-generic = "${EPEL_MIRROR}/aarch64/Packages/s/sddm-wayland-generic-0.21.0-9.el10_1.noarch.rpm;name=aarch64_sddm-wayland-generic;unpack=0"
SRC_URI:append = " ${URI_aarch64_sddm-wayland-generic}"
SRC_URI[aarch64_sddm-wayland-generic.sha256sum] = "9afbe2bf262b7e8b1007040dc792bb2fe5127488c5c5822928d80928226c0d90"
RPROVIDES:sddm-wayland-generic:aarch64 = "virtual/sddm-greeter-displayserver"

RDEPENDS:sddm = " \
 bash \
 glibc \
 libXau \
 libgcc \
 libstdc++ \
 libxcb \
 pam-libs \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 shadow-utils \
 systemd \
 systemd-libs \
 virtual/sddm-greeter-displayserver \
 "
RDEPENDS:sddm-themes = " \
 sddm \
 "
RDEPENDS:sddm-wayland-generic = " \
 sddm \
 weston \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/sddm-greeter-displayserver"

PROVIDES:append:aarch64 = " rpm/virtual/sddm-greeter-displayserver"
