# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-inventory"
PV = "0.3.24"
PR = "1.el10_3"
PACKAGES = " \
 rust-inventory+default-devel \
 rust-inventory-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-inventory-0.3.24-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "158b16fb7ec69693c8a819e980d10c1ffa26dd5b394b87c67e1797b44049eaf7"

URI_x86_64_v2_rust-inventory+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inventory+default-devel-0.3.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inventory+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inventory+default-devel}"
SRC_URI[x86_64_v2_rust-inventory+default-devel.sha256sum] = "ff67b7c71598118f0cb8968a4b420dc7a4631c422b051802aef738a931adbeff"

URI_x86_64_v2_rust-inventory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-inventory-devel-0.3.24-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-inventory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-inventory-devel}"
SRC_URI[x86_64_v2_rust-inventory-devel.sha256sum] = "f722a922595df8e61687afc3808fb4e0e54c421a16c0c13bc25ff5e45fcb7697"

URI_aarch64_rust-inventory+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inventory+default-devel-0.3.24-1.el10_3.noarch.rpm;name=aarch64_rust-inventory+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inventory+default-devel}"
SRC_URI[aarch64_rust-inventory+default-devel.sha256sum] = "990032953c127ecee76e2c68d2625f296518ef2b5287539b5280dfc53b2ea01f"

URI_aarch64_rust-inventory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-inventory-devel-0.3.24-1.el10_3.noarch.rpm;name=aarch64_rust-inventory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-inventory-devel}"
SRC_URI[aarch64_rust-inventory-devel.sha256sum] = "649fa1903554ff2508f34a6e88a2dfa2e753297176d41256392f206cb22d30c3"

RDEPENDS:rust-inventory+default-devel = " \
 cargo \
 rust-inventory-devel \
 "
RDEPENDS:rust-inventory-devel = " \
 cargo \
 rust \
 "
