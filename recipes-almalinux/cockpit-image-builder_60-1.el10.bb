# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "cockpit-image-builder"
PV = "60"
PR = "1.el10"
PACKAGES = " \
 cockpit-image-builder \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/cockpit-image-builder-60-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "cb531847138ae0e1097dade91d756adfb19acad58bab5db9cde4f2751422a037"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/cockpit-image-builder-60-1.el10.noarch.rpm;name=x86_64_v2_cockpit-image-builder;unpack=0"
SRC_URI[x86_64_v2_cockpit-image-builder.sha256sum] = "040deb2c9575912105ec6cc8b30836085a97d3ab0f3f7e9842fa2d8e83522d07"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/cockpit-image-builder-60-1.el10.noarch.rpm;name=aarch64_cockpit-image-builder;unpack=0"
SRC_URI[aarch64_cockpit-image-builder.sha256sum] = "040deb2c9575912105ec6cc8b30836085a97d3ab0f3f7e9842fa2d8e83522d07"

RDEPENDS:cockpit-image-builder = " \
 cockpit \
 cockpit-files \
 osbuild-composer \
 "
