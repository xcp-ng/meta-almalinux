# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-pyperclip"
PV = "1.9.0"
PR = "2.el10_3"
PACKAGES = " \
 python-pyperclip-doc \
 python3-pyperclip \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/python-pyperclip-1.9.0-2.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "db9ace126b87086d5b65258c2409d86db3de651a29699169fdcddb18eebd5fe0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-pyperclip-doc-1.9.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python-pyperclip-doc;unpack=0"
SRC_URI[x86_64_v2_python-pyperclip-doc.sha256sum] = "0218e3974e558f8271ec5fd0fd12276f86b48bfa3f5296c655e830e82820e90f"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-pyperclip-1.9.0-2.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_python3-pyperclip;unpack=0"
SRC_URI[x86_64_v2_python3-pyperclip.sha256sum] = "48424da53e83d6429b91d069a152359d3cca51e66c95b6120be022ac9cca6fc1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python-pyperclip-doc-1.9.0-2.el10_3.noarch.rpm;name=aarch64_python-pyperclip-doc;unpack=0"
SRC_URI[aarch64_python-pyperclip-doc.sha256sum] = "51ca1e19afcb7a7ca6c5bf93f59344994c5c4dd8d49d2c3b03e9748bcb9d0eb4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/python3-pyperclip-1.9.0-2.el10_3.noarch.rpm;name=aarch64_python3-pyperclip;unpack=0"
SRC_URI[aarch64_python3-pyperclip.sha256sum] = "ec273d76e2a208a1e3332da811a0eb121152fcb2117e9bc482f3dfce3e27cbdf"

RDEPENDS:python-pyperclip-doc = " \
 "
RDEPENDS:python3-pyperclip = " \
 python3 \
 "
