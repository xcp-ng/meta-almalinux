# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "nodejs22"
PE = "1"
PV = "22.19.0"
PR = "2.el10_0"
PACKAGES = " \
 nodejs \
 nodejs-devel \
 nodejs-docs \
 nodejs-full-i18n \
 nodejs-libs \
 nodejs-npm \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/nodejs22-22.19.0-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f6a440399af7e1de6f82ca8df79e0a8a91685e65cff6635bcee04ce3e1528512"

URI_x86_64_v2_nodejs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-22.19.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_nodejs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs}"
SRC_URI[x86_64_v2_nodejs.sha256sum] = "a43f82104dbf5c95d3de2391b52e66bcbabd831f468025931934c698283d0dc8"

URI_x86_64_v2_nodejs-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-devel-22.19.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_nodejs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-devel}"
SRC_URI[x86_64_v2_nodejs-devel.sha256sum] = "2abcdbb7b7fbff56534e90fe5df5c6255dea4563ed927056b5ae55f41b036ecc"

URI_x86_64_v2_nodejs-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-docs-22.19.0-2.el10_0.noarch.rpm;name=x86_64_v2_nodejs-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-docs}"
SRC_URI[x86_64_v2_nodejs-docs.sha256sum] = "8cdb23c51a3ecf87bcc6fe86fd82d34cf8a2d89415cfbfd9b9c20fd3eba754c9"

URI_x86_64_v2_nodejs-full-i18n = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-full-i18n-22.19.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_nodejs-full-i18n;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-full-i18n}"
SRC_URI[x86_64_v2_nodejs-full-i18n.sha256sum] = "8f43cc25c29e30c6ee8ae7cffc0d19dfb313206414306d1f77aa9c65bb53efe6"

URI_x86_64_v2_nodejs-libs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-libs-22.19.0-2.el10_0.x86_64_v2.rpm;name=x86_64_v2_nodejs-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-libs}"
SRC_URI[x86_64_v2_nodejs-libs.sha256sum] = "c34ffdc9b6cf00672d2bded68f56a41d5b83f01989b3de42f385b60cba0eea94"

URI_x86_64_v2_nodejs-npm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/nodejs-npm-10.9.3-1.22.19.0.2.el10_0.x86_64_v2.rpm;name=x86_64_v2_nodejs-npm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_nodejs-npm}"
SRC_URI[x86_64_v2_nodejs-npm.sha256sum] = "9ea12fe2d822a10d60489cc594e7bf5c4429e516bcc4bbb771ddfa780fbb1772"

URI_aarch64_nodejs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-22.19.0-2.el10_0.aarch64.rpm;name=aarch64_nodejs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs}"
SRC_URI[aarch64_nodejs.sha256sum] = "4555b066efb0c33368bc2cd23df2e57abae102901cdba694162b6d4ffb1194dc"

URI_aarch64_nodejs-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-devel-22.19.0-2.el10_0.aarch64.rpm;name=aarch64_nodejs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-devel}"
SRC_URI[aarch64_nodejs-devel.sha256sum] = "146092df69c601ee51c12bc5a3df69177d086a1b1d758bde099741a03171d493"

URI_aarch64_nodejs-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-docs-22.19.0-2.el10_0.noarch.rpm;name=aarch64_nodejs-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-docs}"
SRC_URI[aarch64_nodejs-docs.sha256sum] = "8cdb23c51a3ecf87bcc6fe86fd82d34cf8a2d89415cfbfd9b9c20fd3eba754c9"

URI_aarch64_nodejs-full-i18n = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-full-i18n-22.19.0-2.el10_0.aarch64.rpm;name=aarch64_nodejs-full-i18n;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-full-i18n}"
SRC_URI[aarch64_nodejs-full-i18n.sha256sum] = "c0dc554babd094f1672cd67ce964c567b537d0219d647c6e83d4ba8b6df1b04a"

URI_aarch64_nodejs-libs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-libs-22.19.0-2.el10_0.aarch64.rpm;name=aarch64_nodejs-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-libs}"
SRC_URI[aarch64_nodejs-libs.sha256sum] = "0cf416c3e51d6f4be17e528acc0c5df1b440208c748143fd71084a11c26e676d"

URI_aarch64_nodejs-npm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/nodejs-npm-10.9.3-1.22.19.0.2.el10_0.aarch64.rpm;name=aarch64_nodejs-npm;unpack=0"
SRC_URI:append = " ${URI_aarch64_nodejs-npm}"
SRC_URI[aarch64_nodejs-npm.sha256sum] = "dd58f4eaa5bbd68116d5f09a438bf5010ca6fdb8a8c3671cbb05d9e1cfd2f50c"

RDEPENDS:nodejs = " \
 ca-certificates \
 glibc \
 libuv \
 nodejs-libs \
 openssl \
 "
RDEPENDS:nodejs-devel = " \
 bash \
 brotli-devel \
 libuv-devel \
 nodejs \
 nodejs-libs \
 nodejs-packaging \
 openssl-devel \
 pkgconf-pkg-config \
 zlib-ng-compat-devel \
 "
RDEPENDS:nodejs-docs = " \
 nodejs \
 "
RDEPENDS:nodejs-full-i18n = " \
 nodejs \
 "
RDEPENDS:nodejs-libs = " \
 glibc \
 libbrotli \
 libgcc \
 libstdc++ \
 libuv \
 openssl-libs \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:nodejs-npm = " \
 bash \
 nodejs \
 "
