# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-google-cloud-core"
PV = "2.3.3"
PR = "7.el10_1"
PACKAGES = " \
 python3-google-cloud-core \
 python3-google-cloud-core+grpc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-google-cloud-core-2.3.3-7.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "69e1bbc92abd3a4cd78d0eabad84e3a5a9ee8ee28b36c8cfa2f8c32004a69732"

URI_x86_64_v2_python3-google-cloud-core = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-cloud-core-2.3.3-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-cloud-core;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-cloud-core}"
SRC_URI[x86_64_v2_python3-google-cloud-core.sha256sum] = "9d6977d9ffdf5c457f5ab8c7faed5a70e5cc002320f0645aa72d60998a08f944"

URI_x86_64_v2_python3-google-cloud-core+grpc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-google-cloud-core+grpc-2.3.3-7.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-google-cloud-core+grpc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-google-cloud-core+grpc}"
SRC_URI[x86_64_v2_python3-google-cloud-core+grpc.sha256sum] = "2f66bae3ba31803b06a976296a08a8673f778351fa206ef02da9f481bbf2b6a3"

URI_aarch64_python3-google-cloud-core = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-cloud-core-2.3.3-7.el10_1.noarch.rpm;name=aarch64_python3-google-cloud-core;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-cloud-core}"
SRC_URI[aarch64_python3-google-cloud-core.sha256sum] = "f4b5a35a3b4c6b291a7516f68da2b60d58a53b51ae008cdc70e8ef6bb95f9cb0"

URI_aarch64_python3-google-cloud-core+grpc = "${EPEL_MIRROR}/aarch64/Packages/p/python3-google-cloud-core+grpc-2.3.3-7.el10_1.noarch.rpm;name=aarch64_python3-google-cloud-core+grpc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-google-cloud-core+grpc}"
SRC_URI[aarch64_python3-google-cloud-core+grpc.sha256sum] = "8826035a64437f61619a09475733a824a97b1ae1901493db1373d660af47a290"

RDEPENDS:python3-google-cloud-core = " \
 python3 \
 python3-google-api-core \
 python3-google-auth \
 "
RDEPENDS:python3-google-cloud-core+grpc = " \
 python3 \
 python3-google-cloud-core \
 python3-grpcio \
 "
