# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-webpki-roots"
PV = "1.0.9"
PR = "1.el10_2"
PACKAGES = " \
 rust-webpki-roots+default-devel \
 rust-webpki-roots-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-webpki-roots-1.0.9-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e24647abf20768073a38ce6fe8f1d0dec0c056fd96487c3d1250a8616e788446"

URI_x86_64_v2_rust-webpki-roots+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots+default-devel-1.0.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots+default-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots+default-devel.sha256sum] = "cec1dd6993b8deeff6fc69a0b2677c0c93b7dab24435020c4b49e4f0c7fdb10f"

URI_x86_64_v2_rust-webpki-roots-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-webpki-roots-devel-1.0.9-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-webpki-roots-devel}"
SRC_URI[x86_64_v2_rust-webpki-roots-devel.sha256sum] = "ca25bb5e7d92b435206d103bea947e5b9beda7de604abd8f3d18dee84d96c17d"

URI_aarch64_rust-webpki-roots+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots+default-devel-1.0.9-1.el10_2.noarch.rpm;name=aarch64_rust-webpki-roots+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots+default-devel}"
SRC_URI[aarch64_rust-webpki-roots+default-devel.sha256sum] = "81e1b44e0f7a9ddf2495bbb9722932bd0fb863270a6b4e4bbc1909e119c7fde4"

URI_aarch64_rust-webpki-roots-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-webpki-roots-devel-1.0.9-1.el10_2.noarch.rpm;name=aarch64_rust-webpki-roots-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-webpki-roots-devel}"
SRC_URI[aarch64_rust-webpki-roots-devel.sha256sum] = "df137b63916bb068304d0a9fd74fafffe401c056950e0016827ff4b39f698775"

RDEPENDS:rust-webpki-roots+default-devel = " \
 cargo \
 rust-webpki-roots-devel \
 "
RDEPENDS:rust-webpki-roots-devel = " \
 cargo \
 rust \
 rust-rustls-pki-types-devel \
 "
