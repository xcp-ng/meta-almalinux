# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-l2tp"
PV = "1.52.4"
PR = "1.el10_3"
PACKAGES = " \
 NetworkManager-l2tp \
 NetworkManager-l2tp-gnome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-l2tp-1.52.4-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "7b305ad45933dcc44df8b91187892605b87eff6da460e2feb14f09fbf84017c2"

URI_x86_64_v2_NetworkManager-l2tp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-1.52.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-l2tp}"
SRC_URI[x86_64_v2_NetworkManager-l2tp.sha256sum] = "917fc871fa201443277c58ca230e9de5ceb77e29fcfc615bb797a7bcc40e1f48"

URI_x86_64_v2_NetworkManager-l2tp-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-l2tp-gnome-1.52.4-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-l2tp-gnome}"
SRC_URI[x86_64_v2_NetworkManager-l2tp-gnome.sha256sum] = "4367fdab81dce86d20bc7c927fbcd0beee4a4a38e9d192b3e9238f2a660bb419"

URI_aarch64_NetworkManager-l2tp = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-1.52.4-1.el10_3.aarch64.rpm;name=aarch64_NetworkManager-l2tp;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-l2tp}"
SRC_URI[aarch64_NetworkManager-l2tp.sha256sum] = "ba80c8449955e7557bbe196d8043b883cfa22851d813aa791c8ca230f37174fc"

URI_aarch64_NetworkManager-l2tp-gnome = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-l2tp-gnome-1.52.4-1.el10_3.aarch64.rpm;name=aarch64_NetworkManager-l2tp-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-l2tp-gnome}"
SRC_URI[aarch64_NetworkManager-l2tp-gnome.sha256sum] = "1c8bd725d8ce754c0612b26ece2560daeb978465e5dc73cbe547bca71114dd27"

RDEPENDS:NetworkManager-l2tp = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 nspr \
 nss \
 openssl-libs \
 ppp \
 xl2tpd \
 "
RDEPENDS:NetworkManager-l2tp-gnome = " \
 NetworkManager-l2tp \
 NetworkManager-libnm \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 openssl-libs \
 pango \
 vulkan-loader \
 "
