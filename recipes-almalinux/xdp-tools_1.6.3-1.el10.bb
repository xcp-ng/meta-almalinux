# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "xdp-tools"
PV = "1.6.3"
PR = "1.el10"
PACKAGES = " \
 libxdp \
 libxdp-devel \
 libxdp-static \
 xdp-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/xdp-tools-1.6.3-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dd262217a32b6bc0e69dad0b043c8e120d3050c3efddb36efcbca8ab27b47c37"

URI_x86_64_v2_libxdp = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libxdp-1.6.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxdp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdp}"
SRC_URI[x86_64_v2_libxdp.sha256sum] = "f656f8c1e595d47f645871b61fc638373388232c3d4ac99c10fc30d1e90bc322"

URI_x86_64_v2_libxdp-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxdp-devel-1.6.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxdp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdp-devel}"
SRC_URI[x86_64_v2_libxdp-devel.sha256sum] = "2764badf516addb9ae9647ab1922f4f6bc715010a50545ac3cd47024783eec34"

URI_x86_64_v2_libxdp-static = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/libxdp-static-1.6.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_libxdp-static;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libxdp-static}"
SRC_URI[x86_64_v2_libxdp-static.sha256sum] = "b2a98079e2421573259e8b985f74b3cd7e2afd6688a1cd141d13262f437f7609"

URI_x86_64_v2_xdp-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/xdp-tools-1.6.3-1.el10.x86_64_v2.rpm;name=x86_64_v2_xdp-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_xdp-tools}"
SRC_URI[x86_64_v2_xdp-tools.sha256sum] = "9d0a02ff26c05f47e27b6bd9e956eeed5e40618a0bda5981e6c1f7ee0196694e"

URI_aarch64_libxdp = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libxdp-1.6.3-1.el10.aarch64.rpm;name=aarch64_libxdp;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdp}"
SRC_URI[aarch64_libxdp.sha256sum] = "990436992477f220f5c0ebb9ba80da973c0490d12b9dc4f18c9b43066dfe02e7"

URI_aarch64_libxdp-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxdp-devel-1.6.3-1.el10.aarch64.rpm;name=aarch64_libxdp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdp-devel}"
SRC_URI[aarch64_libxdp-devel.sha256sum] = "6d3438e1b00cba53e971051f96ee7cffdce1a21411aaafc3bee840647170aeb4"

URI_aarch64_libxdp-static = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/libxdp-static-1.6.3-1.el10.aarch64.rpm;name=aarch64_libxdp-static;unpack=0"
SRC_URI:append = " ${URI_aarch64_libxdp-static}"
SRC_URI[aarch64_libxdp-static.sha256sum] = "fe8f1874b010bbf14f54ffd80393804fe6750c845bb0d3969de47753e9dc6cd9"

URI_aarch64_xdp-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/xdp-tools-1.6.3-1.el10.aarch64.rpm;name=aarch64_xdp-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_xdp-tools}"
SRC_URI[aarch64_xdp-tools.sha256sum] = "a7870dfddf34273dfba1e385e94b8baa986ae4db007630b41bb66305b4e676a6"

RDEPENDS:libxdp = " \
 glibc \
 libbpf \
 "
RDEPENDS:libxdp-devel = " \
 kernel-headers \
 libbpf-devel \
 libxdp \
 pkgconf-pkg-config \
 "
RDEPENDS:libxdp-static = " \
 libxdp-devel \
 "
RDEPENDS:xdp-tools = " \
 bash \
 glibc \
 libbpf \
 libcap-ng \
 libpcap \
 libxdp \
 "
