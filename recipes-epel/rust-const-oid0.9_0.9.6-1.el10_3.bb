# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-const-oid0.9"
PV = "0.9.6"
PR = "1.el10_3"
PACKAGES = " \
 rust-const-oid0.9+arbitrary-devel \
 rust-const-oid0.9+db-devel \
 rust-const-oid0.9+default-devel \
 rust-const-oid0.9+std-devel \
 rust-const-oid0.9-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-const-oid0.9-0.9.6-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5362789fcf7d5ef85218fce5df7bc463603ad1cd56fb5fd40b81390c819b452e"

URI_x86_64_v2_rust-const-oid0.9+arbitrary-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid0.9+arbitrary-devel-0.9.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid0.9+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid0.9+arbitrary-devel}"
SRC_URI[x86_64_v2_rust-const-oid0.9+arbitrary-devel.sha256sum] = "ba3bc10b266c464185b59475f5126a4eabef84fbb3b0d4a432e6aeae2e7595bc"

URI_x86_64_v2_rust-const-oid0.9+db-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid0.9+db-devel-0.9.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid0.9+db-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid0.9+db-devel}"
SRC_URI[x86_64_v2_rust-const-oid0.9+db-devel.sha256sum] = "2f7db594d24d732ef4825b3dfcc84f018ce6e08c6761e4cdb734ccc609f25f14"

URI_x86_64_v2_rust-const-oid0.9+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid0.9+default-devel-0.9.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid0.9+default-devel}"
SRC_URI[x86_64_v2_rust-const-oid0.9+default-devel.sha256sum] = "c649954bbed85bec4392bbc44dfe8d00140dccb2e9f9084608310e166e1c162d"

URI_x86_64_v2_rust-const-oid0.9+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid0.9+std-devel-0.9.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid0.9+std-devel}"
SRC_URI[x86_64_v2_rust-const-oid0.9+std-devel.sha256sum] = "6b1ceed4074056993a02561cfcbaa5026201d50292bf231803d28f1d4da9b26f"

URI_x86_64_v2_rust-const-oid0.9-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-const-oid0.9-devel-0.9.6-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-const-oid0.9-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-const-oid0.9-devel}"
SRC_URI[x86_64_v2_rust-const-oid0.9-devel.sha256sum] = "92be851cba0f7184f18733df7276c90d31726a577502e87a5e00016fb144a90e"

URI_aarch64_rust-const-oid0.9+arbitrary-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid0.9+arbitrary-devel-0.9.6-1.el10_3.noarch.rpm;name=aarch64_rust-const-oid0.9+arbitrary-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid0.9+arbitrary-devel}"
SRC_URI[aarch64_rust-const-oid0.9+arbitrary-devel.sha256sum] = "c0230c62da3c9bb860567d4ee7c1bb732a44e89e506a3671b08513de0e8412a1"

URI_aarch64_rust-const-oid0.9+db-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid0.9+db-devel-0.9.6-1.el10_3.noarch.rpm;name=aarch64_rust-const-oid0.9+db-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid0.9+db-devel}"
SRC_URI[aarch64_rust-const-oid0.9+db-devel.sha256sum] = "c12145de0bbe0efa3559e8301f1297a0c8b4375b034ab68de918aba464535608"

URI_aarch64_rust-const-oid0.9+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid0.9+default-devel-0.9.6-1.el10_3.noarch.rpm;name=aarch64_rust-const-oid0.9+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid0.9+default-devel}"
SRC_URI[aarch64_rust-const-oid0.9+default-devel.sha256sum] = "91e7ddc8ada9568bab022a3ea53f5ace0c47a0f22a6e8dfe7df4d87a2f249811"

URI_aarch64_rust-const-oid0.9+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid0.9+std-devel-0.9.6-1.el10_3.noarch.rpm;name=aarch64_rust-const-oid0.9+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid0.9+std-devel}"
SRC_URI[aarch64_rust-const-oid0.9+std-devel.sha256sum] = "a547ae366070a59a2ccfe544b59b86e39f99c0ee7de758bd5afb7b594bee38c2"

URI_aarch64_rust-const-oid0.9-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-const-oid0.9-devel-0.9.6-1.el10_3.noarch.rpm;name=aarch64_rust-const-oid0.9-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-const-oid0.9-devel}"
SRC_URI[aarch64_rust-const-oid0.9-devel.sha256sum] = "0d2bbbe906ab00c172330cc456c96e4d3600e19967f321a7df85c358ee392adb"

RDEPENDS:rust-const-oid0.9+arbitrary-devel = " \
 cargo \
 rust-arbitrary+default-devel \
 rust-arbitrary+derive-devel \
 rust-const-oid0.9-devel \
 "
RDEPENDS:rust-const-oid0.9+db-devel = " \
 cargo \
 rust-const-oid0.9-devel \
 "
RDEPENDS:rust-const-oid0.9+default-devel = " \
 cargo \
 rust-const-oid0.9-devel \
 "
RDEPENDS:rust-const-oid0.9+std-devel = " \
 cargo \
 rust-const-oid0.9-devel \
 "
RDEPENDS:rust-const-oid0.9-devel = " \
 cargo \
 rust \
 "
