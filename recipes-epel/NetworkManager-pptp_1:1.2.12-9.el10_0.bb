# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager-pptp"
PE = "1"
PV = "1.2.12"
PR = "9.el10_0"
PACKAGES = " \
 NetworkManager-pptp \
 NetworkManager-pptp-gnome \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/n/NetworkManager-pptp-1.2.12-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4d0d4aed50dd1eeda68076fde82f84870b07d57c083e2719ae43db14795338b0"

URI_x86_64_v2_NetworkManager-pptp = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-pptp-1.2.12-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-pptp;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-pptp}"
SRC_URI[x86_64_v2_NetworkManager-pptp.sha256sum] = "0d8226b7f09b65c6cb7e084767010531a8c8a6a528444c14b47f4ba7a7c57bec"

URI_x86_64_v2_NetworkManager-pptp-gnome = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/NetworkManager-pptp-gnome-1.2.12-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-pptp-gnome;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_NetworkManager-pptp-gnome}"
SRC_URI[x86_64_v2_NetworkManager-pptp-gnome.sha256sum] = "cff83cc9cdda884fb9c72ac06020b971ba4c69f137c50ae53f4f8a99cc4ddd1e"

URI_aarch64_NetworkManager-pptp = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-pptp-1.2.12-9.el10_0.aarch64.rpm;name=aarch64_NetworkManager-pptp;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-pptp}"
SRC_URI[aarch64_NetworkManager-pptp.sha256sum] = "3b4c1cc0c2a616d9b0f0386cb153c7bad3b56ddd1ee9f6ef3e604ee4891fbf27"

URI_aarch64_NetworkManager-pptp-gnome = "${EPEL_MIRROR}/aarch64/Packages/n/NetworkManager-pptp-gnome-1.2.12-9.el10_0.aarch64.rpm;name=aarch64_NetworkManager-pptp-gnome;unpack=0"
SRC_URI:append = " ${URI_aarch64_NetworkManager-pptp-gnome}"
SRC_URI[aarch64_NetworkManager-pptp-gnome.sha256sum] = "f67197da9b9dd271bac92167c865fe9edefc5c157b70b78e2ec3270791e2d254"

RDEPENDS:NetworkManager-pptp = " \
 NetworkManager \
 NetworkManager-libnm \
 dbus-common \
 glib2 \
 glibc \
 libgcc \
 ppp \
 pptp \
 "
RDEPENDS:NetworkManager-pptp-gnome = " \
 NetworkManager-libnm \
 NetworkManager-pptp \
 atk \
 cairo \
 cairo-gobject \
 gdk-pixbuf2 \
 glib2 \
 glibc \
 graphene \
 gtk3 \
 gtk4 \
 harfbuzz \
 libgcc \
 libnma \
 libnma-gtk4 \
 libsecret \
 pango \
 vulkan-loader \
 "
