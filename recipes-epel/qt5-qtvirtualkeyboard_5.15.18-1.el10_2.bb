# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtvirtualkeyboard"
PV = "5.15.18"
PR = "1.el10_2"
PACKAGES = " \
 qt5-qtvirtualkeyboard \
 qt5-qtvirtualkeyboard-devel \
 qt5-qtvirtualkeyboard-examples \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtvirtualkeyboard-5.15.18-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "572f53bc5fda3043480fe624da799e3d2d9a35e406f47be329d43efae19b9a38"

URI_x86_64_v2_qt5-qtvirtualkeyboard = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard.sha256sum] = "7ebe930b8f6fdf6be198efa7790a777ebb498600d27abdb1d03e0f7a32d4049f"

URI_x86_64_v2_qt5-qtvirtualkeyboard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-devel-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard-devel}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard-devel.sha256sum] = "098efb996db0cf74864cd118fca283e3d1f8e78450e17c31e74b066fdb74bafe"

URI_x86_64_v2_qt5-qtvirtualkeyboard-examples = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtvirtualkeyboard-examples-5.15.18-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtvirtualkeyboard-examples}"
SRC_URI[x86_64_v2_qt5-qtvirtualkeyboard-examples.sha256sum] = "d03991658128c23da0dacae2f7a59f514be471de22fe5c265066eec3ff92de00"

URI_aarch64_qt5-qtvirtualkeyboard = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtvirtualkeyboard;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard.sha256sum] = "276807936b11a55cc2ab1c4fe9c115cc30fac6864f65784c543519aaed4bb9be"

URI_aarch64_qt5-qtvirtualkeyboard-devel = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-devel-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtvirtualkeyboard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard-devel}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard-devel.sha256sum] = "35c735ceae0ad4358e17fee0022bf999ecabed45ecca4f88a3763568c207c75a"

URI_aarch64_qt5-qtvirtualkeyboard-examples = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtvirtualkeyboard-examples-5.15.18-1.el10_2.aarch64.rpm;name=aarch64_qt5-qtvirtualkeyboard-examples;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtvirtualkeyboard-examples}"
SRC_URI[aarch64_qt5-qtvirtualkeyboard-examples.sha256sum] = "5864ff3c041d8598ac0eb7ff8f0f6e852d2aaf024c1c022825d8f52ce7b63896"

RDEPENDS:qt5-qtvirtualkeyboard = " \
 glibc \
 hunspell \
 libstdc++ \
 qt5-qtbase \
 qt5-qtbase-gui \
 qt5-qtdeclarative \
 qt5-qtsvg \
 "
RDEPENDS:qt5-qtvirtualkeyboard-devel = " \
 cmake-filesystem \
 pkgconf-pkg-config \
 qt5-qtbase-devel \
 qt5-qtdeclarative-devel \
 qt5-qtvirtualkeyboard \
 "
RDEPENDS:qt5-qtvirtualkeyboard-examples = " \
 qt5-qtvirtualkeyboard \
 "
