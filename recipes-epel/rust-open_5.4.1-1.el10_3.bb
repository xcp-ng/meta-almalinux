# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-open"
PV = "5.4.1"
PR = "1.el10_3"
PACKAGES = " \
 rust-open+default-devel \
 rust-open-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-open-5.4.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "d29ec278d5dce158cb6a98bcb4dbb58fc26ea46ef252aba087f1efbc33d5ea7b"

URI_x86_64_v2_rust-open+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open+default-devel-5.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-open+default-devel}"
SRC_URI[x86_64_v2_rust-open+default-devel.sha256sum] = "03d99ff3139775f29251d642f56bce58f97ff862aaf75d1f66468580841c0069"

URI_x86_64_v2_rust-open-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-open-devel-5.4.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-open-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-open-devel}"
SRC_URI[x86_64_v2_rust-open-devel.sha256sum] = "6f87917aeaacc5c19bba7b86e71fa991ee1ecef36278a6db1d2f4d68c91d6b20"

URI_aarch64_rust-open+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-open+default-devel-5.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-open+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-open+default-devel}"
SRC_URI[aarch64_rust-open+default-devel.sha256sum] = "5cfa6a657008e47324f3a424a57dfa96c51ef549488150ddd78e6dc3fcf9ed44"

URI_aarch64_rust-open-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-open-devel-5.4.1-1.el10_3.noarch.rpm;name=aarch64_rust-open-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-open-devel}"
SRC_URI[aarch64_rust-open-devel.sha256sum] = "43de1cd677a6b085d48690d224ceaaf0b2f2f50157207fd30a8eab78175f24a2"

RDEPENDS:rust-open+default-devel = " \
 cargo \
 rust-open-devel \
 "
RDEPENDS:rust-open-devel = " \
 cargo \
 rust \
 rust-is-wsl+default-devel \
 rust-libc+default-devel \
 "
