# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-markup5ever"
PV = "0.39.0"
PR = "1.el10_3"
PACKAGES = " \
 rust-markup5ever+default-devel \
 rust-markup5ever+serde-devel \
 rust-markup5ever-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-markup5ever-0.39.0-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8a8b1b8162d240bf4af445496530459fa38ce061320976a18befd70f94bb22f6"

URI_x86_64_v2_rust-markup5ever+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever+default-devel-0.39.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever+default-devel}"
SRC_URI[x86_64_v2_rust-markup5ever+default-devel.sha256sum] = "b9c2f20d4e931ee094e8587b1e6400e86df6d93dab47e0b217364b05bb43d33b"

URI_x86_64_v2_rust-markup5ever+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever+serde-devel-0.39.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever+serde-devel}"
SRC_URI[x86_64_v2_rust-markup5ever+serde-devel.sha256sum] = "5fc892597d1dcc4ebed981963c9b47ecf811c106cea9d2ecea193417018cb934"

URI_x86_64_v2_rust-markup5ever-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-markup5ever-devel-0.39.0-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-markup5ever-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-markup5ever-devel}"
SRC_URI[x86_64_v2_rust-markup5ever-devel.sha256sum] = "95d23b0cb8327910525cb10d7ec58ea5067a4e2a210872234020f5c73cfd212b"

URI_aarch64_rust-markup5ever+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever+default-devel-0.39.0-1.el10_3.noarch.rpm;name=aarch64_rust-markup5ever+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever+default-devel}"
SRC_URI[aarch64_rust-markup5ever+default-devel.sha256sum] = "c320f784d640e61167e33d554334b1caa213c03723aeb3cbdc3039c07027612d"

URI_aarch64_rust-markup5ever+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever+serde-devel-0.39.0-1.el10_3.noarch.rpm;name=aarch64_rust-markup5ever+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever+serde-devel}"
SRC_URI[aarch64_rust-markup5ever+serde-devel.sha256sum] = "b5d07662be1c7f03b5142bc3f4bd92c6ae07b74960509f79cf7aae151661b5c8"

URI_aarch64_rust-markup5ever-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-markup5ever-devel-0.39.0-1.el10_3.noarch.rpm;name=aarch64_rust-markup5ever-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-markup5ever-devel}"
SRC_URI[aarch64_rust-markup5ever-devel.sha256sum] = "a42ea0b877664cbe3baca2eb851238998e4d77d1b9896efdcb80161d987ed927"

RDEPENDS:rust-markup5ever+default-devel = " \
 cargo \
 rust-markup5ever-devel \
 "
RDEPENDS:rust-markup5ever+serde-devel = " \
 cargo \
 rust-markup5ever-devel \
 rust-web_atoms+serde-devel \
 "
RDEPENDS:rust-markup5ever-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-tendril+default-devel \
 rust-web_atoms+default-devel \
 "
