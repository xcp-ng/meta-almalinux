# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-fern"
PV = "0.7.1"
PR = "4.el10_1"
PACKAGES = " \
 rust-fern+chrono-devel \
 rust-fern+colored-devel \
 rust-fern+date-based-devel \
 rust-fern+default-devel \
 rust-fern+libc-devel \
 rust-fern+meta-logging-in-format-devel \
 rust-fern+syslog-6-devel \
 rust-fern+syslog6-devel \
 rust-fern-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-fern-0.7.1-4.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "dc11e6bbb59d2a22b5a962e522a3073b8dfc0a5a427c0b0776bda8c692085a86"

URI_x86_64_v2_rust-fern+chrono-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+chrono-devel-0.7.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+chrono-devel}"
SRC_URI[x86_64_v2_rust-fern+chrono-devel.sha256sum] = "ec9fd05cf647cbe52ec76d64934a47d906b170fd753a6f00dba2a46b68a16aaa"

URI_x86_64_v2_rust-fern+colored-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+colored-devel-0.7.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+colored-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+colored-devel}"
SRC_URI[x86_64_v2_rust-fern+colored-devel.sha256sum] = "1cc7ef971b3ee313a440b631f2f671496e5f909855cf23c2ee93cf97defd0906"

URI_x86_64_v2_rust-fern+date-based-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+date-based-devel-0.7.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+date-based-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+date-based-devel}"
SRC_URI[x86_64_v2_rust-fern+date-based-devel.sha256sum] = "352fbb7a03fa2f3df674896501a0ec0b3f3cef400dfc78c940c71f58f9ea4564"

URI_x86_64_v2_rust-fern+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+default-devel-0.7.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+default-devel}"
SRC_URI[x86_64_v2_rust-fern+default-devel.sha256sum] = "0a95cb167b907ffaa31a59db49524a9ee40d5372cc05ff9d4b407ca3411812f2"

URI_x86_64_v2_rust-fern+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+libc-devel-0.7.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+libc-devel}"
SRC_URI[x86_64_v2_rust-fern+libc-devel.sha256sum] = "01b30b0caab48879eb566b6f753ae68edea23ff32383af824d4706030769fdc2"

URI_x86_64_v2_rust-fern+meta-logging-in-format-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+meta-logging-in-format-devel-0.7.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+meta-logging-in-format-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+meta-logging-in-format-devel}"
SRC_URI[x86_64_v2_rust-fern+meta-logging-in-format-devel.sha256sum] = "e2de1bddd63bfadab232d788979773cfb65102ecbd0f4ae9363e169a0006b43b"

URI_x86_64_v2_rust-fern+syslog-6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+syslog-6-devel-0.7.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+syslog-6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+syslog-6-devel}"
SRC_URI[x86_64_v2_rust-fern+syslog-6-devel.sha256sum] = "e9f2cad9566aab058e0b4d4dad745b305625de7e9cb876074ad15ac1d9f277a1"

URI_x86_64_v2_rust-fern+syslog6-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern+syslog6-devel-0.7.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern+syslog6-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern+syslog6-devel}"
SRC_URI[x86_64_v2_rust-fern+syslog6-devel.sha256sum] = "dcda866a6f993fbf92efe086f25ceca2717247b9a15cb68bb6a32ffccbbb74d6"

URI_x86_64_v2_rust-fern-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-fern-devel-0.7.1-4.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-fern-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-fern-devel}"
SRC_URI[x86_64_v2_rust-fern-devel.sha256sum] = "3d89a2874f547a4a419d1d84422c8c96d1322359f5a46e45ae6c7ba9319ec530"

URI_aarch64_rust-fern+chrono-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+chrono-devel-0.7.1-4.el10_1.noarch.rpm;name=aarch64_rust-fern+chrono-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+chrono-devel}"
SRC_URI[aarch64_rust-fern+chrono-devel.sha256sum] = "1b31dd1d2bb947dc37fb5c3d86f579bda609067e1c824b2d802d7994fef04a82"

URI_aarch64_rust-fern+colored-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+colored-devel-0.7.1-4.el10_1.noarch.rpm;name=aarch64_rust-fern+colored-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+colored-devel}"
SRC_URI[aarch64_rust-fern+colored-devel.sha256sum] = "3ab170a671a10f7cc953da9150ce3e08a305d62aced9fb971e2fc71cc3bdac06"

URI_aarch64_rust-fern+date-based-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+date-based-devel-0.7.1-4.el10_1.noarch.rpm;name=aarch64_rust-fern+date-based-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+date-based-devel}"
SRC_URI[aarch64_rust-fern+date-based-devel.sha256sum] = "f13bbb01daac2e5a752a603ae745ae3031215462269287ae0ea5c59f1059af21"

URI_aarch64_rust-fern+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+default-devel-0.7.1-4.el10_1.noarch.rpm;name=aarch64_rust-fern+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+default-devel}"
SRC_URI[aarch64_rust-fern+default-devel.sha256sum] = "45c6e4b6a26c243b95795c6cdb28dd0ecbf175063847de5be947585ae27febe9"

URI_aarch64_rust-fern+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+libc-devel-0.7.1-4.el10_1.noarch.rpm;name=aarch64_rust-fern+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+libc-devel}"
SRC_URI[aarch64_rust-fern+libc-devel.sha256sum] = "0950ed936ba4eaab667f88fe9a24badd6e357570e50aa00274137f13676b080f"

URI_aarch64_rust-fern+meta-logging-in-format-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+meta-logging-in-format-devel-0.7.1-4.el10_1.noarch.rpm;name=aarch64_rust-fern+meta-logging-in-format-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+meta-logging-in-format-devel}"
SRC_URI[aarch64_rust-fern+meta-logging-in-format-devel.sha256sum] = "b460ed7868197cd4e9eb93d334c010f7ae210621d8850fe831551a83463dbec4"

URI_aarch64_rust-fern+syslog-6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+syslog-6-devel-0.7.1-4.el10_1.noarch.rpm;name=aarch64_rust-fern+syslog-6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+syslog-6-devel}"
SRC_URI[aarch64_rust-fern+syslog-6-devel.sha256sum] = "e69f1ca78ec6bc813b4ac839ec2697043fbe09f2cc866da3a8a796a2d31f54fd"

URI_aarch64_rust-fern+syslog6-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern+syslog6-devel-0.7.1-4.el10_1.noarch.rpm;name=aarch64_rust-fern+syslog6-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern+syslog6-devel}"
SRC_URI[aarch64_rust-fern+syslog6-devel.sha256sum] = "1aea8c471046c03329db3f16a9c97b9a79c1ccb3846ccb78d4ae6da6e377febd"

URI_aarch64_rust-fern-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-fern-devel-0.7.1-4.el10_1.noarch.rpm;name=aarch64_rust-fern-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-fern-devel}"
SRC_URI[aarch64_rust-fern-devel.sha256sum] = "acc6069321b8aab223247596b0aa9e9030358b727069ac1e0ea9a2e749234cdc"

RDEPENDS:rust-fern+chrono-devel = " \
 cargo \
 rust-chrono+clock-devel \
 rust-chrono+std-devel \
 rust-chrono-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+colored-devel = " \
 cargo \
 rust-colored2+default-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+date-based-devel = " \
 cargo \
 rust-fern+chrono-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+default-devel = " \
 cargo \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+libc-devel = " \
 cargo \
 rust-fern-devel \
 rust-libc+default-devel \
 "
RDEPENDS:rust-fern+meta-logging-in-format-devel = " \
 cargo \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+syslog-6-devel = " \
 cargo \
 rust-fern+syslog6-devel \
 rust-fern-devel \
 "
RDEPENDS:rust-fern+syslog6-devel = " \
 cargo \
 rust-fern-devel \
 rust-syslog+default-devel \
 "
RDEPENDS:rust-fern-devel = " \
 cargo \
 rust \
 rust-log+default-devel \
 rust-log+std-devel \
 "
