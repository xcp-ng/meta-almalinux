# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-tokio"
PV = "1.46.1"
PR = "1.el10_0"
PACKAGES = " \
 rust-tokio+bytes-devel \
 rust-tokio+default-devel \
 rust-tokio+fs-devel \
 rust-tokio+full-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+libc-devel \
 rust-tokio+macros-devel \
 rust-tokio+mio-devel \
 rust-tokio+net-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio+socket2-devel \
 rust-tokio+sync-devel \
 rust-tokio+test-util-devel \
 rust-tokio+time-devel \
 rust-tokio+tokio-macros-devel \
 rust-tokio-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-tokio-1.46.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "af1ae37b92333c816b68ab3f5779ba7c4fa5ad03fdb85cfa44c7cd532d2a8428"

URI_x86_64_v2_rust-tokio+bytes-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+bytes-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+bytes-devel}"
SRC_URI[x86_64_v2_rust-tokio+bytes-devel.sha256sum] = "4a3fcb9e00bf4061d8c28f9f8aa905c6277c00211ac03846a7f81f246e14686d"

URI_x86_64_v2_rust-tokio+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+default-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+default-devel}"
SRC_URI[x86_64_v2_rust-tokio+default-devel.sha256sum] = "e0b3c5a5bc3fbfac66fee5c4a68f49b43dc5cf2b489b5b3d95890ccb875583af"

URI_x86_64_v2_rust-tokio+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+fs-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+fs-devel}"
SRC_URI[x86_64_v2_rust-tokio+fs-devel.sha256sum] = "ff07b018b7b40b885bde2fa1f0d15118e0c8faced4751a4302623aaeaf3db29f"

URI_x86_64_v2_rust-tokio+full-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+full-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+full-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+full-devel}"
SRC_URI[x86_64_v2_rust-tokio+full-devel.sha256sum] = "24add82fbc815aa97b59e9e4816243773a878f96ec96b666bc6f4e3660596580"

URI_x86_64_v2_rust-tokio+io-std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+io-std-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+io-std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+io-std-devel}"
SRC_URI[x86_64_v2_rust-tokio+io-std-devel.sha256sum] = "c89833b58e017d121fc28c51b909e534d4b5b308a397555891c1a83994bc224c"

URI_x86_64_v2_rust-tokio+io-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+io-util-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+io-util-devel}"
SRC_URI[x86_64_v2_rust-tokio+io-util-devel.sha256sum] = "b22dcb45a3b20dd34739377cfb7feb874d0d0fbace3fc6d4d686d2593ae9008d"

URI_x86_64_v2_rust-tokio+libc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+libc-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+libc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+libc-devel}"
SRC_URI[x86_64_v2_rust-tokio+libc-devel.sha256sum] = "b66c35572ecf9d899cd8f1e72aa6f3b835f124658d2602b6e74aefa2bb53fd91"

URI_x86_64_v2_rust-tokio+macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+macros-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+macros-devel}"
SRC_URI[x86_64_v2_rust-tokio+macros-devel.sha256sum] = "ce4b6d608e453954d8668742d15f1fa1310383fc73c227a61d2d94762cbb19b7"

URI_x86_64_v2_rust-tokio+mio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+mio-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+mio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+mio-devel}"
SRC_URI[x86_64_v2_rust-tokio+mio-devel.sha256sum] = "574f55394e2bf1968f8b9b69df73feaf54b3513d491b515dee4f93d2a2f187cc"

URI_x86_64_v2_rust-tokio+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+net-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+net-devel}"
SRC_URI[x86_64_v2_rust-tokio+net-devel.sha256sum] = "9d7cca1be3dee2de1976a2a34f9f6e4a71f0a558bd012116d145b74bdb44a5bd"

URI_x86_64_v2_rust-tokio+parking_lot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+parking_lot-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+parking_lot-devel}"
SRC_URI[x86_64_v2_rust-tokio+parking_lot-devel.sha256sum] = "7dbf993efa1caab1e13f97d4aab9edcb694aeb53343871cbb53c9f60e7fe0d6c"

URI_x86_64_v2_rust-tokio+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+process-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+process-devel}"
SRC_URI[x86_64_v2_rust-tokio+process-devel.sha256sum] = "c174fdba16228a4b7c86c0dd64a157b8ad05f8962e0900508faa9cb116eeeb42"

URI_x86_64_v2_rust-tokio+rt-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+rt-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+rt-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+rt-devel}"
SRC_URI[x86_64_v2_rust-tokio+rt-devel.sha256sum] = "bc195beaaf10b008a23e121f2067ad35c7e77277134b6ef0f29ae4634afa9c72"

URI_x86_64_v2_rust-tokio+rt-multi-thread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+rt-multi-thread-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+rt-multi-thread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+rt-multi-thread-devel}"
SRC_URI[x86_64_v2_rust-tokio+rt-multi-thread-devel.sha256sum] = "deef54429b88ce75fe9855a82f7c2551dd8d6418a6439de6e699c4f144e3ae06"

URI_x86_64_v2_rust-tokio+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+signal-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+signal-devel}"
SRC_URI[x86_64_v2_rust-tokio+signal-devel.sha256sum] = "5ff9dcdf55451271417f6b07ccf52f418e1ca9786c73c99ef5603e81a7537536"

URI_x86_64_v2_rust-tokio+signal-hook-registry-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+signal-hook-registry-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+signal-hook-registry-devel}"
SRC_URI[x86_64_v2_rust-tokio+signal-hook-registry-devel.sha256sum] = "0cb1a19fd390d2522490bfdae7f979519cdae5742ca061432ed88ca82826dfcd"

URI_x86_64_v2_rust-tokio+socket2-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+socket2-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+socket2-devel}"
SRC_URI[x86_64_v2_rust-tokio+socket2-devel.sha256sum] = "d13df352732ecbe02875f9bacb0b9931e3edbb09822878e782f7508c9526e1b8"

URI_x86_64_v2_rust-tokio+sync-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+sync-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+sync-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+sync-devel}"
SRC_URI[x86_64_v2_rust-tokio+sync-devel.sha256sum] = "b10954512c472cb14a36f87fef3157d731dd2b1fc5f8dd93cc05d8b66ec90356"

URI_x86_64_v2_rust-tokio+test-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+test-util-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+test-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+test-util-devel}"
SRC_URI[x86_64_v2_rust-tokio+test-util-devel.sha256sum] = "3d22ba612bf8d7197a16ccac687b1a74978b2cf3064baa1fcb97519b2d975f66"

URI_x86_64_v2_rust-tokio+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+time-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+time-devel}"
SRC_URI[x86_64_v2_rust-tokio+time-devel.sha256sum] = "1126203fd9b0d62162bf0407e3b8051f8c0fa4e6c33fa1f81ee90d5864cc4c00"

URI_x86_64_v2_rust-tokio+tokio-macros-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio+tokio-macros-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio+tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio+tokio-macros-devel}"
SRC_URI[x86_64_v2_rust-tokio+tokio-macros-devel.sha256sum] = "e1d7cee64a15db9d773ca850d2d93e4f07fd6e9781b433d44b689dd3dcfbb13f"

URI_x86_64_v2_rust-tokio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-tokio-devel-1.46.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-tokio-devel}"
SRC_URI[x86_64_v2_rust-tokio-devel.sha256sum] = "948ebfa38059e1308adb1ce0264146385d23093c5196a271bd38c3bf7bb3dff9"

URI_aarch64_rust-tokio+bytes-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+bytes-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+bytes-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+bytes-devel}"
SRC_URI[aarch64_rust-tokio+bytes-devel.sha256sum] = "3a0751a751ba392006da0e28665ec2e37a3d34508c90a1e2bdf50be398dafe80"

URI_aarch64_rust-tokio+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+default-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+default-devel}"
SRC_URI[aarch64_rust-tokio+default-devel.sha256sum] = "8ee0aea953de40b75a2813d4972d1241a32e6aa37e4989ef00d884d1f19f5201"

URI_aarch64_rust-tokio+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+fs-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+fs-devel}"
SRC_URI[aarch64_rust-tokio+fs-devel.sha256sum] = "c45bd558e687f15336646f64fc0f99491de1b81a475379a082ff354b0018b373"

URI_aarch64_rust-tokio+full-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+full-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+full-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+full-devel}"
SRC_URI[aarch64_rust-tokio+full-devel.sha256sum] = "3f1096dfddd80038a3cc77a412d2392050f2ffeadab0a2a055f7d30f6c288b11"

URI_aarch64_rust-tokio+io-std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+io-std-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+io-std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+io-std-devel}"
SRC_URI[aarch64_rust-tokio+io-std-devel.sha256sum] = "411dbb6893ae8c4d48f6c8f65ccf1ea085bdaeae94840f7aa7506427389ca926"

URI_aarch64_rust-tokio+io-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+io-util-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+io-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+io-util-devel}"
SRC_URI[aarch64_rust-tokio+io-util-devel.sha256sum] = "4bcf1b788ded2043eda90bfc4475f553b5e9b01641251f9703c28496cd0a9888"

URI_aarch64_rust-tokio+libc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+libc-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+libc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+libc-devel}"
SRC_URI[aarch64_rust-tokio+libc-devel.sha256sum] = "568b4f2e17791d45f4b5cc80f5712a9e3d4b18bcc73ed4f102343d266999b42d"

URI_aarch64_rust-tokio+macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+macros-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+macros-devel}"
SRC_URI[aarch64_rust-tokio+macros-devel.sha256sum] = "a81f7ae1fa7ece732adf5d15099a7807937171bba8169bc95387e7b25748d8b0"

URI_aarch64_rust-tokio+mio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+mio-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+mio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+mio-devel}"
SRC_URI[aarch64_rust-tokio+mio-devel.sha256sum] = "29204eab34ae0a9b785ebe674858fb5ef25624b4c6a9cb2a582ec800af691a23"

URI_aarch64_rust-tokio+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+net-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+net-devel}"
SRC_URI[aarch64_rust-tokio+net-devel.sha256sum] = "99d08a71daf22580855b736bbbea9246af61b6008858c838e900a4b27892994b"

URI_aarch64_rust-tokio+parking_lot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+parking_lot-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+parking_lot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+parking_lot-devel}"
SRC_URI[aarch64_rust-tokio+parking_lot-devel.sha256sum] = "0c73fb8f78f71eddde76ac3afd56239a6f75835958bb25c7047f35a822356531"

URI_aarch64_rust-tokio+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+process-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+process-devel}"
SRC_URI[aarch64_rust-tokio+process-devel.sha256sum] = "4a9963f7bf6adc953190a53c8e78fedc38fdaca512c492cab7f46a8b7160f913"

URI_aarch64_rust-tokio+rt-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+rt-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+rt-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+rt-devel}"
SRC_URI[aarch64_rust-tokio+rt-devel.sha256sum] = "1a6b8c96f39114070cca9197d94c397abb0f97f0ecc2e28424dfb452fc48d46f"

URI_aarch64_rust-tokio+rt-multi-thread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+rt-multi-thread-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+rt-multi-thread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+rt-multi-thread-devel}"
SRC_URI[aarch64_rust-tokio+rt-multi-thread-devel.sha256sum] = "a765105b26df953b15f1584a2b027a86fe1d1a0b76a1cd9611b29c553ebd7d6d"

URI_aarch64_rust-tokio+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+signal-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+signal-devel}"
SRC_URI[aarch64_rust-tokio+signal-devel.sha256sum] = "b0b509358bb7f32e2bf4c109878beb550d903d0aaa46002067f7546845cabc11"

URI_aarch64_rust-tokio+signal-hook-registry-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+signal-hook-registry-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+signal-hook-registry-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+signal-hook-registry-devel}"
SRC_URI[aarch64_rust-tokio+signal-hook-registry-devel.sha256sum] = "4945fd74ef34246deb5e68b90c6ffaab4ad5d9929076d44cd612858c08c7b3de"

URI_aarch64_rust-tokio+socket2-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+socket2-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+socket2-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+socket2-devel}"
SRC_URI[aarch64_rust-tokio+socket2-devel.sha256sum] = "25a67135d42da8aff9edcd23b336edd9b2a23b4c65cfa98b14c3f9662c4a4ea4"

URI_aarch64_rust-tokio+sync-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+sync-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+sync-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+sync-devel}"
SRC_URI[aarch64_rust-tokio+sync-devel.sha256sum] = "7b705b2d0204681407d4c325698b799f3301488e826426a6f4a0fcfaebd49d2b"

URI_aarch64_rust-tokio+test-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+test-util-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+test-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+test-util-devel}"
SRC_URI[aarch64_rust-tokio+test-util-devel.sha256sum] = "73b6cd7e448429c8bddf567fb07a63acecb6701a2b6ed3b51d05322802981d43"

URI_aarch64_rust-tokio+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+time-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+time-devel}"
SRC_URI[aarch64_rust-tokio+time-devel.sha256sum] = "143c03cce4db36f1ddc1f1f82e1ea669b97b2adf0dc2fe783de803a05cda65e1"

URI_aarch64_rust-tokio+tokio-macros-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio+tokio-macros-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio+tokio-macros-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio+tokio-macros-devel}"
SRC_URI[aarch64_rust-tokio+tokio-macros-devel.sha256sum] = "de57903b9026783585b909aeb2081eab981968d7eddc259c30e94f4af356d357"

URI_aarch64_rust-tokio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-tokio-devel-1.46.1-1.el10_0.noarch.rpm;name=aarch64_rust-tokio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-tokio-devel}"
SRC_URI[aarch64_rust-tokio-devel.sha256sum] = "65aae56c9c090d14294108adfeaa31955e2aafb01109d53ebfc035e807dd7b47"

RDEPENDS:rust-tokio+bytes-devel = " \
 cargo \
 rust-bytes+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+default-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+fs-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+full-devel = " \
 cargo \
 rust-tokio+fs-devel \
 rust-tokio+io-std-devel \
 rust-tokio+io-util-devel \
 rust-tokio+macros-devel \
 rust-tokio+net-devel \
 rust-tokio+parking_lot-devel \
 rust-tokio+process-devel \
 rust-tokio+rt-devel \
 rust-tokio+rt-multi-thread-devel \
 rust-tokio+signal-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+io-std-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+io-util-devel = " \
 cargo \
 rust-tokio+bytes-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+libc-devel = " \
 cargo \
 rust-libc+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+macros-devel = " \
 cargo \
 rust-tokio+tokio-macros-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+mio-devel = " \
 cargo \
 rust-mio-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+net-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+libc-devel \
 rust-tokio+socket2-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+parking_lot-devel = " \
 cargo \
 rust-parking_lot+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+process-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+bytes-devel \
 rust-tokio+libc-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+rt-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+rt-multi-thread-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+signal-devel = " \
 cargo \
 rust-mio+net-devel \
 rust-mio+os-ext-devel \
 rust-mio+os-poll-devel \
 rust-mio-devel \
 rust-tokio+libc-devel \
 rust-tokio+signal-hook-registry-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+signal-hook-registry-devel = " \
 cargo \
 rust-signal-hook-registry+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+socket2-devel = " \
 cargo \
 rust-socket2+all-devel \
 rust-socket2+default-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+sync-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+test-util-devel = " \
 cargo \
 rust-tokio+rt-devel \
 rust-tokio+sync-devel \
 rust-tokio+time-devel \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+time-devel = " \
 cargo \
 rust-tokio-devel \
 "
RDEPENDS:rust-tokio+tokio-macros-devel = " \
 cargo \
 rust-tokio-devel \
 rust-tokio-macros+default-devel \
 "
RDEPENDS:rust-tokio-devel = " \
 cargo \
 rust \
 rust-pin-project-lite+default-devel \
 "
