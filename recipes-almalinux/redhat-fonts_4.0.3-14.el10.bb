# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "redhat-fonts"
PV = "4.0.3"
PR = "14.el10"
PACKAGES = " \
 redhat-display-fonts \
 redhat-display-vf-fonts \
 redhat-mono-fonts \
 redhat-mono-vf-fonts \
 redhat-text-fonts \
 redhat-text-vf-fonts \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/redhat-fonts-4.0.3-14.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56d34ec871f79e074bf1a09910d651eba5b0583c2a809a9232455655685c1575"

URI_x86_64_v2_redhat-display-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-display-fonts-4.0.3-14.el10.noarch.rpm;name=x86_64_v2_redhat-display-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-display-fonts}"
SRC_URI[x86_64_v2_redhat-display-fonts.sha256sum] = "acf308683f0fe00034491607dae90df36af50402d479dbd0dc5934428d95e524"
RPROVIDES:redhat-display-fonts:x86_64_v2 = "virtual/font_redhatdisplay_"

URI_x86_64_v2_redhat-display-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-display-vf-fonts-4.0.3-14.el10.noarch.rpm;name=x86_64_v2_redhat-display-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-display-vf-fonts}"
SRC_URI[x86_64_v2_redhat-display-vf-fonts.sha256sum] = "8d7dc0be20684a7a3fb378ba6669b1e30fcf01abeacb86938421ee3404a084a9"
RPROVIDES:redhat-display-vf-fonts:x86_64_v2 = "virtual/font_redhatdisplay_"

URI_x86_64_v2_redhat-mono-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-mono-fonts-4.0.3-14.el10.noarch.rpm;name=x86_64_v2_redhat-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-mono-fonts}"
SRC_URI[x86_64_v2_redhat-mono-fonts.sha256sum] = "c150d69b3a7761e00521443ca8fc9135c33bfc62971c1cd4559874cbb91f5408"

URI_x86_64_v2_redhat-mono-vf-fonts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/redhat-mono-vf-fonts-4.0.3-14.el10.noarch.rpm;name=x86_64_v2_redhat-mono-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-mono-vf-fonts}"
SRC_URI[x86_64_v2_redhat-mono-vf-fonts.sha256sum] = "5e00a71043dfc40c10f4e7a88ceeb5bff54cfcb3d3bb3a67ffe0284e72f34495"

URI_x86_64_v2_redhat-text-fonts = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/redhat-text-fonts-4.0.3-14.el10.noarch.rpm;name=x86_64_v2_redhat-text-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-text-fonts}"
SRC_URI[x86_64_v2_redhat-text-fonts.sha256sum] = "ece22d18996081baa8160cc48a0dedf36332dd8342aa67a968ac3280ee62dc38"
RPROVIDES:redhat-text-fonts:x86_64_v2 = "virtual/font_redhattext_"

URI_x86_64_v2_redhat-text-vf-fonts = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/redhat-text-vf-fonts-4.0.3-14.el10.noarch.rpm;name=x86_64_v2_redhat-text-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_redhat-text-vf-fonts}"
SRC_URI[x86_64_v2_redhat-text-vf-fonts.sha256sum] = "627e01e8dfcf82e44aee6972ca2b8f2ebcb9efcc8cac60e5d824baa8bd645ce9"
RPROVIDES:redhat-text-vf-fonts:x86_64_v2 = "virtual/font_redhattext_"

URI_aarch64_redhat-display-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-display-fonts-4.0.3-14.el10.noarch.rpm;name=aarch64_redhat-display-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-display-fonts}"
SRC_URI[aarch64_redhat-display-fonts.sha256sum] = "acf308683f0fe00034491607dae90df36af50402d479dbd0dc5934428d95e524"
RPROVIDES:redhat-display-fonts:aarch64 = "virtual/font_redhatdisplay_"

URI_aarch64_redhat-display-vf-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-display-vf-fonts-4.0.3-14.el10.noarch.rpm;name=aarch64_redhat-display-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-display-vf-fonts}"
SRC_URI[aarch64_redhat-display-vf-fonts.sha256sum] = "8d7dc0be20684a7a3fb378ba6669b1e30fcf01abeacb86938421ee3404a084a9"
RPROVIDES:redhat-display-vf-fonts:aarch64 = "virtual/font_redhatdisplay_"

URI_aarch64_redhat-mono-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-mono-fonts-4.0.3-14.el10.noarch.rpm;name=aarch64_redhat-mono-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-mono-fonts}"
SRC_URI[aarch64_redhat-mono-fonts.sha256sum] = "c150d69b3a7761e00521443ca8fc9135c33bfc62971c1cd4559874cbb91f5408"

URI_aarch64_redhat-mono-vf-fonts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/redhat-mono-vf-fonts-4.0.3-14.el10.noarch.rpm;name=aarch64_redhat-mono-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-mono-vf-fonts}"
SRC_URI[aarch64_redhat-mono-vf-fonts.sha256sum] = "5e00a71043dfc40c10f4e7a88ceeb5bff54cfcb3d3bb3a67ffe0284e72f34495"

URI_aarch64_redhat-text-fonts = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/redhat-text-fonts-4.0.3-14.el10.noarch.rpm;name=aarch64_redhat-text-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-text-fonts}"
SRC_URI[aarch64_redhat-text-fonts.sha256sum] = "ece22d18996081baa8160cc48a0dedf36332dd8342aa67a968ac3280ee62dc38"
RPROVIDES:redhat-text-fonts:aarch64 = "virtual/font_redhattext_"

URI_aarch64_redhat-text-vf-fonts = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/redhat-text-vf-fonts-4.0.3-14.el10.noarch.rpm;name=aarch64_redhat-text-vf-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_redhat-text-vf-fonts}"
SRC_URI[aarch64_redhat-text-vf-fonts.sha256sum] = "627e01e8dfcf82e44aee6972ca2b8f2ebcb9efcc8cac60e5d824baa8bd645ce9"
RPROVIDES:redhat-text-vf-fonts:aarch64 = "virtual/font_redhattext_"

RDEPENDS:redhat-display-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-display-vf-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-mono-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-mono-vf-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-text-fonts = " \
 fonts-filesystem \
 "
RDEPENDS:redhat-text-vf-fonts = " \
 fonts-filesystem \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/font_redhatdisplay_ rpm/virtual/font_redhattext_"

PROVIDES:append:aarch64 = " rpm/virtual/font_redhatdisplay_ rpm/virtual/font_redhattext_"
