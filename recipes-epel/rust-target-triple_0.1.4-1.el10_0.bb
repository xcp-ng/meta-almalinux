# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-target-triple"
PV = "0.1.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-target-triple+default-devel \
 rust-target-triple-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-target-triple-0.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "8f6b149bf526fc27f50286b7b2f9801b304533c54f68c80a5ed3004a75fa7d36"

URI_x86_64_v2_rust-target-triple+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-triple+default-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-triple+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-triple+default-devel}"
SRC_URI[x86_64_v2_rust-target-triple+default-devel.sha256sum] = "0158e31759747e6db7944875c648f0ce7dfba36f034e0e3fe219ab8b8d4af94e"

URI_x86_64_v2_rust-target-triple-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-target-triple-devel-0.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-target-triple-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-target-triple-devel}"
SRC_URI[x86_64_v2_rust-target-triple-devel.sha256sum] = "aba517454f88fc69b2fa8542b3d215707a0e7628a451a6db9dcd477e21fe4bae"

URI_aarch64_rust-target-triple+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-triple+default-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-target-triple+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-triple+default-devel}"
SRC_URI[aarch64_rust-target-triple+default-devel.sha256sum] = "efadd4a8e2e9a05da9f265716d0a03406a8b004f0c5e43ebdd27b6b6f2fbe0c1"

URI_aarch64_rust-target-triple-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-target-triple-devel-0.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-target-triple-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-target-triple-devel}"
SRC_URI[aarch64_rust-target-triple-devel.sha256sum] = "55fec39ccdf64da9578214e8cdfa6d4dce35763b42f94e415ad10b5933389567"

RDEPENDS:rust-target-triple+default-devel = " \
 cargo \
 rust-target-triple-devel \
 "
RDEPENDS:rust-target-triple-devel = " \
 cargo \
 rust \
 "
