# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kapptemplate"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kapptemplate \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kapptemplate-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "f168a349bd1cc861d8f1cb73a58fcdee82b15d0890c425e9f7d6336572b6199b"

URI_x86_64_v2_kapptemplate = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kapptemplate-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kapptemplate;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kapptemplate}"
SRC_URI[x86_64_v2_kapptemplate.sha256sum] = "360ede9abbe6c615eab5d21ccdc6c8f0efed0eb26419c8ccaf808a327b6a1589"

URI_aarch64_kapptemplate = "${EPEL_MIRROR}/aarch64/Packages/k/kapptemplate-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kapptemplate;unpack=0"
SRC_URI:append = " ${URI_aarch64_kapptemplate}"
SRC_URI[aarch64_kapptemplate.sha256sum] = "4045c73e2b36629f9f1c71392515da1111f8bdf49ee1b157fab35ce9ae9b7d5b"

RDEPENDS:kapptemplate = " \
 glibc \
 kf6-karchive \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
