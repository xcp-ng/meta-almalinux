# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "NetworkManager"
PE = "1"
PV = "1.58.0"
PR = "1.el10"
PACKAGES = " \
 NetworkManager \
 NetworkManager-adsl \
 NetworkManager-bluetooth \
 NetworkManager-cloud-setup \
 NetworkManager-config-connectivity-redhat \
 NetworkManager-config-server \
 NetworkManager-libnm \
 NetworkManager-libnm-devel \
 NetworkManager-ovs \
 NetworkManager-ppp \
 NetworkManager-tui \
 NetworkManager-wifi \
 NetworkManager-wwan \
 "

SRC_URI = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/NetworkManager-1.58.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "d6fe1fb93105f31b84733c09ecbbb1e4be860307b9646cba38becf52e5230e5b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager;unpack=0"
SRC_URI[x86_64_v2_NetworkManager.sha256sum] = "7efc28ab4ccb65b1e7854e9b0ce54f42e695a531bb0e24c5b1fb8c9efcda52e8"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-adsl-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-adsl;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-adsl.sha256sum] = "75b6a5b299605ebf56aba51b5075cd85d5d198e631888e051a5b3533e4fdd0e2"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-bluetooth-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-bluetooth;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-bluetooth.sha256sum] = "2b7638636808ac0b34b1eb0e52509c9c3428710a70522fd63da53351babe7fa6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-cloud-setup-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-cloud-setup;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-cloud-setup.sha256sum] = "570f4c854160607596db71b83de586afaecc9d2f2d135872d5274d3c7aa488e5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-config-connectivity-redhat-1.58.0-1.el10.noarch.rpm;name=x86_64_v2_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-config-connectivity-redhat.sha256sum] = "83ca69f5cc1709da29f5b6c69dd7be427f3a8c1219ed55542f2a8e8a27b5ccac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-config-server-1.58.0-1.el10.noarch.rpm;name=x86_64_v2_NetworkManager-config-server;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-config-server.sha256sum] = "cd16354939e7611dba55a7ac2df939c4d36e1cb39209e07cea9f50cdc322d36c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-libnm-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-libnm.sha256sum] = "6bf094face267d3a5b18d9f32271b48bac7ecce667f1b76886687d1f3e0fe83d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/NetworkManager-libnm-devel-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-libnm-devel;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-libnm-devel.sha256sum] = "057fce421647ea091f48692305ae226aa064fa1ab13b88e075927a7ed1e930db"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ovs-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ovs;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-ovs.sha256sum] = "2121543dfe797cad2561340220561f30c0f41facea210c7d7dc07b7d50375b10"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/NetworkManager-ppp-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-ppp;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-ppp.sha256sum] = "80c879885b4145fb5123daa775b695026c781496aa9e8bf14408a04f0f222aef"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-tui-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-tui;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-tui.sha256sum] = "af7b63dd6f18f115f0cb54e12a68dfb97eb3682e7ff0aae596164768fb3a6e51"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wifi-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wifi;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-wifi.sha256sum] = "dfc0430766740776fa9604a74b570df81d58a62d2e5f8dc2b32fd441820095f3"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/NetworkManager-wwan-1.58.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_NetworkManager-wwan;unpack=0"
SRC_URI[x86_64_v2_NetworkManager-wwan.sha256sum] = "4b4ff6a32c9bf334e6533b83d477e04f80247b0949a0127be9279dfdae02777e"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager;unpack=0"
SRC_URI[aarch64_NetworkManager.sha256sum] = "6b86d36c9426afd57e2bccce3179c9cce90ebb5f17992b1885a6d85fc08405c5"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-adsl-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-adsl;unpack=0"
SRC_URI[aarch64_NetworkManager-adsl.sha256sum] = "ea033a0901826bbb5087556483bd1795a9ed9017071019e5b1a3947d0c953a33"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-bluetooth-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-bluetooth;unpack=0"
SRC_URI[aarch64_NetworkManager-bluetooth.sha256sum] = "7f8be0c8085ffac4a956c84e4fa870654ce68ada6ba99009673ab079e4e6a9f6"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-cloud-setup-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-cloud-setup;unpack=0"
SRC_URI[aarch64_NetworkManager-cloud-setup.sha256sum] = "07896ae18c4b97bc1452f395490e3297e5050432d4382c77ed33f303f1cbd392"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-config-connectivity-redhat-1.58.0-1.el10.noarch.rpm;name=aarch64_NetworkManager-config-connectivity-redhat;unpack=0"
SRC_URI[aarch64_NetworkManager-config-connectivity-redhat.sha256sum] = "83ca69f5cc1709da29f5b6c69dd7be427f3a8c1219ed55542f2a8e8a27b5ccac"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-config-server-1.58.0-1.el10.noarch.rpm;name=aarch64_NetworkManager-config-server;unpack=0"
SRC_URI[aarch64_NetworkManager-config-server.sha256sum] = "cd16354939e7611dba55a7ac2df939c4d36e1cb39209e07cea9f50cdc322d36c"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-libnm-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-libnm;unpack=0"
SRC_URI[aarch64_NetworkManager-libnm.sha256sum] = "98cd2f97447afc8c0a897e768e7e37975dd6f6168c1cf879ee92c6540c93fc5a"

SRC_URI:append = " ${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/NetworkManager-libnm-devel-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-libnm-devel;unpack=0"
SRC_URI[aarch64_NetworkManager-libnm-devel.sha256sum] = "e66ac312a8e58ff661647244b70d36ec17ed19a3ba6f83d992b680c89f9c8724"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ovs-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-ovs;unpack=0"
SRC_URI[aarch64_NetworkManager-ovs.sha256sum] = "8c8a528b9c7103ecfe13920dd0b443f3d5d508f5310d5b1dadf7c45484e7f21b"

SRC_URI:append = " ${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/NetworkManager-ppp-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-ppp;unpack=0"
SRC_URI[aarch64_NetworkManager-ppp.sha256sum] = "46589dd4b610718388a0d4b98b16d373f661ba99d35559893646bd9c9fa8cac4"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-tui-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-tui;unpack=0"
SRC_URI[aarch64_NetworkManager-tui.sha256sum] = "05f8e197b9d278c1555395ffa45e558a8c0fb3284e854f1ebd3b650699b7963d"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wifi-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-wifi;unpack=0"
SRC_URI[aarch64_NetworkManager-wifi.sha256sum] = "758ba574287ddf646eec03aa8ecb82c56c798ad04b3856b8bc5b6ea3b195b5c9"

SRC_URI:append = " ${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/NetworkManager-wwan-1.58.0-1.el10.aarch64.rpm;name=aarch64_NetworkManager-wwan;unpack=0"
SRC_URI[aarch64_NetworkManager-wwan.sha256sum] = "e7b61a5c0623d621e0597aba3be790b28e6139bc2272d692d40a224de9a46b95"

RDEPENDS:NetworkManager = " \
 NetworkManager-libnm \
 audit-libs \
 bash \
 dbus \
 glib2 \
 glibc \
 gnutls \
 libbpf \
 libgcc \
 libndp \
 libselinux \
 readline \
 systemd \
 systemd-libs \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-adsl = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-bluetooth = " \
 NetworkManager \
 NetworkManager-wwan \
 bluez \
 bluez-libs \
 glib2 \
 glibc \
 libgcc \
 "
RDEPENDS:NetworkManager-cloud-setup = " \
 NetworkManager \
 NetworkManager-libnm \
 bash \
 glib2 \
 glibc \
 jansson \
 libgcc \
 virtual/libcurl.so.4___64bit_ \
 "
RDEPENDS:NetworkManager-config-connectivity-redhat = " \
 "
RDEPENDS:NetworkManager-config-server = " \
 "
RDEPENDS:NetworkManager-libnm = " \
 glib2 \
 glibc \
 gnutls \
 libgcc \
 systemd-libs \
 "
RDEPENDS:NetworkManager-libnm-devel = " \
 NetworkManager-libnm \
 glib2-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:NetworkManager-ovs = " \
 NetworkManager \
 glib2 \
 glibc \
 jansson \
 libgcc \
 "
RDEPENDS:NetworkManager-ppp = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 ppp \
 "
RDEPENDS:NetworkManager-tui = " \
 NetworkManager \
 NetworkManager-libnm \
 glib2 \
 glibc \
 libgcc \
 newt \
 slang \
 "
RDEPENDS:NetworkManager-wifi = " \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 wireless-regdb \
 wpa_supplicant \
 "
RDEPENDS:NetworkManager-wwan = " \
 ModemManager \
 ModemManager-glib \
 NetworkManager \
 glib2 \
 glibc \
 libgcc \
 systemd-libs \
 "
