# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Compress-Raw-Lzma"
PV = "2.212"
PR = "3.el10"
PACKAGES = " \
 perl-Compress-Raw-Lzma \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/perl-Compress-Raw-Lzma-2.212-3.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "3d4a3c36d3276616c464d63cc3afb0e75995075c60f214e1d653cc731a0f1bbe"

URI_x86_64_v2_perl-Compress-Raw-Lzma = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/perl-Compress-Raw-Lzma-2.212-3.el10.x86_64_v2.rpm;name=x86_64_v2_perl-Compress-Raw-Lzma;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Compress-Raw-Lzma}"
SRC_URI[x86_64_v2_perl-Compress-Raw-Lzma.sha256sum] = "173da6840df5c589ba007c94c161c99373659e70b21745aaf02822061cc38b63"

URI_aarch64_perl-Compress-Raw-Lzma = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/perl-Compress-Raw-Lzma-2.212-3.el10.aarch64.rpm;name=aarch64_perl-Compress-Raw-Lzma;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Compress-Raw-Lzma}"
SRC_URI[aarch64_perl-Compress-Raw-Lzma.sha256sum] = "f05412d224136d3761ae70c381c64d7730fba50e18ac953b6f56407d8fb49719"

RDEPENDS:perl-Compress-Raw-Lzma = " \
 glibc \
 perl-AutoLoader \
 perl-Carp \
 perl-Exporter \
 perl-Scalar-List-Utils \
 perl-constant \
 perl-libs \
 xz-libs \
 "
