# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "mercurial"
PV = "6.8.1"
PR = "2.el10_0"
PACKAGES = " \
 mercurial \
 mercurial-chg \
 mercurial-hgk \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/m/mercurial-6.8.1-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5e4fd4f9fd8ea322d2a1394cd1e6b1f448c6650081b9e93a315660dc9777ce27"

URI_x86_64_v2_mercurial = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mercurial-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mercurial;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mercurial}"
SRC_URI[x86_64_v2_mercurial.sha256sum] = "ebce46805ece0f0c26a812d5d2b8a2f8e864b1c5ff3a5655a0089d153c9b7e92"

URI_x86_64_v2_mercurial-chg = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mercurial-chg-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mercurial-chg;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mercurial-chg}"
SRC_URI[x86_64_v2_mercurial-chg.sha256sum] = "9ebb88e7a90c655ae9ce4a2d7fa4552cbd0fa931821b572020d262c96bdba460"

URI_x86_64_v2_mercurial-hgk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/mercurial-hgk-6.8.1-2.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_mercurial-hgk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_mercurial-hgk}"
SRC_URI[x86_64_v2_mercurial-hgk.sha256sum] = "c690878453fa2f07f7dcbc32ede348251472501db96c0dd95620757bc6eb6b6e"

URI_aarch64_mercurial = "${EPEL_MIRROR}/aarch64/Packages/m/mercurial-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_mercurial;unpack=0"
SRC_URI:append = " ${URI_aarch64_mercurial}"
SRC_URI[aarch64_mercurial.sha256sum] = "048a63bca00d72e98bdca7a87f2f02151a29a5eac488a497701feffa3feb675f"

URI_aarch64_mercurial-chg = "${EPEL_MIRROR}/aarch64/Packages/m/mercurial-chg-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_mercurial-chg;unpack=0"
SRC_URI:append = " ${URI_aarch64_mercurial-chg}"
SRC_URI[aarch64_mercurial-chg.sha256sum] = "5192231191693c52969889b6f252fcbbda1c586d94b57613ac6db3a78cd56c6d"

URI_aarch64_mercurial-hgk = "${EPEL_MIRROR}/aarch64/Packages/m/mercurial-hgk-6.8.1-2.el10_0.aarch64.rpm;name=aarch64_mercurial-hgk;unpack=0"
SRC_URI:append = " ${URI_aarch64_mercurial-hgk}"
SRC_URI[aarch64_mercurial-hgk.sha256sum] = "b4522fad1b97e709c911d24e762bc563fae2e2a8796381581eb38c2c63c873b5"

RDEPENDS:mercurial = " \
 emacs-filesystem \
 glibc \
 python3 \
 "
RDEPENDS:mercurial-chg = " \
 glibc \
 mercurial \
 "
RDEPENDS:mercurial-hgk = " \
 mercurial \
 python3 \
 tk \
 "
