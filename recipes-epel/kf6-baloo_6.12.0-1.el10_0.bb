# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-baloo"
PV = "6.12.0"
PR = "1.el10_0"
PACKAGES = " \
 kf6-baloo \
 kf6-baloo-devel \
 kf6-baloo-doc \
 kf6-baloo-file \
 kf6-baloo-libs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-baloo-6.12.0-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "56d8d1343ab53679a54015ca05b5f3c4fee4d5d0b82847f37eff45ecd6d695fc"

URI_x86_64_v2_kf6-baloo = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo}"
SRC_URI[x86_64_v2_kf6-baloo.sha256sum] = "ed03be65d5a0b24cea94b66947c457b96bae40b4fff6e0bd8fb531a7997e17e0"

URI_x86_64_v2_kf6-baloo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-devel-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-devel}"
SRC_URI[x86_64_v2_kf6-baloo-devel.sha256sum] = "7615bb01688a71805767d85945b0c49af7c58a5cd7f6c9c8c8e560f04250d860"

URI_x86_64_v2_kf6-baloo-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-doc-6.12.0-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-baloo-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-doc}"
SRC_URI[x86_64_v2_kf6-baloo-doc.sha256sum] = "6bf4d2d6821e19cb0d2c32f23d9262f3c6d836eda0ca8f61a90ff1a8f5791d53"

URI_x86_64_v2_kf6-baloo-file = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-file-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-file;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-file}"
SRC_URI[x86_64_v2_kf6-baloo-file.sha256sum] = "f398400208c05f4830edb8dd4919a8901a6e964b66c3f037497da32a79956a4b"

URI_x86_64_v2_kf6-baloo-libs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-baloo-libs-6.12.0-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-baloo-libs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-baloo-libs}"
SRC_URI[x86_64_v2_kf6-baloo-libs.sha256sum] = "f9c9b1574e358af72e6d59c20c86cd6421f949de017f9a45b7d391c14ab43491"

URI_aarch64_kf6-baloo = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-baloo;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo}"
SRC_URI[aarch64_kf6-baloo.sha256sum] = "6a744e19e3601678fabf339ba7f61351131d79d8ba204b6b9760fdff5211bd6c"

URI_aarch64_kf6-baloo-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-devel-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-baloo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-devel}"
SRC_URI[aarch64_kf6-baloo-devel.sha256sum] = "ca325567ccf0b5187c828fa6c52d884f0b0ff5ba40083f92f683d8bb90d0f3f2"

URI_aarch64_kf6-baloo-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-doc-6.12.0-1.el10_0.noarch.rpm;name=aarch64_kf6-baloo-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-doc}"
SRC_URI[aarch64_kf6-baloo-doc.sha256sum] = "be7bbb7cad9b4913103256f192068324f304a735deacba487ac222486d42331b"

URI_aarch64_kf6-baloo-file = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-file-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-baloo-file;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-file}"
SRC_URI[aarch64_kf6-baloo-file.sha256sum] = "4cea7853a2280387e3241ec28988d32c8cdd4ec24466c916eb0e8eb192b6bef9"

URI_aarch64_kf6-baloo-libs = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-baloo-libs-6.12.0-1.el10_0.aarch64.rpm;name=aarch64_kf6-baloo-libs;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-baloo-libs}"
SRC_URI[aarch64_kf6-baloo-libs.sha256sum] = "b4ab7ef6643f183b6efe790278393d7bcf16546971f4bd45dbae4966bf859c6e"

RDEPENDS:kf6-baloo = " \
 glibc \
 kf6-baloo-libs \
 kf6-kcoreaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 libstdc++ \
 qt6-qtbase \
 "
RDEPENDS:kf6-baloo-devel = " \
 cmake-filesystem \
 kf6-baloo-libs \
 kf6-kcoreaddons-devel \
 kf6-kfilemetadata-devel \
 pkgconf-pkg-config \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-baloo-doc = " \
 "
RDEPENDS:kf6-baloo-file = " \
 glibc \
 kf6-baloo-libs \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kidletime \
 kf6-solid \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
RDEPENDS:kf6-baloo-libs = " \
 glibc \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kdbusaddons \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-solid \
 libstdc++ \
 lmdb-libs \
 qt6-qtbase \
 qt6-qtdeclarative \
 "
