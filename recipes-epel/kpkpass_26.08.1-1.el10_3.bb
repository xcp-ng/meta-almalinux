# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kpkpass"
PV = "26.08.1"
PR = "1.el10_3"
PACKAGES = " \
 kpkpass \
 kpkpass-devel \
 kpkpass-doc \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/k/kpkpass-26.08.1-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "a30a6b7e5b80f664065a30858c818de9ca61b5f86cdaf87ea24833c020671bcf"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass;unpack=0"
SRC_URI[x86_64_v2_kpkpass.sha256sum] = "70ca8f2a905b3a7b3ed4925a4e7670e643f39a1f4614fbb8da2957e8167fae5c"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-devel-26.08.1-1.el10_3.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kpkpass-devel;unpack=0"
SRC_URI[x86_64_v2_kpkpass-devel.sha256sum] = "534785b26514531c6a5d143525453955fc29a470ea3ec366c19a5a106fd82200"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kpkpass-doc-26.08.1-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_kpkpass-doc;unpack=0"
SRC_URI[x86_64_v2_kpkpass-doc.sha256sum] = "861e504c3c41dfbeaf4cbf537431706a83fec5410297b36098e1d43dbdc6edd9"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kpkpass;unpack=0"
SRC_URI[aarch64_kpkpass.sha256sum] = "8273f9249b464eeae2eea3f9ae7465f3daf33ef550d898d3228fea910f1f8430"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-devel-26.08.1-1.el10_3.aarch64.rpm;name=aarch64_kpkpass-devel;unpack=0"
SRC_URI[aarch64_kpkpass-devel.sha256sum] = "566e97957c956421bce8ee6180541e1d94fb25cb43d81704557c6bc39d9b4ca1"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/k/kpkpass-doc-26.08.1-1.el10_3.noarch.rpm;name=aarch64_kpkpass-doc;unpack=0"
SRC_URI[aarch64_kpkpass-doc.sha256sum] = "b8c4127f1078bbe74ea6362d2791c484ab94834e40432e6371f3d4a541164668"

RDEPENDS:kpkpass = " \
 glibc \
 kf6-karchive \
 libstdc++ \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 "
RDEPENDS:kpkpass-devel = " \
 cmake-filesystem \
 kf6-karchive-devel \
 kpkpass \
 "
RDEPENDS:kpkpass-doc = " \
 "
