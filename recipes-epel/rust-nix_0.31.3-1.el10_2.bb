# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-nix"
PV = "0.31.3"
PR = "1.el10_2"
PACKAGES = " \
 rust-nix+acct-devel \
 rust-nix+aio-devel \
 rust-nix+default-devel \
 rust-nix+dir-devel \
 rust-nix+env-devel \
 rust-nix+event-devel \
 rust-nix+fanotify-devel \
 rust-nix+feature-devel \
 rust-nix+fs-devel \
 rust-nix+hostname-devel \
 rust-nix+inotify-devel \
 rust-nix+ioctl-devel \
 rust-nix+kmod-devel \
 rust-nix+memoffset-devel \
 rust-nix+mman-devel \
 rust-nix+mount-devel \
 rust-nix+mqueue-devel \
 rust-nix+net-devel \
 rust-nix+personality-devel \
 rust-nix+pin-utils-devel \
 rust-nix+poll-devel \
 rust-nix+process-devel \
 rust-nix+pthread-devel \
 rust-nix+ptrace-devel \
 rust-nix+quota-devel \
 rust-nix+reboot-devel \
 rust-nix+resource-devel \
 rust-nix+sched-devel \
 rust-nix+signal-devel \
 rust-nix+socket-devel \
 rust-nix+syslog-devel \
 rust-nix+term-devel \
 rust-nix+time-devel \
 rust-nix+ucontext-devel \
 rust-nix+uio-devel \
 rust-nix+user-devel \
 rust-nix+zerocopy-devel \
 rust-nix-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-nix-0.31.3-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5261578d61bf04d0d1272792b3af8557dd603fabfffff6e29c7f866f9ba998fa"

URI_x86_64_v2_rust-nix+acct-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+acct-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+acct-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+acct-devel}"
SRC_URI[x86_64_v2_rust-nix+acct-devel.sha256sum] = "20a4b493b6ef1db49a25c51fdb89840b597dfc289e8b5f2d3cc099dd5698fa86"

URI_x86_64_v2_rust-nix+aio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+aio-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+aio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+aio-devel}"
SRC_URI[x86_64_v2_rust-nix+aio-devel.sha256sum] = "8f73becad39f62aec60ef7dcf8865ff0fb7ad2d596554ca87dc649520e659407"

URI_x86_64_v2_rust-nix+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+default-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+default-devel}"
SRC_URI[x86_64_v2_rust-nix+default-devel.sha256sum] = "a9b0fb125fa15d5f75a426d9edef2ee692ea487912d808129154b45cf2516941"

URI_x86_64_v2_rust-nix+dir-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+dir-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+dir-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+dir-devel}"
SRC_URI[x86_64_v2_rust-nix+dir-devel.sha256sum] = "a4fdca9774e79956dbd32a933db371e9ee20aee0259b58d59d67b1da8f9d02b2"

URI_x86_64_v2_rust-nix+env-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+env-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+env-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+env-devel}"
SRC_URI[x86_64_v2_rust-nix+env-devel.sha256sum] = "ff6709e699de3cce6d87ec61abe82dd7d71a788416aefca6ca28e7a099278e2e"

URI_x86_64_v2_rust-nix+event-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+event-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+event-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+event-devel}"
SRC_URI[x86_64_v2_rust-nix+event-devel.sha256sum] = "76a36880e987189aa7fe398ac337b075589bbdd200ace5f955a8a321636554dc"

URI_x86_64_v2_rust-nix+fanotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+fanotify-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+fanotify-devel}"
SRC_URI[x86_64_v2_rust-nix+fanotify-devel.sha256sum] = "4cd2ea8ca14fd83e051a04e1a2a8ed05dfd975f9f546781f8e38b01295ad380b"

URI_x86_64_v2_rust-nix+feature-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+feature-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+feature-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+feature-devel}"
SRC_URI[x86_64_v2_rust-nix+feature-devel.sha256sum] = "129db474feeeed3bf28b641ce1021c1a95fd7d1f21cc1509d0aefbe1e3757ee0"

URI_x86_64_v2_rust-nix+fs-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+fs-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+fs-devel}"
SRC_URI[x86_64_v2_rust-nix+fs-devel.sha256sum] = "73f06edd00de43c6c678990cdbe0e09832b59e4b7b2bc9d300ba073455d6533f"

URI_x86_64_v2_rust-nix+hostname-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+hostname-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+hostname-devel}"
SRC_URI[x86_64_v2_rust-nix+hostname-devel.sha256sum] = "807754edc7fcf5f6d5bf86acb5392a04eaf0805f13575b3ee49c57a033db1289"

URI_x86_64_v2_rust-nix+inotify-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+inotify-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+inotify-devel}"
SRC_URI[x86_64_v2_rust-nix+inotify-devel.sha256sum] = "1a4ca7100c12fd4ddf4343480e0e53076aff1a7a707ef570754451034409ddf9"

URI_x86_64_v2_rust-nix+ioctl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ioctl-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ioctl-devel}"
SRC_URI[x86_64_v2_rust-nix+ioctl-devel.sha256sum] = "77c35ac878cb93989db1334541f60bdbf6fd8bb2f0c3798c3120a671e017fe81"

URI_x86_64_v2_rust-nix+kmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+kmod-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+kmod-devel}"
SRC_URI[x86_64_v2_rust-nix+kmod-devel.sha256sum] = "c5b256f638184bd5bded476d7daa70a87ac61aaf26c96681e6e11e980efcb413"

URI_x86_64_v2_rust-nix+memoffset-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+memoffset-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+memoffset-devel}"
SRC_URI[x86_64_v2_rust-nix+memoffset-devel.sha256sum] = "d538848e2d07cffcaba7bfcddda7c4abadd3cb50f55a3a6579b8dd468a88d431"

URI_x86_64_v2_rust-nix+mman-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mman-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mman-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mman-devel}"
SRC_URI[x86_64_v2_rust-nix+mman-devel.sha256sum] = "95b51f1c19b7744eea1fe6ecd98d49dba35ec5b706e0647c2e400921b22c796a"

URI_x86_64_v2_rust-nix+mount-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mount-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mount-devel}"
SRC_URI[x86_64_v2_rust-nix+mount-devel.sha256sum] = "4a728b218b09fdfa2dfc51b189d5187748895f3b044e5fe0383c054f1c497150"

URI_x86_64_v2_rust-nix+mqueue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+mqueue-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+mqueue-devel}"
SRC_URI[x86_64_v2_rust-nix+mqueue-devel.sha256sum] = "3542918c5a763156f606012b9a8de91439dcd35d74607cbd09ee3c450f762d92"

URI_x86_64_v2_rust-nix+net-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+net-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+net-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+net-devel}"
SRC_URI[x86_64_v2_rust-nix+net-devel.sha256sum] = "033d00aae614d274816664586b0991510ebc72152461408b78da76c285011ff0"

URI_x86_64_v2_rust-nix+personality-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+personality-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+personality-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+personality-devel}"
SRC_URI[x86_64_v2_rust-nix+personality-devel.sha256sum] = "f17a2346efa040eb4d016e882542251692e517acb384f517507557bc8d5768ec"

URI_x86_64_v2_rust-nix+pin-utils-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+pin-utils-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+pin-utils-devel}"
SRC_URI[x86_64_v2_rust-nix+pin-utils-devel.sha256sum] = "0b83d8a59e6e7c97d1baf985b79d74ae4ae3bc14d611710bf75aab940d9fda48"

URI_x86_64_v2_rust-nix+poll-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+poll-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+poll-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+poll-devel}"
SRC_URI[x86_64_v2_rust-nix+poll-devel.sha256sum] = "5aff94fc0cc70a81e1b19d3f14c34ee7273000f2cfb35b5a5351f498e5f4d8c7"

URI_x86_64_v2_rust-nix+process-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+process-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+process-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+process-devel}"
SRC_URI[x86_64_v2_rust-nix+process-devel.sha256sum] = "1600d4929772b988cf1da45a57119da696522d8d9db80803dc0222b5cec04273"

URI_x86_64_v2_rust-nix+pthread-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+pthread-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+pthread-devel}"
SRC_URI[x86_64_v2_rust-nix+pthread-devel.sha256sum] = "67d31bc194e281bd29fc69518634c2977e8df3be8f7f50949918a45c6f768c96"

URI_x86_64_v2_rust-nix+ptrace-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ptrace-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ptrace-devel}"
SRC_URI[x86_64_v2_rust-nix+ptrace-devel.sha256sum] = "4ceac37b130e058118b3f6c4dc89fa3d5a0d9a88f6f5b0464b7de630d50cb00b"

URI_x86_64_v2_rust-nix+quota-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+quota-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+quota-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+quota-devel}"
SRC_URI[x86_64_v2_rust-nix+quota-devel.sha256sum] = "9c9517327103b56acaea5a761f50e67ae472269c2488bcc7edc9246c7618ef8f"

URI_x86_64_v2_rust-nix+reboot-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+reboot-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+reboot-devel}"
SRC_URI[x86_64_v2_rust-nix+reboot-devel.sha256sum] = "0d3e4a74a0b8ef417c6140bf2434c5b66e0e4f24442bb3f1a3d73167e3f4515d"

URI_x86_64_v2_rust-nix+resource-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+resource-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+resource-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+resource-devel}"
SRC_URI[x86_64_v2_rust-nix+resource-devel.sha256sum] = "b998346210fad9461dfc6481cbd23306a6f4fb90e7da5e8d013ead595a182f92"

URI_x86_64_v2_rust-nix+sched-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+sched-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+sched-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+sched-devel}"
SRC_URI[x86_64_v2_rust-nix+sched-devel.sha256sum] = "37e05d7a0cb4ba6b85fcdf77040acb3f2bd41faf48c094310ad89c80eef847e2"

URI_x86_64_v2_rust-nix+signal-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+signal-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+signal-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+signal-devel}"
SRC_URI[x86_64_v2_rust-nix+signal-devel.sha256sum] = "bd6600b98fd557ea2cdc609bddf2a8d68bbcdac6d61c9ba80403a491e5a8402d"

URI_x86_64_v2_rust-nix+socket-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+socket-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+socket-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+socket-devel}"
SRC_URI[x86_64_v2_rust-nix+socket-devel.sha256sum] = "b65613622fb32035b4ea46293f53817a86a49f6ebe972a649213fe7da05a7fc6"

URI_x86_64_v2_rust-nix+syslog-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+syslog-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+syslog-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+syslog-devel}"
SRC_URI[x86_64_v2_rust-nix+syslog-devel.sha256sum] = "afeaf19273b88dd70e48704327f810fb506271704627fd5f684271b8dd0baf30"

URI_x86_64_v2_rust-nix+term-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+term-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+term-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+term-devel}"
SRC_URI[x86_64_v2_rust-nix+term-devel.sha256sum] = "c78c7f69fc23779df3de2575f44c6691e422ed787f51517c31e5cad5374dd0e2"

URI_x86_64_v2_rust-nix+time-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+time-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+time-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+time-devel}"
SRC_URI[x86_64_v2_rust-nix+time-devel.sha256sum] = "81b86b64a284c6f04ec34458a0fb5db6fda37ca5e82c2de28d298060bb860765"

URI_x86_64_v2_rust-nix+ucontext-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+ucontext-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+ucontext-devel}"
SRC_URI[x86_64_v2_rust-nix+ucontext-devel.sha256sum] = "669e6e0a2c477eda1d4eefeca325928c7192c8eac557f706a6f1dcd377ce208f"

URI_x86_64_v2_rust-nix+uio-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+uio-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+uio-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+uio-devel}"
SRC_URI[x86_64_v2_rust-nix+uio-devel.sha256sum] = "044c0055622651c6a7c79fbdfd633e0b6f3ea20f1f08a9b02130ea9ff5366d64"

URI_x86_64_v2_rust-nix+user-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+user-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+user-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+user-devel}"
SRC_URI[x86_64_v2_rust-nix+user-devel.sha256sum] = "21181916f9debf655c39a16041b6ceeb4e3182620263b8dff9b1fd9a5a07cd7c"

URI_x86_64_v2_rust-nix+zerocopy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix+zerocopy-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix+zerocopy-devel}"
SRC_URI[x86_64_v2_rust-nix+zerocopy-devel.sha256sum] = "2737ebf750b2e97c552fe37e91dc04c158f2f74d3b632513e52fe8b0b4a8adc6"

URI_x86_64_v2_rust-nix-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-nix-devel-0.31.3-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-nix-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-nix-devel}"
SRC_URI[x86_64_v2_rust-nix-devel.sha256sum] = "86deea2c54e13a021af03ab90edbdb0a9b163eddd3167ca92dc1c534f491ac57"

URI_aarch64_rust-nix+acct-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+acct-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+acct-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+acct-devel}"
SRC_URI[aarch64_rust-nix+acct-devel.sha256sum] = "a5be7c41180ce768cc1225967864bb3cd251f8848873dd2a1ebc85bf081cf7e2"

URI_aarch64_rust-nix+aio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+aio-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+aio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+aio-devel}"
SRC_URI[aarch64_rust-nix+aio-devel.sha256sum] = "7d119051a602f3d380e468338008bd48648242df5a762620076b96090b484f96"

URI_aarch64_rust-nix+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+default-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+default-devel}"
SRC_URI[aarch64_rust-nix+default-devel.sha256sum] = "f844a86c6c08ff0436146ddfa9912dbc246c8051417b216c3dc1855ce88bd2df"

URI_aarch64_rust-nix+dir-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+dir-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+dir-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+dir-devel}"
SRC_URI[aarch64_rust-nix+dir-devel.sha256sum] = "17cf99362c53b898acfd2fcb6311c9659fdec5daa1f5e37724fc57a7df0b1f26"

URI_aarch64_rust-nix+env-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+env-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+env-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+env-devel}"
SRC_URI[aarch64_rust-nix+env-devel.sha256sum] = "82f09c5ee833369b6061595d31ddc3541313cb9233ff62322f4a18a0595b4092"

URI_aarch64_rust-nix+event-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+event-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+event-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+event-devel}"
SRC_URI[aarch64_rust-nix+event-devel.sha256sum] = "b0b7dac1867948c0ffcb6cb4a55082759e26441e1cf85c3eb2b91d4ae237e907"

URI_aarch64_rust-nix+fanotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+fanotify-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+fanotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+fanotify-devel}"
SRC_URI[aarch64_rust-nix+fanotify-devel.sha256sum] = "faee47ca7c4c381817976df4db4c98e22f7ac664f4ab940247084f774c2b8621"

URI_aarch64_rust-nix+feature-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+feature-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+feature-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+feature-devel}"
SRC_URI[aarch64_rust-nix+feature-devel.sha256sum] = "ed54381ba11497e1760e9ad3c3e7f28bfa1eaed914fcbafeddb17ecb9acee851"

URI_aarch64_rust-nix+fs-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+fs-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+fs-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+fs-devel}"
SRC_URI[aarch64_rust-nix+fs-devel.sha256sum] = "21f706eaba38e171ccb185c40abb8fd059f27b2c77462c688172f6915f4cdb45"

URI_aarch64_rust-nix+hostname-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+hostname-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+hostname-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+hostname-devel}"
SRC_URI[aarch64_rust-nix+hostname-devel.sha256sum] = "5f42626f9bc3694f426f1f7a27fc98a3a664938cd3a41135d0ee036f6c6d0428"

URI_aarch64_rust-nix+inotify-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+inotify-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+inotify-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+inotify-devel}"
SRC_URI[aarch64_rust-nix+inotify-devel.sha256sum] = "85e40054c78af0a25c858e1a2ce2d7b0c5cd4c887b568c6224385aab5270f247"

URI_aarch64_rust-nix+ioctl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ioctl-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+ioctl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ioctl-devel}"
SRC_URI[aarch64_rust-nix+ioctl-devel.sha256sum] = "0ef8c231562690326b18344e525e769de5839a99d9d956f08028d0add5341c7c"

URI_aarch64_rust-nix+kmod-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+kmod-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+kmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+kmod-devel}"
SRC_URI[aarch64_rust-nix+kmod-devel.sha256sum] = "fc701fc6c7052377e5aef0eb243f4da13210085d67b884dd693bfb4692a9a4ae"

URI_aarch64_rust-nix+memoffset-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+memoffset-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+memoffset-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+memoffset-devel}"
SRC_URI[aarch64_rust-nix+memoffset-devel.sha256sum] = "8b5fdaedb5e622cae3992f367dfc1ac4ace880d90673045972735c5dc6d58767"

URI_aarch64_rust-nix+mman-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mman-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+mman-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mman-devel}"
SRC_URI[aarch64_rust-nix+mman-devel.sha256sum] = "acfd14143c9d4dedf07234dd96968364d600b02e30a71fa3a2307232f425905a"

URI_aarch64_rust-nix+mount-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mount-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+mount-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mount-devel}"
SRC_URI[aarch64_rust-nix+mount-devel.sha256sum] = "401cdfe1223d92ad87ad6b9e8f6d5345fd6f09a92da4c51891eefa1966c52b6c"

URI_aarch64_rust-nix+mqueue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+mqueue-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+mqueue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+mqueue-devel}"
SRC_URI[aarch64_rust-nix+mqueue-devel.sha256sum] = "c5f37c9e19ca1c1e0924b3f1f3c9916fd632a2b281417156590bc2d08d637cae"

URI_aarch64_rust-nix+net-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+net-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+net-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+net-devel}"
SRC_URI[aarch64_rust-nix+net-devel.sha256sum] = "faaf0f1a8173958a882263f81e41c85120adfa355b18750a71b8e6fb0f4b286e"

URI_aarch64_rust-nix+personality-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+personality-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+personality-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+personality-devel}"
SRC_URI[aarch64_rust-nix+personality-devel.sha256sum] = "b7ff830830e171c285bfbd0e1cac55bef91deab28188b0ad7ed38e4a83932abf"

URI_aarch64_rust-nix+pin-utils-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+pin-utils-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+pin-utils-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+pin-utils-devel}"
SRC_URI[aarch64_rust-nix+pin-utils-devel.sha256sum] = "32cda22070ea9e60a7736de955bd4d81d3e5aca59fd5e2f91a95eee909850337"

URI_aarch64_rust-nix+poll-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+poll-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+poll-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+poll-devel}"
SRC_URI[aarch64_rust-nix+poll-devel.sha256sum] = "ffaae68d139a9a9027c341384ab913f8c65854321d79569d35dcecb88af28388"

URI_aarch64_rust-nix+process-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+process-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+process-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+process-devel}"
SRC_URI[aarch64_rust-nix+process-devel.sha256sum] = "e3def24031adfbe2730376c0cb4df71763c911e6dc81f9a95ccf3bb1e0a4a606"

URI_aarch64_rust-nix+pthread-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+pthread-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+pthread-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+pthread-devel}"
SRC_URI[aarch64_rust-nix+pthread-devel.sha256sum] = "41e074e2a133f4f2a9f10f08a887cd21e2713aeb1caa93fd04a417f151bd1094"

URI_aarch64_rust-nix+ptrace-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ptrace-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+ptrace-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ptrace-devel}"
SRC_URI[aarch64_rust-nix+ptrace-devel.sha256sum] = "4ae42cd6af56c5abbf1fd9844efe04a449aea8d0019c267a69a6b5ba3f8b2615"

URI_aarch64_rust-nix+quota-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+quota-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+quota-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+quota-devel}"
SRC_URI[aarch64_rust-nix+quota-devel.sha256sum] = "f9586d0f99908bb458ef21f45604dc6b32bce2e5c9214c1f7b7fbe74089c7382"

URI_aarch64_rust-nix+reboot-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+reboot-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+reboot-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+reboot-devel}"
SRC_URI[aarch64_rust-nix+reboot-devel.sha256sum] = "195dad2027fac6e632e4c9da130bc44d886ac2ee716233f6cfd35efd01230ee3"

URI_aarch64_rust-nix+resource-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+resource-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+resource-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+resource-devel}"
SRC_URI[aarch64_rust-nix+resource-devel.sha256sum] = "f7a22cccc26f1164b8e89964c1cf5c0caa31efaa266cc65cfff433d622d662e2"

URI_aarch64_rust-nix+sched-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+sched-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+sched-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+sched-devel}"
SRC_URI[aarch64_rust-nix+sched-devel.sha256sum] = "a93290e0acf40d5f6ee4bb29367754e712923c410eee4b04d8ac95889eecb725"

URI_aarch64_rust-nix+signal-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+signal-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+signal-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+signal-devel}"
SRC_URI[aarch64_rust-nix+signal-devel.sha256sum] = "7994e0453a8800c1f61955305085a06be921ea027579bd4ba5cd483b2fb9d247"

URI_aarch64_rust-nix+socket-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+socket-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+socket-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+socket-devel}"
SRC_URI[aarch64_rust-nix+socket-devel.sha256sum] = "26898de1533810f49ffbde835690dc20bb5ce1c6ce458fe0e770a28e0635fc2c"

URI_aarch64_rust-nix+syslog-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+syslog-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+syslog-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+syslog-devel}"
SRC_URI[aarch64_rust-nix+syslog-devel.sha256sum] = "97afb00ba9a5bccf25a3b03c0145a43206c0d143ecfad4d09a95af65f7b96f92"

URI_aarch64_rust-nix+term-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+term-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+term-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+term-devel}"
SRC_URI[aarch64_rust-nix+term-devel.sha256sum] = "2dfabac3e1d0236fb7a929ce09e3d89db84a9ef8656bb3ad8ac8bd62d6333d2c"

URI_aarch64_rust-nix+time-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+time-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+time-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+time-devel}"
SRC_URI[aarch64_rust-nix+time-devel.sha256sum] = "84b4c4d67c61be1a438fe2d539d4986eddd1fe86740365ccba91b7b08a2dcdcb"

URI_aarch64_rust-nix+ucontext-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+ucontext-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+ucontext-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+ucontext-devel}"
SRC_URI[aarch64_rust-nix+ucontext-devel.sha256sum] = "8ca9e5772e8ed35dfaba7ecbed29b516f2dffcab23dd8072f52b891932365ad4"

URI_aarch64_rust-nix+uio-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+uio-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+uio-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+uio-devel}"
SRC_URI[aarch64_rust-nix+uio-devel.sha256sum] = "338ec7c77e19adc03c3b837ec631307a058f5825688e9a140a56e167d3a0e186"

URI_aarch64_rust-nix+user-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+user-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+user-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+user-devel}"
SRC_URI[aarch64_rust-nix+user-devel.sha256sum] = "163611d1de98ef974dc5c075e90abd494e0ac492b1234f10f5056f34678c37d4"

URI_aarch64_rust-nix+zerocopy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix+zerocopy-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix+zerocopy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix+zerocopy-devel}"
SRC_URI[aarch64_rust-nix+zerocopy-devel.sha256sum] = "fc2df25311b20259c2949c25dfef28c82a163a5b39037ba30cd4bc9aa186879b"

URI_aarch64_rust-nix-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-nix-devel-0.31.3-1.el10_2.noarch.rpm;name=aarch64_rust-nix-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-nix-devel}"
SRC_URI[aarch64_rust-nix-devel.sha256sum] = "71788d4586cd718251e1f487dd1c4bfc4700e2d49ad90c484cff9b685a44bdc2"

RDEPENDS:rust-nix+acct-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+aio-devel = " \
 cargo \
 rust-nix+pin-utils-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+default-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+dir-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+env-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+event-devel = " \
 cargo \
 rust-nix+poll-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+fanotify-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+feature-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+fs-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+hostname-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+inotify-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ioctl-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+kmod-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+memoffset-devel = " \
 cargo \
 rust-memoffset+default-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mman-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mount-devel = " \
 cargo \
 rust-nix+uio-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+mqueue-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+net-devel = " \
 cargo \
 rust-nix+socket-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+personality-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+pin-utils-devel = " \
 cargo \
 rust-nix-devel \
 rust-pin-utils+default-devel \
 "
RDEPENDS:rust-nix+poll-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+process-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+pthread-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ptrace-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+quota-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+reboot-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+resource-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+sched-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+signal-devel = " \
 cargo \
 rust-nix+process-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+socket-devel = " \
 cargo \
 rust-nix+memoffset-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+syslog-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+term-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+time-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+ucontext-devel = " \
 cargo \
 rust-nix+signal-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+uio-devel = " \
 cargo \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+user-devel = " \
 cargo \
 rust-nix+feature-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix+zerocopy-devel = " \
 cargo \
 rust-nix+fs-devel \
 rust-nix+uio-devel \
 rust-nix-devel \
 "
RDEPENDS:rust-nix-devel = " \
 cargo \
 rust \
 rust-bitflags+default-devel \
 rust-cfg-if+default-devel \
 rust-cfg_aliases+default-devel \
 rust-libc+default-devel \
 rust-libc+extra_traits-devel \
 "
