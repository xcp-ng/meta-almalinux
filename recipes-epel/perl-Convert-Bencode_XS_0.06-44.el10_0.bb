# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Convert-Bencode_XS"
PV = "0.06"
PR = "44.el10_0"
PACKAGES = " \
 perl-Convert-Bencode_XS \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Convert-Bencode_XS-0.06-44.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "cfbe9164959c38c8abc086c636284dcd376108453595f53e20acafddfed1592b"

URI_x86_64_v2_perl-Convert-Bencode_XS = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Convert-Bencode_XS-0.06-44.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Convert-Bencode_XS;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Convert-Bencode_XS}"
SRC_URI[x86_64_v2_perl-Convert-Bencode_XS.sha256sum] = "bcf85d8204160537f7016c16112a2e802602cf2fe3c7702db78800bb7e1b85c3"

URI_aarch64_perl-Convert-Bencode_XS = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Convert-Bencode_XS-0.06-44.el10_0.aarch64.rpm;name=aarch64_perl-Convert-Bencode_XS;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Convert-Bencode_XS}"
SRC_URI[aarch64_perl-Convert-Bencode_XS.sha256sum] = "5815431ca9cf1fa713cc1a00d3e29dcb5e998c302758922241c601c545c97253"

RDEPENDS:perl-Convert-Bencode_XS = " \
 glibc \
 perl-Carp \
 perl-DynaLoader \
 perl-Exporter \
 perl-base \
 perl-libs \
 "
