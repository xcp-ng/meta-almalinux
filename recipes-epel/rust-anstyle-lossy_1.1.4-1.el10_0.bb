# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-anstyle-lossy"
PV = "1.1.4"
PR = "1.el10_0"
PACKAGES = " \
 rust-anstyle-lossy+default-devel \
 rust-anstyle-lossy-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-anstyle-lossy-1.1.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c572c4a5eb02e56efce0c3d0b3940d2f7e70cb36fbc486e27bcf04bc057c0c3c"

URI_x86_64_v2_rust-anstyle-lossy+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-lossy+default-devel-1.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-lossy+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-lossy+default-devel}"
SRC_URI[x86_64_v2_rust-anstyle-lossy+default-devel.sha256sum] = "14034dc370530a1778b3527189ec7586b167982da7f935c32ba76b7df2786cce"

URI_x86_64_v2_rust-anstyle-lossy-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-anstyle-lossy-devel-1.1.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-anstyle-lossy-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-anstyle-lossy-devel}"
SRC_URI[x86_64_v2_rust-anstyle-lossy-devel.sha256sum] = "c6a55f5acfa887b44dfe8ec9ba43683c231581b90c791aedd7ee998bdbf9e5d4"

URI_aarch64_rust-anstyle-lossy+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-lossy+default-devel-1.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-lossy+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-lossy+default-devel}"
SRC_URI[aarch64_rust-anstyle-lossy+default-devel.sha256sum] = "5f8cce5330b96b8f4e4c69c5398bf52437da9ef53c0cb35df0b293b2a398da7d"

URI_aarch64_rust-anstyle-lossy-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-anstyle-lossy-devel-1.1.4-1.el10_0.noarch.rpm;name=aarch64_rust-anstyle-lossy-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-anstyle-lossy-devel}"
SRC_URI[aarch64_rust-anstyle-lossy-devel.sha256sum] = "9d0e5cbf021a596d31eac62e7e8004bdb322b5b316a20ea446df317bff87c945"

RDEPENDS:rust-anstyle-lossy+default-devel = " \
 cargo \
 rust-anstyle-lossy-devel \
 "
RDEPENDS:rust-anstyle-lossy-devel = " \
 cargo \
 rust \
 rust-anstyle+default-devel \
 "
