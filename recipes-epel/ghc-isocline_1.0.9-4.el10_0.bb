# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-isocline"
PV = "1.0.9"
PR = "4.el10_0"
PACKAGES = " \
 ghc-isocline \
 ghc-isocline-devel \
 ghc-isocline-doc \
 ghc-isocline-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-isocline-1.0.9-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c7fa7f2fd0dd819cf80c12d5163aacedb7f321623a14b9e50adbc017e40c0ce0"

URI_x86_64_v2_ghc-isocline = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-isocline-1.0.9-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-isocline;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-isocline}"
SRC_URI[x86_64_v2_ghc-isocline.sha256sum] = "a9bff55cca3486f4322d3cb3ed142a6265e45bbe692d14eaf6570700c76179e4"

URI_x86_64_v2_ghc-isocline-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-isocline-devel-1.0.9-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-isocline-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-isocline-devel}"
SRC_URI[x86_64_v2_ghc-isocline-devel.sha256sum] = "0f8add28b02fdee204a09b46ea1ba267ac16727a09f3a611e5505b93e4d5bc80"

URI_x86_64_v2_ghc-isocline-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-isocline-doc-1.0.9-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-isocline-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-isocline-doc}"
SRC_URI[x86_64_v2_ghc-isocline-doc.sha256sum] = "3d42a70e82127e99621b8c03bd3cf0412c1dab238d26d1aac016275c967b6da4"

URI_x86_64_v2_ghc-isocline-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-isocline-prof-1.0.9-4.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-isocline-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-isocline-prof}"
SRC_URI[x86_64_v2_ghc-isocline-prof.sha256sum] = "ad0c03e86897ab3655dfc2eaec387a6ec7146a9cac679306350eeda406650332"

URI_aarch64_ghc-isocline = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-isocline-1.0.9-4.el10_0.aarch64.rpm;name=aarch64_ghc-isocline;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-isocline}"
SRC_URI[aarch64_ghc-isocline.sha256sum] = "0b9087266aef5e06e4c91b98c1b67aac34cfcc440482a38b222a61243493cebe"

URI_aarch64_ghc-isocline-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-isocline-devel-1.0.9-4.el10_0.aarch64.rpm;name=aarch64_ghc-isocline-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-isocline-devel}"
SRC_URI[aarch64_ghc-isocline-devel.sha256sum] = "d3a1a896ac7451bedb8317465186f484227bc33eaadc889c7a3d7a9110463f67"

URI_aarch64_ghc-isocline-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-isocline-doc-1.0.9-4.el10_0.noarch.rpm;name=aarch64_ghc-isocline-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-isocline-doc}"
SRC_URI[aarch64_ghc-isocline-doc.sha256sum] = "4c3b7f434ac845d851e409efdab9a9fc11bb205fa28232ee3e025e121e551c1e"

URI_aarch64_ghc-isocline-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-isocline-prof-1.0.9-4.el10_0.aarch64.rpm;name=aarch64_ghc-isocline-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-isocline-prof}"
SRC_URI[aarch64_ghc-isocline-prof.sha256sum] = "a0ee1d4e68ad4a92480a3d2b125c03e8242c709fcd8f2925d128eccc4be7a9c6"

RDEPENDS:ghc-isocline = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-containers \
 ghc-deepseq \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-pretty \
 ghc-template-haskell \
 ghc-text \
 glibc \
 gmp \
 "
RDEPENDS:ghc-isocline-devel = " \
 ghc-base-devel \
 ghc-bytestring-devel \
 ghc-compiler \
 ghc-isocline \
 ghc-text-devel \
 glibc \
 gmp \
 libffi \
 "
RDEPENDS:ghc-isocline-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-isocline-prof = " \
 ghc-base-prof \
 ghc-bytestring-prof \
 ghc-isocline-devel \
 ghc-text-prof \
 "
