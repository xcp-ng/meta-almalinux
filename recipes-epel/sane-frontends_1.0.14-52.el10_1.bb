# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sane-frontends"
PV = "1.0.14"
PR = "52.el10_1"
PACKAGES = " \
 sane-frontends \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sane-frontends-1.0.14-52.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "50761fa2452c9c340234f7b68a43771e21433889e6068b22a4f4cd569914a2fb"

URI_x86_64_v2_sane-frontends = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sane-frontends-1.0.14-52.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sane-frontends;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sane-frontends}"
SRC_URI[x86_64_v2_sane-frontends.sha256sum] = "06c2d2751c6a6246f51a9e72c950c4f49cf1815cd277e0c612b01f1acc104b9d"

URI_aarch64_sane-frontends = "${EPEL_MIRROR}/aarch64/Packages/s/sane-frontends-1.0.14-52.el10_1.aarch64.rpm;name=aarch64_sane-frontends;unpack=0"
SRC_URI:append = " ${URI_aarch64_sane-frontends}"
SRC_URI[aarch64_sane-frontends.sha256sum] = "ca519b2f3c5299282b40ba5868228feac7dcb4472b54d6839bd4a21510a2d4c6"

RDEPENDS:sane-frontends = " \
 glib2 \
 glibc \
 gtk2 \
 sane-backends-libs \
 "
