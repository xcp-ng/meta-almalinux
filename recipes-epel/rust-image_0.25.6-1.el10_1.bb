# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-image"
PV = "0.25.6"
PR = "1.el10_1"
PACKAGES = " \
 rust-image+avif-devel \
 rust-image+avif-native-devel \
 rust-image+bmp-devel \
 rust-image+color_quant-devel \
 rust-image+dds-devel \
 rust-image+default-devel \
 rust-image+default-formats-devel \
 rust-image+exr-devel \
 rust-image+ff-devel \
 rust-image+gif-devel \
 rust-image+hdr-devel \
 rust-image+ico-devel \
 rust-image+jpeg-devel \
 rust-image+nasm-devel \
 rust-image+png-devel \
 rust-image+pnm-devel \
 rust-image+qoi-devel \
 rust-image+rayon-devel \
 rust-image+serde-devel \
 rust-image+tga-devel \
 rust-image+tiff-devel \
 rust-image+webp-devel \
 rust-image-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-image-0.25.6-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a179d05740691e3b59b686c7790359b1367f5f37c10d547643eb299900b672d6"

URI_x86_64_v2_rust-image+avif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+avif-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+avif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+avif-devel}"
SRC_URI[x86_64_v2_rust-image+avif-devel.sha256sum] = "8aaed02871e29383db183e632c3e7583fa5e0b2df40773f233ca68db60ec45b8"

URI_x86_64_v2_rust-image+avif-native-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+avif-native-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+avif-native-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+avif-native-devel}"
SRC_URI[x86_64_v2_rust-image+avif-native-devel.sha256sum] = "cb178cb5959891d9fe0ea3f9b29614a36f75d1dcc4f34bfa6fe29d794d0e346d"

URI_x86_64_v2_rust-image+bmp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+bmp-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+bmp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+bmp-devel}"
SRC_URI[x86_64_v2_rust-image+bmp-devel.sha256sum] = "01274a29fff12e5e984a553390d5c7ddeb3f54fc0cd8ab1eb494fe57f9a1b4eb"

URI_x86_64_v2_rust-image+color_quant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+color_quant-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+color_quant-devel}"
SRC_URI[x86_64_v2_rust-image+color_quant-devel.sha256sum] = "6f6c32fef38f00f6af07b7b3598ddd927346dc41f5233a1c779ef44a03e506af"

URI_x86_64_v2_rust-image+dds-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+dds-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+dds-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+dds-devel}"
SRC_URI[x86_64_v2_rust-image+dds-devel.sha256sum] = "5621a73220f6d21d1f20767f7c8a1af8f531128d84fba43967c40c96e73c56bc"

URI_x86_64_v2_rust-image+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+default-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+default-devel}"
SRC_URI[x86_64_v2_rust-image+default-devel.sha256sum] = "9f60066afaa4be7ebd8988f8cf54ee38ff6e3be4073fd04fc17ac3a2e3fbd91e"

URI_x86_64_v2_rust-image+default-formats-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+default-formats-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+default-formats-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+default-formats-devel}"
SRC_URI[x86_64_v2_rust-image+default-formats-devel.sha256sum] = "4ada346f2f7958c16bdda06f605b2e164d310afacbaf0e87a43af036b9fa9f3c"

URI_x86_64_v2_rust-image+exr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+exr-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+exr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+exr-devel}"
SRC_URI[x86_64_v2_rust-image+exr-devel.sha256sum] = "c837df249bae12f18c7ee12250ce0487a76b1c25ba806b5af13e982aca5d4f44"

URI_x86_64_v2_rust-image+ff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+ff-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+ff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+ff-devel}"
SRC_URI[x86_64_v2_rust-image+ff-devel.sha256sum] = "aed717fb7cee1ece3974937b78da681622bc2311500460faf519bfc41bad723a"

URI_x86_64_v2_rust-image+gif-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+gif-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+gif-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+gif-devel}"
SRC_URI[x86_64_v2_rust-image+gif-devel.sha256sum] = "d6cddaecefe543314c7fb78c8f39fe339cfb7dc5d933e0bb1f547af3dde77a90"

URI_x86_64_v2_rust-image+hdr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+hdr-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+hdr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+hdr-devel}"
SRC_URI[x86_64_v2_rust-image+hdr-devel.sha256sum] = "511f0e62c13211f80cc81534567da104dc572b8b90db589d3953f1b06f69353d"

URI_x86_64_v2_rust-image+ico-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+ico-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+ico-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+ico-devel}"
SRC_URI[x86_64_v2_rust-image+ico-devel.sha256sum] = "cfbfe615e1008b953f91db1cc37e29b1587a25507dd62deb6c68ce5adf3b0334"

URI_x86_64_v2_rust-image+jpeg-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+jpeg-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+jpeg-devel}"
SRC_URI[x86_64_v2_rust-image+jpeg-devel.sha256sum] = "8ba8ed37f135489686f9a7a534d22f8e87e42fba1416463ab5e5c0a7d799937d"

URI_x86_64_v2_rust-image+nasm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+nasm-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+nasm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+nasm-devel}"
SRC_URI[x86_64_v2_rust-image+nasm-devel.sha256sum] = "3abaee014bf82a66e25ea475be2280eb88ca7c05e1dadf677fdfc3ee9fd13328"

URI_x86_64_v2_rust-image+png-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+png-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+png-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+png-devel}"
SRC_URI[x86_64_v2_rust-image+png-devel.sha256sum] = "d73cc9b31e75dbba90824cff5b463a3049b037bbd1b3db906418bc6a4205b638"

URI_x86_64_v2_rust-image+pnm-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+pnm-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+pnm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+pnm-devel}"
SRC_URI[x86_64_v2_rust-image+pnm-devel.sha256sum] = "dc2959c8f70684089571f232cdbd34973a812d52b9be68abde5534cfb8bc7161"

URI_x86_64_v2_rust-image+qoi-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+qoi-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+qoi-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+qoi-devel}"
SRC_URI[x86_64_v2_rust-image+qoi-devel.sha256sum] = "2b0436d132ac6f2265fd9ce74730c39ddf66d4082c6c84847f95f8ba8b304c5f"

URI_x86_64_v2_rust-image+rayon-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+rayon-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+rayon-devel}"
SRC_URI[x86_64_v2_rust-image+rayon-devel.sha256sum] = "0114fd262418d559628dff73cb4abf1fb3e3b2e1b15b8782b838938cca0a0626"

URI_x86_64_v2_rust-image+serde-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+serde-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+serde-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+serde-devel}"
SRC_URI[x86_64_v2_rust-image+serde-devel.sha256sum] = "72babc44ad4d48c930bfac17ea695d0bdd298d638854ea1ad7665ffe6fd2e4e5"

URI_x86_64_v2_rust-image+tga-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+tga-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+tga-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+tga-devel}"
SRC_URI[x86_64_v2_rust-image+tga-devel.sha256sum] = "17c59e68439c402cef96100b2a3ac51117c96385fcf4c1e3bf06b2ba938cfb0c"

URI_x86_64_v2_rust-image+tiff-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+tiff-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+tiff-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+tiff-devel}"
SRC_URI[x86_64_v2_rust-image+tiff-devel.sha256sum] = "8c57fc72e32439c14902b8e812526b761154ea7a60a83d81ec753c9f13cc14e4"

URI_x86_64_v2_rust-image+webp-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image+webp-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image+webp-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image+webp-devel}"
SRC_URI[x86_64_v2_rust-image+webp-devel.sha256sum] = "777c4e08614b2a046e5a395eeedac8c0e8c19bcfb88b5192eafd1216fc37b6ee"

URI_x86_64_v2_rust-image-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-image-devel-0.25.6-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-image-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-image-devel}"
SRC_URI[x86_64_v2_rust-image-devel.sha256sum] = "367d26726f87b6f301f6f6b84ba0350a3b12a75cf9f894980303ad10dd731e16"

URI_aarch64_rust-image+avif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+avif-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+avif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+avif-devel}"
SRC_URI[aarch64_rust-image+avif-devel.sha256sum] = "3d80d927cad0cd5e847af48bb765c33d18744de3d98e6e0ef5422a2ed3d39452"

URI_aarch64_rust-image+avif-native-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+avif-native-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+avif-native-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+avif-native-devel}"
SRC_URI[aarch64_rust-image+avif-native-devel.sha256sum] = "01a655303ea990274a0e94d8b20d321102ec739d1c033acceb7094f363fd407c"

URI_aarch64_rust-image+bmp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+bmp-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+bmp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+bmp-devel}"
SRC_URI[aarch64_rust-image+bmp-devel.sha256sum] = "6a69da0842e058ca7522c1137956de01c22a5245ca007422c164e615df6e6f6f"

URI_aarch64_rust-image+color_quant-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+color_quant-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+color_quant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+color_quant-devel}"
SRC_URI[aarch64_rust-image+color_quant-devel.sha256sum] = "f7fa195a4f5c52cd49ba3c561b2913c2e83739f4392e35e9aa0c395cc75a3463"

URI_aarch64_rust-image+dds-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+dds-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+dds-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+dds-devel}"
SRC_URI[aarch64_rust-image+dds-devel.sha256sum] = "8483a91fca91b4afec1af729794d99e21dbd7a4354c4c1a43f87c8e7cf39311c"

URI_aarch64_rust-image+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+default-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+default-devel}"
SRC_URI[aarch64_rust-image+default-devel.sha256sum] = "c17a86bec88cb0507cc9ac7270a8d4246179403d26f455d51ecbddf5aa2ea3c8"

URI_aarch64_rust-image+default-formats-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+default-formats-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+default-formats-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+default-formats-devel}"
SRC_URI[aarch64_rust-image+default-formats-devel.sha256sum] = "292eb8b9fb579772052b47740e4081e55868b4e0e538d47a0cb88901eb4e9a74"

URI_aarch64_rust-image+exr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+exr-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+exr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+exr-devel}"
SRC_URI[aarch64_rust-image+exr-devel.sha256sum] = "0f95cac6f9c78eb1fc4c50e9264c180db30f77e788f4b3980c9d813b765d6b39"

URI_aarch64_rust-image+ff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+ff-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+ff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+ff-devel}"
SRC_URI[aarch64_rust-image+ff-devel.sha256sum] = "7f42f9674a1d749d5c29b030ccc62bfa400efa67aaf24c42f9ecc1ee00d29edb"

URI_aarch64_rust-image+gif-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+gif-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+gif-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+gif-devel}"
SRC_URI[aarch64_rust-image+gif-devel.sha256sum] = "784a5c8e6d4be5b049338ddb8df415f564f691cb62d818734a4d944cd8009ea1"

URI_aarch64_rust-image+hdr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+hdr-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+hdr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+hdr-devel}"
SRC_URI[aarch64_rust-image+hdr-devel.sha256sum] = "70f9671ec26b70d45315f4b5bfb4f2d99c2c1ef964c494951893e169ae514cb6"

URI_aarch64_rust-image+ico-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+ico-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+ico-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+ico-devel}"
SRC_URI[aarch64_rust-image+ico-devel.sha256sum] = "7a8fb09994c1780826c2a4e79c6a292394f03b20f5dd8b96efe5ab0d4c496b1e"

URI_aarch64_rust-image+jpeg-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+jpeg-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+jpeg-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+jpeg-devel}"
SRC_URI[aarch64_rust-image+jpeg-devel.sha256sum] = "bcb46e8a3dbd8dee1c1b98c74d3ad1b1fecf16981b1bc589098d8d01236104c7"

URI_aarch64_rust-image+nasm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+nasm-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+nasm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+nasm-devel}"
SRC_URI[aarch64_rust-image+nasm-devel.sha256sum] = "2872189f25091deef4cf528066172a5fb7db24c834f712569098c80a4e7b6dbe"

URI_aarch64_rust-image+png-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+png-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+png-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+png-devel}"
SRC_URI[aarch64_rust-image+png-devel.sha256sum] = "fb42343d4f32acea109f9832df46b25bb95e06dd417a5b09de7e2651d769e588"

URI_aarch64_rust-image+pnm-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+pnm-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+pnm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+pnm-devel}"
SRC_URI[aarch64_rust-image+pnm-devel.sha256sum] = "ad7968ad1a9c1cd43c293565c963252ead1da3422489efb77c0efd44c8b97a87"

URI_aarch64_rust-image+qoi-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+qoi-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+qoi-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+qoi-devel}"
SRC_URI[aarch64_rust-image+qoi-devel.sha256sum] = "83e8fdc616d35257ea769ab4537ffa36c63bb519c90bb8ce8939e92f9459661d"

URI_aarch64_rust-image+rayon-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+rayon-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+rayon-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+rayon-devel}"
SRC_URI[aarch64_rust-image+rayon-devel.sha256sum] = "8cfad935cd8fee9b416c43dcc5026f58d900c42fdd266209abe0ad4ac14a868a"

URI_aarch64_rust-image+serde-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+serde-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+serde-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+serde-devel}"
SRC_URI[aarch64_rust-image+serde-devel.sha256sum] = "199d5372745f80e85ef4233e8be1cb34726cbe29760919885457dc64cd5e06c7"

URI_aarch64_rust-image+tga-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+tga-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+tga-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+tga-devel}"
SRC_URI[aarch64_rust-image+tga-devel.sha256sum] = "9b1733b9e3e88f533a5b8ed5269180dd8abd5f605b2d0cb83fda555769d2815e"

URI_aarch64_rust-image+tiff-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+tiff-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+tiff-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+tiff-devel}"
SRC_URI[aarch64_rust-image+tiff-devel.sha256sum] = "5d9a83926097450ac01804d274646ae6ceb739cd5baf1a1556572ade67ee857a"

URI_aarch64_rust-image+webp-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image+webp-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image+webp-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image+webp-devel}"
SRC_URI[aarch64_rust-image+webp-devel.sha256sum] = "d6aee96d5f4ab18b27322186a8a59eeb6eb2f32eb3e1f18f930944956e28e05c"

URI_aarch64_rust-image-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-image-devel-0.25.6-1.el10_1.noarch.rpm;name=aarch64_rust-image-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-image-devel}"
SRC_URI[aarch64_rust-image-devel.sha256sum] = "5c164a0f3270840185fe6a0df364526c460dd340b52d9c450f41a09d08a44a37"

RDEPENDS:rust-image+avif-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif-devel \
 rust-rgb-devel \
 "
RDEPENDS:rust-image+avif-native-devel = " \
 cargo \
 rust-dav1d+default-devel \
 rust-image-devel \
 rust-mp4parse+default-devel \
 "
RDEPENDS:rust-image+bmp-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+color_quant-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+dds-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+default-devel = " \
 cargo \
 rust-image+default-formats-devel \
 rust-image+rayon-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+default-formats-devel = " \
 cargo \
 rust-image+avif-devel \
 rust-image+bmp-devel \
 rust-image+dds-devel \
 rust-image+exr-devel \
 rust-image+ff-devel \
 rust-image+gif-devel \
 rust-image+hdr-devel \
 rust-image+ico-devel \
 rust-image+jpeg-devel \
 rust-image+png-devel \
 rust-image+pnm-devel \
 rust-image+qoi-devel \
 rust-image+tga-devel \
 rust-image+tiff-devel \
 rust-image+webp-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+exr-devel = " \
 cargo \
 rust-exr+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+ff-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+gif-devel = " \
 cargo \
 rust-color_quant+default-devel \
 rust-gif+default-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+hdr-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+ico-devel = " \
 cargo \
 rust-image+bmp-devel \
 rust-image+png-devel \
 rust-image-devel \
 "
RDEPENDS:rust-image+jpeg-devel = " \
 cargo \
 rust-image-devel \
 rust-zune-core-devel \
 rust-zune-jpeg+default-devel \
 "
RDEPENDS:rust-image+nasm-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif+asm-devel \
 rust-ravif-devel \
 "
RDEPENDS:rust-image+png-devel = " \
 cargo \
 rust-image-devel \
 rust-png+default-devel \
 "
RDEPENDS:rust-image+pnm-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+qoi-devel = " \
 cargo \
 rust-image-devel \
 rust-qoi+default-devel \
 "
RDEPENDS:rust-image+rayon-devel = " \
 cargo \
 rust-image-devel \
 rust-ravif+threading-devel \
 rust-ravif-devel \
 rust-rayon+default-devel \
 "
RDEPENDS:rust-image+serde-devel = " \
 cargo \
 rust-image-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
RDEPENDS:rust-image+tga-devel = " \
 cargo \
 rust-image-devel \
 "
RDEPENDS:rust-image+tiff-devel = " \
 cargo \
 rust-image-devel \
 rust-tiff+default-devel \
 "
RDEPENDS:rust-image+webp-devel = " \
 cargo \
 rust-image-devel \
 rust-image-webp+default-devel \
 "
RDEPENDS:rust-image-devel = " \
 cargo \
 rust \
 rust-bytemuck+default-devel \
 rust-bytemuck+extern_crate_alloc-devel \
 rust-byteorder-lite+default-devel \
 rust-num-traits+default-devel \
 "
