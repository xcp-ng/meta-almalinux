# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libgit2-sys"
PV = "0.18.8"
PR = "1.el10_2"
PACKAGES = " \
 rust-libgit2-sys+default-devel \
 rust-libgit2-sys+https-devel \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys+ssh-devel \
 rust-libgit2-sys-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-libgit2-sys-0.18.8-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "73d15ee11de18b39c149593850cc52d22e7785fbabb65c01f49d07e85723bcf4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+default-devel-0.18.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+default-devel.sha256sum] = "a33fa31f15188c2b08e1ed6db115b09bd454b86f013da81e20e4ae96e07dcb30"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+https-devel-0.18.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+https-devel.sha256sum] = "7dd169689506bf900b3bbd462bafa1f85308204a11df3958bfa3dd8177e671c1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+libssh2-sys-devel-0.18.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "c60259b52b95389c8a991889a8e390c5109d9dee30be1a9c4579023f021a0095"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+openssl-sys-devel-0.18.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "877b8d9875a4897b15e60695213a0cfe17667684fd902c301971f65198a769be"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys+ssh-devel-0.18.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys+ssh-devel.sha256sum] = "b75d65621e254665049d185c40bc60e7e246b25b941bf3ac1c8fe594f1e69f71"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libgit2-sys-devel-0.18.8-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libgit2-sys-devel;unpack=0"
SRC_URI[x86_64_v2_rust-libgit2-sys-devel.sha256sum] = "032481d8587efc2c66811da2e085dd37050f66df216f2a935c423c00f7f5d5d3"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+default-devel-0.18.8-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+default-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+default-devel.sha256sum] = "4205d1698758e1d4dbb8534eb0b9c024451e1d7797fe91247f65a2c75e4e626c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+https-devel-0.18.8-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+https-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+https-devel.sha256sum] = "a9be20efc5f0390e34aab377c7fd4749cd7bf1312e9623a76e3e408cec40b3ec"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+libssh2-sys-devel-0.18.8-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+libssh2-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+libssh2-sys-devel.sha256sum] = "75115cdb9b4e1580deabefcbddeeeb08f2b8eb1f77814a41a893f4029c2ee27c"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+openssl-sys-devel-0.18.8-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+openssl-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+openssl-sys-devel.sha256sum] = "f087f88de7e437b0488a63ca85c57bd5d4ecfb414faccb35b0529b887c38e69d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys+ssh-devel-0.18.8-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys+ssh-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys+ssh-devel.sha256sum] = "84e8aa8dc68dc61c624d44c1c1b2b90fe9221de151cc84ea0d7b4f66505a0e5d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-libgit2-sys-devel-0.18.8-1.el10_2.noarch.rpm;name=aarch64_rust-libgit2-sys-devel;unpack=0"
SRC_URI[aarch64_rust-libgit2-sys-devel.sha256sum] = "75f5500f53f05aeaf05efed7130d5496228abf27a1a92747825295c0ad869bff"

RDEPENDS:rust-libgit2-sys+default-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+https-devel = " \
 cargo \
 rust-libgit2-sys+openssl-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys+libssh2-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-libssh2-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+openssl-sys-devel = " \
 cargo \
 rust-libgit2-sys-devel \
 rust-openssl-sys+default-devel \
 "
RDEPENDS:rust-libgit2-sys+ssh-devel = " \
 cargo \
 rust-libgit2-sys+libssh2-sys-devel \
 rust-libgit2-sys-devel \
 "
RDEPENDS:rust-libgit2-sys-devel = " \
 cargo \
 libgit2_1.9-devel \
 rust-cc+default-devel \
 rust-cc+parallel-devel \
 rust-libc+default-devel \
 rust-libz-sys+libc-devel \
 rust-libz-sys-devel \
 rust-pkg-config+default-devel \
 "
