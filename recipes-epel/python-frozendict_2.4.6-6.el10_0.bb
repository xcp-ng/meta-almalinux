# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-frozendict"
PV = "2.4.6"
PR = "6.el10_0"
PACKAGES = " \
 python3-frozendict \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-frozendict-2.4.6-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "11244e695acf2de1f9191ae1253cc3113a34d681e630a20ac53bdcf8e5540c0e"

URI_x86_64_v2_python3-frozendict = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-frozendict-2.4.6-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-frozendict;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-frozendict}"
SRC_URI[x86_64_v2_python3-frozendict.sha256sum] = "5c2afa8d354469c495dfa384f2844b66fe19e5076b45bf8174c273e5b76ba0fa"

URI_aarch64_python3-frozendict = "${EPEL_MIRROR}/aarch64/Packages/p/python3-frozendict-2.4.6-6.el10_0.noarch.rpm;name=aarch64_python3-frozendict;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-frozendict}"
SRC_URI[aarch64_python3-frozendict.sha256sum] = "f27835762927104e24861fa7776b211f4f27d190977e13c4c53473be0fdd30b9"

RDEPENDS:python3-frozendict = " \
 python3 \
 "
