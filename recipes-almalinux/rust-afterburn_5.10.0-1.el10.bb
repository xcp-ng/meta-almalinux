# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-afterburn"
PV = "5.10.0"
PR = "1.el10"
PACKAGES = " \
 afterburn \
 afterburn-dracut \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/rust-afterburn-5.10.0-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aeb9b6093562aa702705d0ead62c64ed5faed089ef04bbde71b6eed4a19914ea"

URI_x86_64_v2_afterburn = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-5.10.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_afterburn}"
SRC_URI[x86_64_v2_afterburn.sha256sum] = "5d663df5de0a6460b7b23580a41b116214544f5108823f8ff72686fd3fdc9ad1"

URI_x86_64_v2_afterburn-dracut = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/afterburn-dracut-5.10.0-1.el10.x86_64_v2.rpm;name=x86_64_v2_afterburn-dracut;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_afterburn-dracut}"
SRC_URI[x86_64_v2_afterburn-dracut.sha256sum] = "75c721314541afbfc59c38f4e46fae5d94548e0c7a598390dbce972d17850f7e"

URI_aarch64_afterburn = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-5.10.0-1.el10.aarch64.rpm;name=aarch64_afterburn;unpack=0"
SRC_URI:append = " ${URI_aarch64_afterburn}"
SRC_URI[aarch64_afterburn.sha256sum] = "4800148e42342b75914ddc1641b4fed360367282322aa4b8639f056149ffcec3"

URI_aarch64_afterburn-dracut = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/afterburn-dracut-5.10.0-1.el10.aarch64.rpm;name=aarch64_afterburn-dracut;unpack=0"
SRC_URI:append = " ${URI_aarch64_afterburn-dracut}"
SRC_URI[aarch64_afterburn-dracut.sha256sum] = "0c84bfcb4bc2ad55fe3644e4daa6d8158e9af03d722bf3e656f393369fe5f926"

RDEPENDS:afterburn = " \
 bash \
 glibc \
 libgcc \
 openssl-libs \
 systemd \
 "
RDEPENDS:afterburn-dracut = " \
 afterburn \
 bash \
 dracut \
 dracut-network \
 "
