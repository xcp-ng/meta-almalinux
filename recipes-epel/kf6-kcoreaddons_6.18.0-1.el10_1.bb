# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kf6-kcoreaddons"
PV = "6.18.0"
PR = "1.el10_1"
PACKAGES = " \
 kf6-kcoreaddons \
 kf6-kcoreaddons-devel \
 kf6-kcoreaddons-doc \
 kf6-kcoreaddons-html \
 python3-kf6-kcoreaddons \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kf6-kcoreaddons-6.18.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "003a29de22d95e4833380be1068f006bb4c2a184fffd34077e9ceb3713bce42f"

URI_x86_64_v2_kf6-kcoreaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons}"
SRC_URI[x86_64_v2_kf6-kcoreaddons.sha256sum] = "852cb794c57f79e1fed25586fe04fef3f56df8e476d5f3b2b6c0b6f92bbd6085"

URI_x86_64_v2_kf6-kcoreaddons-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-devel-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kf6-kcoreaddons-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-devel}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-devel.sha256sum] = "764b9a58b7f0f9349fe5d3df98fdefcde5516acc493c5f9fd52063a0e1084790"

URI_x86_64_v2_kf6-kcoreaddons-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-doc-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcoreaddons-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-doc}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-doc.sha256sum] = "e7e952407bae329771ebe11a473ce4457a5ca69daad1cfd20adcff42f783f397"

URI_x86_64_v2_kf6-kcoreaddons-html = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kf6-kcoreaddons-html-6.18.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_kf6-kcoreaddons-html;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kf6-kcoreaddons-html}"
SRC_URI[x86_64_v2_kf6-kcoreaddons-html.sha256sum] = "9716e9b33a00a3c1f09727218d55f0f555bfb4d259b61336f82a5d2f490eaa29"

URI_x86_64_v2_python3-kf6-kcoreaddons = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-kf6-kcoreaddons-6.18.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_python3-kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-kf6-kcoreaddons}"
SRC_URI[x86_64_v2_python3-kf6-kcoreaddons.sha256sum] = "19fa541a93c3cce886d3359a631fd597db04f64f7a58ca385e4ffa1e579a1617"

URI_aarch64_kf6-kcoreaddons = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons}"
SRC_URI[aarch64_kf6-kcoreaddons.sha256sum] = "fa025e713c315566b76b2bc09032ce39497fd9c8ac1340fb53d52c6db288a264"

URI_aarch64_kf6-kcoreaddons-devel = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-devel-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_kf6-kcoreaddons-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-devel}"
SRC_URI[aarch64_kf6-kcoreaddons-devel.sha256sum] = "7aba7a33ad19ca6c39ffd78ba48cf24d861101ed6b08c3564817677976288ef2"

URI_aarch64_kf6-kcoreaddons-doc = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-doc-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcoreaddons-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-doc}"
SRC_URI[aarch64_kf6-kcoreaddons-doc.sha256sum] = "cd7606051513349d9cbdd459e18246d62cd27ea5b2926fd84d77a55afdd3a498"

URI_aarch64_kf6-kcoreaddons-html = "${EPEL_MIRROR}/aarch64/Packages/k/kf6-kcoreaddons-html-6.18.0-1.el10_1.noarch.rpm;name=aarch64_kf6-kcoreaddons-html;unpack=0"
SRC_URI:append = " ${URI_aarch64_kf6-kcoreaddons-html}"
SRC_URI[aarch64_kf6-kcoreaddons-html.sha256sum] = "697faadf37cbb0641c993fb604e0d325d8c4a3228f6ed63fa4e98c4fcd284c82"

URI_aarch64_python3-kf6-kcoreaddons = "${EPEL_MIRROR}/aarch64/Packages/p/python3-kf6-kcoreaddons-6.18.0-1.el10_1.aarch64.rpm;name=aarch64_python3-kf6-kcoreaddons;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-kf6-kcoreaddons}"
SRC_URI[aarch64_python3-kf6-kcoreaddons.sha256sum] = "f6f3b4a53a45f39e5a02e209da01342424dbc51f08a0209ed9f048892e0d5fbc"

RDEPENDS:kf6-kcoreaddons = " \
 glibc \
 kf6-filesystem \
 libgcc \
 libstdc++ \
 qt6-qtbase \
 qt6-qtdeclarative \
 systemd-libs \
 "
RDEPENDS:kf6-kcoreaddons-devel = " \
 cmake-filesystem \
 kf6-kcoreaddons \
 pkgconf-pkg-config \
 python3-pyside6-devel \
 qt6-qtbase-devel \
 "
RDEPENDS:kf6-kcoreaddons-doc = " \
 "
RDEPENDS:kf6-kcoreaddons-html = " \
 "
RDEPENDS:python3-kf6-kcoreaddons = " \
 glibc \
 kf6-kcoreaddons \
 libgcc \
 libstdc++ \
 python3 \
 python3-libs \
 python3-pyside6 \
 python3-shiboken6 \
 qt6-qtbase \
 "
