# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-piper"
PV = "0.2.5"
PR = "1.el10_3"
PACKAGES = " \
 rust-piper+default-devel \
 rust-piper+futures-io-devel \
 rust-piper+portable-atomic-devel \
 rust-piper+portable-atomic-util-devel \
 rust-piper+portable_atomic_crate-devel \
 rust-piper+std-devel \
 rust-piper-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-piper-0.2.5-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "22e364bba2f401d065ac05dcef8ad5d99706e36495827718ba4eac9acf2c0b68"

URI_x86_64_v2_rust-piper+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+default-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+default-devel}"
SRC_URI[x86_64_v2_rust-piper+default-devel.sha256sum] = "8ef8348f0a2f180a4a31f3802fa194a5b9888842a990ef8d7e013c858b37ea11"

URI_x86_64_v2_rust-piper+futures-io-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+futures-io-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+futures-io-devel}"
SRC_URI[x86_64_v2_rust-piper+futures-io-devel.sha256sum] = "c9a3c2cf937a61c566f31694e2bde29c5b4ba8168d4db568fab3809c0de780f1"

URI_x86_64_v2_rust-piper+portable-atomic-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+portable-atomic-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+portable-atomic-devel}"
SRC_URI[x86_64_v2_rust-piper+portable-atomic-devel.sha256sum] = "03171a4a896429baaa70a763bab18d1f03d0765aa9a44e79855769a33220c470"

URI_x86_64_v2_rust-piper+portable-atomic-util-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+portable-atomic-util-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+portable-atomic-util-devel}"
SRC_URI[x86_64_v2_rust-piper+portable-atomic-util-devel.sha256sum] = "bd5af2e42ae190f3b8c382595660168fd51f27b0dd991391ccf799ad87b75538"

URI_x86_64_v2_rust-piper+portable_atomic_crate-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+portable_atomic_crate-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+portable_atomic_crate-devel}"
SRC_URI[x86_64_v2_rust-piper+portable_atomic_crate-devel.sha256sum] = "dfbd75fbc35cc762f3e36359038fa39b586d5b3936a04d96101b22604db9679a"

URI_x86_64_v2_rust-piper+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper+std-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper+std-devel}"
SRC_URI[x86_64_v2_rust-piper+std-devel.sha256sum] = "ee71e3a8b3232124ee660028e2e29bd047d094797c0773f4353e156bd0048ac9"

URI_x86_64_v2_rust-piper-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-piper-devel-0.2.5-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-piper-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-piper-devel}"
SRC_URI[x86_64_v2_rust-piper-devel.sha256sum] = "9ce434ae407da6f51ee6ee714332fe0e45a73da17364d6fcbaa7e969a3783012"

URI_aarch64_rust-piper+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+default-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-piper+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+default-devel}"
SRC_URI[aarch64_rust-piper+default-devel.sha256sum] = "90fa3720cf331721b3d971d4b395c159317f7fb2cf03d4c3750de59dce9f9ecd"

URI_aarch64_rust-piper+futures-io-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+futures-io-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-piper+futures-io-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+futures-io-devel}"
SRC_URI[aarch64_rust-piper+futures-io-devel.sha256sum] = "445dd9c12b3101880f444c7d68b135e5709fe12a6bd0a375444287d0718dcd59"

URI_aarch64_rust-piper+portable-atomic-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+portable-atomic-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-piper+portable-atomic-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+portable-atomic-devel}"
SRC_URI[aarch64_rust-piper+portable-atomic-devel.sha256sum] = "c53f6e856e82b9c54dd33f456557747f34fe9f38df61a2dc4d2962f9f676efa2"

URI_aarch64_rust-piper+portable-atomic-util-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+portable-atomic-util-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-piper+portable-atomic-util-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+portable-atomic-util-devel}"
SRC_URI[aarch64_rust-piper+portable-atomic-util-devel.sha256sum] = "db8287b79d3fdd2445b7becc2dc7badd96c06345c98ca7fb20ba1800077a3079"

URI_aarch64_rust-piper+portable_atomic_crate-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+portable_atomic_crate-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-piper+portable_atomic_crate-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+portable_atomic_crate-devel}"
SRC_URI[aarch64_rust-piper+portable_atomic_crate-devel.sha256sum] = "5349132a5d051126e1a6d44d1e20286cbc90b09388108ab1f74d1f399fbad171"

URI_aarch64_rust-piper+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper+std-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-piper+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper+std-devel}"
SRC_URI[aarch64_rust-piper+std-devel.sha256sum] = "8057ec155b9fbeb8072334c150cdc85667b12d4579d1d59069e3e32dc7a4752c"

URI_aarch64_rust-piper-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-piper-devel-0.2.5-1.el10_3.noarch.rpm;name=aarch64_rust-piper-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-piper-devel}"
SRC_URI[aarch64_rust-piper-devel.sha256sum] = "d380c7972acb0bda762088790d441b856538909d9273b41c6da14408a38cf280"

RDEPENDS:rust-piper+default-devel = " \
 cargo \
 rust-piper+std-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper+futures-io-devel = " \
 cargo \
 rust-futures-io+default-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper+portable-atomic-devel = " \
 cargo \
 rust-atomic-waker+portable-atomic-devel \
 rust-piper+portable-atomic-util-devel \
 rust-piper+portable_atomic_crate-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper+portable-atomic-util-devel = " \
 cargo \
 rust-piper-devel \
 rust-portable-atomic-util+alloc-devel \
 rust-portable-atomic-util+default-devel \
 "
RDEPENDS:rust-piper+portable_atomic_crate-devel = " \
 cargo \
 rust-piper-devel \
 rust-portable-atomic-devel \
 "
RDEPENDS:rust-piper+std-devel = " \
 cargo \
 rust-fastrand+std-devel \
 rust-piper+futures-io-devel \
 rust-piper-devel \
 "
RDEPENDS:rust-piper-devel = " \
 cargo \
 rust \
 rust-atomic-waker+default-devel \
 rust-fastrand-devel \
 "
