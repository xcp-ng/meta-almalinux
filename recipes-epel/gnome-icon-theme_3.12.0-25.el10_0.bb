# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gnome-icon-theme"
PV = "3.12.0"
PR = "25.el10_0"
PACKAGES = " \
 gnome-icon-theme \
 gnome-icon-theme-devel \
 gnome-icon-theme-legacy \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gnome-icon-theme-3.12.0-25.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9ba043e3f96fafa22f789f8225b2a03865c1fa898803f95e70b59e5c4e7a277d"

URI_x86_64_v2_gnome-icon-theme = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-icon-theme-3.12.0-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-icon-theme;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-icon-theme}"
SRC_URI[x86_64_v2_gnome-icon-theme.sha256sum] = "f18ce2dfd9f4f9974bd7b458851c91bb7d57dd7c3e2770c52430b42a90bf1d1a"

URI_x86_64_v2_gnome-icon-theme-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-icon-theme-devel-3.12.0-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-icon-theme-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-icon-theme-devel}"
SRC_URI[x86_64_v2_gnome-icon-theme-devel.sha256sum] = "c209e9cdc286c8e511a2669b5ccf44ecc180307d1898e9b9d28de47f3dffa94b"

URI_x86_64_v2_gnome-icon-theme-legacy = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gnome-icon-theme-legacy-3.12.0-25.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_gnome-icon-theme-legacy;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gnome-icon-theme-legacy}"
SRC_URI[x86_64_v2_gnome-icon-theme-legacy.sha256sum] = "7508882183fff00aa02c6617031759f640a445cda45e960393fb9f3d5286e03c"

URI_aarch64_gnome-icon-theme = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-icon-theme-3.12.0-25.el10_0.noarch.rpm;name=aarch64_gnome-icon-theme;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-icon-theme}"
SRC_URI[aarch64_gnome-icon-theme.sha256sum] = "d04f5da9b3cd6acaa5885793d32666c1b1bc413c0ad909f2fdefd39160cbea24"

URI_aarch64_gnome-icon-theme-devel = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-icon-theme-devel-3.12.0-25.el10_0.noarch.rpm;name=aarch64_gnome-icon-theme-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-icon-theme-devel}"
SRC_URI[aarch64_gnome-icon-theme-devel.sha256sum] = "61d56e0cb8673678f08ca7dbd5c308fccc5a5ce76c72f78a05f969200d35a366"

URI_aarch64_gnome-icon-theme-legacy = "${EPEL_MIRROR}/aarch64/Packages/g/gnome-icon-theme-legacy-3.12.0-25.el10_0.noarch.rpm;name=aarch64_gnome-icon-theme-legacy;unpack=0"
SRC_URI:append = " ${URI_aarch64_gnome-icon-theme-legacy}"
SRC_URI[aarch64_gnome-icon-theme-legacy.sha256sum] = "030dc8184e03c0637f1d62b7bc07044008a25f58c8ba215aacaeee641f4335aa"

RDEPENDS:gnome-icon-theme = " \
 bash \
 hicolor-icon-theme \
 "
RDEPENDS:gnome-icon-theme-devel = " \
 gnome-icon-theme \
 pkgconf-pkg-config \
 "
RDEPENDS:gnome-icon-theme-legacy = " \
 gnome-icon-theme \
 "
