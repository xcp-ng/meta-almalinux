# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-crossbeam-queue"
PV = "0.3.13"
PR = "1.el10_2"
PACKAGES = " \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue+default-devel \
 rust-crossbeam-queue+nightly-devel \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-crossbeam-queue-0.3.13-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "14c2f6a1d65a503322cd311af4bef8ea7a457b71938e371e2d330e7e4776307d"

URI_x86_64_v2_rust-crossbeam-queue+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+alloc-devel-0.3.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+alloc-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+alloc-devel.sha256sum] = "15d62c017fa41e6f63f37fa0bad3f07593b2cc4c40840394580509f91dee73ae"

URI_x86_64_v2_rust-crossbeam-queue+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+default-devel-0.3.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+default-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+default-devel.sha256sum] = "dd8e075734b2bacb3b8de95cbf63a306e5afaaa50c46cf8feca5cd21502a56e2"

URI_x86_64_v2_rust-crossbeam-queue+nightly-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+nightly-devel-0.3.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+nightly-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+nightly-devel.sha256sum] = "15e4b95446df54344b91cb553f2ee51fb552730ab1aa60d904ef863f1333bc42"

URI_x86_64_v2_rust-crossbeam-queue+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue+std-devel-0.3.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue+std-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue+std-devel.sha256sum] = "4bf97a1d1d1f7080ae52df8ca91bcc72c04e497e2dce73b89ce2a29b47947d24"

URI_x86_64_v2_rust-crossbeam-queue-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-crossbeam-queue-devel-0.3.13-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-crossbeam-queue-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-crossbeam-queue-devel}"
SRC_URI[x86_64_v2_rust-crossbeam-queue-devel.sha256sum] = "60f6fb1bcf976c8e5f66f1316212a2b9511f9082bb3a420df01c0aaa02a71792"

URI_aarch64_rust-crossbeam-queue+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+alloc-devel-0.3.13-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+alloc-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+alloc-devel.sha256sum] = "ad898a3e8696f2d69f3a1da250af8752d1f69494c5806344cea0f04e91ba5a6c"

URI_aarch64_rust-crossbeam-queue+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+default-devel-0.3.13-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+default-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+default-devel.sha256sum] = "b4dfa2336d4f6f432edb9246c4d74563826ab438ce73b8ca6c73aabfa1810cd3"

URI_aarch64_rust-crossbeam-queue+nightly-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+nightly-devel-0.3.13-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue+nightly-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+nightly-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+nightly-devel.sha256sum] = "31c2d497271227ea03a707bc03a529e714d3707c82925631cd8d58fefbf1ecdc"

URI_aarch64_rust-crossbeam-queue+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue+std-devel-0.3.13-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue+std-devel}"
SRC_URI[aarch64_rust-crossbeam-queue+std-devel.sha256sum] = "966f9e21ced250dffc227ccb114de2edd56a7a38df62102dd820544972ee0175"

URI_aarch64_rust-crossbeam-queue-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-crossbeam-queue-devel-0.3.13-1.el10_2.noarch.rpm;name=aarch64_rust-crossbeam-queue-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-crossbeam-queue-devel}"
SRC_URI[aarch64_rust-crossbeam-queue-devel.sha256sum] = "d39ffa642d36a62dd6f50fe479fa89a97f87aaf136925d4f66d88d5934a040a6"

RDEPENDS:rust-crossbeam-queue+alloc-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+default-devel = " \
 cargo \
 rust-crossbeam-queue+std-devel \
 rust-crossbeam-queue-devel \
 "
RDEPENDS:rust-crossbeam-queue+nightly-devel = " \
 cargo \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+nightly-devel \
 "
RDEPENDS:rust-crossbeam-queue+std-devel = " \
 cargo \
 rust-crossbeam-queue+alloc-devel \
 rust-crossbeam-queue-devel \
 rust-crossbeam-utils+std-devel \
 "
RDEPENDS:rust-crossbeam-queue-devel = " \
 cargo \
 rust \
 rust-crossbeam-utils-devel \
 "
