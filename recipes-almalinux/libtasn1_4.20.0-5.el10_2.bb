# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libtasn1"
PV = "4.20.0"
PR = "5.el10_2"
PACKAGES = " \
 libtasn1 \
 libtasn1-devel \
 libtasn1-tools \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/BaseOS/Source/Packages/libtasn1-4.20.0-5.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1d93855625a17714698d7f5bc334977c6bb773acdb37704ee2c75ac73dcc4d45"

URI_x86_64_v2_libtasn1 = "${ALMALINUX_MIRROR}/BaseOS/x86_64_v2/os/Packages/libtasn1-4.20.0-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_libtasn1;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtasn1}"
SRC_URI[x86_64_v2_libtasn1.sha256sum] = "51c9d7cdc2258e156c27400c5f341b7ae4609566dee9236f2e9b8569a0683736"

URI_x86_64_v2_libtasn1-devel = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtasn1-devel-4.20.0-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_libtasn1-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtasn1-devel}"
SRC_URI[x86_64_v2_libtasn1-devel.sha256sum] = "fdbe765d1ac2e295e1503e8d52e109cb5e4b4c76b9152410a158bcd34cd0951f"

URI_x86_64_v2_libtasn1-tools = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/libtasn1-tools-4.20.0-5.el10_2.x86_64_v2.rpm;name=x86_64_v2_libtasn1-tools;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libtasn1-tools}"
SRC_URI[x86_64_v2_libtasn1-tools.sha256sum] = "6087696f874919c9b7940341a1c872b870efcc922bda34f62a436b10a4ab5839"

URI_aarch64_libtasn1 = "${ALMALINUX_MIRROR}/BaseOS/aarch64/os/Packages/libtasn1-4.20.0-5.el10_2.aarch64.rpm;name=aarch64_libtasn1;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtasn1}"
SRC_URI[aarch64_libtasn1.sha256sum] = "582a90dceb8a51e07561df25cb81ec41ddb90d5b014db4cf468f1aba3b71711c"

URI_aarch64_libtasn1-devel = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtasn1-devel-4.20.0-5.el10_2.aarch64.rpm;name=aarch64_libtasn1-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtasn1-devel}"
SRC_URI[aarch64_libtasn1-devel.sha256sum] = "ab66beb80a547044e194a3a377af5fe5a6aaa2658df7fe66a9434ac9819e7b4b"

URI_aarch64_libtasn1-tools = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/libtasn1-tools-4.20.0-5.el10_2.aarch64.rpm;name=aarch64_libtasn1-tools;unpack=0"
SRC_URI:append = " ${URI_aarch64_libtasn1-tools}"
SRC_URI[aarch64_libtasn1-tools.sha256sum] = "4b7c2610fdbc255ba3e2030bd4a963d0a156b37f656b835bdafbcec0f21cda57"

RDEPENDS:libtasn1 = " \
 glibc \
 "
RDEPENDS:libtasn1-devel = " \
 libtasn1 \
 libtasn1-tools \
 pkgconf-pkg-config \
 "
RDEPENDS:libtasn1-tools = " \
 glibc \
 libtasn1 \
 "
