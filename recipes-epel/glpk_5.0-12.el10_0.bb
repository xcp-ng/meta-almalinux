# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "glpk"
PV = "5.0"
PR = "12.el10_0"
PACKAGES = " \
 glpk \
 glpk-devel \
 glpk-doc \
 glpk-utils \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/glpk-5.0-12.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "476686bb8e7b98513e9a44415a7fad9e1ccc6f8f5e1f2faaa01c7609daca8127"

URI_x86_64_v2_glpk = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-5.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk}"
SRC_URI[x86_64_v2_glpk.sha256sum] = "a89bb708a64f2aa329d3636f4d3630a582721b76e880171987921e08c1150a6c"

URI_x86_64_v2_glpk-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-devel-5.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk-devel}"
SRC_URI[x86_64_v2_glpk-devel.sha256sum] = "6a8a589eba87d7d62dca5ff6900370e69b37086ede554fe5994b2e8f3f104509"

URI_x86_64_v2_glpk-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-doc-5.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk-doc}"
SRC_URI[x86_64_v2_glpk-doc.sha256sum] = "780a4550d8da1b7dd0e2b43c93fd3de975395320ef54f95a44962f053bce3dda"

URI_x86_64_v2_glpk-utils = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/glpk-utils-5.0-12.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_glpk-utils;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_glpk-utils}"
SRC_URI[x86_64_v2_glpk-utils.sha256sum] = "28dce69ee38acace5a6281a34248fbb9b5114ce493503dea5a43b8fe250b2cf8"

URI_aarch64_glpk = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-5.0-12.el10_0.aarch64.rpm;name=aarch64_glpk;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk}"
SRC_URI[aarch64_glpk.sha256sum] = "af67408ab861a0766f51a39b2635afd156c410a369847b411d8edaac4b5290c8"

URI_aarch64_glpk-devel = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-devel-5.0-12.el10_0.aarch64.rpm;name=aarch64_glpk-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk-devel}"
SRC_URI[aarch64_glpk-devel.sha256sum] = "59f74f9be9034aa00269e99de835ea451b21e4675ab00c84294a658767706ba6"

URI_aarch64_glpk-doc = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-doc-5.0-12.el10_0.aarch64.rpm;name=aarch64_glpk-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk-doc}"
SRC_URI[aarch64_glpk-doc.sha256sum] = "9e340c957eda5c5ec85be4aad49b75abd1da6f0edcc6af08630903b7f38ee820"

URI_aarch64_glpk-utils = "${EPEL_MIRROR}/aarch64/Packages/g/glpk-utils-5.0-12.el10_0.aarch64.rpm;name=aarch64_glpk-utils;unpack=0"
SRC_URI:append = " ${URI_aarch64_glpk-utils}"
SRC_URI[aarch64_glpk-utils.sha256sum] = "56bd0f3fd977679321bd67942f6550c53cf9bb419ec17607fd4726bd80f97e92"

RDEPENDS:glpk = " \
 glibc \
 gmp \
 suitesparse \
 zlib-ng-compat \
 "
RDEPENDS:glpk-devel = " \
 glpk \
 "
RDEPENDS:glpk-doc = " \
 "
RDEPENDS:glpk-utils = " \
 glibc \
 glpk \
 "
