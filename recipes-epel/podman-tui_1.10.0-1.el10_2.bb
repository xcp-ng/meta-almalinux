# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "podman-tui"
PV = "1.10.0"
PR = "1.el10_2"
PACKAGES = " \
 podman-tui \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/podman-tui-1.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "367172eb0222a161fc32240e1a47dcf02a092023a05996b5cee4f4969d864b07"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/podman-tui-1.10.0-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_podman-tui;unpack=0"
SRC_URI[x86_64_v2_podman-tui.sha256sum] = "9fa71049f76324b43e5128c9de0d5f687aff7cb7bc6f4c812aad809ef53399ae"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/podman-tui-1.10.0-1.el10_2.aarch64.rpm;name=aarch64_podman-tui;unpack=0"
SRC_URI[aarch64_podman-tui.sha256sum] = "b84d651b26d5b3888851b58743de838c015b5208aed4263b5e27d749df0e14b0"

RDEPENDS:podman-tui = " \
 glibc \
 "
