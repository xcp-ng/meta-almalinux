# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-xcursor"
PV = "0.3.11"
PR = "1.el10_2"
PACKAGES = " \
 rust-xcursor+default-devel \
 rust-xcursor-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-xcursor-0.3.11-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "23fc7fbde5bd2b1683e06e7a0fcdcf5f394792b5d304e27458074e1763b7c07e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xcursor+default-devel-0.3.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xcursor+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xcursor+default-devel.sha256sum] = "569d75f87911b0852cdc652b16d79e66c5f6f16c09ea795c8bd0a1332d4345d4"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-xcursor-devel-0.3.11-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-xcursor-devel;unpack=0"
SRC_URI[x86_64_v2_rust-xcursor-devel.sha256sum] = "bb8543ab81c744423029d61701b715899f8c11ae2475ef8b4dee88a4a696a73a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xcursor+default-devel-0.3.11-1.el10_2.noarch.rpm;name=aarch64_rust-xcursor+default-devel;unpack=0"
SRC_URI[aarch64_rust-xcursor+default-devel.sha256sum] = "a215b840376663861340d7a6c0691cd0ba964f80bfe2a0889b29d1106443490f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-xcursor-devel-0.3.11-1.el10_2.noarch.rpm;name=aarch64_rust-xcursor-devel;unpack=0"
SRC_URI[aarch64_rust-xcursor-devel.sha256sum] = "eecf1cac970af748afefefc0dc132ccea743196f4d69b2fc79460fd710f1d1fe"

RDEPENDS:rust-xcursor+default-devel = " \
 cargo \
 rust-xcursor-devel \
 "
RDEPENDS:rust-xcursor-devel = " \
 cargo \
 "
