# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kfind"
PV = "24.12.3"
PR = "1.el10_0"
PACKAGES = " \
 kfind \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kfind-24.12.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "4097d97707ae5a45f3ff330547f7c2b5c29ac84488bc773992da0383c1abe5b9"

URI_x86_64_v2_kfind = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kfind-24.12.3-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kfind;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kfind}"
SRC_URI[x86_64_v2_kfind.sha256sum] = "120813251134d6ad715b745f8df0d004380c247c1d6eacc00e0ad51a3bbe9ee2"

URI_aarch64_kfind = "${EPEL_MIRROR}/aarch64/Packages/k/kfind-24.12.3-1.el10_0.aarch64.rpm;name=aarch64_kfind;unpack=0"
SRC_URI:append = " ${URI_aarch64_kfind}"
SRC_URI[aarch64_kfind.sha256sum] = "322b81119ba3a7bbf503e4e26c6dfe9c258d982b7f43d214581c4613d16f9564"

RDEPENDS:kfind = " \
 glibc \
 kf6-karchive \
 kf6-kcompletion \
 kf6-kconfig \
 kf6-kconfigwidgets \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kfilemetadata \
 kf6-ki18n \
 kf6-kio-core-libs \
 kf6-kio-gui \
 kf6-kio-widgets-libs \
 kf6-kwidgetsaddons \
 kf6-kxmlgui \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 "
