# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "luarocks"
PV = "3.9.2"
PR = "6.el10_0"
PACKAGES = " \
 luarocks \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/l/luarocks-3.9.2-6.el10_0.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "13112c9e0a4482a8de6e94250390bb44ce1e5c132efaeaa02308f164a150480e"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/luarocks-3.9.2-6.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_luarocks;unpack=0"
SRC_URI[x86_64_v2_luarocks.sha256sum] = "2de669f91890dc22385ab19616593d2133fc19893b742980f006a26271ada09e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/l/luarocks-3.9.2-6.el10_0.noarch.rpm;name=aarch64_luarocks;unpack=0"
SRC_URI[aarch64_luarocks.sha256sum] = "ff3262c3c778a16e5d2327f9b6bc4ae3d7a9ae499f47a7cbf6ccefc300cad066"

RDEPENDS:luarocks = " \
 gcc \
 lua \
 lua-libs \
 unzip \
 zip \
 "
