# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-rustfix"
PV = "0.9.7"
PR = "1.el10_3"
PACKAGES = " \
 rust-rustfix+default-devel \
 rust-rustfix-devel \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/r/rust-rustfix-0.9.7-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "855d57c1a0622a133c17683945b5a33299fd6ab4086c43607bf467397a56a266"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix+default-devel-0.9.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix+default-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustfix+default-devel.sha256sum] = "b0b152e9b9db43a0039690465503c290474a2d6ad07edfee39402e63c3a631e0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-rustfix-devel-0.9.7-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-rustfix-devel;unpack=0"
SRC_URI[x86_64_v2_rust-rustfix-devel.sha256sum] = "be2dfc796b989bd00a2ef4f539091eee275c71ca044e54ef83024700b400dfa2"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix+default-devel-0.9.7-1.el10_3.noarch.rpm;name=aarch64_rust-rustfix+default-devel;unpack=0"
SRC_URI[aarch64_rust-rustfix+default-devel.sha256sum] = "8907cb23c24bff8e27578706f114c8a4f655d2e2eec04d1f63b85850197f2471"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/r/rust-rustfix-devel-0.9.7-1.el10_3.noarch.rpm;name=aarch64_rust-rustfix-devel;unpack=0"
SRC_URI[aarch64_rust-rustfix-devel.sha256sum] = "3f838954937680fe9744f332b153c6612858ecbaec6ab3dcaa2abd3aa6b87067"

RDEPENDS:rust-rustfix+default-devel = " \
 cargo \
 rust-rustfix-devel \
 "
RDEPENDS:rust-rustfix-devel = " \
 cargo \
 rust \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde_json+default-devel \
 rust-thiserror+default-devel \
 "
