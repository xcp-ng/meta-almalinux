# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-libloading0.8"
PV = "0.8.9"
PR = "1.el10_3"
PACKAGES = " \
 rust-libloading0.8+default-devel \
 rust-libloading0.8-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-libloading0.8-0.8.9-1.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "368cafc6a4c48a5bba0e3595f2d0719aca94a6c82072100d96fc43aecf6bd3e8"

URI_x86_64_v2_rust-libloading0.8+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libloading0.8+default-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libloading0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libloading0.8+default-devel}"
SRC_URI[x86_64_v2_rust-libloading0.8+default-devel.sha256sum] = "e2c50e6ed0e0a5c62d4993b728be9dbfb43ed519998d043589247f27438ec66a"
RPROVIDES:rust-libloading0.8+default-devel:x86_64_v2 = "virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"

URI_x86_64_v2_rust-libloading0.8-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-libloading0.8-devel-0.8.9-1.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-libloading0.8-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-libloading0.8-devel}"
SRC_URI[x86_64_v2_rust-libloading0.8-devel.sha256sum] = "a213624e9e9357639e0b02bc854744411368d3a62b782183f0a599b1ea31d314"

URI_aarch64_rust-libloading0.8+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libloading0.8+default-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-libloading0.8+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libloading0.8+default-devel}"
SRC_URI[aarch64_rust-libloading0.8+default-devel.sha256sum] = "1a8d6a9c82a015c728b69ae6fae331f2e52702d0048ddbdc9dd6246c2e20aa91"
RPROVIDES:rust-libloading0.8+default-devel:aarch64 = "virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"

URI_aarch64_rust-libloading0.8-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-libloading0.8-devel-0.8.9-1.el10_3.noarch.rpm;name=aarch64_rust-libloading0.8-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-libloading0.8-devel}"
SRC_URI[aarch64_rust-libloading0.8-devel.sha256sum] = "424d9cd2af6b008851f6a7b442bb924095e4988084f1d41c91d78fae9be053fa"

RDEPENDS:rust-libloading0.8+default-devel = " \
 cargo \
 rust-libloading0.8-devel \
 "
RDEPENDS:rust-libloading0.8-devel = " \
 cargo \
 rust \
 rust-cfg-if+default-devel \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"

PROVIDES:append:aarch64 = " rpm/virtual/crate_libloading/default__ge_0.7.0_with_crate_libloading/default__lt_0.9.0~"
