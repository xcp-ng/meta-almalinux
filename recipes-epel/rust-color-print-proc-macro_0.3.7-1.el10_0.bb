# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-color-print-proc-macro"
PV = "0.3.7"
PR = "1.el10_0"
PACKAGES = " \
 rust-color-print-proc-macro+default-devel \
 rust-color-print-proc-macro+terminfo-devel \
 rust-color-print-proc-macro-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-color-print-proc-macro-0.3.7-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ac8707e020a7d92ba8aabb9c5e548c0d5291f8862e444d4d88ca980a66cd10c2"

URI_x86_64_v2_rust-color-print-proc-macro+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-print-proc-macro+default-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-print-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-color-print-proc-macro+default-devel}"
SRC_URI[x86_64_v2_rust-color-print-proc-macro+default-devel.sha256sum] = "aea61e7fd4f93d80d9a4aae33b26028e5745870e840663a09aa15717835fbc4d"

URI_x86_64_v2_rust-color-print-proc-macro+terminfo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-print-proc-macro+terminfo-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-print-proc-macro+terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-color-print-proc-macro+terminfo-devel}"
SRC_URI[x86_64_v2_rust-color-print-proc-macro+terminfo-devel.sha256sum] = "568c4c989474deaaf09a5e3eca6ddd0c35f89afce70d5475335b33d7e3af5b29"

URI_x86_64_v2_rust-color-print-proc-macro-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-color-print-proc-macro-devel-0.3.7-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-color-print-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-color-print-proc-macro-devel}"
SRC_URI[x86_64_v2_rust-color-print-proc-macro-devel.sha256sum] = "1d4cffd072243c93b7acefb3fd27210a95c41068392b4ce967e68fcf16736c7b"

URI_aarch64_rust-color-print-proc-macro+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-color-print-proc-macro+default-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-color-print-proc-macro+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-color-print-proc-macro+default-devel}"
SRC_URI[aarch64_rust-color-print-proc-macro+default-devel.sha256sum] = "d3e27c9eccedaae4b55da37d81f1db013dbe133298bb0c31ecb86a0ef0fce5f7"

URI_aarch64_rust-color-print-proc-macro+terminfo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-color-print-proc-macro+terminfo-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-color-print-proc-macro+terminfo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-color-print-proc-macro+terminfo-devel}"
SRC_URI[aarch64_rust-color-print-proc-macro+terminfo-devel.sha256sum] = "3168693f3174854b9e70f2fe07742f5bade7e5837b71a1bbcb4a7ec93cd42740"

URI_aarch64_rust-color-print-proc-macro-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-color-print-proc-macro-devel-0.3.7-1.el10_0.noarch.rpm;name=aarch64_rust-color-print-proc-macro-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-color-print-proc-macro-devel}"
SRC_URI[aarch64_rust-color-print-proc-macro-devel.sha256sum] = "eca2efc61eddc564968ede4a80da184f7b6d5a13e1ec1dd5ca53484f88fe9ccf"

RDEPENDS:rust-color-print-proc-macro+default-devel = " \
 cargo \
 rust-color-print-proc-macro-devel \
 "
RDEPENDS:rust-color-print-proc-macro+terminfo-devel = " \
 cargo \
 rust-color-print-proc-macro-devel \
 "
RDEPENDS:rust-color-print-proc-macro-devel = " \
 cargo \
 rust-nom+default-devel \
 rust-proc-macro2+default-devel \
 rust-quote+default-devel \
 rust-syn+default-devel \
 rust-syn+full-devel \
 "
