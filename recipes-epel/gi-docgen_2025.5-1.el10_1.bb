# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "gi-docgen"
PV = "2025.5"
PR = "1.el10_1"
PACKAGES = " \
 gi-docgen \
 gi-docgen-doc \
 gi-docgen-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/gi-docgen-2025.5-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "15f98d3f39c1a993cae2534081db62d74f3db0da8fd5895f2064e0575bc2f018"

URI_x86_64_v2_gi-docgen = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gi-docgen-2025.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gi-docgen;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gi-docgen}"
SRC_URI[x86_64_v2_gi-docgen.sha256sum] = "b2e17c5f5b72e8ed976aa8a42885000910b743fdd4c70d631398a4916c2afadd"

URI_x86_64_v2_gi-docgen-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gi-docgen-doc-2025.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gi-docgen-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gi-docgen-doc}"
SRC_URI[x86_64_v2_gi-docgen-doc.sha256sum] = "03af52730f812fc6d830839e571a560742f00cfc2b4f067e4ecf219381e93479"

URI_x86_64_v2_gi-docgen-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/gi-docgen-fonts-2025.5-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_gi-docgen-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_gi-docgen-fonts}"
SRC_URI[x86_64_v2_gi-docgen-fonts.sha256sum] = "d8323fd51048b4da45c02924f6433c8ca858cdbcd1731c2961d972291404e1be"

URI_aarch64_gi-docgen = "${EPEL_MIRROR}/aarch64/Packages/g/gi-docgen-2025.5-1.el10_1.noarch.rpm;name=aarch64_gi-docgen;unpack=0"
SRC_URI:append = " ${URI_aarch64_gi-docgen}"
SRC_URI[aarch64_gi-docgen.sha256sum] = "fc6521d6ce53f8166657c2de09b461e0b2c34a4e388688c57d78905de57376ab"

URI_aarch64_gi-docgen-doc = "${EPEL_MIRROR}/aarch64/Packages/g/gi-docgen-doc-2025.5-1.el10_1.noarch.rpm;name=aarch64_gi-docgen-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_gi-docgen-doc}"
SRC_URI[aarch64_gi-docgen-doc.sha256sum] = "52e5fdd42b06e2dd76363d7838f874818d866a3ab190961b9af758a214c1b319"

URI_aarch64_gi-docgen-fonts = "${EPEL_MIRROR}/aarch64/Packages/g/gi-docgen-fonts-2025.5-1.el10_1.noarch.rpm;name=aarch64_gi-docgen-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_gi-docgen-fonts}"
SRC_URI[aarch64_gi-docgen-fonts.sha256sum] = "0a79baa3c772fd8b1410c4bea31dcc080b264b3011623d6b8df8235d45dad7e2"

RDEPENDS:gi-docgen = " \
 gi-docgen-fonts \
 pkgconf-pkg-config \
 python3 \
 python3-jinja2 \
 python3-markdown \
 python3-markupsafe \
 python3-packaging \
 python3-pygments \
 python3-typogrify \
 "
RDEPENDS:gi-docgen-doc = " \
 "
RDEPENDS:gi-docgen-fonts = " \
 redhat-display-fonts \
 redhat-mono-vf-fonts \
 redhat-text-fonts \
 virtual/font_redhatdisplay_ \
 virtual/font_redhattext_ \
 "
