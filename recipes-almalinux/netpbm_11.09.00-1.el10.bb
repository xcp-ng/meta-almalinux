# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "netpbm"
PV = "11.09.00"
PR = "1.el10"
PACKAGES = " \
 netpbm \
 netpbm-devel \
 netpbm-doc \
 netpbm-progs \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/netpbm-11.09.00-1.el10.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1bbb396ba66784a8f9e11cbf4ad30e4d8bf0f40ff620ef5eb782dc064f002dda"

URI_x86_64_v2_netpbm = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netpbm-11.09.00-1.el10.x86_64_v2.rpm;name=x86_64_v2_netpbm;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netpbm}"
SRC_URI[x86_64_v2_netpbm.sha256sum] = "eb1725c20bcc10f3d63b7868666039c9728ad7409058d0552f206ef0b8a04897"

URI_x86_64_v2_netpbm-devel = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/netpbm-devel-11.09.00-1.el10.x86_64_v2.rpm;name=x86_64_v2_netpbm-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netpbm-devel}"
SRC_URI[x86_64_v2_netpbm-devel.sha256sum] = "556bcff136c950eee77f133b8efbdf1c97945634ef6fd2b6adb90db7f1380635"

URI_x86_64_v2_netpbm-doc = "${ALMALINUX_MIRROR}/CRB/x86_64_v2/os/Packages/netpbm-doc-11.09.00-1.el10.x86_64_v2.rpm;name=x86_64_v2_netpbm-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netpbm-doc}"
SRC_URI[x86_64_v2_netpbm-doc.sha256sum] = "ce1839fbab5dc74657ddcc8a554d226c27c61d770e54be88a8b44117206df3f0"

URI_x86_64_v2_netpbm-progs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/netpbm-progs-11.09.00-1.el10.x86_64_v2.rpm;name=x86_64_v2_netpbm-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_netpbm-progs}"
SRC_URI[x86_64_v2_netpbm-progs.sha256sum] = "caf3ce363bd9ce3be4445c5c5ce1444725f49cf3609dfdde0844d201ca0d4d12"

URI_aarch64_netpbm = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netpbm-11.09.00-1.el10.aarch64.rpm;name=aarch64_netpbm;unpack=0"
SRC_URI:append = " ${URI_aarch64_netpbm}"
SRC_URI[aarch64_netpbm.sha256sum] = "a8947059b5f862cdb794d96a8b118e70cfc9483773f922303cbe70ef278d249f"

URI_aarch64_netpbm-devel = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/netpbm-devel-11.09.00-1.el10.aarch64.rpm;name=aarch64_netpbm-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_netpbm-devel}"
SRC_URI[aarch64_netpbm-devel.sha256sum] = "849d07a8dbc148b41c26f430485d6c736a7603b3889115be816782018d437d1b"

URI_aarch64_netpbm-doc = "${ALMALINUX_MIRROR}/CRB/aarch64/os/Packages/netpbm-doc-11.09.00-1.el10.aarch64.rpm;name=aarch64_netpbm-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_netpbm-doc}"
SRC_URI[aarch64_netpbm-doc.sha256sum] = "eb0cafce455eeee8225a94cda5bc084f861bcc6ddca8fc71b3d3d72edbd6c65e"

URI_aarch64_netpbm-progs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/netpbm-progs-11.09.00-1.el10.aarch64.rpm;name=aarch64_netpbm-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_netpbm-progs}"
SRC_URI[aarch64_netpbm-progs.sha256sum] = "6183a10b74836ad44170e3cd05bb085a95ab907e808cc95ec4e7367c7a69dce0"

RDEPENDS:netpbm = " \
 glibc \
 "
RDEPENDS:netpbm-devel = " \
 netpbm \
 "
RDEPENDS:netpbm-doc = " \
 netpbm-progs \
 "
RDEPENDS:netpbm-progs = " \
 bash \
 ghostscript \
 glibc \
 jasper-libs \
 jbigkit-libs \
 libX11 \
 libgcc \
 libjpeg-turbo \
 libpng \
 libtiff \
 libxml2 \
 netpbm \
 perl-English \
 perl-Errno \
 perl-Fcntl \
 perl-File-Basename \
 perl-File-Copy \
 perl-File-Temp \
 perl-Getopt-Long \
 perl-IO \
 perl-PathTools \
 perl-interpreter \
 perl-libs \
 zlib-ng-compat \
 "
