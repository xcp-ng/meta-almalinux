# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-colcon-argcomplete"
PV = "0.3.3"
PR = "1.el10_0"
PACKAGES = " \
 python3-colcon-argcomplete \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-colcon-argcomplete-0.3.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "05b7abe0bda1b8f4bd7fc86fdde9b584c1cbe3fab223c78442289d3162dc42c7"

URI_x86_64_v2_python3-colcon-argcomplete = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-colcon-argcomplete-0.3.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-colcon-argcomplete;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-colcon-argcomplete}"
SRC_URI[x86_64_v2_python3-colcon-argcomplete.sha256sum] = "4a110408cd99fb233c2a4f6c25850777e8ac2e395f209173d5ef2c26ee060fa8"

URI_aarch64_python3-colcon-argcomplete = "${EPEL_MIRROR}/aarch64/Packages/p/python3-colcon-argcomplete-0.3.3-1.el10_0.noarch.rpm;name=aarch64_python3-colcon-argcomplete;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-colcon-argcomplete}"
SRC_URI[aarch64_python3-colcon-argcomplete.sha256sum] = "58d80317bf233e11be26e29b6eb73a6bbaa39075cdb0a5769094f69e878977a4"

RDEPENDS:python3-colcon-argcomplete = " \
 python3 \
 python3-argcomplete \
 python3-colcon-core \
 "
