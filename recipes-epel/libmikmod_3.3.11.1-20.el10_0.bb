# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "libmikmod"
PV = "3.3.11.1"
PR = "20.el10_0"
PACKAGES = " \
 libmikmod \
 libmikmod-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/libmikmod-3.3.11.1-20.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "de6df0ffc49b384f337ac6e476d531a97f2e3ceec8452cc5125f6c81bab63ad7"

URI_x86_64_v2_libmikmod = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmikmod-3.3.11.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmikmod;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmikmod}"
SRC_URI[x86_64_v2_libmikmod.sha256sum] = "9b096bba194e1612cf9f4a02af8a9c6fc3d3bfeb03513236759155fea939ba90"

URI_x86_64_v2_libmikmod-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/libmikmod-devel-3.3.11.1-20.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_libmikmod-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_libmikmod-devel}"
SRC_URI[x86_64_v2_libmikmod-devel.sha256sum] = "3dfa03a6062aa9e6e9a3874af7c228c9cc3911b20e160affef2ac9179d2e05e0"

URI_aarch64_libmikmod = "${EPEL_MIRROR}/aarch64/Packages/l/libmikmod-3.3.11.1-20.el10_0.aarch64.rpm;name=aarch64_libmikmod;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmikmod}"
SRC_URI[aarch64_libmikmod.sha256sum] = "4e82feb95182fefd82a16a28a510c40277395a893be9d882501d2760d9f22fa5"

URI_aarch64_libmikmod-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libmikmod-devel-3.3.11.1-20.el10_0.aarch64.rpm;name=aarch64_libmikmod-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libmikmod-devel}"
SRC_URI[aarch64_libmikmod-devel.sha256sum] = "488a6955fdb7ca0fc0f5f24c8ced13c8639ce8a8da4593c7069af62d22e62892"

RDEPENDS:libmikmod = " \
 glibc \
 pulseaudio-libs \
 "
RDEPENDS:libmikmod-devel = " \
 bash \
 libmikmod \
 pkgconf-pkg-config \
 pulseaudio-libs-devel \
 "
