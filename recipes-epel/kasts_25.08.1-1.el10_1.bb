# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "kasts"
PV = "25.08.1"
PR = "1.el10_1"
PACKAGES = " \
 kasts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/k/kasts-25.08.1-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "1cada9ad12f7c748295faf83f5f3638f4ce7e966fd333a3051c2c4800368c703"

URI_x86_64_v2_kasts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/kasts-25.08.1-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_kasts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_kasts}"
SRC_URI[x86_64_v2_kasts.sha256sum] = "9a9a6efdd6e3e54cabc4e7eb5f44a59b861ab711c1b9f58b9c1d7a20c6b05acb"

URI_aarch64_kasts = "${EPEL_MIRROR}/aarch64/Packages/k/kasts-25.08.1-1.el10_1.aarch64.rpm;name=aarch64_kasts;unpack=0"
SRC_URI:append = " ${URI_aarch64_kasts}"
SRC_URI[aarch64_kasts.sha256sum] = "34716fc235cd1bb55ae95b655c546bc87c810866600ddc8963282275b73db7c0"

RDEPENDS:kasts = " \
 glibc \
 kf6-breeze-icons \
 kf6-kcolorscheme \
 kf6-kconfig \
 kf6-kcoreaddons \
 kf6-kcrash \
 kf6-kdbusaddons \
 kf6-ki18n \
 kf6-kiconthemes \
 kf6-kirigami \
 kf6-kirigami-addons \
 kf6-kwindowsystem \
 kf6-syndication \
 kf6-threadweaver \
 libgcc \
 libstdc++ \
 qt6-qt5compat \
 qt6-qtbase \
 qt6-qtbase-gui \
 qt6-qtdeclarative \
 qt6-qtmultimedia \
 qtkeychain-qt6 \
 taglib \
 vlc-libs \
 "
