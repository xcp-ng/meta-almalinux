# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gengo"
PV = "0.14.3"
PR = "4.el10_3"
PACKAGES = " \
 rust-gengo+default-devel \
 rust-gengo+directory-devel \
 rust-gengo+git-devel \
 rust-gengo+max-performance-devel \
 rust-gengo+max-performance-safe-devel \
 rust-gengo-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gengo-0.14.3-4.el10_3.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "82a91af834ba390b93d132c31908ff80a1e7987b44f7eb90ddb14bc136e4a3e0"

URI_x86_64_v2_rust-gengo+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+default-devel-0.14.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+default-devel}"
SRC_URI[x86_64_v2_rust-gengo+default-devel.sha256sum] = "9f56299fda3dcd8941dc780acdf2892fa8bc779da0cdaf18291e8da57d498c33"

URI_x86_64_v2_rust-gengo+directory-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+directory-devel-0.14.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+directory-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+directory-devel}"
SRC_URI[x86_64_v2_rust-gengo+directory-devel.sha256sum] = "2ab6cd1d107e08f838171afcc5a1bf76ad72c958eb01fc6d526592d3e73e179c"

URI_x86_64_v2_rust-gengo+git-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+git-devel-0.14.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+git-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+git-devel}"
SRC_URI[x86_64_v2_rust-gengo+git-devel.sha256sum] = "efa848acd0baabc0bb49329b2239669340d0b3e0b3f917120a35207eb7ee7be3"

URI_x86_64_v2_rust-gengo+max-performance-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+max-performance-devel-0.14.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+max-performance-devel}"
SRC_URI[x86_64_v2_rust-gengo+max-performance-devel.sha256sum] = "33acf193101e64610985a61bc35b5cb335c69873269c83ae7e0fe8488e83afdb"

URI_x86_64_v2_rust-gengo+max-performance-safe-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo+max-performance-safe-devel-0.14.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo+max-performance-safe-devel}"
SRC_URI[x86_64_v2_rust-gengo+max-performance-safe-devel.sha256sum] = "9c42f1e8492daad8a6fc4211a2a282d773e3af71701f0ead9234f19a6fdb9a75"

URI_x86_64_v2_rust-gengo-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gengo-devel-0.14.3-4.el10_3.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gengo-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gengo-devel}"
SRC_URI[x86_64_v2_rust-gengo-devel.sha256sum] = "bc25af6c6fe407c2ea7a7abe85ff56cab083ce7d5cb7d7ac4fd3ab88db2698af"

URI_aarch64_rust-gengo+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+default-devel-0.14.3-4.el10_3.noarch.rpm;name=aarch64_rust-gengo+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+default-devel}"
SRC_URI[aarch64_rust-gengo+default-devel.sha256sum] = "728f11097b46e8f2e88cc4798a2b652132e935b5796c16f789db3fcf2a914673"

URI_aarch64_rust-gengo+directory-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+directory-devel-0.14.3-4.el10_3.noarch.rpm;name=aarch64_rust-gengo+directory-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+directory-devel}"
SRC_URI[aarch64_rust-gengo+directory-devel.sha256sum] = "e792eb29dc0ea4d062d4830c1de2faa999107b36fecfe1f65d4006eefd4a5103"

URI_aarch64_rust-gengo+git-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+git-devel-0.14.3-4.el10_3.noarch.rpm;name=aarch64_rust-gengo+git-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+git-devel}"
SRC_URI[aarch64_rust-gengo+git-devel.sha256sum] = "43eeb3cf01264193ff9b53a87596215ffaabf032c3eae6f60b2385439c993052"

URI_aarch64_rust-gengo+max-performance-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+max-performance-devel-0.14.3-4.el10_3.noarch.rpm;name=aarch64_rust-gengo+max-performance-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+max-performance-devel}"
SRC_URI[aarch64_rust-gengo+max-performance-devel.sha256sum] = "8c4082c19fdae8392bded0426dae4987b00984e57f347347878f3f8de718ded1"

URI_aarch64_rust-gengo+max-performance-safe-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo+max-performance-safe-devel-0.14.3-4.el10_3.noarch.rpm;name=aarch64_rust-gengo+max-performance-safe-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo+max-performance-safe-devel}"
SRC_URI[aarch64_rust-gengo+max-performance-safe-devel.sha256sum] = "d2072052497560db05d88d35d2d96ea43031d8d3448a95dc1e71d57d5d7b08c4"

URI_aarch64_rust-gengo-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gengo-devel-0.14.3-4.el10_3.noarch.rpm;name=aarch64_rust-gengo-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gengo-devel}"
SRC_URI[aarch64_rust-gengo-devel.sha256sum] = "1be2aa19e0aed5714ec8acf4f127a447a89745004d1c26e3f7e321d19de6b6fe"

RDEPENDS:rust-gengo+default-devel = " \
 cargo \
 rust-gengo+directory-devel \
 rust-gengo+git-devel \
 rust-gengo+max-performance-safe-devel \
 rust-gengo-devel \
 "
RDEPENDS:rust-gengo+directory-devel = " \
 cargo \
 rust-gengo-devel \
 rust-ignore+default-devel \
 "
RDEPENDS:rust-gengo+git-devel = " \
 cargo \
 rust-gengo-devel \
 rust-gix+attributes-devel \
 rust-gix+index-devel \
 rust-gix+parallel-devel \
 rust-gix+revision-devel \
 rust-gix+sha1-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gengo+max-performance-devel = " \
 cargo \
 rust-gengo-devel \
 rust-gix+attributes-devel \
 rust-gix+index-devel \
 rust-gix+max-performance-devel \
 rust-gix+parallel-devel \
 rust-gix+revision-devel \
 rust-gix+sha1-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gengo+max-performance-safe-devel = " \
 cargo \
 rust-gengo-devel \
 rust-gix+attributes-devel \
 rust-gix+index-devel \
 rust-gix+max-performance-safe-devel \
 rust-gix+parallel-devel \
 rust-gix+revision-devel \
 rust-gix+sha1-devel \
 rust-gix-devel \
 "
RDEPENDS:rust-gengo-devel = " \
 cargo \
 rust \
 rust-gengo-language+default-devel \
 rust-glob+default-devel \
 rust-indexmap+default-devel \
 rust-indexmap+rayon-devel \
 rust-indexmap+serde-devel \
 rust-rayon+default-devel \
 rust-regex+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 "
