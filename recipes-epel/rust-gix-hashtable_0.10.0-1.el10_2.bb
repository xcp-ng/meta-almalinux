# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-hashtable"
PV = "0.10.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-hashtable+default-devel \
 rust-gix-hashtable-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-hashtable-0.10.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b360a0a7014a3099ea6931b80e1d41e6745e6ce8ab2baff45ed9e9ed3cbcfa2d"

URI_x86_64_v2_rust-gix-hashtable+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable+default-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable+default-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable+default-devel.sha256sum] = "7a6af71e41f3e196845af3123f448ce2e6ee1a8c7e9602f5845c8f73d9b310bb"

URI_x86_64_v2_rust-gix-hashtable-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-hashtable-devel-0.10.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-hashtable-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-hashtable-devel}"
SRC_URI[x86_64_v2_rust-gix-hashtable-devel.sha256sum] = "81b7b11d4fc880e2fadfd366731d559754610877bf8c3f295c4e1afd086b00e9"

URI_aarch64_rust-gix-hashtable+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable+default-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-hashtable+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable+default-devel}"
SRC_URI[aarch64_rust-gix-hashtable+default-devel.sha256sum] = "b21977b7614cdb2910f51e1a99e4396c386ae6639ab91ef92c21fca7a93387a7"

URI_aarch64_rust-gix-hashtable-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-hashtable-devel-0.10.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-hashtable-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-hashtable-devel}"
SRC_URI[aarch64_rust-gix-hashtable-devel.sha256sum] = "b6cdad62989c90058ea7d430de7a3bce8b280e512c51125d6d201ae74622d8d1"

RDEPENDS:rust-gix-hashtable+default-devel = " \
 cargo \
 rust-gix-hashtable-devel \
 "
RDEPENDS:rust-gix-hashtable-devel = " \
 cargo \
 rust \
 rust-gix-hash+default-devel \
 rust-hashbrown+inline-more-devel \
 rust-hashbrown-devel \
 rust-parking_lot+default-devel \
 "
