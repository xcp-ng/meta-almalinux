# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "dustin-dustismo-fonts"
PV = "20030318"
PR = "33.el10_0"
PACKAGES = " \
 dustin-dustismo-fonts-common \
 dustin-dustismo-roman-fonts \
 dustin-dustismo-sans-fonts \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/d/dustin-dustismo-fonts-20030318-33.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a764526ab47cabb46ae17d8f23f9947c2f06c26131aee97788d03de3640d69a3"

URI_x86_64_v2_dustin-dustismo-fonts-common = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dustin-dustismo-fonts-common-20030318-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dustin-dustismo-fonts-common;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dustin-dustismo-fonts-common}"
SRC_URI[x86_64_v2_dustin-dustismo-fonts-common.sha256sum] = "76550ad182ff2edb012595305cbb9708a68487d8c32bc3011c33b3136f4d81eb"

URI_x86_64_v2_dustin-dustismo-roman-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dustin-dustismo-roman-fonts-20030318-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dustin-dustismo-roman-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dustin-dustismo-roman-fonts}"
SRC_URI[x86_64_v2_dustin-dustismo-roman-fonts.sha256sum] = "47fb37588faacc5489f0120fa11f9b379030ae5cc949620025b9dbaa9fdcba25"

URI_x86_64_v2_dustin-dustismo-sans-fonts = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/dustin-dustismo-sans-fonts-20030318-33.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_dustin-dustismo-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_dustin-dustismo-sans-fonts}"
SRC_URI[x86_64_v2_dustin-dustismo-sans-fonts.sha256sum] = "00f75e51896dbc1a20336a7303baf3149812cd096540df5c7f2c68b68f707e1e"

URI_aarch64_dustin-dustismo-fonts-common = "${EPEL_MIRROR}/aarch64/Packages/d/dustin-dustismo-fonts-common-20030318-33.el10_0.noarch.rpm;name=aarch64_dustin-dustismo-fonts-common;unpack=0"
SRC_URI:append = " ${URI_aarch64_dustin-dustismo-fonts-common}"
SRC_URI[aarch64_dustin-dustismo-fonts-common.sha256sum] = "8a7914feaa27269efceab48bf314fe1d02cf2ee6d3c108654960d85662d7b62a"

URI_aarch64_dustin-dustismo-roman-fonts = "${EPEL_MIRROR}/aarch64/Packages/d/dustin-dustismo-roman-fonts-20030318-33.el10_0.noarch.rpm;name=aarch64_dustin-dustismo-roman-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dustin-dustismo-roman-fonts}"
SRC_URI[aarch64_dustin-dustismo-roman-fonts.sha256sum] = "f7e601976e6b15ce88c48b531c7a2919abdd090f96c230f35eabd976204a554d"

URI_aarch64_dustin-dustismo-sans-fonts = "${EPEL_MIRROR}/aarch64/Packages/d/dustin-dustismo-sans-fonts-20030318-33.el10_0.noarch.rpm;name=aarch64_dustin-dustismo-sans-fonts;unpack=0"
SRC_URI:append = " ${URI_aarch64_dustin-dustismo-sans-fonts}"
SRC_URI[aarch64_dustin-dustismo-sans-fonts.sha256sum] = "32bf697e5a5f4fe18796c760cfb220c5c2ae67be77461187d8c61d2d06752459"

RDEPENDS:dustin-dustismo-fonts-common = " \
 fonts-filesystem \
 "
RDEPENDS:dustin-dustismo-roman-fonts = " \
 dustin-dustismo-fonts-common \
 "
RDEPENDS:dustin-dustismo-sans-fonts = " \
 dustin-dustismo-fonts-common \
 "
