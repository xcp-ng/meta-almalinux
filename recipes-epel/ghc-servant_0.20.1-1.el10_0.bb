# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-servant"
PV = "0.20.1"
PR = "1.el10_0"
PACKAGES = " \
 ghc-servant \
 ghc-servant-devel \
 ghc-servant-doc \
 ghc-servant-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-servant-0.20.1-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c9e5b04aee586981a51021de4f6eab57d52e08f8635955dbc2258a4426a75cd1"

URI_x86_64_v2_ghc-servant = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-0.20.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant}"
SRC_URI[x86_64_v2_ghc-servant.sha256sum] = "22d42888409179fe9b297dce9397638c433588ed036bd8c0e3d7ed6a42bbc55f"

URI_x86_64_v2_ghc-servant-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-devel-0.20.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-devel}"
SRC_URI[x86_64_v2_ghc-servant-devel.sha256sum] = "a860bea3c9045cac1ad31d68431e1633ec3a09965b6b111ded9232654fa5efb8"

URI_x86_64_v2_ghc-servant-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-doc-0.20.1-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-servant-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-doc}"
SRC_URI[x86_64_v2_ghc-servant-doc.sha256sum] = "fc42fe5fa519ef8e1950ac2f7e06365e3d9cea3f52c7d98174761cdfd00c4cdc"

URI_x86_64_v2_ghc-servant-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-servant-prof-0.20.1-1.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-servant-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-servant-prof}"
SRC_URI[x86_64_v2_ghc-servant-prof.sha256sum] = "488161ea834f8cdbd0ba6311cf9cf4b8f6c9b0e66c480f22d14f35046ac4b721"

URI_aarch64_ghc-servant = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-0.20.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-servant;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant}"
SRC_URI[aarch64_ghc-servant.sha256sum] = "5a8a2d2f2093efacc783ac23e4d85bc387d3beafb71bccc0189e7261f3d9382c"

URI_aarch64_ghc-servant-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-devel-0.20.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-servant-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-devel}"
SRC_URI[aarch64_ghc-servant-devel.sha256sum] = "61eb18d61a301ac3574ea1997ea99b5a3595992e7156bbf694b2b769a2a58d01"

URI_aarch64_ghc-servant-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-doc-0.20.1-1.el10_0.noarch.rpm;name=aarch64_ghc-servant-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-doc}"
SRC_URI[aarch64_ghc-servant-doc.sha256sum] = "dc4e341bc5aa4797cb09cf77665a2575b4d89f2326aba092dd3aa46404d5dc9d"

URI_aarch64_ghc-servant-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-servant-prof-0.20.1-1.el10_0.aarch64.rpm;name=aarch64_ghc-servant-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-servant-prof}"
SRC_URI[aarch64_ghc-servant-prof.sha256sum] = "5ddca7ffb7d4bf5995203ca9a49016943adfe48f44221000a2213a2b8e38dee4"

RDEPENDS:ghc-servant = " \
 ghc-OneTuple \
 ghc-QuickCheck \
 ghc-StateVar \
 ghc-aeson \
 ghc-array \
 ghc-assoc \
 ghc-attoparsec \
 ghc-attoparsec-iso8601 \
 ghc-base \
 ghc-base-compat \
 ghc-base-compat-batteries \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-binary \
 ghc-boring \
 ghc-bytestring \
 ghc-case-insensitive \
 ghc-comonad \
 ghc-constraints \
 ghc-containers \
 ghc-contravariant \
 ghc-cookie \
 ghc-data-default-class \
 ghc-data-fix \
 ghc-dec \
 ghc-deepseq \
 ghc-distributive \
 ghc-dlist \
 ghc-exceptions \
 ghc-filepath \
 ghc-generically \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-hashable \
 ghc-http-api-data \
 ghc-http-media \
 ghc-http-types \
 ghc-indexed-traversable \
 ghc-indexed-traversable-instances \
 ghc-integer-conversion \
 ghc-integer-logarithms \
 ghc-mmorph \
 ghc-mtl \
 ghc-network-uri \
 ghc-os-string \
 ghc-parsec \
 ghc-pretty \
 ghc-primitive \
 ghc-random \
 ghc-scientific \
 ghc-semialign \
 ghc-semigroupoids \
 ghc-singleton-bool \
 ghc-some \
 ghc-sop-core \
 ghc-splitmix \
 ghc-stm \
 ghc-strict \
 ghc-string-conversions \
 ghc-tagged \
 ghc-template-haskell \
 ghc-text \
 ghc-text-short \
 ghc-th-abstraction \
 ghc-th-compat \
 ghc-these \
 ghc-time \
 ghc-time-compat \
 ghc-transformers \
 ghc-transformers-compat \
 ghc-unix \
 ghc-unordered-containers \
 ghc-utf8-string \
 ghc-uuid-types \
 ghc-vault \
 ghc-vector \
 ghc-vector-stream \
 ghc-witherable \
 glibc \
 gmp \
 "
RDEPENDS:ghc-servant-devel = " \
 ghc-QuickCheck-devel \
 ghc-aeson-devel \
 ghc-attoparsec-devel \
 ghc-base-compat-devel \
 ghc-base-devel \
 ghc-bifunctors-devel \
 ghc-bytestring-devel \
 ghc-case-insensitive-devel \
 ghc-compiler \
 ghc-constraints-devel \
 ghc-deepseq-devel \
 ghc-http-api-data-devel \
 ghc-http-media-devel \
 ghc-http-types-devel \
 ghc-mmorph-devel \
 ghc-mtl-devel \
 ghc-network-uri-devel \
 ghc-servant \
 ghc-singleton-bool-devel \
 ghc-sop-core-devel \
 ghc-string-conversions-devel \
 ghc-tagged-devel \
 ghc-text-devel \
 ghc-transformers-devel \
 ghc-vault-devel \
 "
RDEPENDS:ghc-servant-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-servant-prof = " \
 ghc-QuickCheck-prof \
 ghc-aeson-prof \
 ghc-attoparsec-prof \
 ghc-base-compat-prof \
 ghc-base-prof \
 ghc-bifunctors-prof \
 ghc-bytestring-prof \
 ghc-case-insensitive-prof \
 ghc-constraints-prof \
 ghc-deepseq-prof \
 ghc-http-api-data-prof \
 ghc-http-media-prof \
 ghc-http-types-prof \
 ghc-mmorph-prof \
 ghc-mtl-prof \
 ghc-network-uri-prof \
 ghc-servant-devel \
 ghc-singleton-bool-prof \
 ghc-sop-core-prof \
 ghc-string-conversions-prof \
 ghc-tagged-prof \
 ghc-text-prof \
 ghc-transformers-prof \
 ghc-vault-prof \
 "
