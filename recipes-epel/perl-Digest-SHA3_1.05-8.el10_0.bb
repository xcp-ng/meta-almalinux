# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "perl-Digest-SHA3"
PV = "1.05"
PR = "8.el10_0"
PACKAGES = " \
 perl-Digest-SHA3 \
 perl-Digest-SHA3-tests \
 sha3sum \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/perl-Digest-SHA3-1.05-8.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e05f36fe661746653bfa8f0f2da6c255e1365fe656975044ada38d7e4a47c883"

URI_x86_64_v2_perl-Digest-SHA3 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Digest-SHA3-1.05-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Digest-SHA3;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Digest-SHA3}"
SRC_URI[x86_64_v2_perl-Digest-SHA3.sha256sum] = "8d2d2f2785f74a3aabfcd30fa87d75a55cdc2627c31edb001e791957c8e521b6"

URI_x86_64_v2_perl-Digest-SHA3-tests = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/perl-Digest-SHA3-tests-1.05-8.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_perl-Digest-SHA3-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_perl-Digest-SHA3-tests}"
SRC_URI[x86_64_v2_perl-Digest-SHA3-tests.sha256sum] = "7c6a47600182ecfb5298c7c8efe9cfdf4430ebcc00f1f0d502b2a95bc28ed028"

URI_x86_64_v2_sha3sum = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sha3sum-1.05-8.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_sha3sum;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sha3sum}"
SRC_URI[x86_64_v2_sha3sum.sha256sum] = "8968ec8cf0115dcd0522d7c6f991902e837cf1b5ec44270ab293300f20c3e328"

URI_aarch64_perl-Digest-SHA3 = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Digest-SHA3-1.05-8.el10_0.aarch64.rpm;name=aarch64_perl-Digest-SHA3;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Digest-SHA3}"
SRC_URI[aarch64_perl-Digest-SHA3.sha256sum] = "cf3a4894d9704b0b065f0e75f035ddc416f7464399406e11bd26fa49210ae78b"

URI_aarch64_perl-Digest-SHA3-tests = "${EPEL_MIRROR}/aarch64/Packages/p/perl-Digest-SHA3-tests-1.05-8.el10_0.aarch64.rpm;name=aarch64_perl-Digest-SHA3-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_perl-Digest-SHA3-tests}"
SRC_URI[aarch64_perl-Digest-SHA3-tests.sha256sum] = "495c1d956dd62daee0a06058ff4d2ae3a10c2a542221e8bb5a087986cbdb061d"

URI_aarch64_sha3sum = "${EPEL_MIRROR}/aarch64/Packages/s/sha3sum-1.05-8.el10_0.noarch.rpm;name=aarch64_sha3sum;unpack=0"
SRC_URI:append = " ${URI_aarch64_sha3sum}"
SRC_URI[aarch64_sha3sum.sha256sum] = "bea8a9b5832e8241809dfa19ece2c335774574b577af3b734fe7e0be9eda0f10"

RDEPENDS:perl-Digest-SHA3 = " \
 glibc \
 perl-Carp \
 perl-Digest \
 perl-Exporter \
 perl-Fcntl \
 perl-PathTools \
 perl-libs \
 perl-vars \
 "
RDEPENDS:perl-Digest-SHA3-tests = " \
 bash \
 perl-Digest-SHA3 \
 perl-Test-Harness \
 perl-interpreter \
 perl-libs \
 "
RDEPENDS:sha3sum = " \
 perl-Digest-SHA3 \
 perl-Fcntl \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 "
