# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "proftpd"
PV = "1.3.9d"
PR = "2.el10_2"
PACKAGES = " \
 proftpd \
 proftpd-devel \
 proftpd-ldap \
 proftpd-mysql \
 proftpd-postgresql \
 proftpd-proxy \
 proftpd-sqlite \
 proftpd-utils \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/p/proftpd-1.3.9d-2.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "71c4b2c709362676f0cf7e16eb4c27c2bf3ec00f9052cbdf79f1defa979762c2"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-1.3.9d-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd;unpack=0"
SRC_URI[x86_64_v2_proftpd.sha256sum] = "8b386532c182e0e2193b73cfc732454f5a4994846c592ca2ae0e1b4b16319ee0"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-devel-1.3.9d-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-devel;unpack=0"
SRC_URI[x86_64_v2_proftpd-devel.sha256sum] = "2b26fea32e51a4eaf3248c831b93debafb8e24ea79d7061c2bee24ae0fc4b0f9"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-ldap-1.3.9d-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-ldap;unpack=0"
SRC_URI[x86_64_v2_proftpd-ldap.sha256sum] = "58c0de6868736b1304c74724d9cf9f82b7a35d4613bfd9069b70f5c45b18bb1d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-mysql-1.3.9d-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-mysql;unpack=0"
SRC_URI[x86_64_v2_proftpd-mysql.sha256sum] = "b2bc61b76a5a65b1e4ea080e20d439aaaf89e17d5637f01d5748211ac4f988a1"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-postgresql-1.3.9d-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-postgresql;unpack=0"
SRC_URI[x86_64_v2_proftpd-postgresql.sha256sum] = "62d7706666842cabc4509f0de3344ea80eb06c0deb37612cdde953ea485e457d"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-proxy-1.3.9d-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-proxy;unpack=0"
SRC_URI[x86_64_v2_proftpd-proxy.sha256sum] = "58c6c6af71c2e34c63b8b77959f20b48f5b053eba00cc9c7155bd519e6ca3915"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-sqlite-1.3.9d-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-sqlite;unpack=0"
SRC_URI[x86_64_v2_proftpd-sqlite.sha256sum] = "4f5451e714ef8bebd7c13ee6529cd18bf86e2c0f7b1c1c4245b3243fb20a33b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/proftpd-utils-1.3.9d-2.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_proftpd-utils;unpack=0"
SRC_URI[x86_64_v2_proftpd-utils.sha256sum] = "239537b418f4bd29280afd646909d0c58fb783fa743aa26f01cbb8974b174352"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-1.3.9d-2.el10_2.aarch64.rpm;name=aarch64_proftpd;unpack=0"
SRC_URI[aarch64_proftpd.sha256sum] = "f33128a557f93e78844e896b30d0b05661c6cff0ff1223f715105713d083e5a4"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-devel-1.3.9d-2.el10_2.aarch64.rpm;name=aarch64_proftpd-devel;unpack=0"
SRC_URI[aarch64_proftpd-devel.sha256sum] = "830386ce7ae1704b23762a7ed8231df6c4cc0f1b94923ff31bbe62b916a1050f"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-ldap-1.3.9d-2.el10_2.aarch64.rpm;name=aarch64_proftpd-ldap;unpack=0"
SRC_URI[aarch64_proftpd-ldap.sha256sum] = "ecd369e101814bda9152ba82dae65702d14f7a035db322572eba1103a7804469"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-mysql-1.3.9d-2.el10_2.aarch64.rpm;name=aarch64_proftpd-mysql;unpack=0"
SRC_URI[aarch64_proftpd-mysql.sha256sum] = "9e49b9325217ab373c2620a18cebec470152a420e3fb9c0c310920398142696a"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-postgresql-1.3.9d-2.el10_2.aarch64.rpm;name=aarch64_proftpd-postgresql;unpack=0"
SRC_URI[aarch64_proftpd-postgresql.sha256sum] = "34bc15c8f1c1441044e7df4242b1005fc1003f2f598a4ed2ae7e66667626e86e"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-proxy-1.3.9d-2.el10_2.aarch64.rpm;name=aarch64_proftpd-proxy;unpack=0"
SRC_URI[aarch64_proftpd-proxy.sha256sum] = "ab054735dbd63df63b9d248b5febdaa94c6f6d7d9a54a26af06524e599a5c15d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-sqlite-1.3.9d-2.el10_2.aarch64.rpm;name=aarch64_proftpd-sqlite;unpack=0"
SRC_URI[aarch64_proftpd-sqlite.sha256sum] = "b642c9b556952964b3ef0101cc8ebcf4011c59edd87984524b3d397450afe808"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/p/proftpd-utils-1.3.9d-2.el10_2.aarch64.rpm;name=aarch64_proftpd-utils;unpack=0"
SRC_URI[aarch64_proftpd-utils.sha256sum] = "4465c4c0b8e4aed99cd5aeded0835bd6606fa537489b92c469a269158581458d"

RDEPENDS:proftpd = " \
 bash \
 findutils \
 glibc \
 libacl \
 libcap \
 libidn2 \
 libmemcached-awesome \
 libsodium \
 libxcrypt \
 logrotate \
 openssl-libs \
 pam-libs \
 pcre2 \
 systemd \
 virtual/coreutils \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-devel = " \
 gcc \
 libacl-devel \
 libcap-devel \
 libmemcached-awesome-devel \
 libpq-devel \
 libsodium-devel \
 mariadb-connector-c-devel \
 ncurses-devel \
 openldap-devel \
 openssl-devel \
 pam-devel \
 pcre2-devel \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-interpreter \
 perl-libs \
 pkgconf-pkg-config \
 proftpd \
 sqlite-devel \
 zlib-ng-compat-devel \
 "
RDEPENDS:proftpd-ldap = " \
 glibc \
 libidn2 \
 libsodium \
 openldap \
 proftpd \
 "
RDEPENDS:proftpd-mysql = " \
 glibc \
 libidn2 \
 libsodium \
 mariadb-connector-c \
 proftpd \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-postgresql = " \
 glibc \
 libidn2 \
 libpq \
 libsodium \
 proftpd \
 "
RDEPENDS:proftpd-proxy = " \
 glibc \
 libidn2 \
 libsodium \
 openssl-libs \
 proftpd \
 sqlite-libs \
 zlib-ng-compat \
 "
RDEPENDS:proftpd-sqlite = " \
 glibc \
 libidn2 \
 libsodium \
 proftpd \
 sqlite-libs \
 "
RDEPENDS:proftpd-utils = " \
 glibc \
 ncurses-libs \
 perl-Crypt-Cracklib \
 perl-Fcntl \
 perl-File-Basename \
 perl-Getopt-Long \
 perl-IO \
 perl-MIME-Base64 \
 perl-Mail-Sendmail \
 perl-Time-HiRes \
 perl-interpreter \
 perl-libs \
 proftpd \
 "
