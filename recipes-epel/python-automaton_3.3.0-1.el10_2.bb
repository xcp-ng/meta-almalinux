# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-automaton"
PV = "3.3.0"
PR = "1.el10_2"
PACKAGES = " \
 python-automaton-doc \
 python3-automaton \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-automaton-3.3.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "5120d00bfb2163f040aef42b34153442bb8c3aaf409d7adeaba25aec0c187b03"

URI_x86_64_v2_python-automaton-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python-automaton-doc-3.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python-automaton-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python-automaton-doc}"
SRC_URI[x86_64_v2_python-automaton-doc.sha256sum] = "030d5d73f9582c8f3362ec368df9b6bcbf99405f9079e98e93ea744fcc37e689"

URI_x86_64_v2_python3-automaton = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-automaton-3.3.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_python3-automaton;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-automaton}"
SRC_URI[x86_64_v2_python3-automaton.sha256sum] = "edce4bc6a9c5d34d75eaafb553d0b78c4edfc38a576c1aa8962d3c03ecaeece4"

URI_aarch64_python-automaton-doc = "${EPEL_MIRROR}/aarch64/Packages/p/python-automaton-doc-3.3.0-1.el10_2.noarch.rpm;name=aarch64_python-automaton-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_python-automaton-doc}"
SRC_URI[aarch64_python-automaton-doc.sha256sum] = "6da0f967b58e4efa204eeac61d9a704d7d1aab7009972a2e8728db4828a0c6ed"

URI_aarch64_python3-automaton = "${EPEL_MIRROR}/aarch64/Packages/p/python3-automaton-3.3.0-1.el10_2.noarch.rpm;name=aarch64_python3-automaton;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-automaton}"
SRC_URI[aarch64_python3-automaton.sha256sum] = "7d0170831646eb88a07e90d220a2b8a5ff7aa361d7527266bc5babebd33a41df"

RDEPENDS:python-automaton-doc = " \
 "
RDEPENDS:python3-automaton = " \
 python3 \
 python3-pbr \
 python3-prettytable \
 "
