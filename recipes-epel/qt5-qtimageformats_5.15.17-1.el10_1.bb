# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "qt5-qtimageformats"
PV = "5.15.17"
PR = "1.el10_1"
PACKAGES = " \
 qt5-qtimageformats \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/q/qt5-qtimageformats-5.15.17-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ff3033e9d3b7a58334064102ae48559826f49962eb60f035ccec8a58f888cd96"

URI_x86_64_v2_qt5-qtimageformats = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/qt5-qtimageformats-5.15.17-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_qt5-qtimageformats;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_qt5-qtimageformats}"
SRC_URI[x86_64_v2_qt5-qtimageformats.sha256sum] = "aa57f960f3d329204e0e53f5f5aa54670d94b8b57d2c0c4b3db666d2d49c99b8"

URI_aarch64_qt5-qtimageformats = "${EPEL_MIRROR}/aarch64/Packages/q/qt5-qtimageformats-5.15.17-1.el10_1.aarch64.rpm;name=aarch64_qt5-qtimageformats;unpack=0"
SRC_URI:append = " ${URI_aarch64_qt5-qtimageformats}"
SRC_URI[aarch64_qt5-qtimageformats.sha256sum] = "bffa3c258ca19070eb6e2ef2305889218fa32d944f1275438b2bae6290a41539"

RDEPENDS:qt5-qtimageformats = " \
 glibc \
 jasper-libs \
 libmng \
 libstdc++ \
 libtiff \
 libwebp \
 qt5-qtbase \
 qt5-qtbase-gui \
 "
