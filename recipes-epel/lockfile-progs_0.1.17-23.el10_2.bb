# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "lockfile-progs"
PV = "0.1.17"
PR = "23.el10_2"
PACKAGES = " \
 lockfile-progs \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/lockfile-progs-0.1.17-23.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "28d47693675155e248c90e95cd2731e81bd199daf6d0ff52209eb3a0b69d72b6"

URI_x86_64_v2_lockfile-progs = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/lockfile-progs-0.1.17-23.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_lockfile-progs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_lockfile-progs}"
SRC_URI[x86_64_v2_lockfile-progs.sha256sum] = "44429c7f16ef5c5d477b084e6823ebe6207eaa02fe8915de9f49df375f78b8c1"

URI_aarch64_lockfile-progs = "${EPEL_MIRROR}/aarch64/Packages/l/lockfile-progs-0.1.17-23.el10_2.aarch64.rpm;name=aarch64_lockfile-progs;unpack=0"
SRC_URI:append = " ${URI_aarch64_lockfile-progs}"
SRC_URI[aarch64_lockfile-progs.sha256sum] = "64bfff59211326ee8f7dc86a37eba602ba3140c7c58caec9ee180cf579edffd6"

RDEPENDS:lockfile-progs = " \
 glibc \
 liblockfile \
 "
