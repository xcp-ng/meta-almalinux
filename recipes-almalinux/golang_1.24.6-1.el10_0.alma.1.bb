# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang"
PV = "1.24.6"
PR = "1.el10_0.alma.1"
PACKAGES = " \
 go-toolset \
 golang \
 golang-bin \
 golang-docs \
 golang-misc \
 golang-race \
 golang-src \
 golang-tests \
 "

URI_src = "${ALMALINUXSRC_MIRROR}/AppStream/Source/Packages/golang-1.24.6-1.el10_0.alma.1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "ad95f4001b7b5d6b907c0eda45b90b9bb482294df1003fc2decb2086f14beb74"

URI_x86_64_v2_go-toolset = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/go-toolset-1.24.6-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_go-toolset;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_go-toolset}"
SRC_URI[x86_64_v2_go-toolset.sha256sum] = "15a4e159c3d5d7335273f124c9de106aa5c3adbb19e5f26417c455a77ff01f76"

URI_x86_64_v2_golang = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-1.24.6-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang}"
SRC_URI[x86_64_v2_golang.sha256sum] = "f40370ad23068ebbcb629c1496095902c4de715ec70c4d222c4ed566897fdb65"

URI_x86_64_v2_golang-bin = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-bin-1.24.6-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-bin;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-bin}"
SRC_URI[x86_64_v2_golang-bin.sha256sum] = "209930824be5b6b9a2d3218797eb28a4d11e056057dca0d8a33a8d34c33009f8"

URI_x86_64_v2_golang-docs = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-docs-1.24.6-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_golang-docs;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-docs}"
SRC_URI[x86_64_v2_golang-docs.sha256sum] = "b540c93d9030e14609394ea67606f28cd6f298bcddaaae80a6be8d7183f50ecf"

URI_x86_64_v2_golang-misc = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-misc-1.24.6-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_golang-misc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-misc}"
SRC_URI[x86_64_v2_golang-misc.sha256sum] = "83670aa8ef8253d2cb3f7b30cf7fded4995488eec26e485effc10065b9c86975"

URI_x86_64_v2_golang-race = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-race-1.24.6-1.el10_0.alma.1.x86_64_v2.rpm;name=x86_64_v2_golang-race;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-race}"
SRC_URI[x86_64_v2_golang-race.sha256sum] = "b3c08b7954aa095119848440303f5d34a67817bb6940b6607243cc3944ad94d7"

URI_x86_64_v2_golang-src = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-src-1.24.6-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_golang-src;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-src}"
SRC_URI[x86_64_v2_golang-src.sha256sum] = "48ca27c5b38c1f2fa1ac58ece2e1458a2dc7567cbcd79dcb6776e513680a5167"

URI_x86_64_v2_golang-tests = "${ALMALINUX_MIRROR}/AppStream/x86_64_v2/os/Packages/golang-tests-1.24.6-1.el10_0.alma.1.noarch.rpm;name=x86_64_v2_golang-tests;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-tests}"
SRC_URI[x86_64_v2_golang-tests.sha256sum] = "d2f30e00924a779cf17c9bde4531ce463af71fc9b65a7cfa2fb330d6b1275c01"
RPROVIDES:golang-tests:x86_64_v2 = "virtual/libtiffxx.so.6___64bit_"

URI_aarch64_go-toolset = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/go-toolset-1.24.6-1.el10_0.alma.1.aarch64.rpm;name=aarch64_go-toolset;unpack=0"
SRC_URI:append = " ${URI_aarch64_go-toolset}"
SRC_URI[aarch64_go-toolset.sha256sum] = "f721d93451bd31e3f5afbbfedb046917c93bc8fafc81d34758f08377bc6e3f38"

URI_aarch64_golang = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-1.24.6-1.el10_0.alma.1.aarch64.rpm;name=aarch64_golang;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang}"
SRC_URI[aarch64_golang.sha256sum] = "7edca3c050f8b9ce399bdaeef323064bb9c5ae5509ea7f2d74fc5d8e2079b557"

URI_aarch64_golang-bin = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-bin-1.24.6-1.el10_0.alma.1.aarch64.rpm;name=aarch64_golang-bin;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-bin}"
SRC_URI[aarch64_golang-bin.sha256sum] = "85f47545b6f695592dd308dece6c992fef7d3f7a3b5afe198ea6c5f61a268b4f"

URI_aarch64_golang-docs = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-docs-1.24.6-1.el10_0.alma.1.noarch.rpm;name=aarch64_golang-docs;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-docs}"
SRC_URI[aarch64_golang-docs.sha256sum] = "b540c93d9030e14609394ea67606f28cd6f298bcddaaae80a6be8d7183f50ecf"

URI_aarch64_golang-misc = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-misc-1.24.6-1.el10_0.alma.1.noarch.rpm;name=aarch64_golang-misc;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-misc}"
SRC_URI[aarch64_golang-misc.sha256sum] = "83670aa8ef8253d2cb3f7b30cf7fded4995488eec26e485effc10065b9c86975"

URI_aarch64_golang-race = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-race-1.24.6-1.el10_0.alma.1.aarch64.rpm;name=aarch64_golang-race;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-race}"
SRC_URI[aarch64_golang-race.sha256sum] = "71507059dff78cf357300bbd800d11ee4091d9f5d628dfc29d425867bde56df4"

URI_aarch64_golang-src = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-src-1.24.6-1.el10_0.alma.1.noarch.rpm;name=aarch64_golang-src;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-src}"
SRC_URI[aarch64_golang-src.sha256sum] = "48ca27c5b38c1f2fa1ac58ece2e1458a2dc7567cbcd79dcb6776e513680a5167"

URI_aarch64_golang-tests = "${ALMALINUX_MIRROR}/AppStream/aarch64/os/Packages/golang-tests-1.24.6-1.el10_0.alma.1.noarch.rpm;name=aarch64_golang-tests;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-tests}"
SRC_URI[aarch64_golang-tests.sha256sum] = "d2f30e00924a779cf17c9bde4531ce463af71fc9b65a7cfa2fb330d6b1275c01"
RPROVIDES:golang-tests:aarch64 = "virtual/libtiffxx.so.6___64bit_"

RDEPENDS:go-toolset = " \
 delve \
 golang \
 "
RDEPENDS:golang = " \
 golang-bin \
 golang-race \
 golang-src \
 openssl-devel \
 "
RDEPENDS:golang-bin = " \
 alternatives \
 bash \
 gcc \
 glibc \
 golang \
 "
RDEPENDS:golang-docs = " \
 golang \
 "
RDEPENDS:golang-misc = " \
 golang \
 "
RDEPENDS:golang-race = " \
 golang \
 "
RDEPENDS:golang-src = " \
 "
RDEPENDS:golang-tests = " \
 golang \
 "

PROVIDES:append:x86_64_v2 = " rpm/virtual/libtiffxx.so.6___64bit_"

PROVIDES:append:aarch64 = " rpm/virtual/libtiffxx.so.6___64bit_"
