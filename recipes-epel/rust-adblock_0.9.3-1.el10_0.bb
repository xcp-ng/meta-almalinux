# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-adblock"
PV = "0.9.3"
PR = "1.el10_0"
PACKAGES = " \
 rust-adblock+addr-devel \
 rust-adblock+content-blocking-devel \
 rust-adblock+default-devel \
 rust-adblock+embedded-domain-resolver-devel \
 rust-adblock+full-regex-handling-devel \
 rust-adblock+lifeguard-devel \
 rust-adblock+object-pooling-devel \
 rust-adblock+regex-debug-info-devel \
 rust-adblock+resource-assembler-devel \
 rust-adblock+unsync-regex-caching-devel \
 rust-adblock-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-adblock-0.9.3-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "2305b9feb4b74d2eba39c1e0dc6c8e1974f209f0fe8bdff932b841ac4b6a33c8"

URI_x86_64_v2_rust-adblock+addr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+addr-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+addr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+addr-devel}"
SRC_URI[x86_64_v2_rust-adblock+addr-devel.sha256sum] = "91d923e74c45a18c852e2c81c9e342c4f6499542333f6f302e7c35e323c90a5f"

URI_x86_64_v2_rust-adblock+content-blocking-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+content-blocking-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+content-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+content-blocking-devel}"
SRC_URI[x86_64_v2_rust-adblock+content-blocking-devel.sha256sum] = "a7ce8f13296b6b96e721c052378f86a169fe5985a68dbb686db7e6339d43bf58"

URI_x86_64_v2_rust-adblock+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+default-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+default-devel}"
SRC_URI[x86_64_v2_rust-adblock+default-devel.sha256sum] = "b58e5693a5bcc4588fb8e1a24d7b1adf975d2fa50fb7060bd157b0a6062a7e81"

URI_x86_64_v2_rust-adblock+embedded-domain-resolver-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+embedded-domain-resolver-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+embedded-domain-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+embedded-domain-resolver-devel}"
SRC_URI[x86_64_v2_rust-adblock+embedded-domain-resolver-devel.sha256sum] = "dd761b3e8f3cf5f5fd964670cd52c3abb820f96d6ed4c3ea09eaea7dbf6583da"

URI_x86_64_v2_rust-adblock+full-regex-handling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+full-regex-handling-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+full-regex-handling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+full-regex-handling-devel}"
SRC_URI[x86_64_v2_rust-adblock+full-regex-handling-devel.sha256sum] = "5730eb8be5ff6cc016ee22a4dcb2a649e7f89d63795942b9578603438ab3b2f9"

URI_x86_64_v2_rust-adblock+lifeguard-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+lifeguard-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+lifeguard-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+lifeguard-devel}"
SRC_URI[x86_64_v2_rust-adblock+lifeguard-devel.sha256sum] = "fd2443b1b5ae5322b672aabcb0edf38fee2ad788a16035cffe68abc606ce8333"

URI_x86_64_v2_rust-adblock+object-pooling-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+object-pooling-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+object-pooling-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+object-pooling-devel}"
SRC_URI[x86_64_v2_rust-adblock+object-pooling-devel.sha256sum] = "3dcc8b8822c67a89d360279764bf4c6a7cd5f13cf39bec958f38a26f9054ccd3"

URI_x86_64_v2_rust-adblock+regex-debug-info-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+regex-debug-info-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+regex-debug-info-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+regex-debug-info-devel}"
SRC_URI[x86_64_v2_rust-adblock+regex-debug-info-devel.sha256sum] = "fc0ba79e9630ad2daeff686e1002263768a01c67476cf86141bbae4ec1117d90"

URI_x86_64_v2_rust-adblock+resource-assembler-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+resource-assembler-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+resource-assembler-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+resource-assembler-devel}"
SRC_URI[x86_64_v2_rust-adblock+resource-assembler-devel.sha256sum] = "2e0365aa462d9d8b8442e557ac34345d17f76b4e9fd23e9f4cfe7a26d3317366"

URI_x86_64_v2_rust-adblock+unsync-regex-caching-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock+unsync-regex-caching-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock+unsync-regex-caching-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock+unsync-regex-caching-devel}"
SRC_URI[x86_64_v2_rust-adblock+unsync-regex-caching-devel.sha256sum] = "73f89cde3501860ef66a012d9961590d13f90817ba802f9f90dbde7856135117"

URI_x86_64_v2_rust-adblock-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-adblock-devel-0.9.3-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-adblock-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-adblock-devel}"
SRC_URI[x86_64_v2_rust-adblock-devel.sha256sum] = "65d8ee016f018094d6e67adbc97d26f5ab62fe87d8f878ec24bd2fe218fd32ad"

URI_aarch64_rust-adblock+addr-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+addr-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+addr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+addr-devel}"
SRC_URI[aarch64_rust-adblock+addr-devel.sha256sum] = "4a2a9a3fefd04cdf89b06a37e19000d05ced5a4ac18b91099aedcb5b0fc09f60"

URI_aarch64_rust-adblock+content-blocking-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+content-blocking-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+content-blocking-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+content-blocking-devel}"
SRC_URI[aarch64_rust-adblock+content-blocking-devel.sha256sum] = "6f480769ecd41048bfc3ab3ffd948b34b37ec9a996ea49da0ba4fbc2b3be8a68"

URI_aarch64_rust-adblock+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+default-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+default-devel}"
SRC_URI[aarch64_rust-adblock+default-devel.sha256sum] = "6f1106a6e0c9ead2f248de4114bb5f3160e77985f66d877970af4513b6f15232"

URI_aarch64_rust-adblock+embedded-domain-resolver-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+embedded-domain-resolver-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+embedded-domain-resolver-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+embedded-domain-resolver-devel}"
SRC_URI[aarch64_rust-adblock+embedded-domain-resolver-devel.sha256sum] = "7b3336ce81b84239fd40744e67e5f258113e06ebd554040453aa6f73e8da3c09"

URI_aarch64_rust-adblock+full-regex-handling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+full-regex-handling-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+full-regex-handling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+full-regex-handling-devel}"
SRC_URI[aarch64_rust-adblock+full-regex-handling-devel.sha256sum] = "a0286627a6fcdbe7f822b9d0f2f653b9e46e6684eaf92f719f088dc321f88b95"

URI_aarch64_rust-adblock+lifeguard-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+lifeguard-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+lifeguard-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+lifeguard-devel}"
SRC_URI[aarch64_rust-adblock+lifeguard-devel.sha256sum] = "b3f8d6460549528b5954212b8ca9c407f14c55cbaf523e6af3c53182b8711425"

URI_aarch64_rust-adblock+object-pooling-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+object-pooling-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+object-pooling-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+object-pooling-devel}"
SRC_URI[aarch64_rust-adblock+object-pooling-devel.sha256sum] = "63f9f3ac91ce5fb9e0a9945ee0a4290bb1df2bb4eb4cbec2014ddb87f61a2696"

URI_aarch64_rust-adblock+regex-debug-info-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+regex-debug-info-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+regex-debug-info-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+regex-debug-info-devel}"
SRC_URI[aarch64_rust-adblock+regex-debug-info-devel.sha256sum] = "8af8f4fc2d5c666b96775c7c00da826ac9ea7519218b3f8525ddadf850296751"

URI_aarch64_rust-adblock+resource-assembler-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+resource-assembler-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+resource-assembler-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+resource-assembler-devel}"
SRC_URI[aarch64_rust-adblock+resource-assembler-devel.sha256sum] = "a9160d85187b1e2a3c43d5ef3872ad7f77fe17ae2e7345d49ba3d40ca7447eb9"

URI_aarch64_rust-adblock+unsync-regex-caching-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock+unsync-regex-caching-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock+unsync-regex-caching-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock+unsync-regex-caching-devel}"
SRC_URI[aarch64_rust-adblock+unsync-regex-caching-devel.sha256sum] = "020f195e793b6543ce80d6467f6e5e1d31e9d5497b76f9c68795cfd91ef85e75"

URI_aarch64_rust-adblock-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-adblock-devel-0.9.3-1.el10_0.noarch.rpm;name=aarch64_rust-adblock-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-adblock-devel}"
SRC_URI[aarch64_rust-adblock-devel.sha256sum] = "30483dc2896d4c5efc85ce23a49f7443bfb2dfeafe593c1e2e665f8ace36af12"

RDEPENDS:rust-adblock+addr-devel = " \
 cargo \
 rust-adblock-devel \
 rust-addr+psl-devel \
 rust-addr-devel \
 "
RDEPENDS:rust-adblock+content-blocking-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+default-devel = " \
 cargo \
 rust-adblock+embedded-domain-resolver-devel \
 rust-adblock+full-regex-handling-devel \
 rust-adblock+object-pooling-devel \
 rust-adblock+unsync-regex-caching-devel \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+embedded-domain-resolver-devel = " \
 cargo \
 rust-adblock+addr-devel \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+full-regex-handling-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+lifeguard-devel = " \
 cargo \
 rust-adblock-devel \
 rust-lifeguard+default-devel \
 "
RDEPENDS:rust-adblock+object-pooling-devel = " \
 cargo \
 rust-adblock+lifeguard-devel \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+regex-debug-info-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+resource-assembler-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock+unsync-regex-caching-devel = " \
 cargo \
 rust-adblock-devel \
 "
RDEPENDS:rust-adblock-devel = " \
 cargo \
 rust-base64+default-devel \
 rust-bitflags1+default-devel \
 rust-idna+default-devel \
 rust-itertools0.13+default-devel \
 rust-memchr+default-devel \
 rust-once_cell+default-devel \
 rust-percent-encoding+default-devel \
 rust-regex+default-devel \
 rust-rmp-serde+default-devel \
 rust-seahash3+default-devel \
 rust-serde+default-devel \
 rust-serde+derive-devel \
 rust-serde+rc-devel \
 rust-serde_json+default-devel \
 rust-thiserror1+default-devel \
 rust-url+default-devel \
 "
