# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-autopage"
PV = "0.6.0"
PR = "1.el10_1"
PACKAGES = " \
 python3-autopage \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-autopage-0.6.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "fa4bcce0fdc621b2c81fc056ab49e3a6976988b5664f745e872ba1a9da20acd8"

URI_x86_64_v2_python3-autopage = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-autopage-0.6.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_python3-autopage;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-autopage}"
SRC_URI[x86_64_v2_python3-autopage.sha256sum] = "3da93397ad3dbb4f9d8d1f62fabf889133cdb9ad894ae05695f48e69cb092062"

URI_aarch64_python3-autopage = "${EPEL_MIRROR}/aarch64/Packages/p/python3-autopage-0.6.0-1.el10_1.noarch.rpm;name=aarch64_python3-autopage;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-autopage}"
SRC_URI[aarch64_python3-autopage.sha256sum] = "275ce10501198e1a620d500104fb760c09afa30f89afa4a1995761c4c88667b3"

RDEPENDS:python3-autopage = " \
 python3 \
 "
