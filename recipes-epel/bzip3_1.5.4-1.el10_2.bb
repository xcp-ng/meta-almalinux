# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "bzip3"
PV = "1.5.4"
PR = "1.el10_2"
PACKAGES = " \
 bzip3 \
 bzip3-devel \
 bzip3-grep \
 bzip3-less \
 bzip3-libs \
 bzip3-more \
 bzip3-tools \
 "

SRC_URI = "${EPELSRC_MIRROR}/Packages/b/bzip3-1.5.4-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI[src.sha256sum] = "da2fe7a3a3423da9c6aa822cfc8e01d54355d44c4a8c20a4d60ca876a7e66643"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3;unpack=0"
SRC_URI[x86_64_v2_bzip3.sha256sum] = "f9aad66c05a3818aba40164a6914c2bd146247c3e471fcbf72fdcc61faa600f8"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-devel-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-devel;unpack=0"
SRC_URI[x86_64_v2_bzip3-devel.sha256sum] = "9a815835813392acf24d286c239c309a5d11b76a301bac8badc1884d0c491343"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-grep-1.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-grep;unpack=0"
SRC_URI[x86_64_v2_bzip3-grep.sha256sum] = "bf96cb679be4465a4040c173d8c839190535e76f118ac61d0b859e25ff5cf42b"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-less-1.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-less;unpack=0"
SRC_URI[x86_64_v2_bzip3-less.sha256sum] = "050f151dfc9f36472b2b6b412cb81193cc207fdd6bd68e123b60d257a9fe0db3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-libs-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-libs;unpack=0"
SRC_URI[x86_64_v2_bzip3-libs.sha256sum] = "05b02f6411004182ff4f2d12d7694a480941d89f5ad2be55964a14f68d9799b3"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-more-1.5.4-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_bzip3-more;unpack=0"
SRC_URI[x86_64_v2_bzip3-more.sha256sum] = "7f58e44714cf610368258dc2cb2f1971ca6243bbaef3e507850a808172e1a28a"

SRC_URI:append = " ${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/bzip3-tools-1.5.4-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_bzip3-tools;unpack=0"
SRC_URI[x86_64_v2_bzip3-tools.sha256sum] = "1e3cc2088564c437a4cd9fdbf2ffbeff343c0a4ee680724debe6b9f690472a71"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_bzip3;unpack=0"
SRC_URI[aarch64_bzip3.sha256sum] = "0e954e0fd5e9c6f893d012e886b90af958d9691ba6042c93ba00b28ab122d507"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-devel-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_bzip3-devel;unpack=0"
SRC_URI[aarch64_bzip3-devel.sha256sum] = "8f90cdec2ca2976b43c2bc134fe95170344f1db3d60aee3f57aeebaef8fc590d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-grep-1.5.4-1.el10_2.noarch.rpm;name=aarch64_bzip3-grep;unpack=0"
SRC_URI[aarch64_bzip3-grep.sha256sum] = "82a389174629f16ec3b2454237bd349dbd842efc8a30e7d9417b3b7b92f0e49d"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-less-1.5.4-1.el10_2.noarch.rpm;name=aarch64_bzip3-less;unpack=0"
SRC_URI[aarch64_bzip3-less.sha256sum] = "917ee06fc519f5058bfd1ac066fc2cd6380871c2b45bd101d01e44d05b6ea6d8"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-libs-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_bzip3-libs;unpack=0"
SRC_URI[aarch64_bzip3-libs.sha256sum] = "570e5b92716dee8317607591a446f1ba3b545c8569734ea41c3390e80f137c35"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-more-1.5.4-1.el10_2.noarch.rpm;name=aarch64_bzip3-more;unpack=0"
SRC_URI[aarch64_bzip3-more.sha256sum] = "ece4b5803b59b434832fcbe32caf20d08bf946fbc4044664673c88557b7b198b"

SRC_URI:append = " ${EPEL_MIRROR}/aarch64/Packages/b/bzip3-tools-1.5.4-1.el10_2.aarch64.rpm;name=aarch64_bzip3-tools;unpack=0"
SRC_URI[aarch64_bzip3-tools.sha256sum] = "f11c12115b669d67a85d7b7cf35f240418b303f5fdcf07063c82bed2f899f8b0"

RDEPENDS:bzip3 = " \
 bzip3-grep \
 bzip3-less \
 bzip3-more \
 bzip3-tools \
 "
RDEPENDS:bzip3-devel = " \
 bzip3-libs \
 pkgconf-pkg-config \
 "
RDEPENDS:bzip3-grep = " \
 bash \
 bzip3-tools \
 grep \
 "
RDEPENDS:bzip3-less = " \
 bash \
 bzip3-tools \
 less \
 "
RDEPENDS:bzip3-libs = " \
 glibc \
 "
RDEPENDS:bzip3-more = " \
 bash \
 bzip3-tools \
 util-linux-core \
 "
RDEPENDS:bzip3-tools = " \
 bash \
 bzip3-libs \
 glibc \
 "
