# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-cpp_demangle"
PV = "0.4.5"
PR = "1.el10_0"
PACKAGES = " \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle+default-devel \
 rust-cpp_demangle+logging-devel \
 rust-cpp_demangle+run_libiberty_tests-devel \
 rust-cpp_demangle+std-devel \
 rust-cpp_demangle-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-cpp_demangle-0.4.5-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9519c5236c05e51594b324f565a00794ae5c3bf8a7f9a53eb9fb16e8a8f280d1"

URI_x86_64_v2_rust-cpp_demangle+alloc-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+alloc-devel-0.4.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+alloc-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+alloc-devel.sha256sum] = "6a534f79dbaab8a80d5cd59a5f20ee1b08bdcf95922c1a6958d11bebf6c22fe4"

URI_x86_64_v2_rust-cpp_demangle+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+default-devel-0.4.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+default-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+default-devel.sha256sum] = "23c55c6cea5365c80d6f80977944c03d2195d1527b8b7cd4f53f23b5b2ac73b0"

URI_x86_64_v2_rust-cpp_demangle+logging-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+logging-devel-0.4.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+logging-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+logging-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+logging-devel.sha256sum] = "5f83b5eef7a47e36403a2b742cafc5c8d99c2065f584d38232810c4bd75413d7"

URI_x86_64_v2_rust-cpp_demangle+run_libiberty_tests-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+run_libiberty_tests-devel-0.4.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+run_libiberty_tests-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+run_libiberty_tests-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+run_libiberty_tests-devel.sha256sum] = "296c9556ffa5fc6be41c2eb287ff3c90ad55e89daa2d1a633b62d5a21ab35251"

URI_x86_64_v2_rust-cpp_demangle+std-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle+std-devel-0.4.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle+std-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle+std-devel.sha256sum] = "30976da14a0152e9311e479b034520d643262d24ec9051efb2d3e15954325152"

URI_x86_64_v2_rust-cpp_demangle-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-cpp_demangle-devel-0.4.5-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_rust-cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-cpp_demangle-devel}"
SRC_URI[x86_64_v2_rust-cpp_demangle-devel.sha256sum] = "38d67607677f8d9a971e2417c1693302865db4e3e8198b6c31ebcc541eace240"

URI_aarch64_rust-cpp_demangle+alloc-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+alloc-devel-0.4.5-1.el10_0.noarch.rpm;name=aarch64_rust-cpp_demangle+alloc-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+alloc-devel}"
SRC_URI[aarch64_rust-cpp_demangle+alloc-devel.sha256sum] = "616617c5dbbf4ce7d6d822f6668239c8c5e3dad93b8ac63030a9232b229a90d4"

URI_aarch64_rust-cpp_demangle+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+default-devel-0.4.5-1.el10_0.noarch.rpm;name=aarch64_rust-cpp_demangle+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+default-devel}"
SRC_URI[aarch64_rust-cpp_demangle+default-devel.sha256sum] = "b14cfe0d8c38abb1eaf376a4b664fe93c9d730fdfba5b1ecf88e273acbc6d9e5"

URI_aarch64_rust-cpp_demangle+logging-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+logging-devel-0.4.5-1.el10_0.noarch.rpm;name=aarch64_rust-cpp_demangle+logging-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+logging-devel}"
SRC_URI[aarch64_rust-cpp_demangle+logging-devel.sha256sum] = "ff5b5dfb708e2165b3122cb831f246b12c755afb964e32c86fee95b3b63ac14c"

URI_aarch64_rust-cpp_demangle+run_libiberty_tests-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+run_libiberty_tests-devel-0.4.5-1.el10_0.noarch.rpm;name=aarch64_rust-cpp_demangle+run_libiberty_tests-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+run_libiberty_tests-devel}"
SRC_URI[aarch64_rust-cpp_demangle+run_libiberty_tests-devel.sha256sum] = "9c72c231007016010ed2b14181d6377aaf21557d33b00ee7eaf663020267428a"

URI_aarch64_rust-cpp_demangle+std-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle+std-devel-0.4.5-1.el10_0.noarch.rpm;name=aarch64_rust-cpp_demangle+std-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle+std-devel}"
SRC_URI[aarch64_rust-cpp_demangle+std-devel.sha256sum] = "96cd454453b5f405019ce027c3c31318e10f9bac8cb3e3c22a920e2f4fb6053e"

URI_aarch64_rust-cpp_demangle-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-cpp_demangle-devel-0.4.5-1.el10_0.noarch.rpm;name=aarch64_rust-cpp_demangle-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-cpp_demangle-devel}"
SRC_URI[aarch64_rust-cpp_demangle-devel.sha256sum] = "ff5bdbbfd98df6d63c02bf4b28e21987099e3f0aa8edceab0daba279540a1d37"

RDEPENDS:rust-cpp_demangle+alloc-devel = " \
 cargo \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+default-devel = " \
 cargo \
 rust-cpp_demangle+std-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+logging-devel = " \
 cargo \
 rust-cpp_demangle+std-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+run_libiberty_tests-devel = " \
 cargo \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle+std-devel = " \
 cargo \
 rust-cpp_demangle+alloc-devel \
 rust-cpp_demangle-devel \
 "
RDEPENDS:rust-cpp_demangle-devel = " \
 cargo \
 rust-cfg-if+default-devel \
 "
