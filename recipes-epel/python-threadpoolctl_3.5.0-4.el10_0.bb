# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-threadpoolctl"
PV = "3.5.0"
PR = "4.el10_0"
PACKAGES = " \
 python3-threadpoolctl \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-threadpoolctl-3.5.0-4.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "9fa5aca5ea585f1dd8f5cc280de66b872946342231e3ed12ea9ad9a51117f269"

URI_x86_64_v2_python3-threadpoolctl = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-threadpoolctl-3.5.0-4.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-threadpoolctl;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-threadpoolctl}"
SRC_URI[x86_64_v2_python3-threadpoolctl.sha256sum] = "2a5327278fa8d7b801b439a39b9046114a3db32681d0ba1ac2cfca9cf9cdb198"

URI_aarch64_python3-threadpoolctl = "${EPEL_MIRROR}/aarch64/Packages/p/python3-threadpoolctl-3.5.0-4.el10_0.noarch.rpm;name=aarch64_python3-threadpoolctl;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-threadpoolctl}"
SRC_URI[aarch64_python3-threadpoolctl.sha256sum] = "016dc21b4cf7c90d2462a61b3821dd066d83cb2d29703a2984edb9cc2971a942"

RDEPENDS:python3-threadpoolctl = " \
 python3 \
 "
