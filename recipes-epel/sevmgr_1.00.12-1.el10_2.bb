# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "sevmgr"
PV = "1.00.12"
PR = "1.el10_2"
PACKAGES = " \
 sevmgr \
 sevmgr-devel \
 sevmgr-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/s/sevmgr-1.00.12-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b272ead50f060a013acafc222bb20c4dacc98ab8717e1d4ae1ada99420b26f8f"

URI_x86_64_v2_sevmgr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sevmgr-1.00.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sevmgr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sevmgr}"
SRC_URI[x86_64_v2_sevmgr.sha256sum] = "b3d63ebf6a12bce23949e24cb1fb0fc8dc4d9086f53a8447e557ebd0dc7a7552"

URI_x86_64_v2_sevmgr-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sevmgr-devel-1.00.12-1.el10_2.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_sevmgr-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sevmgr-devel}"
SRC_URI[x86_64_v2_sevmgr-devel.sha256sum] = "50b7dd7beb348d7118cd4ca847aafa5d398d872a27cb5c241c571b2d85304c82"

URI_x86_64_v2_sevmgr-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/sevmgr-doc-1.00.12-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_sevmgr-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_sevmgr-doc}"
SRC_URI[x86_64_v2_sevmgr-doc.sha256sum] = "ec2a7a6f97a631865a5621f6170a7dbe9e71da97c3ba47a2065cdbaa7d5cd581"

URI_aarch64_sevmgr = "${EPEL_MIRROR}/aarch64/Packages/s/sevmgr-1.00.12-1.el10_2.aarch64.rpm;name=aarch64_sevmgr;unpack=0"
SRC_URI:append = " ${URI_aarch64_sevmgr}"
SRC_URI[aarch64_sevmgr.sha256sum] = "cc6517893b636eea1ee0d31208e33dd80752ff3caa512d06f7d9ea4a7e0e6467"

URI_aarch64_sevmgr-devel = "${EPEL_MIRROR}/aarch64/Packages/s/sevmgr-devel-1.00.12-1.el10_2.aarch64.rpm;name=aarch64_sevmgr-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_sevmgr-devel}"
SRC_URI[aarch64_sevmgr-devel.sha256sum] = "3ce2e9820327c3a6234e9748d4f7e512b30794e344e2a8bb2f3b771b030188c8"

URI_aarch64_sevmgr-doc = "${EPEL_MIRROR}/aarch64/Packages/s/sevmgr-doc-1.00.12-1.el10_2.noarch.rpm;name=aarch64_sevmgr-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_sevmgr-doc}"
SRC_URI[aarch64_sevmgr-doc.sha256sum] = "e496ce13ee1a4f1a29055488bbb224bbd33bda3be067a158b215099a79b9413b"

RDEPENDS:sevmgr = " \
 boost-program-options \
 glibc \
 libgcc \
 libstdc++ \
 readline \
 stdair \
 "
RDEPENDS:sevmgr-devel = " \
 bash \
 cmake-filesystem \
 pkgconf-pkg-config \
 sevmgr \
 "
RDEPENDS:sevmgr-doc = " \
 "
