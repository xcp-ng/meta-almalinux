# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-gix-worktree-stream"
PV = "0.24.0"
PR = "1.el10_2"
PACKAGES = " \
 rust-gix-worktree-stream+default-devel \
 rust-gix-worktree-stream-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-gix-worktree-stream-0.24.0-1.el10_2.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "b268b254e9e313ee9e282dc1e537e73cf002160bd847318b386fb012c0df822c"

URI_x86_64_v2_rust-gix-worktree-stream+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream+default-devel-0.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream+default-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream+default-devel.sha256sum] = "1a2bbcb073617b85613610bc71a65a572cf2f9313f13f66b10b0780a66423e41"

URI_x86_64_v2_rust-gix-worktree-stream-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-gix-worktree-stream-devel-0.24.0-1.el10_2.alma_altarch.noarch.rpm;name=x86_64_v2_rust-gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-gix-worktree-stream-devel}"
SRC_URI[x86_64_v2_rust-gix-worktree-stream-devel.sha256sum] = "e6939ef865060c5b98c26c1f3c37877cf4bca991e4e812995fe1d27c43f3ca03"

URI_aarch64_rust-gix-worktree-stream+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream+default-devel-0.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-worktree-stream+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream+default-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream+default-devel.sha256sum] = "053c8e2082bc631331006ea7cab71c3be864fe79a2d14e81ed801ed369e83f05"

URI_aarch64_rust-gix-worktree-stream-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-gix-worktree-stream-devel-0.24.0-1.el10_2.noarch.rpm;name=aarch64_rust-gix-worktree-stream-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-gix-worktree-stream-devel}"
SRC_URI[aarch64_rust-gix-worktree-stream-devel.sha256sum] = "14848c0905ccf59bf883bc6d3b2cdda0e3fce1dc86de82d7b2befef814365e10"

RDEPENDS:rust-gix-worktree-stream+default-devel = " \
 cargo \
 rust-gix-worktree-stream-devel \
 "
RDEPENDS:rust-gix-worktree-stream-devel = " \
 cargo \
 rust \
 rust-gix-attributes+default-devel \
 rust-gix-features+default-devel \
 rust-gix-features+io-pipe-devel \
 rust-gix-features+progress-devel \
 rust-gix-filter+default-devel \
 rust-gix-fs+default-devel \
 rust-gix-hash+default-devel \
 rust-gix-object+default-devel \
 rust-gix-path+default-devel \
 rust-gix-traverse+default-devel \
 rust-parking_lot+default-devel \
 rust-thiserror+default-devel \
 "
