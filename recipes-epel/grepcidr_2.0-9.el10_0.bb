# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "grepcidr"
PV = "2.0"
PR = "9.el10_0"
PACKAGES = " \
 grepcidr \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/grepcidr-2.0-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "e9ff0efcb6854e7d73cff3f324ee8c38f5d8f6cd64205038219cc85bfe99fe49"

URI_x86_64_v2_grepcidr = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/grepcidr-2.0-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_grepcidr;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_grepcidr}"
SRC_URI[x86_64_v2_grepcidr.sha256sum] = "79e38b48bd729e9311706a84526a30333e6cf53756e287117307d369649b4300"

URI_aarch64_grepcidr = "${EPEL_MIRROR}/aarch64/Packages/g/grepcidr-2.0-9.el10_0.aarch64.rpm;name=aarch64_grepcidr;unpack=0"
SRC_URI:append = " ${URI_aarch64_grepcidr}"
SRC_URI[aarch64_grepcidr.sha256sum] = "6bf1e684f35f8661147112d7e7d3482c1a467a105c5384a88b9871d7a1214ddf"

RDEPENDS:grepcidr = " \
 glibc \
 "
