# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "python-rfc3987"
PV = "1.3.8"
PR = "16.el10_0"
PACKAGES = " \
 python3-rfc3987 \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/p/python-rfc3987-1.3.8-16.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "bd65c8938a60a51b168e7a77763445c585f90fad6e8f5815ea27957cf0070044"

URI_x86_64_v2_python3-rfc3987 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/python3-rfc3987-1.3.8-16.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_python3-rfc3987;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_python3-rfc3987}"
SRC_URI[x86_64_v2_python3-rfc3987.sha256sum] = "53cd4b33973798feb67cdba98fa8de379948038b540e9a47551ba7dc6a5a99e7"

URI_aarch64_python3-rfc3987 = "${EPEL_MIRROR}/aarch64/Packages/p/python3-rfc3987-1.3.8-16.el10_0.noarch.rpm;name=aarch64_python3-rfc3987;unpack=0"
SRC_URI:append = " ${URI_aarch64_python3-rfc3987}"
SRC_URI[aarch64_python3-rfc3987.sha256sum] = "0d898a79c649d61251a768a14a9506354f01d3b5bf0406b3829c1762e96b14e4"

RDEPENDS:python3-rfc3987 = " \
 python3 \
 "
