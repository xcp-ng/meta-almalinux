# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "golang-github-cyphar-filepath-securejoin"
PV = "0.3.4"
PR = "1.el10_0"
PACKAGES = " \
 golang-github-cyphar-filepath-securejoin-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/golang-github-cyphar-filepath-securejoin-0.3.4-1.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "aed89470c167ee430e7ac23171fd3645970789105c606234c1b9d76c5103da96"

URI_x86_64_v2_golang-github-cyphar-filepath-securejoin-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/golang-github-cyphar-filepath-securejoin-devel-0.3.4-1.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_golang-github-cyphar-filepath-securejoin-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_golang-github-cyphar-filepath-securejoin-devel}"
SRC_URI[x86_64_v2_golang-github-cyphar-filepath-securejoin-devel.sha256sum] = "41b9313c63d829a66b5c272a8b007b382e632f158d8b79544193b5527dac8ea9"

URI_aarch64_golang-github-cyphar-filepath-securejoin-devel = "${EPEL_MIRROR}/aarch64/Packages/g/golang-github-cyphar-filepath-securejoin-devel-0.3.4-1.el10_0.noarch.rpm;name=aarch64_golang-github-cyphar-filepath-securejoin-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_golang-github-cyphar-filepath-securejoin-devel}"
SRC_URI[aarch64_golang-github-cyphar-filepath-securejoin-devel.sha256sum] = "8520f0224d32098e9e456dd950a557cf22281be062a24a8e95fade23502461d5"

RDEPENDS:golang-github-cyphar-filepath-securejoin-devel = " \
 go-filesystem \
 golang-x-sys-devel \
 "
