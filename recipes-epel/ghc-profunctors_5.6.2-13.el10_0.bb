# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-profunctors"
PV = "5.6.2"
PR = "13.el10_0"
PACKAGES = " \
 ghc-profunctors \
 ghc-profunctors-devel \
 ghc-profunctors-doc \
 ghc-profunctors-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-profunctors-5.6.2-13.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "a0ec35f9c1a7543f45f3cf0a1b96914fd0bef95545993e4188461c0f30464914"

URI_x86_64_v2_ghc-profunctors = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-profunctors-5.6.2-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-profunctors;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-profunctors}"
SRC_URI[x86_64_v2_ghc-profunctors.sha256sum] = "cc3abf483d535652586542aae48bf049edcbfbc8e84f89b3ea61ffed1a0c4e23"

URI_x86_64_v2_ghc-profunctors-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-profunctors-devel-5.6.2-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-profunctors-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-profunctors-devel}"
SRC_URI[x86_64_v2_ghc-profunctors-devel.sha256sum] = "9562cb1d1867fbb2a978ff876615311351a1de4cdfa068363047e97ddb0df416"

URI_x86_64_v2_ghc-profunctors-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-profunctors-doc-5.6.2-13.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-profunctors-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-profunctors-doc}"
SRC_URI[x86_64_v2_ghc-profunctors-doc.sha256sum] = "986f8075e90814033528900fd0f9d22621c58d9235c395a349fc1991ea4b5a28"

URI_x86_64_v2_ghc-profunctors-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-profunctors-prof-5.6.2-13.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-profunctors-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-profunctors-prof}"
SRC_URI[x86_64_v2_ghc-profunctors-prof.sha256sum] = "7a795f71599b60c08da751a73e72b1734cc7fcfd7d28bf283aa78f37828ef6d5"

URI_aarch64_ghc-profunctors = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-profunctors-5.6.2-13.el10_0.aarch64.rpm;name=aarch64_ghc-profunctors;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-profunctors}"
SRC_URI[aarch64_ghc-profunctors.sha256sum] = "2b6783839047e2dbedb14e440261bca39f38cf4c32ac5f64c6ce40c55f930e24"

URI_aarch64_ghc-profunctors-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-profunctors-devel-5.6.2-13.el10_0.aarch64.rpm;name=aarch64_ghc-profunctors-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-profunctors-devel}"
SRC_URI[aarch64_ghc-profunctors-devel.sha256sum] = "159d78489f1cba3918b9af1dfbc4b30b1b8d6e3ddfae03d4a24007c11f77ff76"

URI_aarch64_ghc-profunctors-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-profunctors-doc-5.6.2-13.el10_0.noarch.rpm;name=aarch64_ghc-profunctors-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-profunctors-doc}"
SRC_URI[aarch64_ghc-profunctors-doc.sha256sum] = "31e0cfabf21c322cc644752accb993e3d789932cd166888e1a92161de0d3a930"

URI_aarch64_ghc-profunctors-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-profunctors-prof-5.6.2-13.el10_0.aarch64.rpm;name=aarch64_ghc-profunctors-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-profunctors-prof}"
SRC_URI[aarch64_ghc-profunctors-prof.sha256sum] = "2bb1b6d9196c05f739be3baaa2af202baf769b4046327b3092afc7e139090d5a"

RDEPENDS:ghc-profunctors = " \
 ghc-StateVar \
 ghc-array \
 ghc-assoc \
 ghc-base \
 ghc-base-orphans \
 ghc-bifunctors \
 ghc-comonad \
 ghc-containers \
 ghc-contravariant \
 ghc-deepseq \
 ghc-distributive \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-indexed-traversable \
 ghc-pretty \
 ghc-stm \
 ghc-tagged \
 ghc-template-haskell \
 ghc-th-abstraction \
 ghc-transformers \
 ghc-transformers-compat \
 glibc \
 gmp \
 "
RDEPENDS:ghc-profunctors-devel = " \
 ghc-base-devel \
 ghc-base-orphans-devel \
 ghc-bifunctors-devel \
 ghc-comonad-devel \
 ghc-compiler \
 ghc-contravariant-devel \
 ghc-distributive-devel \
 ghc-profunctors \
 ghc-tagged-devel \
 ghc-transformers-devel \
 "
RDEPENDS:ghc-profunctors-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-profunctors-prof = " \
 ghc-base-orphans-prof \
 ghc-base-prof \
 ghc-bifunctors-prof \
 ghc-comonad-prof \
 ghc-contravariant-prof \
 ghc-distributive-prof \
 ghc-profunctors-devel \
 ghc-tagged-prof \
 ghc-transformers-prof \
 "
