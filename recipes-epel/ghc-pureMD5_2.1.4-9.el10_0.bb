# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ghc-pureMD5"
PV = "2.1.4"
PR = "9.el10_0"
PACKAGES = " \
 ghc-pureMD5 \
 ghc-pureMD5-devel \
 ghc-pureMD5-doc \
 ghc-pureMD5-prof \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/g/ghc-pureMD5-2.1.4-9.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "698b43b85b974fa9ab159c64b9288eab1926e3f36d2cfbe25a2f09f32a4d3f0f"

URI_x86_64_v2_ghc-pureMD5 = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pureMD5-2.1.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pureMD5;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pureMD5}"
SRC_URI[x86_64_v2_ghc-pureMD5.sha256sum] = "a2f4378099e941d2ee7364585c2a0c48c03c7b260f54ea1dce0fd683aa5a754c"

URI_x86_64_v2_ghc-pureMD5-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pureMD5-devel-2.1.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pureMD5-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pureMD5-devel}"
SRC_URI[x86_64_v2_ghc-pureMD5-devel.sha256sum] = "0106b7126b420ad866eddac29a21d5688043d83451c489d31a37b6633296e727"

URI_x86_64_v2_ghc-pureMD5-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pureMD5-doc-2.1.4-9.el10_0.alma_altarch.noarch.rpm;name=x86_64_v2_ghc-pureMD5-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pureMD5-doc}"
SRC_URI[x86_64_v2_ghc-pureMD5-doc.sha256sum] = "7f116ab80005454d980564f6e930c336e924e4f1942d85f92e2ad78d4c647ba5"

URI_x86_64_v2_ghc-pureMD5-prof = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/ghc-pureMD5-prof-2.1.4-9.el10_0.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_ghc-pureMD5-prof;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_ghc-pureMD5-prof}"
SRC_URI[x86_64_v2_ghc-pureMD5-prof.sha256sum] = "e8250cfc2bfc5c77e29480d67830b8672c4d3f3d56b1230dcade4c5bb43c1f86"

URI_aarch64_ghc-pureMD5 = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pureMD5-2.1.4-9.el10_0.aarch64.rpm;name=aarch64_ghc-pureMD5;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pureMD5}"
SRC_URI[aarch64_ghc-pureMD5.sha256sum] = "6728eedd0e8aa2bfac1b9220b9e1393c77416b9ac680ba24f27b214178b53ea2"

URI_aarch64_ghc-pureMD5-devel = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pureMD5-devel-2.1.4-9.el10_0.aarch64.rpm;name=aarch64_ghc-pureMD5-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pureMD5-devel}"
SRC_URI[aarch64_ghc-pureMD5-devel.sha256sum] = "f6052caa8170c81f15b82dec51f3aaf8d30b68ea8b2f9170720c12ea5d935395"

URI_aarch64_ghc-pureMD5-doc = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pureMD5-doc-2.1.4-9.el10_0.noarch.rpm;name=aarch64_ghc-pureMD5-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pureMD5-doc}"
SRC_URI[aarch64_ghc-pureMD5-doc.sha256sum] = "b3661cfa467d4d37783358e8e9930e4ee7a4cdb644451c5c9dc997765acab09d"

URI_aarch64_ghc-pureMD5-prof = "${EPEL_MIRROR}/aarch64/Packages/g/ghc-pureMD5-prof-2.1.4-9.el10_0.aarch64.rpm;name=aarch64_ghc-pureMD5-prof;unpack=0"
SRC_URI:append = " ${URI_aarch64_ghc-pureMD5-prof}"
SRC_URI[aarch64_ghc-pureMD5-prof.sha256sum] = "d028fb02427bd66ab872f892ac7d5ee8b7f4876a22adb1cdf581636ddc2d6434"

RDEPENDS:ghc-pureMD5 = " \
 ghc-array \
 ghc-base \
 ghc-binary \
 ghc-bytestring \
 ghc-cereal \
 ghc-containers \
 ghc-crypto-api \
 ghc-deepseq \
 ghc-entropy \
 ghc-exceptions \
 ghc-filepath \
 ghc-ghc-bignum \
 ghc-ghc-boot-th \
 ghc-mtl \
 ghc-pretty \
 ghc-stm \
 ghc-tagged \
 ghc-template-haskell \
 ghc-time \
 ghc-transformers \
 ghc-unix \
 glibc \
 gmp \
 "
RDEPENDS:ghc-pureMD5-devel = " \
 ghc-base-devel \
 ghc-binary-devel \
 ghc-bytestring-devel \
 ghc-cereal-devel \
 ghc-compiler \
 ghc-crypto-api-devel \
 ghc-pureMD5 \
 ghc-tagged-devel \
 "
RDEPENDS:ghc-pureMD5-doc = " \
 ghc-filesystem \
 "
RDEPENDS:ghc-pureMD5-prof = " \
 ghc-base-prof \
 ghc-binary-prof \
 ghc-bytestring-prof \
 ghc-cereal-prof \
 ghc-crypto-api-prof \
 ghc-pureMD5-devel \
 ghc-tagged-prof \
 "
