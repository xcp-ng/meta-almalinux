# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "log4cxx"
PV = "1.4.0"
PR = "1.el10_1"
PACKAGES = " \
 log4cxx \
 log4cxx-devel \
 log4cxx-doc \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/l/log4cxx-1.4.0-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "819413d2d02ac4e0ed47cc5df447b65c6b5f89402665d0102677ba8a0acc107c"

URI_x86_64_v2_log4cxx = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-1.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cxx;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cxx}"
SRC_URI[x86_64_v2_log4cxx.sha256sum] = "bdc23b022c309f1fae0c3068f59821be83c46ae0f3d7af8331bfe31f6554730b"

URI_x86_64_v2_log4cxx-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-devel-1.4.0-1.el10_1.alma_altarch.x86_64_v2.rpm;name=x86_64_v2_log4cxx-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cxx-devel}"
SRC_URI[x86_64_v2_log4cxx-devel.sha256sum] = "7e6acd1c9d63548a9791d77d260f49d21175dd7b8389201d02a5deede2622984"

URI_x86_64_v2_log4cxx-doc = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/log4cxx-doc-1.4.0-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_log4cxx-doc;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_log4cxx-doc}"
SRC_URI[x86_64_v2_log4cxx-doc.sha256sum] = "0c45fd47ea20ee4170140ed8cbd9b7d8df82010ed90db74cab72ad56c2c5913e"

URI_aarch64_log4cxx = "${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-1.4.0-1.el10_1.aarch64.rpm;name=aarch64_log4cxx;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cxx}"
SRC_URI[aarch64_log4cxx.sha256sum] = "6f3fc1a4a601818660c98ee2a099308185062266a087ac5f2c00a7e43d281736"

URI_aarch64_log4cxx-devel = "${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-devel-1.4.0-1.el10_1.aarch64.rpm;name=aarch64_log4cxx-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cxx-devel}"
SRC_URI[aarch64_log4cxx-devel.sha256sum] = "2609e45482ec992705896273cb747c89b9b8f8d75effa2c3f8f47d584c09639c"

URI_aarch64_log4cxx-doc = "${EPEL_MIRROR}/aarch64/Packages/l/log4cxx-doc-1.4.0-1.el10_1.noarch.rpm;name=aarch64_log4cxx-doc;unpack=0"
SRC_URI:append = " ${URI_aarch64_log4cxx-doc}"
SRC_URI[aarch64_log4cxx-doc.sha256sum] = "a05c4a9ebe30ca6ed773718bd2cd603eee9bf6076c299fb33ad845dbbf1a64d0"

RDEPENDS:log4cxx = " \
 apr \
 apr-util \
 glibc \
 libgcc \
 libstdc++ \
 "
RDEPENDS:log4cxx-devel = " \
 apr-devel \
 apr-util-devel \
 cmake-filesystem \
 log4cxx \
 pkgconf-pkg-config \
 "
RDEPENDS:log4cxx-doc = " \
 "
