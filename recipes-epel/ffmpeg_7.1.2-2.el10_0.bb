# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "ffmpeg"
PV = "7.1.2"
PR = "2.el10_0"
PACKAGES = " \
 ffmpeg-free \
 ffmpeg-free-devel \
 libavcodec-free \
 libavcodec-free-devel \
 libavdevice-free \
 libavdevice-free-devel \
 libavfilter-free \
 libavfilter-free-devel \
 libavformat-free \
 libavformat-free-devel \
 libavutil-free \
 libavutil-free-devel \
 libpostproc-free \
 libpostproc-free-devel \
 libswresample-free \
 libswresample-free-devel \
 libswscale-free \
 libswscale-free-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/f/ffmpeg-7.1.2-2.el10_0.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "39c3a81b2a206c935a3b543905d81aed5f5b17b179ad3030d4b97de50f5a589d"

URI_aarch64_ffmpeg-free = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpeg-free-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_ffmpeg-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpeg-free}"
SRC_URI[aarch64_ffmpeg-free.sha256sum] = "34adea21a3b59ee5f68d093518b788fef751bb06e1f15e5b9d8897b22ef2b6ff"

URI_aarch64_ffmpeg-free-devel = "${EPEL_MIRROR}/aarch64/Packages/f/ffmpeg-free-devel-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_ffmpeg-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_ffmpeg-free-devel}"
SRC_URI[aarch64_ffmpeg-free-devel.sha256sum] = "025dec67c2958e45f86b08ee26d887815e911df9000d81ac268c8211b67e66a2"

URI_aarch64_libavcodec-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavcodec-free-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavcodec-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavcodec-free}"
SRC_URI[aarch64_libavcodec-free.sha256sum] = "2b220cd703999383b9051e8f238dd3ec62a51253af06abaf1f4f22815037d21f"

URI_aarch64_libavcodec-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavcodec-free-devel-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavcodec-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavcodec-free-devel}"
SRC_URI[aarch64_libavcodec-free-devel.sha256sum] = "4b8597b79105918d18ba2220c113b11c3143c07fdd5dca04392498a9329616e5"

URI_aarch64_libavdevice-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavdevice-free-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavdevice-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavdevice-free}"
SRC_URI[aarch64_libavdevice-free.sha256sum] = "85e7e8407520133ec35843c6dc93772e5293e69aeacb3105d717cc84285401a2"

URI_aarch64_libavdevice-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavdevice-free-devel-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavdevice-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavdevice-free-devel}"
SRC_URI[aarch64_libavdevice-free-devel.sha256sum] = "8b6417e3a9970fe2ec0529fa0ed859ed2a8a0ef1b65512624a204643777c394f"

URI_aarch64_libavfilter-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavfilter-free-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavfilter-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavfilter-free}"
SRC_URI[aarch64_libavfilter-free.sha256sum] = "dc26eed3c728ca277e5410d49530d56a0b71d09d18a9c30ec3181ac1acdb6a24"

URI_aarch64_libavfilter-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavfilter-free-devel-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavfilter-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavfilter-free-devel}"
SRC_URI[aarch64_libavfilter-free-devel.sha256sum] = "977a699a341c8e86d1c1ab3f4645d29e0021153778fb16d366dc61818755a5fd"

URI_aarch64_libavformat-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavformat-free-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavformat-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavformat-free}"
SRC_URI[aarch64_libavformat-free.sha256sum] = "091697c724ad27384a33149bfc298f131647873fe5f88308f9b64f7e40846df0"

URI_aarch64_libavformat-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavformat-free-devel-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavformat-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavformat-free-devel}"
SRC_URI[aarch64_libavformat-free-devel.sha256sum] = "f059312fec158ba5706425c6a54cccb7c8aec53c08f1de40581a7bbf90b62223"

URI_aarch64_libavutil-free = "${EPEL_MIRROR}/aarch64/Packages/l/libavutil-free-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavutil-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavutil-free}"
SRC_URI[aarch64_libavutil-free.sha256sum] = "a4058e8792e5fbba4f1ea4b9c88d264e38aec2b49a950cc3f2510be4e058dead"

URI_aarch64_libavutil-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libavutil-free-devel-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libavutil-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libavutil-free-devel}"
SRC_URI[aarch64_libavutil-free-devel.sha256sum] = "6c4ced7ede17d273faef2793534f2bc473dfa167af28102f5a85f13461e33ff8"

URI_aarch64_libpostproc-free = "${EPEL_MIRROR}/aarch64/Packages/l/libpostproc-free-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libpostproc-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpostproc-free}"
SRC_URI[aarch64_libpostproc-free.sha256sum] = "93ae578ca423684175b5a1b817f9f3e444a747bff55fbc5dc95f60f164c40054"

URI_aarch64_libpostproc-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libpostproc-free-devel-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libpostproc-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libpostproc-free-devel}"
SRC_URI[aarch64_libpostproc-free-devel.sha256sum] = "da7bd411acffa1caed9770abf14fc1ca03bad64ef034a792bde9f67a8252eafb"

URI_aarch64_libswresample-free = "${EPEL_MIRROR}/aarch64/Packages/l/libswresample-free-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libswresample-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libswresample-free}"
SRC_URI[aarch64_libswresample-free.sha256sum] = "c137ea877928b700f84834d1ef8358c8d5c985eae7525a70cd38b95ad667e81b"

URI_aarch64_libswresample-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libswresample-free-devel-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libswresample-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libswresample-free-devel}"
SRC_URI[aarch64_libswresample-free-devel.sha256sum] = "7f40cc271595fa408748912ac1729ce7e3505c85c5a4e3f649fd0e076ad6cb21"

URI_aarch64_libswscale-free = "${EPEL_MIRROR}/aarch64/Packages/l/libswscale-free-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libswscale-free;unpack=0"
SRC_URI:append = " ${URI_aarch64_libswscale-free}"
SRC_URI[aarch64_libswscale-free.sha256sum] = "b52fca085abf53e398a4131766ef0e5a6d5e72a28c6b20f1b34e77f49eb2d655"

URI_aarch64_libswscale-free-devel = "${EPEL_MIRROR}/aarch64/Packages/l/libswscale-free-devel-7.1.2-2.el10_0.aarch64.rpm;name=aarch64_libswscale-free-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_libswscale-free-devel}"
SRC_URI[aarch64_libswscale-free-devel.sha256sum] = "3830787714b9909326a8801456f8443d81465cb603864bf784f76cc9ece2b740"

RDEPENDS:ffmpeg-free = " \
 glibc \
 libavcodec-free \
 libavdevice-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libplacebo \
 libpostproc-free \
 libswresample-free \
 libswscale-free \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:ffmpeg-free-devel = " \
 libavcodec-free-devel \
 libavdevice-free-devel \
 libavfilter-free-devel \
 libavformat-free-devel \
 libavutil-free-devel \
 libpostproc-free-devel \
 libswresample-free-devel \
 libswscale-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavcodec-free = " \
 aribb24 \
 cairo \
 codec2 \
 fdk-aac-free \
 glib2 \
 glibc \
 gsm \
 ilbc \
 lame-libs \
 lcms2 \
 libaom \
 libaribcaption \
 libavutil-free \
 libdav1d \
 libjxl \
 librsvg2 \
 libswresample-free \
 libtheora \
 libva \
 libvorbis \
 libvpx \
 libwebp \
 noopenh264 \
 opencore-amr \
 openjpeg2 \
 opus \
 rav1e-libs \
 snappy \
 speex \
 svt-av1-libs \
 twolame-libs \
 vo-amrwbenc \
 xevd-libs \
 xeve-libs \
 xvidcore \
 xz-libs \
 zlib-ng-compat \
 zvbi \
 "
RDEPENDS:libavcodec-free-devel = " \
 libavcodec-free \
 libavutil-free-devel \
 libswresample-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavdevice-free = " \
 alsa-lib \
 glibc \
 libX11 \
 libXext \
 libXv \
 libavc1394 \
 libavcodec-free \
 libavfilter-free \
 libavformat-free \
 libavutil-free \
 libcaca \
 libcdio-paranoia \
 libdc1394 \
 libdrm \
 libiec61883 \
 libraw1394 \
 libv4l \
 libxcb \
 pipewire-jack-audio-connection-kit-libs \
 pulseaudio-libs \
 virtual/libSDL2-2.0.so.0___64bit_ \
 "
RDEPENDS:libavdevice-free-devel = " \
 libavcodec-free-devel \
 libavdevice-free \
 libavfilter-free-devel \
 libavformat-free-devel \
 libavutil-free-devel \
 libpostproc-free-devel \
 libswresample-free-devel \
 libswscale-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavfilter-free = " \
 fontconfig \
 freetype \
 fribidi \
 glibc \
 harfbuzz \
 lcms2 \
 libass \
 libavcodec-free \
 libavformat-free \
 libavutil-free \
 libbs2b \
 libmysofa \
 libplacebo \
 libpostproc-free \
 libshaderc \
 libswresample-free \
 libswscale-free \
 libva \
 lilv-libs \
 qrencode-libs \
 rubberband \
 tesseract \
 vid.stab \
 zeromq \
 zimg \
 "
RDEPENDS:libavfilter-free-devel = " \
 libavcodec-free-devel \
 libavfilter-free \
 libavformat-free-devel \
 libavutil-free-devel \
 libpostproc-free-devel \
 libswresample-free-devel \
 libswscale-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavformat-free = " \
 bzip2-libs \
 game-music-emu \
 glibc \
 gmp \
 gnutls \
 libavcodec-free \
 libavutil-free \
 libbluray \
 libdvdnav \
 libdvdread \
 libmodplug \
 libopenmpt \
 librabbitmq \
 librist \
 libsmbclient \
 libssh \
 libxml2 \
 srt-libs \
 zeromq \
 zlib-ng-compat \
 "
RDEPENDS:libavformat-free-devel = " \
 libavcodec-free-devel \
 libavformat-free \
 libavutil-free-devel \
 libswresample-free-devel \
 pkgconf-pkg-config \
 "
RDEPENDS:libavutil-free = " \
 glibc \
 libX11 \
 libdrm \
 libgcrypt \
 libva \
 libvdpau \
 "
RDEPENDS:libavutil-free-devel = " \
 libavutil-free \
 pkgconf-pkg-config \
 "
RDEPENDS:libpostproc-free = " \
 glibc \
 libavutil-free \
 "
RDEPENDS:libpostproc-free-devel = " \
 libavutil-free-devel \
 libpostproc-free \
 pkgconf-pkg-config \
 "
RDEPENDS:libswresample-free = " \
 glibc \
 libavutil-free \
 soxr \
 "
RDEPENDS:libswresample-free-devel = " \
 libavutil-free-devel \
 libswresample-free \
 pkgconf-pkg-config \
 "
RDEPENDS:libswscale-free = " \
 glibc \
 libavutil-free \
 "
RDEPENDS:libswscale-free-devel = " \
 libavutil-free-devel \
 libswscale-free \
 pkgconf-pkg-config \
 "
