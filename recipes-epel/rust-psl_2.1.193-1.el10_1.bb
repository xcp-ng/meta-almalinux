# File generated by gen-dnf-proxy.py, do not modify

inherit dnf-bridge

PN = "rust-psl"
PV = "2.1.193"
PR = "1.el10_1"
PACKAGES = " \
 rust-psl+default-devel \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "

URI_src = "${EPELSRC_MIRROR}/Packages/r/rust-psl-2.1.193-1.el10_1.src.rpm;name=src;unpack=0"
SRC_URI = "${URI_src}"
SRC_URI[src.sha256sum] = "c3fdd359b58786acdf8d113e47c9c8e08c7f5aabe00c9c53bc9d43eef35ad676"

URI_x86_64_v2_rust-psl+default-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+default-devel-2.1.193-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+default-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl+default-devel}"
SRC_URI[x86_64_v2_rust-psl+default-devel.sha256sum] = "da7f7b43aa4d98741954ac5ad67055d4d04799f4bce92fafe063ffc26c87f010"

URI_x86_64_v2_rust-psl+helpers-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl+helpers-devel-2.1.193-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl+helpers-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl+helpers-devel}"
SRC_URI[x86_64_v2_rust-psl+helpers-devel.sha256sum] = "36131776001c1e5f46120b1ab6982c31124b06631181f5ae78e273638678d951"

URI_x86_64_v2_rust-psl-devel = "${EPEL_ALTARCH_MIRROR}/x86_64_v2/Packages/rust-psl-devel-2.1.193-1.el10_1.alma_altarch.noarch.rpm;name=x86_64_v2_rust-psl-devel;unpack=0"
SRC_URI:append = " ${URI_x86_64_v2_rust-psl-devel}"
SRC_URI[x86_64_v2_rust-psl-devel.sha256sum] = "9a76eed862d0c022807630ab6f490b36169caab476031e8b9b6e622d7b4ac6c0"

URI_aarch64_rust-psl+default-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+default-devel-2.1.193-1.el10_1.noarch.rpm;name=aarch64_rust-psl+default-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl+default-devel}"
SRC_URI[aarch64_rust-psl+default-devel.sha256sum] = "85a5b60f71de07753b41e0d226160b098e2d59263d58c6458b37b1455f3cef39"

URI_aarch64_rust-psl+helpers-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl+helpers-devel-2.1.193-1.el10_1.noarch.rpm;name=aarch64_rust-psl+helpers-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl+helpers-devel}"
SRC_URI[aarch64_rust-psl+helpers-devel.sha256sum] = "efb32c6933ce85f765def1bed638bfc0e72e125caaaea1e39caf588bf71d94ec"

URI_aarch64_rust-psl-devel = "${EPEL_MIRROR}/aarch64/Packages/r/rust-psl-devel-2.1.193-1.el10_1.noarch.rpm;name=aarch64_rust-psl-devel;unpack=0"
SRC_URI:append = " ${URI_aarch64_rust-psl-devel}"
SRC_URI[aarch64_rust-psl-devel.sha256sum] = "5542414cfb5e37b6ce53fe3ec0536eadba7ca24374c8fd7697b50aa0069aacb8"

RDEPENDS:rust-psl+default-devel = " \
 cargo \
 rust-psl+helpers-devel \
 rust-psl-devel \
 "
RDEPENDS:rust-psl+helpers-devel = " \
 cargo \
 rust-psl-devel \
 "
RDEPENDS:rust-psl-devel = " \
 cargo \
 rust-psl-types+default-devel \
 "
